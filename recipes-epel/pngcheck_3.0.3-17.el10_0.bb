# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pngcheck"
PV = "3.0.3"
PR = "17.el10_0"
PACKAGES = " \
 pngcheck \
 pngcheck-extras \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pngcheck-3.0.3-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43b307198b0372b2e01da2977d7157c961b90414fe914c569f55208194176e46"

URI_x86_64_v2_pngcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pngcheck-3.0.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pngcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pngcheck}"
SRC_URI[x86_64_v2_pngcheck.sha256sum] = "5feef782ad7bbd16db830660898fe2580ce2ba815e8518b79d50b293041d5dc1"

URI_x86_64_v2_pngcheck-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pngcheck-extras-3.0.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pngcheck-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pngcheck-extras}"
SRC_URI[x86_64_v2_pngcheck-extras.sha256sum] = "682ba9baa64c4fab8bd2c67859b4c91d1d296bb529cbbbfd8d8e70c7faca20d0"

URI_aarch64_pngcheck = "${EPEL_MIRROR}/aarch64/Packages/p/pngcheck-3.0.3-17.el10_0.aarch64.rpm;name=aarch64_pngcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_pngcheck}"
SRC_URI[aarch64_pngcheck.sha256sum] = "2389fab514810d8c6d8ba0f4dae2861f5bc034f4841b43b5bc8763649d73fccd"

URI_aarch64_pngcheck-extras = "${EPEL_MIRROR}/aarch64/Packages/p/pngcheck-extras-3.0.3-17.el10_0.aarch64.rpm;name=aarch64_pngcheck-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_pngcheck-extras}"
SRC_URI[aarch64_pngcheck-extras.sha256sum] = "d7646baeb776435112e3bc9d85fd629714066f082283f7897f6a9b2cb3c3f462"

RDEPENDS:pngcheck = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:pngcheck-extras = " \
 glibc \
 zlib-ng-compat \
 "
