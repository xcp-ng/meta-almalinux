# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-pbs"
PV = "3.1"
PR = "14.el10_0"
PACKAGES = " \
 globus-gram-job-manager-pbs \
 globus-gram-job-manager-pbs-setup-poll \
 globus-gram-job-manager-pbs-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-pbs-3.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4756229a791416a88250e91fc636b080671b010d055e18fc86b9bf12b49b75d0"

URI_x86_64_v2_globus-gram-job-manager-pbs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-pbs-3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-pbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-pbs}"
SRC_URI[x86_64_v2_globus-gram-job-manager-pbs.sha256sum] = "92dee7de82c52f83d44eb831f5b30b2300af86d72345523b6c577b18bc3490fd"

URI_x86_64_v2_globus-gram-job-manager-pbs-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-pbs-setup-poll-3.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-pbs-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-pbs-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-pbs-setup-poll.sha256sum] = "f3196d95bfdabbb8499ede2162a427c991d915264aa34af9b0f2b6fb8a030289"
RPROVIDES:globus-gram-job-manager-pbs-setup-poll:x86_64_v2 = "virtual/globus-gram-job-manager-pbs-setup_eq_3.1-14.el10_0.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-pbs-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-pbs-setup-seg-3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-pbs-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-pbs-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-pbs-setup-seg.sha256sum] = "45776e4ff61af947ead5d864d7cd7b927e4f37ac297695648f0552422cecdefa"
RPROVIDES:globus-gram-job-manager-pbs-setup-seg:x86_64_v2 = "virtual/globus-gram-job-manager-pbs-setup_eq_3.1-14.el10_0.alma_altarch"

URI_aarch64_globus-gram-job-manager-pbs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-pbs-3.1-14.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-pbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-pbs}"
SRC_URI[aarch64_globus-gram-job-manager-pbs.sha256sum] = "4b1b112c794d48ace6d1071597e53d0a4a997db757750e36de6eadf6ffc54703"

URI_aarch64_globus-gram-job-manager-pbs-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-pbs-setup-poll-3.1-14.el10_0.noarch.rpm;name=aarch64_globus-gram-job-manager-pbs-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-pbs-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-pbs-setup-poll.sha256sum] = "d689ae9d07e162e78cd69b993e0e9232e4d7849964aa7e07ca3758fbf4e95833"
RPROVIDES:globus-gram-job-manager-pbs-setup-poll:aarch64 = "virtual/globus-gram-job-manager-pbs-setup_eq_3.1-14.el10_0"

URI_aarch64_globus-gram-job-manager-pbs-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-pbs-setup-seg-3.1-14.el10_0.aarch64.rpm;name=aarch64_globus-gram-job-manager-pbs-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-pbs-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-pbs-setup-seg.sha256sum] = "62dcfddf93a746af4a04299f40d1270a4754ba92259e72d875a105b6e94c3378"
RPROVIDES:globus-gram-job-manager-pbs-setup-seg:aarch64 = "virtual/globus-gram-job-manager-pbs-setup_eq_3.1-14.el10_0"

RDEPENDS:globus-gram-job-manager-pbs:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-libs \
 virtual/globus-gram-job-manager-pbs-setup_eq_3.1-14.el10_0.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-pbs:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-libs \
 virtual/globus-gram-job-manager-pbs-setup_eq_3.1-14.el10_0 \
"
RDEPENDS:globus-gram-job-manager-pbs-setup-poll = " \
 bash \
 globus-gram-job-manager-pbs \
 globus-gram-job-manager-scripts \
 "
RDEPENDS:globus-gram-job-manager-pbs-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-pbs \
 globus-gram-job-manager-scripts \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 systemd \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/globus-gram-job-manager-pbs-setup_eq_3.1-14.el10_0.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/globus-gram-job-manager-pbs-setup_eq_3.1-14.el10_0"
