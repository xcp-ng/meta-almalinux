# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ucd-parse"
PV = "0.1.13"
PR = "2.el10_0"
PACKAGES = " \
 rust-ucd-parse+default-devel \
 rust-ucd-parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ucd-parse-0.1.13-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1accc925cd4e6a4b87c58661974547a334b69c74eb100e0c89c805018f5b7e3"

URI_x86_64_v2_rust-ucd-parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ucd-parse+default-devel-0.1.13-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ucd-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ucd-parse+default-devel}"
SRC_URI[x86_64_v2_rust-ucd-parse+default-devel.sha256sum] = "8f69c119798fe52caee62bc19ef96e279d339591fa25a067e114ba56295fa417"

URI_x86_64_v2_rust-ucd-parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ucd-parse-devel-0.1.13-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ucd-parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ucd-parse-devel}"
SRC_URI[x86_64_v2_rust-ucd-parse-devel.sha256sum] = "8a0743ab35f27aa6a717230f12c03e945955ba2af95f70475c5dc9a33e279ba8"

URI_aarch64_rust-ucd-parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ucd-parse+default-devel-0.1.13-2.el10_0.noarch.rpm;name=aarch64_rust-ucd-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ucd-parse+default-devel}"
SRC_URI[aarch64_rust-ucd-parse+default-devel.sha256sum] = "863d7d8cf8c2f26fb95a753f75584ca60bc94e06f388ca4cf943e448b0a8408b"

URI_aarch64_rust-ucd-parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ucd-parse-devel-0.1.13-2.el10_0.noarch.rpm;name=aarch64_rust-ucd-parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ucd-parse-devel}"
SRC_URI[aarch64_rust-ucd-parse-devel.sha256sum] = "8f303ad21ed2f715c904066db0c3963dcfc2ff9f9402fc316c48d1d94a8727d5"

RDEPENDS:rust-ucd-parse+default-devel = " \
 cargo \
 rust-ucd-parse-devel \
 "
RDEPENDS:rust-ucd-parse-devel = " \
 cargo \
 rust \
 rust-regex-lite+default-devel \
 "
