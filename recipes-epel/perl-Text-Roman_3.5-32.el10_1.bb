# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Roman"
PV = "3.5"
PR = "32.el10_1"
PACKAGES = " \
 perl-Text-Roman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-Roman-3.5-32.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "562c3e53f47b3e15a6fdef53a825acf3acb09aaccb342c3866160e5667284788"

URI_x86_64_v2_perl-Text-Roman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-Roman-3.5-32.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-Roman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Roman}"
SRC_URI[x86_64_v2_perl-Text-Roman.sha256sum] = "3feb4af9af977ccb981f4c6819b0f7af66b178f7d543b2b989fc20d81895e011"

URI_aarch64_perl-Text-Roman = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-Roman-3.5-32.el10_1.noarch.rpm;name=aarch64_perl-Text-Roman;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Roman}"
SRC_URI[aarch64_perl-Text-Roman.sha256sum] = "814f27f1c0774da47738f6ead5b1ed0b16635c058d1ca06174010b9c854227c8"

RDEPENDS:perl-Text-Roman = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
