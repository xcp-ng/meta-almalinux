# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hypre"
PV = "2.32.0"
PR = "7.el10_2"
PACKAGES = " \
 hypre \
 hypre-devel \
 hypre-doc \
 hypre-mpich \
 hypre-mpich-devel \
 hypre-openmpi \
 hypre-openmpi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hypre-2.32.0-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c355e5c05aea67288483efe20ac096b83362904041f487fab9f697789e67dd9f"

URI_x86_64_v2_hypre = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-2.32.0-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre}"
SRC_URI[x86_64_v2_hypre.sha256sum] = "f6b9a79ac42120afe1500b7b23f858605eaa9af03abb47e594adecf6f6abfe58"

URI_x86_64_v2_hypre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-devel-2.32.0-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-devel}"
SRC_URI[x86_64_v2_hypre-devel.sha256sum] = "80161fb91bd61664d876bf871c413447442984beb15a7aaffd21d2c737fc6baa"

URI_x86_64_v2_hypre-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-doc-2.32.0-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_hypre-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-doc}"
SRC_URI[x86_64_v2_hypre-doc.sha256sum] = "ec8ca584168be4bbebf0c908509f6666bf14e8ffe013ca0d83f489e4021927b4"

URI_x86_64_v2_hypre-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-mpich-2.32.0-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-mpich}"
SRC_URI[x86_64_v2_hypre-mpich.sha256sum] = "98417f9432f6142abc8e5fca25824d4d50dd7a567d4eb1328bb6faceb184d4d2"

URI_x86_64_v2_hypre-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-mpich-devel-2.32.0-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-mpich-devel}"
SRC_URI[x86_64_v2_hypre-mpich-devel.sha256sum] = "d18a901302dddaaf1ccf65f2560b4b3b9d22d47e19d7d5eb4b2b6dea2485d009"

URI_x86_64_v2_hypre-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-openmpi-2.32.0-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-openmpi}"
SRC_URI[x86_64_v2_hypre-openmpi.sha256sum] = "628190d18f22d56804baa6ce0fb89f1585042938dbd6ccf56d20532df19549f0"

URI_x86_64_v2_hypre-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hypre-openmpi-devel-2.32.0-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hypre-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hypre-openmpi-devel}"
SRC_URI[x86_64_v2_hypre-openmpi-devel.sha256sum] = "dff53956ae13d1f8e6be63b4cdb213c6eace6026747fd9414357b49aee4004ba"

URI_aarch64_hypre = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-2.32.0-7.el10_2.aarch64.rpm;name=aarch64_hypre;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre}"
SRC_URI[aarch64_hypre.sha256sum] = "192e341d9b051e66639081efa66f4e1d12419cd87e5485eaa889d52a271366ee"

URI_aarch64_hypre-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-devel-2.32.0-7.el10_2.aarch64.rpm;name=aarch64_hypre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-devel}"
SRC_URI[aarch64_hypre-devel.sha256sum] = "5192b23087d0856e375f7152a2bc6752a4083e1309babacd750af08b3aca9dbc"

URI_aarch64_hypre-doc = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-doc-2.32.0-7.el10_2.noarch.rpm;name=aarch64_hypre-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-doc}"
SRC_URI[aarch64_hypre-doc.sha256sum] = "e7b6b91703920c311911d42092b0766eb4d325652cea724a1012ecad6859a57d"

URI_aarch64_hypre-mpich = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-mpich-2.32.0-7.el10_2.aarch64.rpm;name=aarch64_hypre-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-mpich}"
SRC_URI[aarch64_hypre-mpich.sha256sum] = "5d76936781d7e82d4782ae0189f72b4eb1c00f1977fbcc398900f08b5ecd3242"

URI_aarch64_hypre-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-mpich-devel-2.32.0-7.el10_2.aarch64.rpm;name=aarch64_hypre-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-mpich-devel}"
SRC_URI[aarch64_hypre-mpich-devel.sha256sum] = "6903c99d5f3ea63de5b9060cb56a54f6e2d0e778120f0a2420f0ce410f5148be"

URI_aarch64_hypre-openmpi = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-openmpi-2.32.0-7.el10_2.aarch64.rpm;name=aarch64_hypre-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-openmpi}"
SRC_URI[aarch64_hypre-openmpi.sha256sum] = "88ced11b14d9d8ac4968da7363c2d2d3cb384806ad477299f253b025025e13eb"

URI_aarch64_hypre-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hypre-openmpi-devel-2.32.0-7.el10_2.aarch64.rpm;name=aarch64_hypre-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hypre-openmpi-devel}"
SRC_URI[aarch64_hypre-openmpi-devel.sha256sum] = "1f12d772f6eb9a006040680bb4b3b46466f3304b4824924fd24db38248829c1b"

RDEPENDS:hypre = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:hypre-devel = " \
 SuperLU-devel \
 cmake-filesystem \
 flexiblas-devel \
 hypre \
 "
RDEPENDS:hypre-doc = " \
 "
RDEPENDS:hypre-mpich = " \
 glibc \
 libgcc \
 libgomp \
 mpich \
 "
RDEPENDS:hypre-mpich-devel = " \
 flexiblas-devel \
 hypre-mpich \
 mpich-devel \
 ptscotch-mpich-devel \
 superlu_dist-mpich-devel \
 "
RDEPENDS:hypre-openmpi = " \
 glibc \
 libgcc \
 libgomp \
 openmpi \
 "
RDEPENDS:hypre-openmpi-devel = " \
 flexiblas-devel \
 hypre-openmpi \
 openmpi-devel \
 ptscotch-openmpi-devel \
 superlu_dist-openmpi-devel \
 "
