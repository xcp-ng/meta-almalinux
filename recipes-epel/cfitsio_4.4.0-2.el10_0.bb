# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cfitsio"
PV = "4.4.0"
PR = "2.el10_0"
PACKAGES = " \
 cfitsio \
 cfitsio-devel \
 cfitsio-docs \
 cfitsio-static \
 fpack \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cfitsio-4.4.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc6eb23c429ac7944db023ca08936a481eab5600bb400e38544b9b63169779ab"

URI_x86_64_v2_cfitsio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-4.4.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio}"
SRC_URI[x86_64_v2_cfitsio.sha256sum] = "37d41abb39c97a48cf25d18049694059e067ba14fb4930e8fe8ca00fb7f2e4f0"

URI_x86_64_v2_cfitsio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-devel-4.4.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-devel}"
SRC_URI[x86_64_v2_cfitsio-devel.sha256sum] = "f88697c7ffea26c398a3fc5c69b345f78097c32050ae28eac868f112cd3732ac"

URI_x86_64_v2_cfitsio-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-docs-4.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cfitsio-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-docs}"
SRC_URI[x86_64_v2_cfitsio-docs.sha256sum] = "e889b228f2a65d28624835aea04890c5aaf8edbe3ee833e5c51ac02671f2e78c"

URI_x86_64_v2_cfitsio-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-static-4.4.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-static}"
SRC_URI[x86_64_v2_cfitsio-static.sha256sum] = "24fe12ccb3255cf96a3e79c0a24fec0cb00646961356ad5fed3996c9c8f29114"

URI_x86_64_v2_fpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fpack-4.4.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fpack}"
SRC_URI[x86_64_v2_fpack.sha256sum] = "2de2afb5d09b37e603a42413d5fccb5034a50f4f13fd70047dc34c2e2ae5585c"

URI_aarch64_cfitsio = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-4.4.0-2.el10_0.aarch64.rpm;name=aarch64_cfitsio;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio}"
SRC_URI[aarch64_cfitsio.sha256sum] = "d3840f0c089f3a48a7a918995715e821fb30533d0cfcedbb16a3bf9acad4e6a2"

URI_aarch64_cfitsio-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-devel-4.4.0-2.el10_0.aarch64.rpm;name=aarch64_cfitsio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-devel}"
SRC_URI[aarch64_cfitsio-devel.sha256sum] = "4abdcf71a9817e6a57ea66021a3c2e6ff4924d549f1e245be7f0b9f77577aa28"

URI_aarch64_cfitsio-docs = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-docs-4.4.0-2.el10_0.noarch.rpm;name=aarch64_cfitsio-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-docs}"
SRC_URI[aarch64_cfitsio-docs.sha256sum] = "147adb79d333cc721095aed51cdc308361cfd4c1d2639acce77eee2e8a8f08e4"

URI_aarch64_cfitsio-static = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-static-4.4.0-2.el10_0.aarch64.rpm;name=aarch64_cfitsio-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-static}"
SRC_URI[aarch64_cfitsio-static.sha256sum] = "7142dd51768a7a6593e50737a9dbe41130af31f3656bb6a078a13e6b49e9143b"

URI_aarch64_fpack = "${EPEL_MIRROR}/aarch64/Packages/f/fpack-4.4.0-2.el10_0.aarch64.rpm;name=aarch64_fpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_fpack}"
SRC_URI[aarch64_fpack.sha256sum] = "0f34e567c715109fcf75114bc1aa431aa1c8310fdaf93f3d8e9e72fa2981aec6"

RDEPENDS:cfitsio = " \
 bzip2-libs \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:cfitsio-devel = " \
 cfitsio \
 pkgconf-pkg-config \
 "
RDEPENDS:cfitsio-docs = " \
 "
RDEPENDS:cfitsio-static = " \
 "
RDEPENDS:fpack = " \
 cfitsio \
 glibc \
 "
