# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicase"
PV = "2.9.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-unicase+default-devel \
 rust-unicase+nightly-devel \
 rust-unicase-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicase-2.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "632225e9af7a530cf262382a452b0e85e15f54116f98415a6bba587513c205a6"

URI_x86_64_v2_rust-unicase+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicase+default-devel-2.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicase+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicase+default-devel}"
SRC_URI[x86_64_v2_rust-unicase+default-devel.sha256sum] = "96ac46c4e01f5212e966fdfad8d863d02e72de153b42ef1d7d3f08a1a7215d58"

URI_x86_64_v2_rust-unicase+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicase+nightly-devel-2.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicase+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicase+nightly-devel}"
SRC_URI[x86_64_v2_rust-unicase+nightly-devel.sha256sum] = "21207a19016151b24d2b7da769528fd5f0ad1862afd81658bf77cc792f94716a"

URI_x86_64_v2_rust-unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicase-devel-2.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicase-devel}"
SRC_URI[x86_64_v2_rust-unicase-devel.sha256sum] = "5e54db95c8afe07adbc37e935d74d1231d937fc5d3d7e58204199efdb6d5e819"

URI_aarch64_rust-unicase+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicase+default-devel-2.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-unicase+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicase+default-devel}"
SRC_URI[aarch64_rust-unicase+default-devel.sha256sum] = "36e4ea04cf70d1dabd39a058e32cc67ae5bc51834262185de929b74cad6d22a9"

URI_aarch64_rust-unicase+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicase+nightly-devel-2.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-unicase+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicase+nightly-devel}"
SRC_URI[aarch64_rust-unicase+nightly-devel.sha256sum] = "08792e4fef07f691d1efc22980808645b46ea093a2595a538d7752efe1b42e07"

URI_aarch64_rust-unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicase-devel-2.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicase-devel}"
SRC_URI[aarch64_rust-unicase-devel.sha256sum] = "a7e07f38123bf64974f1168c7e86d11e9f1b404ad1bf2a710c528613a551e62e"

RDEPENDS:rust-unicase+default-devel = " \
 cargo \
 rust-unicase-devel \
 "
RDEPENDS:rust-unicase+nightly-devel = " \
 cargo \
 rust-unicase-devel \
 "
RDEPENDS:rust-unicase-devel = " \
 cargo \
 "
