# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blinken"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 blinken \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blinken-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7f46cafb6e2cef368844c40cdfc931c827bf45a63019bf794d96abd2f1478cf"

URI_x86_64_v2_blinken = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blinken-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blinken;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blinken}"
SRC_URI[x86_64_v2_blinken.sha256sum] = "d0c2ff81875326d16d986d151c20074dae45ad722ba99513ef608186320b5776"

URI_aarch64_blinken = "${EPEL_MIRROR}/aarch64/Packages/b/blinken-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_blinken;unpack=0"
SRC_URI:append = " ${URI_aarch64_blinken}"
SRC_URI[aarch64_blinken.sha256sum] = "290e2c7ddd6926009455d2955367d5623afb78a503b055a86cb8615b13829bb3"

RDEPENDS:blinken = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 sj-stevehand-fonts \
 "
