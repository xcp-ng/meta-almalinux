# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-qemu-ga-win"
PV = "110.2.2"
PR = "1.el10"
PACKAGES = " \
 mingw-qemu-ga-win \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mingw-qemu-ga-win-110.2.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10d1b7607fbbfd9755b9e6b0ae8474f051c7a9a5eae06388712d1ea252174811"

URI_x86_64_v2_mingw-qemu-ga-win = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mingw-qemu-ga-win-110.2.2-1.el10.noarch.rpm;name=x86_64_v2_mingw-qemu-ga-win;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw-qemu-ga-win}"
SRC_URI[x86_64_v2_mingw-qemu-ga-win.sha256sum] = "dfc47a393387110b9739976459656daaed7c4d4b2d5a942d9b8f57e99126a378"

URI_aarch64_mingw-qemu-ga-win = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mingw-qemu-ga-win-110.2.2-1.el10.noarch.rpm;name=aarch64_mingw-qemu-ga-win;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw-qemu-ga-win}"
SRC_URI[aarch64_mingw-qemu-ga-win.sha256sum] = "dfc47a393387110b9739976459656daaed7c4d4b2d5a942d9b8f57e99126a378"

RDEPENDS:mingw-qemu-ga-win = " \
 systemd \
 "
