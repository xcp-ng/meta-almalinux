# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "autoconf"
PV = "2.71"
PR = "13.el10"
PACKAGES = " \
 autoconf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/autoconf-2.71-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff656e20e1954313e194ea7239de6752613d22807778df795d8f465b84d60bb2"

URI_x86_64_v2_autoconf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/autoconf-2.71-13.el10.noarch.rpm;name=x86_64_v2_autoconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_autoconf}"
SRC_URI[x86_64_v2_autoconf.sha256sum] = "a601c794610b261b12bc87e4986ca8bb95693a4d28a4b1d22764226b5fc9a412"

URI_aarch64_autoconf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/autoconf-2.71-13.el10.noarch.rpm;name=aarch64_autoconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_autoconf}"
SRC_URI[aarch64_autoconf.sha256sum] = "a601c794610b261b12bc87e4986ca8bb95693a4d28a4b1d22764226b5fc9a412"

RDEPENDS:autoconf = " \
 bash \
 emacs-filesystem \
 m4 \
 perl-Carp \
 perl-Class-Struct \
 perl-Data-Dumper \
 perl-Errno \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Temp \
 perl-File-stat \
 perl-Getopt-Long \
 perl-IO \
 perl-POSIX \
 perl-PathTools \
 perl-Text-ParseWords \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
