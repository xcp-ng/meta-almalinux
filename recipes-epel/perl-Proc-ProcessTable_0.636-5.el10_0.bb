# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Proc-ProcessTable"
PV = "0.636"
PR = "5.el10_0"
PACKAGES = " \
 perl-Proc-ProcessTable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Proc-ProcessTable-0.636-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae3dba7b0a4b83592c5cf78abc7ed0826423fab0b3ba4906fe2da2a4c667fd7d"

URI_x86_64_v2_perl-Proc-ProcessTable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Proc-ProcessTable-0.636-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Proc-ProcessTable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Proc-ProcessTable}"
SRC_URI[x86_64_v2_perl-Proc-ProcessTable.sha256sum] = "98cb9d7d226f724cbfdda0d8b9e969c24e3d3015328bdfbc12dd59fa628ba58c"

URI_aarch64_perl-Proc-ProcessTable = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Proc-ProcessTable-0.636-5.el10_0.aarch64.rpm;name=aarch64_perl-Proc-ProcessTable;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Proc-ProcessTable}"
SRC_URI[aarch64_perl-Proc-ProcessTable.sha256sum] = "de4b64e0cde44cf01d952e5456cd15422ba4cc54ea8bc7f77c2b352728cf5fa3"

RDEPENDS:perl-Proc-ProcessTable = " \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Temp \
 perl-Proc-ProcessTable \
 perl-Storable \
 perl-base \
 perl-libs \
 perl-subs \
 perl-vars \
 "
