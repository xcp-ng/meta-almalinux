# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-franela-goblin"
PV = "0.0.3"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-franela-goblin-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-franela-goblin-0.0.3-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6359a8b728a28d950be945528b5bf702f6e8cbdb39df7aa808b641e8665e9215"

URI_x86_64_v2_golang-github-franela-goblin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-franela-goblin-devel-0.0.3-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-franela-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-franela-goblin-devel}"
SRC_URI[x86_64_v2_golang-github-franela-goblin-devel.sha256sum] = "9af2ce43f056db4b45623b6a2092776430befc50d0a3440fe50df5a1e425c0bd"

URI_aarch64_golang-github-franela-goblin-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-franela-goblin-devel-0.0.3-12.el10_0.noarch.rpm;name=aarch64_golang-github-franela-goblin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-franela-goblin-devel}"
SRC_URI[aarch64_golang-github-franela-goblin-devel.sha256sum] = "621e5474f712dca3e720b489c33f27a9e6cac599e6d086414d89c2d121cc8b6a"

RDEPENDS:golang-github-franela-goblin-devel = " \
 go-filesystem \
 "
