# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-connections"
PV = "47.2.1"
PR = "3.el10"
PACKAGES = " \
 gnome-connections \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-connections-47.2.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f38700a80bb49cc5e9178520088eea1a8ac41c88793ddf1fe8eb2b5906c04f3f"

URI_x86_64_v2_gnome-connections = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-connections-47.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-connections;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-connections}"
SRC_URI[x86_64_v2_gnome-connections.sha256sum] = "119933333d44ba71eb40e5259056f1e673cd488ae8cfbce7404b948a69ee4437"

URI_aarch64_gnome-connections = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-connections-47.2.1-3.el10.aarch64.rpm;name=aarch64_gnome-connections;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-connections}"
SRC_URI[aarch64_gnome-connections.sha256sum] = "57206ffe4837a2d6153c76c7b53d16f70673ad728f20be252f327a9b1cba676e"

RDEPENDS:gnome-connections = " \
 cairo \
 freerdp-libs \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk-vnc2 \
 gtk3 \
 gvnc \
 gvncpulse \
 hicolor-icon-theme \
 libhandy \
 libsecret \
 libwinpr \
 libxml2 \
 "
