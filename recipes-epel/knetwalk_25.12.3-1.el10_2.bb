# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knetwalk"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 knetwalk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knetwalk-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0659f43a2cc8d3a0259f9276a090e34d60a20be15b257b73dab35ab4065218b"

URI_x86_64_v2_knetwalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knetwalk-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knetwalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knetwalk}"
SRC_URI[x86_64_v2_knetwalk.sha256sum] = "969739401b211eb1427a965ea7633a5545d9c0f4230e75e9f41ddd4cbfeac0af"

URI_aarch64_knetwalk = "${EPEL_MIRROR}/aarch64/Packages/k/knetwalk-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_knetwalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_knetwalk}"
SRC_URI[aarch64_knetwalk.sha256sum] = "7f9beb94e3a3a3530d9662d0937d7fab3eba8dccfa89d5c31c8388cffe806bb2"

RDEPENDS:knetwalk = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
