# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_generator"
PV = "0.11.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-phf_generator+default-devel \
 rust-phf_generator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_generator-0.11.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25e8a46ec7cbf1f0f8e76f0260737efffda5288f03f86ed9fa54d1afe45413c8"

URI_x86_64_v2_rust-phf_generator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_generator+default-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_generator+default-devel}"
SRC_URI[x86_64_v2_rust-phf_generator+default-devel.sha256sum] = "3d3877c8f0db3f4de62ada470103c47b497c932f0e995dfdf9b6f36ce6235399"

URI_x86_64_v2_rust-phf_generator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_generator-devel-0.11.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_generator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_generator-devel}"
SRC_URI[x86_64_v2_rust-phf_generator-devel.sha256sum] = "caee96e205e72d608b5e00f8fefae6d597f5efad14f9f9c7e7bb95d61882953b"

URI_aarch64_rust-phf_generator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_generator+default-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_generator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_generator+default-devel}"
SRC_URI[aarch64_rust-phf_generator+default-devel.sha256sum] = "aefadf9534e60a734c3501509593e004cc089ee4792e4c4c34dce2c7c1329f39"

URI_aarch64_rust-phf_generator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_generator-devel-0.11.3-1.el10_1.noarch.rpm;name=aarch64_rust-phf_generator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_generator-devel}"
SRC_URI[aarch64_rust-phf_generator-devel.sha256sum] = "9764b248b37977fa2dbf103a23d7aa31dedebd4c25c2e6fdd099974ecf41217f"

RDEPENDS:rust-phf_generator+default-devel = " \
 cargo \
 rust-phf_generator-devel \
 "
RDEPENDS:rust-phf_generator-devel = " \
 cargo \
 rust \
 rust-phf_shared-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand0.8-devel \
 "
