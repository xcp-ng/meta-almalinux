# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dasbus"
PV = "1.7"
PR = "8.el10"
PACKAGES = " \
 python3-dasbus \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-dasbus-1.7-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaaebb9623a067031b9dc1b49ac79c083f5580cb4f21cf9431f908e58432bf1b"

URI_x86_64_v2_python3-dasbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dasbus-1.7-8.el10.noarch.rpm;name=x86_64_v2_python3-dasbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dasbus}"
SRC_URI[x86_64_v2_python3-dasbus.sha256sum] = "748715e39c73b912e71c3e1707ff79af46ecf542521b9c8fc01b71d92482e3b2"

URI_aarch64_python3-dasbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dasbus-1.7-8.el10.noarch.rpm;name=aarch64_python3-dasbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dasbus}"
SRC_URI[aarch64_python3-dasbus.sha256sum] = "748715e39c73b912e71c3e1707ff79af46ecf542521b9c8fc01b71d92482e3b2"

RDEPENDS:python3-dasbus = " \
 python3 \
 python3-gobject-base \
 "
