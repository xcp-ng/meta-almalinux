# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-unicodedata2"
PV = "17.0.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-unicodedata2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-unicodedata2-17.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25f2619c8303694abfe6c2ac94d1de16e294084e524f21b56dd27c5bc693e547"

URI_x86_64_v2_python3-unicodedata2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-unicodedata2-17.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-unicodedata2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-unicodedata2}"
SRC_URI[x86_64_v2_python3-unicodedata2.sha256sum] = "b56690da7d475a3e75507699b9c9aae94edb9a90c3fc8557f33559d9c2068bef"

URI_aarch64_python3-unicodedata2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-unicodedata2-17.0.0-1.el10_2.aarch64.rpm;name=aarch64_python3-unicodedata2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-unicodedata2}"
SRC_URI[aarch64_python3-unicodedata2.sha256sum] = "d29d70b27d91e05c59d6ef7131a92d8418f1b738af1085ac7e0b87408aa918d1"

RDEPENDS:python3-unicodedata2 = " \
 glibc \
 python3 \
 "
