# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-annotated-wl-pprint"
PV = "0.7.0"
PR = "32.el10_0"
PACKAGES = " \
 ghc-annotated-wl-pprint \
 ghc-annotated-wl-pprint-devel \
 ghc-annotated-wl-pprint-doc \
 ghc-annotated-wl-pprint-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-annotated-wl-pprint-0.7.0-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71a31fdcf88173ca0462d96eba737190c21623d5569035b87bcb49b842e7ae18"

URI_x86_64_v2_ghc-annotated-wl-pprint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-annotated-wl-pprint-0.7.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-annotated-wl-pprint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-annotated-wl-pprint}"
SRC_URI[x86_64_v2_ghc-annotated-wl-pprint.sha256sum] = "4c8d60af975a903d03eca768f39c57a3368814a21c12302b66f7d8a6f7c0753a"

URI_x86_64_v2_ghc-annotated-wl-pprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-annotated-wl-pprint-devel-0.7.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-annotated-wl-pprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-annotated-wl-pprint-devel}"
SRC_URI[x86_64_v2_ghc-annotated-wl-pprint-devel.sha256sum] = "f5ce30c6aad09be7d89880a73f7d3da4a311b14a227ff4a17a9a35f10a890ec9"

URI_x86_64_v2_ghc-annotated-wl-pprint-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-annotated-wl-pprint-doc-0.7.0-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-annotated-wl-pprint-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-annotated-wl-pprint-doc}"
SRC_URI[x86_64_v2_ghc-annotated-wl-pprint-doc.sha256sum] = "932a7ac6e46127af0acd75ec2bbbdcb583beab0d1494398dd96b712037b3755e"

URI_x86_64_v2_ghc-annotated-wl-pprint-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-annotated-wl-pprint-prof-0.7.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-annotated-wl-pprint-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-annotated-wl-pprint-prof}"
SRC_URI[x86_64_v2_ghc-annotated-wl-pprint-prof.sha256sum] = "c0c225d6dabe3075889dcc0800d6ed3c319df4b15c4b6267cae9d7e1ad9d5246"

URI_aarch64_ghc-annotated-wl-pprint = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-annotated-wl-pprint-0.7.0-32.el10_0.aarch64.rpm;name=aarch64_ghc-annotated-wl-pprint;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-annotated-wl-pprint}"
SRC_URI[aarch64_ghc-annotated-wl-pprint.sha256sum] = "4fd33b0c003592cdde6302edec9dd3b94e1744c704133de1d932427a62c73215"

URI_aarch64_ghc-annotated-wl-pprint-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-annotated-wl-pprint-devel-0.7.0-32.el10_0.aarch64.rpm;name=aarch64_ghc-annotated-wl-pprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-annotated-wl-pprint-devel}"
SRC_URI[aarch64_ghc-annotated-wl-pprint-devel.sha256sum] = "cf056e2ecb0e3937ee80c2d28a21c1ae88b9ae5b3e93ad40fd1aa43ad96bb289"

URI_aarch64_ghc-annotated-wl-pprint-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-annotated-wl-pprint-doc-0.7.0-32.el10_0.noarch.rpm;name=aarch64_ghc-annotated-wl-pprint-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-annotated-wl-pprint-doc}"
SRC_URI[aarch64_ghc-annotated-wl-pprint-doc.sha256sum] = "a781804cfd9d21648436174082d91f936ac9aa3bf03da6909af9130ef1bcb2ba"

URI_aarch64_ghc-annotated-wl-pprint-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-annotated-wl-pprint-prof-0.7.0-32.el10_0.aarch64.rpm;name=aarch64_ghc-annotated-wl-pprint-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-annotated-wl-pprint-prof}"
SRC_URI[aarch64_ghc-annotated-wl-pprint-prof.sha256sum] = "c44172fbe8a325aaa2e2cd283263e825924e3f8eb26e2d9b901d2a4fbe7ed9f2"

RDEPENDS:ghc-annotated-wl-pprint = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-annotated-wl-pprint-devel = " \
 ghc-annotated-wl-pprint \
 ghc-base-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-annotated-wl-pprint-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-annotated-wl-pprint-prof = " \
 ghc-annotated-wl-pprint-devel \
 ghc-base-prof \
 "
