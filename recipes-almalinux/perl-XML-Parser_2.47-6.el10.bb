# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-Parser"
PV = "2.47"
PR = "6.el10"
PACKAGES = " \
 perl-XML-Parser \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-XML-Parser-2.47-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54075e7d91472179c0820b9a6d0550ca34e61170c7288fa5e83d0bf2de955527"

URI_x86_64_v2_perl-XML-Parser = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-XML-Parser-2.47-6.el10.x86_64_v2.rpm;name=x86_64_v2_perl-XML-Parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Parser}"
SRC_URI[x86_64_v2_perl-XML-Parser.sha256sum] = "b63e4b9496bab505d3abb27f303ff6a7fb718520007e5cd970a96f463a428b65"

URI_aarch64_perl-XML-Parser = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-XML-Parser-2.47-6.el10.aarch64.rpm;name=aarch64_perl-XML-Parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Parser}"
SRC_URI[aarch64_perl-XML-Parser.sha256sum] = "9919363e3358c879337f587c98d65d2519c417ec88eaca5ef3b84f45adf08163"

RDEPENDS:perl-XML-Parser = " \
 expat \
 glibc \
 perl-Carp \
 perl-IO \
 perl-PathTools \
 perl-URI \
 perl-libs \
 perl-libwww-perl \
 perl-overload \
 "
