# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-digitalocean"
PV = "1.17.0"
PR = "15.el10_1"
PACKAGES = " \
 python3-digitalocean \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-digitalocean-1.17.0-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5da4adf788c4f2f01388ffce8c40954e3953738cc1df666506f639b7e028463d"

URI_x86_64_v2_python3-digitalocean = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-digitalocean-1.17.0-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-digitalocean;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-digitalocean}"
SRC_URI[x86_64_v2_python3-digitalocean.sha256sum] = "0310f89f68580b81082dc58d31a191c012e80455fdfa08c8da2363c0b3a8936b"

URI_aarch64_python3-digitalocean = "${EPEL_MIRROR}/aarch64/Packages/p/python3-digitalocean-1.17.0-15.el10_1.noarch.rpm;name=aarch64_python3-digitalocean;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-digitalocean}"
SRC_URI[aarch64_python3-digitalocean.sha256sum] = "f05803695f13bdf39c81c59bf2c74ae29a1bf0a815f21e8dc6ca04b8bc230a48"

RDEPENDS:python3-digitalocean = " \
 python3 \
 python3-jsonpickle \
 python3-requests \
 "
