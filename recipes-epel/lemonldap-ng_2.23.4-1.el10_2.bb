# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lemonldap-ng"
PV = "2.23.4"
PR = "1.el10_2"
PACKAGES = " \
 lemonldap-ng \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-fastcgi-server \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 lemonldap-ng-uwsgi-app \
 perl-Lemonldap-NG-SSOaaS-Apache-Client \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lemonldap-ng-2.23.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9e137eae745a22f5cfe15886184fb0ff41d0de1318fbaeb81bc773b71af03497"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng.sha256sum] = "46ad6607b78e520f201368793bd32b5ceacead4f966f5c392d65411c946c2fa3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-common-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-common;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-common.sha256sum] = "73d47a942b1c3829aa3d24b5d3c5503375913563bcf46edbae206e3b64880b61"
RPROVIDES:lemonldap-ng-common:append:x86_64_v2 = " virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-doc-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-doc;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-doc.sha256sum] = "5cd48a1d83bb7c1a9efa58396854d09e6edd43f6cca6b0d1068023b9c7a06e86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-fastcgi-server-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-fastcgi-server.sha256sum] = "3007b0017bdbaa881451800cb710f13c8c7bc7583d1f33fd3466ccfa5d7d64a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-handler-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-handler;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-handler.sha256sum] = "9b011e88bad10356f2f387a207dbad000ebf7362ba96e387d9480f27ccff8d9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-manager-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-manager;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-manager.sha256sum] = "27a26e8d0d530acc31d1f91745a37086da4bcc75a72f08424336e4df46e3cc18"
RPROVIDES:lemonldap-ng-manager:append:x86_64_v2 = " virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-portal-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-portal;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-portal.sha256sum] = "37036dacf3afab89c25aa891c09e9ed4022c655147bcee5bd6e67aab8283c4b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-selinux-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-selinux;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-selinux.sha256sum] = "7c41fc0dadf2d85631bc30a787980ef75e11f0e52c9cd1f884b171788e6b5804"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-test-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-test;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-test.sha256sum] = "7cc15fc23f1215f714ae73f847c181ef8fc67ff1d785584c53a7884cc4767cb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-uwsgi-app-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI[x86_64_v2_lemonldap-ng-uwsgi-app.sha256sum] = "b8fd8526da5e56ea4f797d028c56ee5c6669edf4525101516e5f1eac058d5d6e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.23.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI[x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "842efa5ebb5e54014f0a9eb86540f05c753c545d5913812d8ec86c207f96fe5b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng;unpack=0"
SRC_URI[aarch64_lemonldap-ng.sha256sum] = "a65ec77aa7f8ff4f0d1ea25656dd908f9240f531a03499e6211a08300beee84a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-common-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-common;unpack=0"
SRC_URI[aarch64_lemonldap-ng-common.sha256sum] = "4ac3db9880c82383bc5bdf5e81802ec935e6e6fa342bdc061c90af67139994e9"
RPROVIDES:lemonldap-ng-common:append:aarch64 = " virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-doc-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-doc;unpack=0"
SRC_URI[aarch64_lemonldap-ng-doc.sha256sum] = "e78e4d662eb85de95ba934bc1bc4931fcdb84e261403ee19e4054ddc01f2fb61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-fastcgi-server-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI[aarch64_lemonldap-ng-fastcgi-server.sha256sum] = "2eae7abe8f5e5c6456dc5d399d1d5ee2b7407626cfccb547821850d0f39b4d21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-handler-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-handler;unpack=0"
SRC_URI[aarch64_lemonldap-ng-handler.sha256sum] = "a623c18113686dbc3231c210b9500d9f89e53cce0a7ee6a3513390bc116b9ba3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-manager-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-manager;unpack=0"
SRC_URI[aarch64_lemonldap-ng-manager.sha256sum] = "363a205b4f0bae0716d34298c901b30df23dd3637ca8f92b3e13a01cd89a59a6"
RPROVIDES:lemonldap-ng-manager:append:aarch64 = " virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-portal-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-portal;unpack=0"
SRC_URI[aarch64_lemonldap-ng-portal.sha256sum] = "f895663a9b8592f324a631bf38144ad2cab711cc9f0cf589724b49d50ab07f16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-selinux-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-selinux;unpack=0"
SRC_URI[aarch64_lemonldap-ng-selinux.sha256sum] = "ae5bb33314a6ed5d47b7d2cd52804c9363df2476a1f83ddcc94d1c9740e76eea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-test-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-test;unpack=0"
SRC_URI[aarch64_lemonldap-ng-test.sha256sum] = "aac000c6a8acb0dd736374dfa0a68ead7684016d9e7a2b04dd3aed85163b3f26"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-uwsgi-app-2.23.4-1.el10_2.noarch.rpm;name=aarch64_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI[aarch64_lemonldap-ng-uwsgi-app.sha256sum] = "775be2d4d2b38c5fcd28d64c45fb2c75d25eebdfef96b2d1cc2f6948fef1a92d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.23.4-1.el10_2.noarch.rpm;name=aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI[aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "9eda5048b53103f7aaaa8e2738fc6f22280b3850d970f2e3e5eef799c7f0a053"

RDEPENDS:lemonldap-ng = " \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 "
RDEPENDS:lemonldap-ng-common = " \
 bash \
 httpd-filesystem \
 lemonldap-ng-common \
 mod_fcgid \
 mod_perl \
 nginx-filesystem \
 perl-Apache-Session \
 perl-Apache-Session-Browseable \
 perl-AutoLoader \
 perl-Cache-Cache \
 perl-Config-IniFiles \
 perl-Convert-Base32 \
 perl-Convert-PEM \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-Rijndael \
 perl-Crypt-URandom \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-IO-String \
 perl-JSON \
 perl-JSON-XS \
 perl-LDAP \
 perl-Log-Log4perl \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack \
 perl-Pod-Usage \
 perl-Protocol-WebSocket \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Sentry-Raven \
 perl-String-Random \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-XML-LibXML \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 virtual/httpd_or_nginx \
 virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_ \
 "
RDEPENDS:lemonldap-ng-doc = " \
 lemonldap-ng-common \
 "
RDEPENDS:lemonldap-ng-fastcgi-server = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_fcgid \
 perl-FCGI-ProcManager \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Plack \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-handler = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_perl \
 perl-Apache-Session \
 perl-AutoLoader \
 perl-Cache-Memcached \
 perl-Digest-SHA \
 perl-Exporter \
 perl-Getopt-Std \
 perl-HTTP-Message \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-Plack \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-URI \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-manager = " \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 perl-Crypt-URandom \
 perl-Data-Dumper \
 perl-English \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-Hash-Merge-Simple \
 perl-Hash-MultiValue \
 perl-IO-String \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-POSIX \
 perl-PathTools \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-Regexp-Common \
 perl-Safe \
 perl-Storable \
 perl-URI \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-portal = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-portal \
 perl-Authen-PAM \
 perl-Authen-Radius \
 perl-Cache-Cache \
 perl-Carp \
 perl-Clone \
 perl-Crypt-JWT \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-URandom \
 perl-DBI \
 perl-DateTime-Format-RFC3339 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-File-Temp \
 perl-GD-SecurityImage \
 perl-GSSAPI \
 perl-Getopt-Long \
 perl-HTML-FormatText-WithLinks \
 perl-HTML-Parser \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-Hash-MultiValue \
 perl-IO-Socket-Timeout \
 perl-IO-String \
 perl-IPC-Run \
 perl-JSON \
 perl-LDAP \
 perl-List-MoreUtils \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-OpenID-Server \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-String-Random \
 perl-Text-Unidecode \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-Web-ID \
 perl-XML-LibXML \
 perl-XML-LibXSLT \
 perl-base \
 perl-constant \
 perl-fields \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:lemonldap-ng-test = " \
 lemonldap-ng-common \
 perl-CGI \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-JSON \
 perl-MIME-Base64 \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-uwsgi-app = " \
 uwsgi-plugin-psgi \
 "
RDEPENDS:perl-Lemonldap-NG-SSOaaS-Apache-Client = " \
 perl-FCGI-Client \
 perl-IO \
 perl-URI \
 perl-constant \
 perl-libs \
 "
