# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nss-pam-ldapd"
PV = "0.9.10"
PR = "17.el10_0"
PACKAGES = " \
 nss-pam-ldapd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nss-pam-ldapd-0.9.10-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2d7800c6d26d92eb1db54f50a8645da08d886d09ef204721328c2d01af53b1b"

URI_x86_64_v2_nss-pam-ldapd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nss-pam-ldapd-0.9.10-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nss-pam-ldapd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-pam-ldapd}"
SRC_URI[x86_64_v2_nss-pam-ldapd.sha256sum] = "e165d089db11b24dfb4a256a6384c09b1bedf5855a92698802add029969ccf5c"

URI_aarch64_nss-pam-ldapd = "${EPEL_MIRROR}/aarch64/Packages/n/nss-pam-ldapd-0.9.10-17.el10_0.aarch64.rpm;name=aarch64_nss-pam-ldapd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-pam-ldapd}"
SRC_URI[aarch64_nss-pam-ldapd.sha256sum] = "47c19ea3b4652113e964b4d3a0da154fb9902cc780cdd99062c68dc3247dac85"

RDEPENDS:nss-pam-ldapd = " \
 bash \
 glibc \
 krb5-libs \
 libgcc \
 openldap \
 pam-libs \
 shadow-utils \
 systemd \
 "
