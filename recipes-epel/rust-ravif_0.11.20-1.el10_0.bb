# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ravif"
PV = "0.11.20"
PR = "1.el10_0"
PACKAGES = " \
 rust-ravif+asm-devel \
 rust-ravif+default-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ravif-0.11.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0972f010c11796ec3f712fe8c286c99aef3454c2381dac040619127ffa83fb4d"

URI_x86_64_v2_rust-ravif+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+asm-devel-0.11.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+asm-devel}"
SRC_URI[x86_64_v2_rust-ravif+asm-devel.sha256sum] = "af4e464e462ba3005099673e94724b59d5c71ba2874f4485b4c76a489e4c8449"

URI_x86_64_v2_rust-ravif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+default-devel-0.11.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+default-devel}"
SRC_URI[x86_64_v2_rust-ravif+default-devel.sha256sum] = "3d7e5e401b2b172f28c39a90acc22577e7bd66ea39d95559ed9fdaca7509d5e4"

URI_x86_64_v2_rust-ravif+threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+threading-devel-0.11.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+threading-devel}"
SRC_URI[x86_64_v2_rust-ravif+threading-devel.sha256sum] = "c1f7541d8c72209901f6e47a4a6b2ac198db0c90c2e3cb386abaadccce2a8fef"

URI_x86_64_v2_rust-ravif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif-devel-0.11.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif-devel}"
SRC_URI[x86_64_v2_rust-ravif-devel.sha256sum] = "f37ba74e66bfbaf23afd2a02c5c7b9a69c5546c48044f60acbe074a12a6952bb"

URI_aarch64_rust-ravif+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+asm-devel-0.11.20-1.el10_0.noarch.rpm;name=aarch64_rust-ravif+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+asm-devel}"
SRC_URI[aarch64_rust-ravif+asm-devel.sha256sum] = "5d015df943211bc4db01b28e2f015add1332213e5e59b60ab4b0cc8d2eff5bd0"

URI_aarch64_rust-ravif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+default-devel-0.11.20-1.el10_0.noarch.rpm;name=aarch64_rust-ravif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+default-devel}"
SRC_URI[aarch64_rust-ravif+default-devel.sha256sum] = "0ef89c8b731204fada4de662ca32130d335517c05b1ddf6a84325f2425aa73c9"

URI_aarch64_rust-ravif+threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+threading-devel-0.11.20-1.el10_0.noarch.rpm;name=aarch64_rust-ravif+threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+threading-devel}"
SRC_URI[aarch64_rust-ravif+threading-devel.sha256sum] = "ebb9452ae52c70130230423a9fc14fb08934ddc1782681c70808b1ca3855eccd"

URI_aarch64_rust-ravif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif-devel-0.11.20-1.el10_0.noarch.rpm;name=aarch64_rust-ravif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif-devel}"
SRC_URI[aarch64_rust-ravif-devel.sha256sum] = "27e8c94881cb72a903f0158dd28428498c96a6c69c93732887ae02066e10ffbf"

RDEPENDS:rust-ravif+asm-devel = " \
 cargo \
 rust-rav1e+asm-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-ravif+default-devel = " \
 cargo \
 rust-ravif+asm-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-ravif+threading-devel = " \
 cargo \
 rust-rav1e+threading-devel \
 rust-ravif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ravif-devel = " \
 cargo \
 rust \
 rust-avif-serialize+default-devel \
 rust-imgref+default-devel \
 rust-loop9+default-devel \
 rust-quick-error+default-devel \
 rust-rav1e-devel \
 rust-rgb-devel \
 "
