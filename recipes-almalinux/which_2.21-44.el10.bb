# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "which"
PV = "2.21"
PR = "44.el10"
PACKAGES = " \
 which \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/which-2.21-44.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8471eda49136b8b255cb3c75cfe63c3402d1190b283e2e3984a127994bc77b6e"

URI_x86_64_v2_which = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/which-2.21-44.el10.x86_64_v2.rpm;name=x86_64_v2_which;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_which}"
SRC_URI[x86_64_v2_which.sha256sum] = "3aff6f910c017f1d9b3a260bdca357421b55f50dc215acbd88628d39667efee1"

URI_aarch64_which = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/which-2.21-44.el10.aarch64.rpm;name=aarch64_which;unpack=0"
SRC_URI:append = " ${URI_aarch64_which}"
SRC_URI[aarch64_which.sha256sum] = "775f45616ec91b0aba895788f9686e638de461f5eec9f2dc66e289ef9b422700"

RDEPENDS:which = " \
 glibc \
 virtual/coreutils \
 "
