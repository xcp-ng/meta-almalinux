# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-pbs"
PV = "3.1"
PR = "20.el10_2"
PACKAGES = " \
 globus-gram-job-manager-pbs \
 globus-gram-job-manager-pbs-setup-poll \
 globus-gram-job-manager-pbs-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-pbs-3.1-20.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea0db54e66f9176acad15eb31c497b4f6100f69e8405baa1094b35f0f8c620a2"

URI_x86_64_v2_globus-gram-job-manager-pbs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-pbs-3.1-20.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-pbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-pbs}"
SRC_URI[x86_64_v2_globus-gram-job-manager-pbs.sha256sum] = "2fdf09897324d9ce88418ad2693025d278797acf96d44d4e392ce9613db288c3"

URI_x86_64_v2_globus-gram-job-manager-pbs-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-pbs-setup-poll-3.1-20.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-pbs-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-pbs-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-pbs-setup-poll.sha256sum] = "633079b14017b0754a78c365a5459cf65cf1c3a7c423d4e7c803b57b209c993f"
RPROVIDES:globus-gram-job-manager-pbs-setup-poll:x86_64_v2 = "virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_2.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-pbs-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-pbs-setup-seg-3.1-20.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-pbs-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-pbs-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-pbs-setup-seg.sha256sum] = "98569fdfa807ecbfa8266b254dc989af706cd88ca497b14c55388760761bb559"
RPROVIDES:globus-gram-job-manager-pbs-setup-seg:x86_64_v2 = "virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_2.alma_altarch"

URI_aarch64_globus-gram-job-manager-pbs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-pbs-3.1-20.el10_2.aarch64.rpm;name=aarch64_globus-gram-job-manager-pbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-pbs}"
SRC_URI[aarch64_globus-gram-job-manager-pbs.sha256sum] = "414ddac62bd7049cfe4cb4437ec31958776d6e91376ccf8290c3a706e8d2ce28"

URI_aarch64_globus-gram-job-manager-pbs-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-pbs-setup-poll-3.1-20.el10_2.noarch.rpm;name=aarch64_globus-gram-job-manager-pbs-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-pbs-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-pbs-setup-poll.sha256sum] = "36e907fca247a6c7095bab3160a49d70a5f7b39ab71b2c7d7eaa251f7199bece"
RPROVIDES:globus-gram-job-manager-pbs-setup-poll:aarch64 = "virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_2"

URI_aarch64_globus-gram-job-manager-pbs-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-pbs-setup-seg-3.1-20.el10_2.aarch64.rpm;name=aarch64_globus-gram-job-manager-pbs-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-pbs-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-pbs-setup-seg.sha256sum] = "319f2fab08e04562e9dcd836bc3db7b34dacb9a401cd2c4431a4f57deb10c3c2"
RPROVIDES:globus-gram-job-manager-pbs-setup-seg:aarch64 = "virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_2"

RDEPENDS:globus-gram-job-manager-pbs:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-libs \
 virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_2.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-pbs:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-libs \
 virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_2 \
"
RDEPENDS:globus-gram-job-manager-pbs-setup-poll = " \
 bash \
 globus-gram-job-manager-pbs \
 globus-gram-job-manager-scripts \
 "
RDEPENDS:globus-gram-job-manager-pbs-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-pbs \
 globus-gram-job-manager-scripts \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 systemd \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_2.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_2"
