# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libao"
PV = "1.2.0"
PR = "29.el10"
PACKAGES = " \
 libao \
 libao-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libao-1.2.0-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb02d438f60fac31a98f18c95ca91dde6a03ace03b8bdb88f3c7f787e66e0a72"

URI_x86_64_v2_libao = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libao-1.2.0-29.el10.x86_64_v2.rpm;name=x86_64_v2_libao;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libao}"
SRC_URI[x86_64_v2_libao.sha256sum] = "fcd995ca4b7faad2ca8361e5a5d74b0cc64da4e8bda6fbbbb68d6c81eddc8df4"

URI_x86_64_v2_libao-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libao-devel-1.2.0-29.el10.x86_64_v2.rpm;name=x86_64_v2_libao-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libao-devel}"
SRC_URI[x86_64_v2_libao-devel.sha256sum] = "f7fcfbf698cf3be86b664139eed26db44bda460d1439f907bd36b23ab92166ac"

URI_aarch64_libao = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libao-1.2.0-29.el10.aarch64.rpm;name=aarch64_libao;unpack=0"
SRC_URI:append = " ${URI_aarch64_libao}"
SRC_URI[aarch64_libao.sha256sum] = "c7c0107f1e992bd874a0662a3bd93eca90b398bdff904de38320bf73f121ad71"

URI_aarch64_libao-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libao-devel-1.2.0-29.el10.aarch64.rpm;name=aarch64_libao-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libao-devel}"
SRC_URI[aarch64_libao-devel.sha256sum] = "4c2522d018b4988bc81e47fb40515f74f5c7ed9ff09288fb9b7674613f24b0a4"

RDEPENDS:libao = " \
 alsa-lib \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:libao-devel = " \
 libao \
 pkgconf-pkg-config \
 "
