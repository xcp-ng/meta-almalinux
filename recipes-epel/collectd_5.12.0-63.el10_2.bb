# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "collectd"
PV = "5.12.0"
PR = "63.el10_2"
PACKAGES = " \
 collectd \
 collectd-amqp \
 collectd-amqp1 \
 collectd-apache \
 collectd-ascent \
 collectd-bind \
 collectd-chrony \
 collectd-curl \
 collectd-curl_xml \
 collectd-dbi \
 collectd-disk \
 collectd-dns \
 collectd-drbd \
 collectd-email \
 collectd-generic-jmx \
 collectd-gps \
 collectd-hugepages \
 collectd-infiniband \
 collectd-ipmi \
 collectd-ipvs \
 collectd-java \
 collectd-lua \
 collectd-mcelog \
 collectd-mdevents \
 collectd-memcachec \
 collectd-modbus \
 collectd-mysql \
 collectd-netlink \
 collectd-nginx \
 collectd-notify_desktop \
 collectd-notify_email \
 collectd-nut \
 collectd-openldap \
 collectd-pinba \
 collectd-ping \
 collectd-postgresql \
 collectd-python \
 collectd-redis \
 collectd-rrdcached \
 collectd-rrdtool \
 collectd-sensors \
 collectd-smart \
 collectd-snmp \
 collectd-snmp_agent \
 collectd-synproxy \
 collectd-utils \
 collectd-varnish \
 collectd-virt \
 collectd-web \
 collectd-write_http \
 collectd-write_kafka \
 collectd-write_prometheus \
 collectd-write_redis \
 collectd-write_riemann \
 collectd-write_sensu \
 collectd-write_syslog \
 collectd-write_tsdb \
 collectd-zookeeper \
 libcollectdclient \
 libcollectdclient-devel \
 perl-Collectd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/collectd-5.12.0-63.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddcb7460bf50b64060f108908e24186505111d4a0358a8dfd157ea214cb43538"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - collectd-gps: libgps.so.31()(64bit)
# - collectd-nut: libupsclient.so.6()(64bit)

URI_x86_64_v2_collectd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd}"
SRC_URI[x86_64_v2_collectd.sha256sum] = "57f69995aaf3187f86e50b354bd1f61bd6509f393b8aeea66f007ad1d3f84a2b"

URI_x86_64_v2_collectd-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-amqp-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-amqp}"
SRC_URI[x86_64_v2_collectd-amqp.sha256sum] = "6be980ad50b8994182c64779aead50e38bb677782c06efffb192e2dfcc7b29e0"

URI_x86_64_v2_collectd-amqp1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-amqp1-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-amqp1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-amqp1}"
SRC_URI[x86_64_v2_collectd-amqp1.sha256sum] = "a99d27ac41551c131c426b8a41e09ab718883ebf5c1b34107b0f6e77a26fa365"

URI_x86_64_v2_collectd-apache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-apache-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-apache}"
SRC_URI[x86_64_v2_collectd-apache.sha256sum] = "9cdb4b95fed1699a48374c2e95fa402d7bd721e537b099939e87e95175c1fc44"

URI_x86_64_v2_collectd-ascent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ascent-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ascent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ascent}"
SRC_URI[x86_64_v2_collectd-ascent.sha256sum] = "7509f5ea2b2e02c8bd5fe5220e20eddf8b33a00b35744eecef06aa70545bdd0b"

URI_x86_64_v2_collectd-bind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-bind-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-bind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-bind}"
SRC_URI[x86_64_v2_collectd-bind.sha256sum] = "f96ab1d31b06555a1be864477bba1e30965143cd86c1ca649d54bd11ac1e7c5c"

URI_x86_64_v2_collectd-chrony = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-chrony-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-chrony;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-chrony}"
SRC_URI[x86_64_v2_collectd-chrony.sha256sum] = "1de78593c12d3924593c11fc8582891fa8b5bf1930cd87013f521c8c84068a7c"

URI_x86_64_v2_collectd-curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-curl-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-curl}"
SRC_URI[x86_64_v2_collectd-curl.sha256sum] = "5d92f2476166bc400d9b19b24dabfe70fcc2f1c986f7e76a22fcc92c26ee9204"

URI_x86_64_v2_collectd-curl_xml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-curl_xml-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-curl_xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-curl_xml}"
SRC_URI[x86_64_v2_collectd-curl_xml.sha256sum] = "2ca000f33ab06bc9b178a1951acae9152797c541b634d803881d9cc62eb476d0"

URI_x86_64_v2_collectd-dbi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-dbi-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-dbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-dbi}"
SRC_URI[x86_64_v2_collectd-dbi.sha256sum] = "5a1f576967f6a1fb35f29688033e19ce5578493a3ec99079a5ea4dc01f704c6a"

URI_x86_64_v2_collectd-disk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-disk-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-disk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-disk}"
SRC_URI[x86_64_v2_collectd-disk.sha256sum] = "5e5122137fc0bc6e863bd2aae9e51b6e68c1eca72f1f6ec84da7e7209fe74b19"

URI_x86_64_v2_collectd-dns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-dns-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-dns}"
SRC_URI[x86_64_v2_collectd-dns.sha256sum] = "e2ee9eaf44760214d8fd9737e9706abce8290ff374572d24a01ad8a4150ba234"

URI_x86_64_v2_collectd-drbd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-drbd-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-drbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-drbd}"
SRC_URI[x86_64_v2_collectd-drbd.sha256sum] = "6b648516c529652ff2cce4cbca113f0b6a88b4d6e22aa802cc7ea04173627120"

URI_x86_64_v2_collectd-email = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-email-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-email;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-email}"
SRC_URI[x86_64_v2_collectd-email.sha256sum] = "3480c1452fb7156f4b98c7a9872389994733b2862528f78524ed358f9d26815f"

URI_x86_64_v2_collectd-generic-jmx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-generic-jmx-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-generic-jmx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-generic-jmx}"
SRC_URI[x86_64_v2_collectd-generic-jmx.sha256sum] = "1f958456e32d2b81db3a3b56c3500b00d42da69203ccb061ed6241e21dfd867f"

URI_x86_64_v2_collectd-gps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-gps-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-gps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-gps}"
SRC_URI[x86_64_v2_collectd-gps.sha256sum] = "576b6b229983e779237f574d11347a84f288fc201acc9df8dd7c98e5cb4f1512"

URI_x86_64_v2_collectd-hugepages = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-hugepages-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-hugepages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-hugepages}"
SRC_URI[x86_64_v2_collectd-hugepages.sha256sum] = "5d8c108504430e2e2ace3582179bffd9cc0bc968df2c65a7487e7273d75bf32d"

URI_x86_64_v2_collectd-infiniband = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-infiniband-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-infiniband;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-infiniband}"
SRC_URI[x86_64_v2_collectd-infiniband.sha256sum] = "f213e837f80b65b2505041e4bcf48d662ac6e9d1f2d5d1339691372876c8aaf8"

URI_x86_64_v2_collectd-ipmi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ipmi-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ipmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ipmi}"
SRC_URI[x86_64_v2_collectd-ipmi.sha256sum] = "2b687aa0a97660188f18f83e1db2c4fa4657c3c596bdef8ea7e5c4584984e0bd"

URI_x86_64_v2_collectd-ipvs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ipvs-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ipvs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ipvs}"
SRC_URI[x86_64_v2_collectd-ipvs.sha256sum] = "67f3e235f7017a2c5dfc62b405b208faac2cd1bc2deb4cee97acdb12b7fcb70e"

URI_x86_64_v2_collectd-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-java-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-java}"
SRC_URI[x86_64_v2_collectd-java.sha256sum] = "d91549455669edb319857054747f50fdbbbbb288c38ea2a57ae8af7a80e0f8da"

URI_x86_64_v2_collectd-lua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-lua-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-lua}"
SRC_URI[x86_64_v2_collectd-lua.sha256sum] = "d784e7fd434bcfc507fa6375f2138da8770e765ab419361df0fba4bd1be77598"

URI_x86_64_v2_collectd-mcelog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-mcelog-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-mcelog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-mcelog}"
SRC_URI[x86_64_v2_collectd-mcelog.sha256sum] = "69b0c79084dd6d73d6c6fbf78075111736d9c4bb22bec0c591cc13747538a52f"

URI_x86_64_v2_collectd-mdevents = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-mdevents-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-mdevents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-mdevents}"
SRC_URI[x86_64_v2_collectd-mdevents.sha256sum] = "4077f7405e2391765a229b6ff168de868da8dd3a767fea44e83a272f02394813"

URI_x86_64_v2_collectd-memcachec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-memcachec-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-memcachec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-memcachec}"
SRC_URI[x86_64_v2_collectd-memcachec.sha256sum] = "e61b43ed59d92f6ec3db48bdfcc1f08296201c227c30d9f217f2e253d5562006"

URI_x86_64_v2_collectd-modbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-modbus-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-modbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-modbus}"
SRC_URI[x86_64_v2_collectd-modbus.sha256sum] = "86b48f39cf7dfddcbcc84229355c3de680f813d9f8ca64cc035d3968eae8c671"

URI_x86_64_v2_collectd-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-mysql-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-mysql}"
SRC_URI[x86_64_v2_collectd-mysql.sha256sum] = "2ca65d01496c03f2eca41dbe6a226b9227bbab85d63b3b777234185baa622da1"

URI_x86_64_v2_collectd-netlink = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-netlink-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-netlink;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-netlink}"
SRC_URI[x86_64_v2_collectd-netlink.sha256sum] = "31a06287cdf94915df80b59e592323dbbc39b511e59a9c0889ffe9a0acbdeacc"

URI_x86_64_v2_collectd-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-nginx-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-nginx}"
SRC_URI[x86_64_v2_collectd-nginx.sha256sum] = "6da5326232ef0e0215d17683967e214a43dbd58713a41f10f925715f2b69f533"

URI_x86_64_v2_collectd-notify_desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-notify_desktop-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-notify_desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-notify_desktop}"
SRC_URI[x86_64_v2_collectd-notify_desktop.sha256sum] = "fea6f00a844215457ef6b8b82bb064c738483c506d0cbf953b094cdb319a694d"

URI_x86_64_v2_collectd-notify_email = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-notify_email-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-notify_email;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-notify_email}"
SRC_URI[x86_64_v2_collectd-notify_email.sha256sum] = "2c7cb9fe54d80497d2c877fa712969dd0f84927a46df3844257b3b36c25ef5fa"

URI_x86_64_v2_collectd-nut = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-nut-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-nut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-nut}"
SRC_URI[x86_64_v2_collectd-nut.sha256sum] = "4495064dee2afa9016439c6f9d982d2512b5e3976c705bfd2633b6aa32fdec25"

URI_x86_64_v2_collectd-openldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-openldap-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-openldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-openldap}"
SRC_URI[x86_64_v2_collectd-openldap.sha256sum] = "a89575652d8cfdf8308367a828ead6a4882d7bd3ded5ff705f5776973591a310"

URI_x86_64_v2_collectd-pinba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-pinba-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-pinba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-pinba}"
SRC_URI[x86_64_v2_collectd-pinba.sha256sum] = "59dca4a9ddae53981d2baa4e96383b30efaf52170eccbd3644516fa610df6bc5"

URI_x86_64_v2_collectd-ping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ping-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ping}"
SRC_URI[x86_64_v2_collectd-ping.sha256sum] = "c5aafb0f171bd7914ac447615b2d36d06eafa21d7d8b5b9a2f937cbe36dc260f"

URI_x86_64_v2_collectd-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-postgresql-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-postgresql}"
SRC_URI[x86_64_v2_collectd-postgresql.sha256sum] = "dfa744b210a550edb7386cef28bb842041024b226f51aca5f056f91504ac083b"

URI_x86_64_v2_collectd-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-python-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-python}"
SRC_URI[x86_64_v2_collectd-python.sha256sum] = "66381f7516aa63a1e5cfc5f5eff2155deda3b854b8c7c9cc1f476f769071d336"

URI_x86_64_v2_collectd-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-redis-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-redis}"
SRC_URI[x86_64_v2_collectd-redis.sha256sum] = "fafd302765c5b5e9522d3394c55b2927ba8943d10ae309796bc4ad1878510db1"

URI_x86_64_v2_collectd-rrdcached = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-rrdcached-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-rrdcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-rrdcached}"
SRC_URI[x86_64_v2_collectd-rrdcached.sha256sum] = "2ab92c3db3cbea6c1d46004ff672fa1fcdf673f062840a9411b95fed0351c98f"

URI_x86_64_v2_collectd-rrdtool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-rrdtool-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-rrdtool}"
SRC_URI[x86_64_v2_collectd-rrdtool.sha256sum] = "02563d27b6720bf587f776a874a2b2d7a7255d2ae3a549c92e5e4a481e2be176"

URI_x86_64_v2_collectd-sensors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-sensors-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-sensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-sensors}"
SRC_URI[x86_64_v2_collectd-sensors.sha256sum] = "144755e0dcc8ee03533a384a155ead88a301cb9d63c657aaf0d1ea1c0ac449c7"

URI_x86_64_v2_collectd-smart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-smart-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-smart}"
SRC_URI[x86_64_v2_collectd-smart.sha256sum] = "4eecbcc11321fd654866af2e4a11acfc514414ad47ff6eb0b01ee033bbcfb108"

URI_x86_64_v2_collectd-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-snmp-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-snmp}"
SRC_URI[x86_64_v2_collectd-snmp.sha256sum] = "f7b7f1eb4b86cb01196c60c2ddfa643def9234aaebc178857bbdec162e241c83"

URI_x86_64_v2_collectd-snmp_agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-snmp_agent-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-snmp_agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-snmp_agent}"
SRC_URI[x86_64_v2_collectd-snmp_agent.sha256sum] = "88a20e7d348fa6601e327ceabca514cf789168a6d5ca0c99d01899d02a6f52ff"

URI_x86_64_v2_collectd-synproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-synproxy-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-synproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-synproxy}"
SRC_URI[x86_64_v2_collectd-synproxy.sha256sum] = "772ee932a192a5f8a501490a328224fe7daba7830a0f56b4668c16d4531b4ac6"

URI_x86_64_v2_collectd-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-utils-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-utils}"
SRC_URI[x86_64_v2_collectd-utils.sha256sum] = "6bf1928f0873a01e5eeb71fb183dda9cfeaade7b94b2118464c1a1839ff622a1"

URI_x86_64_v2_collectd-varnish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-varnish-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-varnish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-varnish}"
SRC_URI[x86_64_v2_collectd-varnish.sha256sum] = "8d50080c8c17572da3b3fb97cc78b7c45731473b85bf517e3c5c50de3b98ed1b"

URI_x86_64_v2_collectd-virt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-virt-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-virt}"
SRC_URI[x86_64_v2_collectd-virt.sha256sum] = "417a1764e1629c3def49ebc44362cf930f9104d26fd45a3f14f708933afca31e"

URI_x86_64_v2_collectd-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-web-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-web}"
SRC_URI[x86_64_v2_collectd-web.sha256sum] = "e122792c538c1d7fe306eb666d364383f7830c598e581380c47ad90426489d78"

URI_x86_64_v2_collectd-write_http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_http-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_http}"
SRC_URI[x86_64_v2_collectd-write_http.sha256sum] = "bc3843497b93c3e8857637451eebaf825c991e245da76a48c0727cdf6e60c91d"

URI_x86_64_v2_collectd-write_kafka = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_kafka-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_kafka}"
SRC_URI[x86_64_v2_collectd-write_kafka.sha256sum] = "8ea42928a420aca5a4f7ef4a2c69fa490688f3faf7d16b3e467025ac19ee0f21"

URI_x86_64_v2_collectd-write_prometheus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_prometheus-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_prometheus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_prometheus}"
SRC_URI[x86_64_v2_collectd-write_prometheus.sha256sum] = "ad46966f79616c70b135a20f4db5eb018f8ff4a39e8eab93b67216e8b8045c1b"

URI_x86_64_v2_collectd-write_redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_redis-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_redis}"
SRC_URI[x86_64_v2_collectd-write_redis.sha256sum] = "02e88c20beee5b9d02cab5283a012aeae9f3422ccbfbe8c9db83d76f145d99fb"

URI_x86_64_v2_collectd-write_riemann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_riemann-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_riemann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_riemann}"
SRC_URI[x86_64_v2_collectd-write_riemann.sha256sum] = "ee01e0c5584bd940b46f406588ab6b1c7f80c391c63f4792bed3c42e676860aa"

URI_x86_64_v2_collectd-write_sensu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_sensu-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_sensu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_sensu}"
SRC_URI[x86_64_v2_collectd-write_sensu.sha256sum] = "5d4215dc4ec81a6ce0beabd9f898e830acc159daeb6be7ae134ead38782b36c1"

URI_x86_64_v2_collectd-write_syslog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_syslog-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_syslog}"
SRC_URI[x86_64_v2_collectd-write_syslog.sha256sum] = "4e5ee06d1f4a316107a273bb15e873514293f739305a15b4706528fca9fbfe3d"

URI_x86_64_v2_collectd-write_tsdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_tsdb-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_tsdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_tsdb}"
SRC_URI[x86_64_v2_collectd-write_tsdb.sha256sum] = "f6a29b99c29527aac466486ff5c57d72011f4599244e27450314cd25f78769e2"

URI_x86_64_v2_collectd-zookeeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-zookeeper-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-zookeeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-zookeeper}"
SRC_URI[x86_64_v2_collectd-zookeeper.sha256sum] = "c1b36494ec163db8da9414a8712c988a521a793de1d119fba0704db3570a7219"

URI_x86_64_v2_libcollectdclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcollectdclient-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcollectdclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcollectdclient}"
SRC_URI[x86_64_v2_libcollectdclient.sha256sum] = "a2b97ed5e0479be4004e19fcc6bf2241a4eb350ff24b922f7167d68ffdecbf0d"

URI_x86_64_v2_libcollectdclient-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcollectdclient-devel-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcollectdclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcollectdclient-devel}"
SRC_URI[x86_64_v2_libcollectdclient-devel.sha256sum] = "14ec89748c8996965bea376196e58ae3093540adf1788d7f4459f34a69885669"

URI_x86_64_v2_perl-Collectd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Collectd-5.12.0-63.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Collectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Collectd}"
SRC_URI[x86_64_v2_perl-Collectd.sha256sum] = "d0e825e489f5093dd3ae87eda05e7206472f036f535fa854b9402a1366c5f994"

URI_aarch64_collectd = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd}"
SRC_URI[aarch64_collectd.sha256sum] = "6776ff785930cb6e351d8dbab2230e58d2de57dfc7912f6cd09f11026db32d4f"

URI_aarch64_collectd-amqp = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-amqp-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-amqp}"
SRC_URI[aarch64_collectd-amqp.sha256sum] = "877f5f220d3790c2e81d03c066ee87473fc308583963c94458203ff25d60c7c0"

URI_aarch64_collectd-amqp1 = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-amqp1-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-amqp1;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-amqp1}"
SRC_URI[aarch64_collectd-amqp1.sha256sum] = "e1b210acad70dd7b55fe4a92ecda02db1c4d1fcc690a7b3a78d2ac716cbf1656"

URI_aarch64_collectd-apache = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-apache-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-apache}"
SRC_URI[aarch64_collectd-apache.sha256sum] = "2d16f51f79867381a399e638a8100c1eaa41c1c832c457a524b88425c63d5ad7"

URI_aarch64_collectd-ascent = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ascent-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-ascent;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ascent}"
SRC_URI[aarch64_collectd-ascent.sha256sum] = "e9a4fd6b39eea9fa4651f461d0abe13965297ab94b44a0d30ad9928333eed710"

URI_aarch64_collectd-bind = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-bind-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-bind;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-bind}"
SRC_URI[aarch64_collectd-bind.sha256sum] = "f23ca57d98f2b03f00227290a0a47fe6948c3bf5ea964b395a0645e7a23ca6db"

URI_aarch64_collectd-chrony = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-chrony-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-chrony;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-chrony}"
SRC_URI[aarch64_collectd-chrony.sha256sum] = "e0bf7151442ab012fedfbffab7bba6ad8467b5c62bf80f5092dbc164e3668a61"

URI_aarch64_collectd-curl = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-curl-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-curl}"
SRC_URI[aarch64_collectd-curl.sha256sum] = "92a5e14b5d2a71fe37691a39abce08e7d279320b64dbc231e688392312b12d63"

URI_aarch64_collectd-curl_xml = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-curl_xml-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-curl_xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-curl_xml}"
SRC_URI[aarch64_collectd-curl_xml.sha256sum] = "70fa09965d9d4aaaba307fd65def7bee6c987dc4a62122946371419174714935"

URI_aarch64_collectd-dbi = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-dbi-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-dbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-dbi}"
SRC_URI[aarch64_collectd-dbi.sha256sum] = "3150214d8413610ca7ddfb341025c76987f096a4b5c69fb1cdef8cc0265e5294"

URI_aarch64_collectd-disk = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-disk-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-disk;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-disk}"
SRC_URI[aarch64_collectd-disk.sha256sum] = "8f697aa4b6863770a72f95fa43e4a1470b7de3a6b9bca7b9f874825f8920efc6"

URI_aarch64_collectd-dns = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-dns-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-dns}"
SRC_URI[aarch64_collectd-dns.sha256sum] = "76db908c31f2f50563ea373cc6bbaa3c9d55769ca1c61e52688c9472e73b74b6"

URI_aarch64_collectd-drbd = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-drbd-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-drbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-drbd}"
SRC_URI[aarch64_collectd-drbd.sha256sum] = "974f50a7af361eac56dab1ff889353265d3321c406b24cf9009ad357916f46a9"

URI_aarch64_collectd-email = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-email-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-email;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-email}"
SRC_URI[aarch64_collectd-email.sha256sum] = "026a63abfc6150ecd396a99c764cd117f59b8301759c61c554880007e934ab4d"

URI_aarch64_collectd-generic-jmx = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-generic-jmx-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-generic-jmx;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-generic-jmx}"
SRC_URI[aarch64_collectd-generic-jmx.sha256sum] = "acad7899fc04cf078a50c8fe62a0d081fb00804f161dbc5b6100e4f1b0ce873b"

URI_aarch64_collectd-gps = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-gps-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-gps;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-gps}"
SRC_URI[aarch64_collectd-gps.sha256sum] = "c418653b5e55684cf872d395b2e03072c9af341772e0502183c45cde5622082e"

URI_aarch64_collectd-hugepages = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-hugepages-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-hugepages;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-hugepages}"
SRC_URI[aarch64_collectd-hugepages.sha256sum] = "2ed3633e11883027e824dc286057cf1c49f15a4af8f5a79e61a0448516921aba"

URI_aarch64_collectd-infiniband = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-infiniband-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-infiniband;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-infiniband}"
SRC_URI[aarch64_collectd-infiniband.sha256sum] = "16289bca10de2d009c0794f2f8ee5f964342656320648d5eb6192755ece63327"

URI_aarch64_collectd-ipmi = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ipmi-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-ipmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ipmi}"
SRC_URI[aarch64_collectd-ipmi.sha256sum] = "c1f4451b5a01fb3349ddc723e25f387b996b5d9cbc46c86b246ece6caf141b51"

URI_aarch64_collectd-ipvs = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ipvs-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-ipvs;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ipvs}"
SRC_URI[aarch64_collectd-ipvs.sha256sum] = "445608172020e0543ae849211ec2ab32a465501c17044c4bb62fe020860d0c68"

URI_aarch64_collectd-java = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-java-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-java}"
SRC_URI[aarch64_collectd-java.sha256sum] = "b7b95ea55899a2ea02e03ed551faf33626a560e8bf3ac2b9286c607ba79174af"

URI_aarch64_collectd-lua = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-lua-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-lua}"
SRC_URI[aarch64_collectd-lua.sha256sum] = "d5469dffa643bd6ee0fbfa72c3d1f1ddcbcfe7a3db44b4e82ae7d3ef1cf55c4e"

URI_aarch64_collectd-mcelog = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-mcelog-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-mcelog;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-mcelog}"
SRC_URI[aarch64_collectd-mcelog.sha256sum] = "9fdc2a1dc8b391c14573cf22bfbaabbdbc495b8f23a00da8c4977779513c76ce"

URI_aarch64_collectd-mdevents = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-mdevents-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-mdevents;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-mdevents}"
SRC_URI[aarch64_collectd-mdevents.sha256sum] = "6d14988fe699e29d3b12d5ac48a4b9759748da539e85f93fdabab47aa39efacc"

URI_aarch64_collectd-memcachec = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-memcachec-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-memcachec;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-memcachec}"
SRC_URI[aarch64_collectd-memcachec.sha256sum] = "9ca1704ab10fd3133c7291dd8f8607aa156430f29cb8e77414f372cbf05a8fd8"

URI_aarch64_collectd-modbus = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-modbus-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-modbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-modbus}"
SRC_URI[aarch64_collectd-modbus.sha256sum] = "f12e2040d73ab78e5a0dbb9d1bab15d5b522ed9896aa2a9f0ab4f9a2ac4eb97e"

URI_aarch64_collectd-mysql = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-mysql-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-mysql}"
SRC_URI[aarch64_collectd-mysql.sha256sum] = "6ab37e8fdfc4136a3fc518afa5be7756050b039403c733133cd17f2a9e354dbb"

URI_aarch64_collectd-netlink = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-netlink-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-netlink;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-netlink}"
SRC_URI[aarch64_collectd-netlink.sha256sum] = "1a7cfa382eee49f87e839ef3c467e42fbc7f0ff6166b51d7dd6c645a869bfff1"

URI_aarch64_collectd-nginx = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-nginx-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-nginx}"
SRC_URI[aarch64_collectd-nginx.sha256sum] = "8ee6597479cdc31f5d2eb8e2dc334e87253db4dbeee55b86aec3b790c39cf101"

URI_aarch64_collectd-notify_desktop = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-notify_desktop-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-notify_desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-notify_desktop}"
SRC_URI[aarch64_collectd-notify_desktop.sha256sum] = "2df7914affae2715a81ef7de6d3bb08aa873543874f350b983459f2a7e65573b"

URI_aarch64_collectd-notify_email = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-notify_email-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-notify_email;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-notify_email}"
SRC_URI[aarch64_collectd-notify_email.sha256sum] = "45dad8f549e6bd3d47c63161c1c5d3c748603d0023aa2594e43a41f8d50732c2"

URI_aarch64_collectd-nut = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-nut-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-nut;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-nut}"
SRC_URI[aarch64_collectd-nut.sha256sum] = "2311cf2c3efe1b9bc5acd3dd2254576de620dab352a9740a2cd1b7cfd2f49ef4"

URI_aarch64_collectd-openldap = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-openldap-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-openldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-openldap}"
SRC_URI[aarch64_collectd-openldap.sha256sum] = "bfd8773063551c8857f0131f34074f8131861d0ceb6129fe7a21deda4a4816ba"

URI_aarch64_collectd-pinba = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-pinba-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-pinba;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-pinba}"
SRC_URI[aarch64_collectd-pinba.sha256sum] = "a5be7b5eea87598002c66e381014a3687f579f2d241fb20d7add2859f5c1d328"

URI_aarch64_collectd-ping = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ping-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ping}"
SRC_URI[aarch64_collectd-ping.sha256sum] = "9b0ee142ebb20dbb99aacbe158c275995c01a68464ae5993e646b9a2e3ff7a62"

URI_aarch64_collectd-postgresql = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-postgresql-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-postgresql}"
SRC_URI[aarch64_collectd-postgresql.sha256sum] = "aaeddec017ab50a88b3b898a8615cf6ce4ba5bd607065257a44c76d0bde33c96"

URI_aarch64_collectd-python = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-python-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-python}"
SRC_URI[aarch64_collectd-python.sha256sum] = "940f93ebda77a936db3f83c5dfd3dfe2b910f62880b5df493ad9f0795edb4c71"

URI_aarch64_collectd-redis = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-redis-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-redis}"
SRC_URI[aarch64_collectd-redis.sha256sum] = "529a0c5a8c521a6f9fa179740db6b854ef00dae76b38b5f51f71bcd0380bc853"

URI_aarch64_collectd-rrdcached = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-rrdcached-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-rrdcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-rrdcached}"
SRC_URI[aarch64_collectd-rrdcached.sha256sum] = "b9d2cb1a41660d06405e72fef142f470cde3db515b01419a3c96dabe748899c5"

URI_aarch64_collectd-rrdtool = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-rrdtool-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-rrdtool}"
SRC_URI[aarch64_collectd-rrdtool.sha256sum] = "644fdbdb0b12cd1c8939d45dd99831cb6ed8244f5a026127f2bfa57153881896"

URI_aarch64_collectd-sensors = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-sensors-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-sensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-sensors}"
SRC_URI[aarch64_collectd-sensors.sha256sum] = "6558491144f7ac40796a54eeda4525225a44e27fac88fdb20c96e7779d9af748"

URI_aarch64_collectd-smart = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-smart-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-smart}"
SRC_URI[aarch64_collectd-smart.sha256sum] = "14ac9a881acb9dec9806a2bf8898b3d3fb63892dc3d86d59721ac5a514fbd37d"

URI_aarch64_collectd-snmp = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-snmp-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-snmp}"
SRC_URI[aarch64_collectd-snmp.sha256sum] = "1be9955b37740d15b4edb5cfc5c41207bcfe4be09e97bb9a64a2fc08c0920190"

URI_aarch64_collectd-snmp_agent = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-snmp_agent-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-snmp_agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-snmp_agent}"
SRC_URI[aarch64_collectd-snmp_agent.sha256sum] = "0e3b59c472e21e54c250d877bb3f981ae899a911f53fa8fd4f31c99b5c3aa5b6"

URI_aarch64_collectd-synproxy = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-synproxy-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-synproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-synproxy}"
SRC_URI[aarch64_collectd-synproxy.sha256sum] = "aa45b44bd75038bea18bb5e1358c6c128176a97101395cf82b939066d3e5717f"

URI_aarch64_collectd-utils = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-utils-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-utils}"
SRC_URI[aarch64_collectd-utils.sha256sum] = "461bf09f2921c1a2441f6c14210d29aed2f1ba5c593070cf5ab9aa51bd426676"

URI_aarch64_collectd-varnish = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-varnish-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-varnish;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-varnish}"
SRC_URI[aarch64_collectd-varnish.sha256sum] = "d792b489e07671f168a8a82d3498b776567f00faacaa64940965c8fd9ab2fbdf"

URI_aarch64_collectd-virt = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-virt-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-virt}"
SRC_URI[aarch64_collectd-virt.sha256sum] = "70997f43aa22894217b4307e36a24e75f5963a2f6fb82b201116428e8ac9ea0f"

URI_aarch64_collectd-web = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-web-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-web}"
SRC_URI[aarch64_collectd-web.sha256sum] = "ffac61343f074d4eb1fa3c869a37964dc232dad46cd390d51027ef6d021ac0a0"

URI_aarch64_collectd-write_http = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_http-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-write_http;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_http}"
SRC_URI[aarch64_collectd-write_http.sha256sum] = "0e1b0066d186614495c2af2055b29a201269948b6bd20b034c04b919440f48d6"

URI_aarch64_collectd-write_kafka = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_kafka-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-write_kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_kafka}"
SRC_URI[aarch64_collectd-write_kafka.sha256sum] = "8d1d3c16355deabccb3af20b411f09f009ee7634f27c0b2f52734ccffc3effcf"

URI_aarch64_collectd-write_prometheus = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_prometheus-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-write_prometheus;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_prometheus}"
SRC_URI[aarch64_collectd-write_prometheus.sha256sum] = "5fd650bc04497d0119b435f04f828389f8287c65e606cf3524f67b74f9c8b2bb"

URI_aarch64_collectd-write_redis = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_redis-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-write_redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_redis}"
SRC_URI[aarch64_collectd-write_redis.sha256sum] = "c8bbef8d5a5b61228f3cccb7cc4de2ed025ee697d7fd6b17df8cc03dfba4bde0"

URI_aarch64_collectd-write_riemann = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_riemann-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-write_riemann;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_riemann}"
SRC_URI[aarch64_collectd-write_riemann.sha256sum] = "e3db633f6a51f8345cedc94b1d0e8813714246effbfb09fd0be7df554c503c8a"

URI_aarch64_collectd-write_sensu = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_sensu-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-write_sensu;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_sensu}"
SRC_URI[aarch64_collectd-write_sensu.sha256sum] = "74dd7130b1e74b4ef120d32e321d286a0e1535cf44ed8720692ae4aa4d4a1f21"

URI_aarch64_collectd-write_syslog = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_syslog-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-write_syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_syslog}"
SRC_URI[aarch64_collectd-write_syslog.sha256sum] = "642b7db26d97815e3d72b51d37cb24f8bb0328ee1b84217f7a65667c9ab2cd34"

URI_aarch64_collectd-write_tsdb = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_tsdb-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-write_tsdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_tsdb}"
SRC_URI[aarch64_collectd-write_tsdb.sha256sum] = "d71e4be11b32f6e532e8d3ad44e53e65cb166f465ef2b80ba1758329a6668a2b"

URI_aarch64_collectd-zookeeper = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-zookeeper-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_collectd-zookeeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-zookeeper}"
SRC_URI[aarch64_collectd-zookeeper.sha256sum] = "9a3ef6862db1e0a5643c8d54ca72189ba503539ee6524635bc3bbecd0c2dae24"

URI_aarch64_libcollectdclient = "${EPEL_MIRROR}/aarch64/Packages/l/libcollectdclient-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_libcollectdclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcollectdclient}"
SRC_URI[aarch64_libcollectdclient.sha256sum] = "138f024307af27ea5ab3d0137d8055e3804e8220e7c23fd49fb6c86461cc6fdf"

URI_aarch64_libcollectdclient-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcollectdclient-devel-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_libcollectdclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcollectdclient-devel}"
SRC_URI[aarch64_libcollectdclient-devel.sha256sum] = "55dfe04a01379d8e5e1788bada3320251b88915aad3297fcf41220337d793d16"

URI_aarch64_perl-Collectd = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Collectd-5.12.0-63.el10_2.aarch64.rpm;name=aarch64_perl-Collectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Collectd}"
SRC_URI[aarch64_perl-Collectd.sha256sum] = "299134713bdc4d49a4dfc4805e989f1e46befa40a2d7cc5d8dd5b0ecb91cc83c"

RDEPENDS:collectd = " \
 bash \
 glibc \
 libgcrypt \
 libgpg-error \
 libmnl \
 systemd \
 "
RDEPENDS:collectd-amqp = " \
 collectd \
 glibc \
 librabbitmq \
 "
RDEPENDS:collectd-amqp1 = " \
 collectd \
 glibc \
 qpid-proton-c \
 "
RDEPENDS:collectd-apache = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-ascent = " \
 collectd \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-bind = " \
 collectd \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-chrony = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-curl = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-curl_xml = " \
 collectd \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-dbi = " \
 collectd \
 glibc \
 libdbi \
 "
RDEPENDS:collectd-disk = " \
 collectd \
 glibc \
 systemd-libs \
 "
RDEPENDS:collectd-dns = " \
 collectd \
 glibc \
 libpcap \
 "
RDEPENDS:collectd-drbd = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-email = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-generic-jmx = " \
 collectd \
 "
RDEPENDS:collectd-gps:x86_64_v2 = " \
 collectd \
 glibc \
"
RDEPENDS:collectd-gps:aarch64 = " \
 collectd \
 glibc \
 gpsd-libs \
"
RDEPENDS:collectd-hugepages = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-infiniband = " \
 glibc \
 "
RDEPENDS:collectd-ipmi = " \
 OpenIPMI-libs \
 collectd \
 glibc \
 "
RDEPENDS:collectd-ipvs = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-java = " \
 collectd \
 glibc \
 java-21-openjdk-headless \
 "
RDEPENDS:collectd-lua = " \
 collectd \
 glibc \
 lua-libs \
 "
RDEPENDS:collectd-mcelog = " \
 collectd \
 glibc \
 libgcc \
 "
RDEPENDS:collectd-mdevents = " \
 glibc \
 "
RDEPENDS:collectd-memcachec = " \
 collectd \
 glibc \
 libmemcached-awesome \
 "
RDEPENDS:collectd-modbus = " \
 collectd \
 glibc \
 libmodbus \
 "
RDEPENDS:collectd-mysql = " \
 collectd \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:collectd-netlink = " \
 collectd \
 glibc \
 libmnl \
 "
RDEPENDS:collectd-nginx = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-notify_desktop = " \
 collectd \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libnotify \
 "
RDEPENDS:collectd-notify_email = " \
 collectd \
 glibc \
 libesmtp \
 "
RDEPENDS:collectd-nut:x86_64_v2 = " \
 collectd \
 glibc \
 openssl-libs \
"
RDEPENDS:collectd-nut:aarch64 = " \
 collectd \
 glibc \
 nut-client \
 openssl-libs \
"
RDEPENDS:collectd-openldap = " \
 collectd \
 glibc \
 openldap \
 "
RDEPENDS:collectd-pinba = " \
 collectd \
 glibc \
 protobuf-c \
 "
RDEPENDS:collectd-ping = " \
 collectd \
 glibc \
 liboping \
 "
RDEPENDS:collectd-postgresql = " \
 collectd \
 glibc \
 libpq \
 "
RDEPENDS:collectd-python = " \
 collectd \
 glibc \
 python3-libs \
 "
RDEPENDS:collectd-redis = " \
 collectd \
 glibc \
 hiredis \
 "
RDEPENDS:collectd-rrdcached = " \
 collectd \
 glibc \
 rrdtool \
 "
RDEPENDS:collectd-rrdtool = " \
 collectd \
 glibc \
 rrdtool \
 "
RDEPENDS:collectd-sensors = " \
 collectd \
 glibc \
 lm_sensors-libs \
 "
RDEPENDS:collectd-smart = " \
 collectd \
 glibc \
 libatasmart \
 systemd-libs \
 "
RDEPENDS:collectd-snmp = " \
 collectd \
 glibc \
 net-snmp-libs \
 "
RDEPENDS:collectd-snmp_agent = " \
 collectd \
 glibc \
 net-snmp-agent-libs \
 "
RDEPENDS:collectd-synproxy = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-utils = " \
 collectd \
 glibc \
 libcollectdclient \
 "
RDEPENDS:collectd-varnish = " \
 collectd \
 glibc \
 varnish \
 "
RDEPENDS:collectd-virt = " \
 collectd \
 glibc \
 libvirt-libs \
 libxml2 \
 "
RDEPENDS:collectd-web = " \
 collectd \
 collectd-rrdtool \
 httpd \
 perl-CGI \
 perl-Carp \
 perl-Collectd \
 perl-Config-General \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Temp \
 perl-FindBin \
 perl-HTML-Parser \
 perl-JSON \
 perl-Regexp-Common \
 perl-URI \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 rrdtool-perl \
 "
RDEPENDS:collectd-write_http = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-write_kafka = " \
 collectd \
 glibc \
 librdkafka \
 "
RDEPENDS:collectd-write_prometheus = " \
 collectd \
 glibc \
 libmicrohttpd \
 protobuf-c \
 "
RDEPENDS:collectd-write_redis = " \
 collectd \
 glibc \
 hiredis \
 "
RDEPENDS:collectd-write_riemann = " \
 collectd \
 glibc \
 riemann-c-client \
 "
RDEPENDS:collectd-write_sensu = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-write_syslog = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-write_tsdb = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-zookeeper = " \
 collectd \
 glibc \
 "
RDEPENDS:libcollectdclient = " \
 glibc \
 libgcrypt \
 libgpg-error \
 "
RDEPENDS:libcollectdclient-devel = " \
 libcollectdclient \
 pkgconf-pkg-config \
 "
RDEPENDS:perl-Collectd = " \
 collectd \
 glibc \
 libxcrypt \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
