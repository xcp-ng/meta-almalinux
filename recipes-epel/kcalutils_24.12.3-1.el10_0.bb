# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcalutils"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kcalutils \
 kcalutils-devel \
 kcalutils-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcalutils-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a01399d1e589d58a00ad3899230e48c46dd8781f67651133f0d4cdaee6b412a"

URI_x86_64_v2_kcalutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalutils}"
SRC_URI[x86_64_v2_kcalutils.sha256sum] = "8592ad3ae4d3d12226b70cb56c986c2cfed99192d1a1ed4e407c456cf83746a8"

URI_x86_64_v2_kcalutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalutils-devel}"
SRC_URI[x86_64_v2_kcalutils-devel.sha256sum] = "4795c899f08d783fab161a9da3cbfadce19949347b93b87cee666168d1a964b0"

URI_x86_64_v2_kcalutils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kcalutils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalutils-doc}"
SRC_URI[x86_64_v2_kcalutils-doc.sha256sum] = "0352255842ec83c6d621d9e5f60a8a65435ead0ac042687febcb445cb164484d"

URI_aarch64_kcalutils = "${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kcalutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalutils}"
SRC_URI[aarch64_kcalutils.sha256sum] = "aaab55a8c09c6bb588b7bbeb7fa0da079970eee2fe387ca68abd33bda1365e75"

URI_aarch64_kcalutils-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kcalutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalutils-devel}"
SRC_URI[aarch64_kcalutils-devel.sha256sum] = "3dae6fb604c4ceb44e24ce861291ba7e5d518152e85cc2e0eecfbbfeb10a2de5"

URI_aarch64_kcalutils-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kcalutils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalutils-doc}"
SRC_URI[aarch64_kcalutils-doc.sha256sum] = "c5d1192b47edd721408a55846594ad4689074565e815962be55a8b550cd7dcb4"

RDEPENDS:kcalutils = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcalutils-devel = " \
 cmake-filesystem \
 kcalutils \
 kf6-kcalendarcore-devel \
 kf6-kcoreaddons-devel \
 "
RDEPENDS:kcalutils-doc = " \
 "
