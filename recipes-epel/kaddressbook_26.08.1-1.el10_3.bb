# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaddressbook"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kaddressbook \
 kaddressbook-devel \
 kaddressbook-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kaddressbook-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "583427bd7f2cf90a053e9c2d52f9c0b0a2a7826c5451bc03fbdd3d8083b6580e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook;unpack=0"
SRC_URI[x86_64_v2_kaddressbook.sha256sum] = "723b28f5caf3ead0c6faf53289211266d4bb12f159f8a025f6b3abcf119ec3e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-devel;unpack=0"
SRC_URI[x86_64_v2_kaddressbook-devel.sha256sum] = "60dbc35960e01ad8d3dd0f32e03cf22d960a9c44c35832557f24175a62aae87c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-libs;unpack=0"
SRC_URI[x86_64_v2_kaddressbook-libs.sha256sum] = "bdfa9191ff7994d7dd2f7f5d5b782703986060f2a8c894ceded2cc4244bbc5f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kaddressbook;unpack=0"
SRC_URI[aarch64_kaddressbook.sha256sum] = "09599d27dde27f36070a97bbe49cd3eab0790cf453bc464af2048223188eba35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kaddressbook-devel;unpack=0"
SRC_URI[aarch64_kaddressbook-devel.sha256sum] = "14a9479415360c0427fc9aa5db342665bed2dd28df864bb2ef656c752ac0c321"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kaddressbook-libs;unpack=0"
SRC_URI[aarch64_kaddressbook-libs.sha256sum] = "4997b6ff1fb6726c524dac63a476ad2a3c4753fb22d0aa1a2d0db5f89ea30f0b"

RDEPENDS:kaddressbook = " \
 glibc \
 kaddressbook-libs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kaddressbook-devel = " \
 cmake-filesystem \
 kaddressbook \
 kaddressbook-libs \
 "
RDEPENDS:kaddressbook-libs = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 grantleetheme \
 kaddressbook \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kldap \
 kontactinterface \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
