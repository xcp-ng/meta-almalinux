# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kjobwidgets"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kjobwidgets \
 kf6-kjobwidgets-devel \
 kf6-kjobwidgets-doc \
 kf6-kjobwidgets-html \
 python3-kf6-kjobwidgets \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kjobwidgets-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e92dea91ed7381fcd5baa794237e0fe34235a6730f1b31f676e28a21f885f02"

URI_x86_64_v2_kf6-kjobwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets}"
SRC_URI[x86_64_v2_kf6-kjobwidgets.sha256sum] = "a0473fc07c253f84aea72887c488a8b12658f795d98eb983510fa4d469911a1a"

URI_x86_64_v2_kf6-kjobwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kjobwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-devel}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-devel.sha256sum] = "4026fcabc429b36142849664ac50a8ccc731ff9e5ad0ad822743e6e305b1d7a0"

URI_x86_64_v2_kf6-kjobwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kjobwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-doc}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-doc.sha256sum] = "115f8eb65984277d97b845b052c9827ecfba2bfc3da33aefaa2bb1f4f84f4ca5"

URI_x86_64_v2_kf6-kjobwidgets-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kjobwidgets-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kjobwidgets-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kjobwidgets-html}"
SRC_URI[x86_64_v2_kf6-kjobwidgets-html.sha256sum] = "857939944ab65939676828a6b265c95100f301b32cef4814bfd924428b2f41ca"

URI_x86_64_v2_python3-kf6-kjobwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kjobwidgets-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kjobwidgets}"
SRC_URI[x86_64_v2_python3-kf6-kjobwidgets.sha256sum] = "f0b4c13e24c23f357aa5349a9c1d26ed789da7c9dd0f780c8715fc1bfa6a1268"

URI_aarch64_kf6-kjobwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets}"
SRC_URI[aarch64_kf6-kjobwidgets.sha256sum] = "ee1d5902443e0938db3d4ebe418e598203f6aeafaa2d83c718d4609370a9000f"

URI_aarch64_kf6-kjobwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kjobwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-devel}"
SRC_URI[aarch64_kf6-kjobwidgets-devel.sha256sum] = "c11b6c434954ddf885c12093bac26bb160bd350c3718f7358b361c49d10c5da3"

URI_aarch64_kf6-kjobwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kjobwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-doc}"
SRC_URI[aarch64_kf6-kjobwidgets-doc.sha256sum] = "ca37099524ae06e56fb11ccd764023f639d1f7d51b399b75054308048dec0900"

URI_aarch64_kf6-kjobwidgets-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kjobwidgets-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kjobwidgets-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kjobwidgets-html}"
SRC_URI[aarch64_kf6-kjobwidgets-html.sha256sum] = "bb1281d1342aad6bfef72c5466a961f9396bccc9686fcec9bbece88b62908ae4"

URI_aarch64_python3-kf6-kjobwidgets = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kjobwidgets-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_python3-kf6-kjobwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kjobwidgets}"
SRC_URI[aarch64_python3-kf6-kjobwidgets.sha256sum] = "3f1f6ac9f5c92000a4f16ed98f34d3defdbe949f48961c781953042705c8e446"

RDEPENDS:kf6-kjobwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kjobwidgets-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kjobwidgets \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kjobwidgets-doc = " \
 "
RDEPENDS:kf6-kjobwidgets-html = " \
 "
RDEPENDS:python3-kf6-kjobwidgets = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kjobwidgets \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
