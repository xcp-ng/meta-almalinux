# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pangomm2.48"
PV = "2.50.2"
PR = "4.el10"
PACKAGES = " \
 pangomm2.48 \
 pangomm2.48-devel \
 pangomm2.48-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pangomm2.48-2.50.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52bba55bff6f59f5752c6fb2452f0f7814ba71ca61bf353cc5452fbac7809bf0"

URI_x86_64_v2_pangomm2.48 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pangomm2.48-2.50.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_pangomm2.48;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pangomm2.48}"
SRC_URI[x86_64_v2_pangomm2.48.sha256sum] = "766623c8610f868f81144ad945f87543bbf4eebe8125a9972f65856db3ae8527"

URI_x86_64_v2_pangomm2.48-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pangomm2.48-devel-2.50.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_pangomm2.48-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pangomm2.48-devel}"
SRC_URI[x86_64_v2_pangomm2.48-devel.sha256sum] = "74c63bb2c22f0e367f63f49004807652491b85f9aae9c0e677965ce3dfe3e4a5"

URI_x86_64_v2_pangomm2.48-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pangomm2.48-doc-2.50.2-4.el10.noarch.rpm;name=x86_64_v2_pangomm2.48-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pangomm2.48-doc}"
SRC_URI[x86_64_v2_pangomm2.48-doc.sha256sum] = "58549f99c1ca52bf0060c8ecf0110d1dd74f6fe123a35f1e7e75e16fca883a16"

URI_aarch64_pangomm2.48 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pangomm2.48-2.50.2-4.el10.aarch64.rpm;name=aarch64_pangomm2.48;unpack=0"
SRC_URI:append = " ${URI_aarch64_pangomm2.48}"
SRC_URI[aarch64_pangomm2.48.sha256sum] = "20aaf7e82ef849a097063b67dd84a707e24b00df11890582f6dd035dbbe0064c"

URI_aarch64_pangomm2.48-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pangomm2.48-devel-2.50.2-4.el10.aarch64.rpm;name=aarch64_pangomm2.48-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pangomm2.48-devel}"
SRC_URI[aarch64_pangomm2.48-devel.sha256sum] = "c2057e35548163a0143c68abe8ace82008be06b73fb4cf3ca05fe91cd5223bdb"

URI_aarch64_pangomm2.48-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pangomm2.48-doc-2.50.2-4.el10.noarch.rpm;name=aarch64_pangomm2.48-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pangomm2.48-doc}"
SRC_URI[aarch64_pangomm2.48-doc.sha256sum] = "58549f99c1ca52bf0060c8ecf0110d1dd74f6fe123a35f1e7e75e16fca883a16"

RDEPENDS:pangomm2.48 = " \
 cairomm1.16 \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 pango \
 "
RDEPENDS:pangomm2.48-devel = " \
 cairomm1.16-devel \
 glibmm2.68-devel \
 pango-devel \
 pangomm2.48 \
 pkgconf-pkg-config \
 "
RDEPENDS:pangomm2.48-doc = " \
 glibmm2.68-doc \
 libsigc++30-doc \
 pangomm2.48 \
 "
