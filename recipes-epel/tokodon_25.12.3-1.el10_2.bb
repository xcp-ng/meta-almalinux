# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tokodon"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 tokodon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tokodon-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e49cc1e81abc0128dccc8dc39bb75ca017563583cecb654ebea806690994b262"

URI_x86_64_v2_tokodon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tokodon-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tokodon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tokodon}"
SRC_URI[x86_64_v2_tokodon.sha256sum] = "ef8b2b3ae81b1f782dc68f8f379b914b7b75328ecaf3187844a9facb76910428"

URI_aarch64_tokodon = "${EPEL_MIRROR}/aarch64/Packages/t/tokodon-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_tokodon;unpack=0"
SRC_URI:append = " ${URI_aarch64_tokodon}"
SRC_URI[aarch64_tokodon.sha256sum] = "81dffda2d67fd3b92caae15e0988e82d5a74f9eee8702862c75d690948513a0a"

RDEPENDS:tokodon = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-sonnet \
 kunifiedpush \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 qt6-qtwebview \
 qtkeychain-qt6 \
 "
