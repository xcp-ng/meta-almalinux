# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valkey"
PV = "8.0.7"
PR = "1.el10_1"
PACKAGES = " \
 valkey \
 valkey-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valkey-8.0.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80e422da309b80c381b24564f2dfff1266bacd5e7d572dc7848013d79e220233"

URI_x86_64_v2_valkey = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-8.0.7-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_valkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valkey}"
SRC_URI[x86_64_v2_valkey.sha256sum] = "7523cdc0ff74920d5862072808db5d1f52379f7b0f58d4ca1ebd6ee452b917c4"

URI_x86_64_v2_valkey-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-devel-8.0.7-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_valkey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valkey-devel}"
SRC_URI[x86_64_v2_valkey-devel.sha256sum] = "b9b46abafba2b793b671fe20c4b2b21859627f03e474c49a69e8a7625b5304b5"

URI_aarch64_valkey = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-8.0.7-1.el10_1.aarch64.rpm;name=aarch64_valkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_valkey}"
SRC_URI[aarch64_valkey.sha256sum] = "c309c907c613b6fe8db76511743ae2c923d2aa920e401b68ea2ea29ef2497731"

URI_aarch64_valkey-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-devel-8.0.7-1.el10_1.aarch64.rpm;name=aarch64_valkey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_valkey-devel}"
SRC_URI[aarch64_valkey-devel.sha256sum] = "45c850e66163f8b2046951f2455a0c6a36b2c9276d945cda92498aee3a439f50"

RDEPENDS:valkey = " \
 bash \
 glibc \
 logrotate \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:valkey-devel = " \
 "
