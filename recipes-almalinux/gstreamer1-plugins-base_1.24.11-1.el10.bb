# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-base"
PV = "1.24.11"
PR = "1.el10"
PACKAGES = " \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 gstreamer1-plugins-base-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-base-1.24.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f99e44a7de941cee74565990e6343579f42996746e0b74313966aa95ebb0914f"

URI_x86_64_v2_gstreamer1-plugins-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-1.24.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base.sha256sum] = "8e8e9a0ecf6fe722b1bc3cb65f87110bcaf0c479a6e57a5cdc1d4692c757ff31"

URI_x86_64_v2_gstreamer1-plugins-base-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-devel-1.24.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base-devel}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-devel.sha256sum] = "5a531cbee08c7afe1e3e8ffe09a5bbaf740946e3965e8eb473e94c08e68ff627"

URI_x86_64_v2_gstreamer1-plugins-base-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-tools-1.24.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base-tools}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-tools.sha256sum] = "0dd76e05926303e979f9ddc598b081530ab1bc0f0e943a0a4f555b42e750ba1b"

URI_aarch64_gstreamer1-plugins-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-1.24.11-1.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base}"
SRC_URI[aarch64_gstreamer1-plugins-base.sha256sum] = "e0e1ef900509725cb8da4cbcbc5d84f7d5b7071152ca2eeead83e968c0ddf133"

URI_aarch64_gstreamer1-plugins-base-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-devel-1.24.11-1.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base-devel}"
SRC_URI[aarch64_gstreamer1-plugins-base-devel.sha256sum] = "96fa13bc043619a76166612f25d95d2a7042c618411d45453eda63a53540e2f3"

URI_aarch64_gstreamer1-plugins-base-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-tools-1.24.11-1.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base-tools}"
SRC_URI[aarch64_gstreamer1-plugins-base-tools.sha256sum] = "ef17af0d44ecd4d611491e00d03d0e4946d73e85ef16571005445d2bf09cb38b"

RDEPENDS:gstreamer1-plugins-base = " \
 alsa-lib \
 cairo \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 iso-codes \
 libX11 \
 libX11-xcb \
 libXext \
 libXi \
 libXv \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libgudev \
 libjpeg-turbo \
 libogg \
 libpng \
 libtheora \
 libvorbis \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxcb \
 mesa-libgbm \
 opus \
 orc \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-base-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 libX11-devel \
 libdrm-devel \
 libglvnd-devel \
 libgudev-devel \
 mesa-libgbm-devel \
 orc-devel \
 pkgconf-pkg-config \
 wayland-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:gstreamer1-plugins-base-tools = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 "
