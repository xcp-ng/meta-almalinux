# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cronolog"
PV = "1.6.2"
PR = "43.el10_0"
PACKAGES = " \
 cronolog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cronolog-1.6.2-43.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a688c7d34835e828e79431c031b4aaab6e015798ef6b98957c5eebc39a164acc"

URI_x86_64_v2_cronolog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cronolog-1.6.2-43.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cronolog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cronolog}"
SRC_URI[x86_64_v2_cronolog.sha256sum] = "8947e3c1a27d901969972dcf58aa126a2bf23c2cdd229733508249ca2fb7659f"

URI_aarch64_cronolog = "${EPEL_MIRROR}/aarch64/Packages/c/cronolog-1.6.2-43.el10_0.aarch64.rpm;name=aarch64_cronolog;unpack=0"
SRC_URI:append = " ${URI_aarch64_cronolog}"
SRC_URI[aarch64_cronolog.sha256sum] = "d0b1d9733eb2e67ff0e375414fad4f441a668d39d645b3154d365a059fcec589"

RDEPENDS:cronolog = " \
 glibc \
 perl-Getopt-Long \
 perl-interpreter \
 "
