# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5 \
 qt5-devel \
 qt5-filesystem \
 qt5-rpm-macros \
 qt5-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0f54d911d9d82bfdac486518552faf41c89ff1f969ffef688f3db2c0c3b6759"

URI_x86_64_v2_qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5}"
SRC_URI[x86_64_v2_qt5.sha256sum] = "f2e8afd32f040f545333479817111a6244cae4d2b4b9680a750c483ea0fe1acd"

URI_x86_64_v2_qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-devel}"
SRC_URI[x86_64_v2_qt5-devel.sha256sum] = "8d63c9bd0dd0fa241aba213113e8d9d9306261c55b2af2332930d7fa21ef4e27"

URI_x86_64_v2_qt5-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-filesystem-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-filesystem}"
SRC_URI[x86_64_v2_qt5-filesystem.sha256sum] = "13486ccb6899b81ff4ca45af1062b433386f3d8d0e04ea57e7d8c50afbc4360a"

URI_x86_64_v2_qt5-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-rpm-macros-5.15.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-rpm-macros}"
SRC_URI[x86_64_v2_qt5-rpm-macros.sha256sum] = "bfcf5ea018df8136a858196d6df19156f6fe844c904fef3a64f035525d5c2075"

URI_x86_64_v2_qt5-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-srpm-macros-5.15.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-srpm-macros}"
SRC_URI[x86_64_v2_qt5-srpm-macros.sha256sum] = "1e3b597d18a57588dd4f4097dc5ec87817ef94ccfe87dac45eeee7ad61ca2759"

URI_aarch64_qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5}"
SRC_URI[aarch64_qt5.sha256sum] = "479cae3d023edbad29a4dc2d3215e3217a43969dc2dff090b7cf50edb519ff5a"

URI_aarch64_qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-devel}"
SRC_URI[aarch64_qt5-devel.sha256sum] = "a0ae2c5e56f7f5074b685ac309f47c3572200d09b882cbe2f52c57b9c4fc8061"

URI_aarch64_qt5-filesystem = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-filesystem-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-filesystem}"
SRC_URI[aarch64_qt5-filesystem.sha256sum] = "43942d30ea383c560997a4c6ebee0565b6b68e64f2cdb633b1fbe1a33575dd84"

URI_aarch64_qt5-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-rpm-macros-5.15.15-1.el10_0.noarch.rpm;name=aarch64_qt5-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-rpm-macros}"
SRC_URI[aarch64_qt5-rpm-macros.sha256sum] = "8e2f20b80ad9ba570a874d53d37056342df1c858f58550d60f1e67ba060bbbf4"

URI_aarch64_qt5-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-srpm-macros-5.15.15-1.el10_0.noarch.rpm;name=aarch64_qt5-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-srpm-macros}"
SRC_URI[aarch64_qt5-srpm-macros.sha256sum] = "28da4f3a722f254771a210c58b9b67b723ec23bc132692475179c5e7e932f02b"

RDEPENDS:qt5 = " \
 qt5-qdbusviewer \
 qt5-qt3d \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtbase-mysql \
 qt5-qtbase-postgresql \
 qt5-qtconnectivity \
 qt5-qtdeclarative \
 qt5-qtdoc \
 qt5-qtgraphicaleffects \
 qt5-qtimageformats \
 qt5-qtlocation \
 qt5-qtmultimedia \
 qt5-qtquickcontrols \
 qt5-qtquickcontrols2 \
 qt5-qtscript \
 qt5-qtsensors \
 qt5-qtserialport \
 qt5-qtsvg \
 qt5-qttools \
 qt5-qtwayland \
 qt5-qtwebchannel \
 qt5-qtwebsockets \
 qt5-qtx11extras \
 qt5-qtxmlpatterns \
 "
RDEPENDS:qt5-devel = " \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qt3d-devel \
 qt5-qtbase-devel \
 qt5-qtbase-static \
 qt5-qtconnectivity-devel \
 qt5-qtdeclarative-devel \
 qt5-qtdeclarative-static \
 qt5-qtlocation-devel \
 qt5-qtmultimedia-devel \
 qt5-qtscript-devel \
 qt5-qtsensors-devel \
 qt5-qtserialport-devel \
 qt5-qtsvg-devel \
 qt5-qttools-devel \
 qt5-qttools-static \
 qt5-qtwayland-devel \
 qt5-qtwebchannel-devel \
 qt5-qtwebsockets-devel \
 qt5-qtx11extras-devel \
 qt5-qtxmlpatterns-devel \
 qt5-rpm-macros \
 "
RDEPENDS:qt5-filesystem = " \
 "
RDEPENDS:qt5-rpm-macros = " \
 bash \
 cmake \
 gcc-c++ \
 "
RDEPENDS:qt5-srpm-macros = " \
 "
