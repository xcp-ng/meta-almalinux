# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-middleware"
PV = "0.5.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqwest-middleware+charset-devel \
 rust-reqwest-middleware+default-devel \
 rust-reqwest-middleware+form-devel \
 rust-reqwest-middleware+http2-devel \
 rust-reqwest-middleware+json-devel \
 rust-reqwest-middleware+multipart-devel \
 rust-reqwest-middleware+query-devel \
 rust-reqwest-middleware+rustls-devel \
 rust-reqwest-middleware+stream-devel \
 rust-reqwest-middleware-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-middleware-0.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bfa223ead6c0fa7c0c3648f58a32d6a19260dc2defbf431b8fdb70a3dd210e5"

URI_x86_64_v2_rust-reqwest-middleware+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+charset-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+charset-devel.sha256sum] = "2e12c559f6a4dbeb0797d76747ab5ebcf9a28a460d824a90f16861f9a534084e"

URI_x86_64_v2_rust-reqwest-middleware+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+default-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+default-devel.sha256sum] = "b80bd2ee363c53dd4f3e5434dc516dfa038e6c2d542d8caa7971065b402f74aa"

URI_x86_64_v2_rust-reqwest-middleware+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+form-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+form-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+form-devel.sha256sum] = "1b3b8d0b3fe9c968ffe4d002355a1a2a7e71c9e2c97bfe9c62334f2b459764b6"

URI_x86_64_v2_rust-reqwest-middleware+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+http2-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+http2-devel.sha256sum] = "d6968cdcf1500e4cb50a030878c542cac8cec794a4da0f14f788b1651c63e064"

URI_x86_64_v2_rust-reqwest-middleware+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+json-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+json-devel.sha256sum] = "a889c330a93c2394deb7e6d2b285573db4b355e2605f3d575303a23a38d1d996"

URI_x86_64_v2_rust-reqwest-middleware+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+multipart-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+multipart-devel.sha256sum] = "f0cc9bbe822af34b7084d3321c6975e5c3fdffec60cf1b977df626733b78737c"

URI_x86_64_v2_rust-reqwest-middleware+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+query-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+query-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+query-devel.sha256sum] = "6eb5305a7e36c061229b6b631c63c64123435ba83370bb863f21e33a15044c0c"

URI_x86_64_v2_rust-reqwest-middleware+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+rustls-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+rustls-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+rustls-devel.sha256sum] = "1defcc1a0307c95ee5cd7234aa4a441768b9c9673e8ffadd30f9483ba33269bc"

URI_x86_64_v2_rust-reqwest-middleware+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+stream-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+stream-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+stream-devel.sha256sum] = "8d2ca108929d30d1e3fb6d57875b8ce2a66e91dd9fad912b71c7bb49df50efe5"

URI_x86_64_v2_rust-reqwest-middleware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware-devel-0.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware-devel.sha256sum] = "5dc94860dcba0897cd81c5a8c97b65307f1291cf729d23c7ea756d893bc67e5d"

URI_aarch64_rust-reqwest-middleware+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+charset-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+charset-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+charset-devel.sha256sum] = "e5abb61363f23f4afe70b28691246f8ab4f23c12be135d85b958b547c959db0a"

URI_aarch64_rust-reqwest-middleware+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+default-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+default-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+default-devel.sha256sum] = "dc990e9b174c2cae154bc9aa1b7638c42e8daab4966fc4d87884e16f93ceebde"

URI_aarch64_rust-reqwest-middleware+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+form-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+form-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+form-devel.sha256sum] = "10f6bcef45b2a24124e8c53d2781e5f00dd8ff768246dc9465bc30e4ccdacc32"

URI_aarch64_rust-reqwest-middleware+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+http2-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+http2-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+http2-devel.sha256sum] = "08acd5a08c5bd83a3fc08f15f5652e4687ecdb1a4ef7b7a3db708de00c193d16"

URI_aarch64_rust-reqwest-middleware+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+json-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+json-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+json-devel.sha256sum] = "b1c4daedf392075be6e82305a355d66c69cbc874d8f24a38f3e806c616b9c843"

URI_aarch64_rust-reqwest-middleware+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+multipart-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+multipart-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+multipart-devel.sha256sum] = "4e668e7b33058913b459cd5624028e991b6b08ad908496cde85c6a51977c9afb"

URI_aarch64_rust-reqwest-middleware+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+query-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+query-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+query-devel.sha256sum] = "b9c3896800c280d717b4bc563ab7187a473d49c2b7aaf160a92a857dfc5d0390"

URI_aarch64_rust-reqwest-middleware+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+rustls-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+rustls-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+rustls-devel.sha256sum] = "6dde7584a8a9da124baa2eb60954b0d3b57cfac39f88dd3945dab744dc5a1431"

URI_aarch64_rust-reqwest-middleware+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+stream-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+stream-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+stream-devel.sha256sum] = "899a54f2082f32f52d9610220b51d9b6c433a702aee74609cc8c423a982a852b"

URI_aarch64_rust-reqwest-middleware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware-devel-0.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware-devel}"
SRC_URI[aarch64_rust-reqwest-middleware-devel.sha256sum] = "f9f671ce4bbd705054e2e10e01a9dd14bd42e493b70c970f52979fb555a8d581"

RDEPENDS:rust-reqwest-middleware+charset-devel = " \
 cargo \
 rust-reqwest+charset-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+default-devel = " \
 cargo \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+form-devel = " \
 cargo \
 rust-reqwest+form-devel \
 rust-reqwest-middleware-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-reqwest-middleware+http2-devel = " \
 cargo \
 rust-reqwest+http2-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+json-devel = " \
 cargo \
 rust-reqwest+json-devel \
 rust-reqwest-middleware-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-reqwest-middleware+multipart-devel = " \
 cargo \
 rust-reqwest+multipart-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+query-devel = " \
 cargo \
 rust-reqwest+query-devel \
 rust-reqwest-middleware-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-reqwest-middleware+rustls-devel = " \
 cargo \
 rust-reqwest+rustls-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+stream-devel = " \
 cargo \
 rust-reqwest+stream-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-reqwest-devel \
 rust-thiserror+default-devel \
 rust-tower-service+default-devel \
 "
