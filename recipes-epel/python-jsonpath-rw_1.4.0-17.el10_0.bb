# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsonpath-rw"
PV = "1.4.0"
PR = "17.el10_0"
PACKAGES = " \
 python3-jsonpath-rw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsonpath-rw-1.4.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f04ddebe6f18af9bee180a8021b4c98505a4fefb8df58265bee596882d4158c"

URI_x86_64_v2_python3-jsonpath-rw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonpath-rw-1.4.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsonpath-rw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonpath-rw}"
SRC_URI[x86_64_v2_python3-jsonpath-rw.sha256sum] = "b90f6bce2b53857f60d1b2a90e9035ce880c9fb22ac08579e06af6906903767e"

URI_aarch64_python3-jsonpath-rw = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonpath-rw-1.4.0-17.el10_0.noarch.rpm;name=aarch64_python3-jsonpath-rw;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonpath-rw}"
SRC_URI[aarch64_python3-jsonpath-rw.sha256sum] = "3a40f5f45a958977b547afdebb864e22577c748ea306336b49c15c7ad4357332"

RDEPENDS:python3-jsonpath-rw = " \
 python3 \
 python3-decorator \
 python3-ply \
 python3-six \
 "
