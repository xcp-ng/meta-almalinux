# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdns-recursor"
PV = "5.4.6"
PR = "2.el10_2"
PACKAGES = " \
 pdns-recursor \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pdns-recursor-5.4.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6a9d626e082ddcfa0884c9d9626fb1676083b209834d1f3440e4c0fbac2e13fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-recursor-5.4.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-recursor;unpack=0"
SRC_URI[x86_64_v2_pdns-recursor.sha256sum] = "e60bdce9a01b48a983da11043809e4c744616786a06e87d4ee296138f2e215ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pdns-recursor-5.4.6-2.el10_2.aarch64.rpm;name=aarch64_pdns-recursor;unpack=0"
SRC_URI[aarch64_pdns-recursor.sha256sum] = "bbcc50034b5eacf1654a0099be7e1145ff031b1979c44e48a1b304d6919eaab4"

RDEPENDS:pdns-recursor = " \
 bash \
 boost-context \
 boost-filesystem \
 fstrm \
 glibc \
 libcap \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
