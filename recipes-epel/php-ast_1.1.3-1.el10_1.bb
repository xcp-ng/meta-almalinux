# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-ast"
PV = "1.1.3"
PR = "1.el10_1"
PACKAGES = " \
 php-ast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-ast-1.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b485efd67112bc87155cf188f1d6c026f7cdd8b6e957fe8e83a9c1da1f1ace2"

URI_x86_64_v2_php-ast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-ast-1.1.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-ast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ast}"
SRC_URI[x86_64_v2_php-ast.sha256sum] = "0c8ee6a7077b326dc1d32e4d2a160cf55d59a24e5c2a4fa58f5edc7ca926fd84"

URI_aarch64_php-ast = "${EPEL_MIRROR}/aarch64/Packages/p/php-ast-1.1.3-1.el10_1.aarch64.rpm;name=aarch64_php-ast;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ast}"
SRC_URI[aarch64_php-ast.sha256sum] = "c421aa7023e75f81da63339c77006471f07845513cddd296b75bacc861f7a2cb"

RDEPENDS:php-ast = " \
 glibc \
 php-common \
 "
