# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaccounts-providers"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kaccounts-providers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaccounts-providers-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ef227dee92b235fa3d38a180e8eddcc83e92c5ae56841796438e281a52897d2"

URI_x86_64_v2_kaccounts-providers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-providers-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-providers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-providers}"
SRC_URI[x86_64_v2_kaccounts-providers.sha256sum] = "870dc7a39104fbcf33fbff802968341d798841b6789d9f04d0b7db557d0f298c"

URI_aarch64_kaccounts-providers = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-providers-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kaccounts-providers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-providers}"
SRC_URI[aarch64_kaccounts-providers.sha256sum] = "6ef17ba56d8f8eab3f640dce22bf7e382c4e878913224c8245bb3b85e232a5fb"

RDEPENDS:kaccounts-providers = " \
 glibc \
 kaccounts-integration-qt6 \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kpackage \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 signon-plugin-oauth2 \
 signon-ui \
 "
