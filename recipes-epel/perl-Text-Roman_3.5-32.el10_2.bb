# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Roman"
PV = "3.5"
PR = "32.el10_2"
PACKAGES = " \
 perl-Text-Roman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-Roman-3.5-32.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a014e5d61744836ddbc9bd3ce4ee41d1e4d343952d7e4853dfe834df7411da6e"

URI_x86_64_v2_perl-Text-Roman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-Roman-3.5-32.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-Roman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Roman}"
SRC_URI[x86_64_v2_perl-Text-Roman.sha256sum] = "8e714fedc16469f5fe351e6ad3f7dbb6628cd3eb6d15ca05fdd1b1ad22c22141"

URI_aarch64_perl-Text-Roman = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-Roman-3.5-32.el10_2.noarch.rpm;name=aarch64_perl-Text-Roman;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Roman}"
SRC_URI[aarch64_perl-Text-Roman.sha256sum] = "a630ca4ea0b1a8bef5dabb39c2c764af632795082a2acc0ea435d7bfcdf622d3"

RDEPENDS:perl-Text-Roman = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
