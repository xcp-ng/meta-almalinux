# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osbuild-composer"
PV = "165.1"
PR = "5.el10_2.alma.1"
PACKAGES = " \
 osbuild-composer \
 osbuild-composer-core \
 osbuild-composer-worker \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osbuild-composer-165.1-5.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4be7fe215daedf15a007ce02d01a6acd8a302db734e7291b43d93b44eef1a714"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-165.1-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer;unpack=0"
SRC_URI[x86_64_v2_osbuild-composer.sha256sum] = "172f55d607891f8bffaea2ae51b8a76948084b3e5b39e03a5d5c0df3d76003bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-core-165.1-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer-core;unpack=0"
SRC_URI[x86_64_v2_osbuild-composer-core.sha256sum] = "f16bb4a094ba68fb71aac935d3b7c486c2c632a6e51573f6505d467e6a8d92d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-composer-worker-165.1-5.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_osbuild-composer-worker;unpack=0"
SRC_URI[x86_64_v2_osbuild-composer-worker.sha256sum] = "96937c5cbc4cddd07d002c113cd84e37e9b3f1173e13811aab11cee38dbd8bc9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-165.1-5.el10_2.alma.1.aarch64.rpm;name=aarch64_osbuild-composer;unpack=0"
SRC_URI[aarch64_osbuild-composer.sha256sum] = "62f26eb922c5d07bb9413e11bb5ba9f9a71152892e88b332ca503ef0b9d3220b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-core-165.1-5.el10_2.alma.1.aarch64.rpm;name=aarch64_osbuild-composer-core;unpack=0"
SRC_URI[aarch64_osbuild-composer-core.sha256sum] = "053b41a97a2fa83fcdda793444eed56cce066493ce50588362e64ea00cbade12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-composer-worker-165.1-5.el10_2.alma.1.aarch64.rpm;name=aarch64_osbuild-composer-worker;unpack=0"
SRC_URI[aarch64_osbuild-composer-worker.sha256sum] = "69b5098870e83cebb11fac23b400a692c62774bbce94b31887fb77e8eff47868"

RDEPENDS:osbuild-composer = " \
 bash \
 osbuild-composer-core \
 osbuild-composer-worker \
 systemd \
 "
RDEPENDS:osbuild-composer-core = " \
 glibc \
 gpgme \
 libxcrypt \
 osbuild-depsolve-dnf \
 "
RDEPENDS:osbuild-composer-worker = " \
 bash \
 glibc \
 gpgme \
 krb5-libs \
 libcom_err \
 libxcrypt \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 qemu-img \
 systemd \
 "
