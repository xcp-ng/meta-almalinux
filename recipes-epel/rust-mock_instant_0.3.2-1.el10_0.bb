# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mock_instant"
PV = "0.3.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-mock_instant+default-devel \
 rust-mock_instant+once_cell-devel \
 rust-mock_instant+sync-devel \
 rust-mock_instant-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mock_instant-0.3.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06917d3b5ddedf8297c0e20d205fd88b98942a217daba4b3f8c7cdf4c83cc6ca"

URI_x86_64_v2_rust-mock_instant+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant+default-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant+default-devel}"
SRC_URI[x86_64_v2_rust-mock_instant+default-devel.sha256sum] = "948f2e5401544e8e2676e6b0d436a9f1bf990ad58ed2893d5ddfcaaf87c055e0"

URI_x86_64_v2_rust-mock_instant+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant+once_cell-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant+once_cell-devel}"
SRC_URI[x86_64_v2_rust-mock_instant+once_cell-devel.sha256sum] = "445212ea759352d513e4eeb17a37a5decb2ef25ad3f888bbf00d58bef502b86f"

URI_x86_64_v2_rust-mock_instant+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant+sync-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant+sync-devel}"
SRC_URI[x86_64_v2_rust-mock_instant+sync-devel.sha256sum] = "1347490e01498a59cb1f91fbb385ecb98f38e1c40a604d5ba8d6706766cf2d31"

URI_x86_64_v2_rust-mock_instant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant-devel}"
SRC_URI[x86_64_v2_rust-mock_instant-devel.sha256sum] = "4922fac36de50fc42c39e58cd3a566c632ea4189578111092efd847121bfe289"

URI_aarch64_rust-mock_instant+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant+default-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-mock_instant+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant+default-devel}"
SRC_URI[aarch64_rust-mock_instant+default-devel.sha256sum] = "8095942f1950a29762b3bebb2f132c99aacab662aee8d834f1ee709ea05c22cc"

URI_aarch64_rust-mock_instant+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant+once_cell-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-mock_instant+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant+once_cell-devel}"
SRC_URI[aarch64_rust-mock_instant+once_cell-devel.sha256sum] = "33c4f0c870a20f604cb6e5586bec5f8c4a7f45f8b6a3f043648ab6126cb8123e"

URI_aarch64_rust-mock_instant+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant+sync-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-mock_instant+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant+sync-devel}"
SRC_URI[aarch64_rust-mock_instant+sync-devel.sha256sum] = "813e3635e72c723253d730dd122e9fb9307555e8ccd0de335af67d4923427ea6"

URI_aarch64_rust-mock_instant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-mock_instant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant-devel}"
SRC_URI[aarch64_rust-mock_instant-devel.sha256sum] = "8964a963ea54d0628871ff5d2972e45cf9aeb7b8a4a227b13985d9a132bfebb5"

RDEPENDS:rust-mock_instant+default-devel = " \
 cargo \
 rust-mock_instant-devel \
 "
RDEPENDS:rust-mock_instant+once_cell-devel = " \
 cargo \
 rust-mock_instant-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-mock_instant+sync-devel = " \
 cargo \
 rust-mock_instant+once_cell-devel \
 rust-mock_instant-devel \
 "
RDEPENDS:rust-mock_instant-devel = " \
 cargo \
 "
