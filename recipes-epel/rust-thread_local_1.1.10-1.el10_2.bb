# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thread_local"
PV = "1.1.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-thread_local+default-devel \
 rust-thread_local+nightly-devel \
 rust-thread_local-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thread_local-1.1.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5c6079e8e6b0ea75ce91d3b2ac01dec8ce4c22aa71d24c623c292ba5bb7166f"

URI_x86_64_v2_rust-thread_local+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local+default-devel-1.1.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local+default-devel}"
SRC_URI[x86_64_v2_rust-thread_local+default-devel.sha256sum] = "a94ec38cd9236285b74da7399947dccdd488a63abe6a9ff2c962fd4fb9bbe43d"

URI_x86_64_v2_rust-thread_local+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local+nightly-devel-1.1.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local+nightly-devel}"
SRC_URI[x86_64_v2_rust-thread_local+nightly-devel.sha256sum] = "41d062624b2d7e5fbea7ceb32a88354da1c66092d7b821c18310f75da8b1cc9b"

URI_x86_64_v2_rust-thread_local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local-devel-1.1.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local-devel}"
SRC_URI[x86_64_v2_rust-thread_local-devel.sha256sum] = "1a5aa693692876e6d08bd0e811f1e6afaaa1e4ab18aca96f969527baa30ef769"

URI_aarch64_rust-thread_local+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local+default-devel-1.1.10-1.el10_2.noarch.rpm;name=aarch64_rust-thread_local+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local+default-devel}"
SRC_URI[aarch64_rust-thread_local+default-devel.sha256sum] = "c87ce4ad66abe6c2c59a03686a7ee446516c8b33524406d6aebd33101d2656d8"

URI_aarch64_rust-thread_local+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local+nightly-devel-1.1.10-1.el10_2.noarch.rpm;name=aarch64_rust-thread_local+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local+nightly-devel}"
SRC_URI[aarch64_rust-thread_local+nightly-devel.sha256sum] = "86c8a6a6531a7ffa10e9b11bfdf030a9fe2d28b3c519cda5b1e48f1192ac26a7"

URI_aarch64_rust-thread_local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local-devel-1.1.10-1.el10_2.noarch.rpm;name=aarch64_rust-thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local-devel}"
SRC_URI[aarch64_rust-thread_local-devel.sha256sum] = "597cdec2e42b79a5b9180bd20183f0d74314c2606b566e154293c25583734d86"

RDEPENDS:rust-thread_local+default-devel = " \
 cargo \
 rust-thread_local-devel \
 "
RDEPENDS:rust-thread_local+nightly-devel = " \
 cargo \
 rust-thread_local-devel \
 "
RDEPENDS:rust-thread_local-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
