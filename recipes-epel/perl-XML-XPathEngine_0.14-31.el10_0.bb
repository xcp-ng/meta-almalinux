# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-XPathEngine"
PV = "0.14"
PR = "31.el10_0"
PACKAGES = " \
 perl-XML-XPathEngine \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-XML-XPathEngine-0.14-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3b349afd9e03c9cde411d668cff9992cfc92e3dfc13ee43a47c3ec0bc89de2d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-XPathEngine-0.14-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-XPathEngine;unpack=0"
SRC_URI[x86_64_v2_perl-XML-XPathEngine.sha256sum] = "36b91bce7269a8266892db8b14199a356e72553b3ec41492a5336e0f8bd2ebab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-XPathEngine-0.14-31.el10_0.noarch.rpm;name=aarch64_perl-XML-XPathEngine;unpack=0"
SRC_URI[aarch64_perl-XML-XPathEngine.sha256sum] = "f1c676964137230881788e97b3ed756cb201c8ae08c939139345467922d53aa7"

RDEPENDS:perl-XML-XPathEngine = " \
 perl-Carp \
 perl-POSIX \
 perl-XML-XPathEngine \
 perl-libs \
 perl-overload \
 perl-vars \
 "
