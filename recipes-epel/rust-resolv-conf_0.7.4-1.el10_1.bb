# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-resolv-conf"
PV = "0.7.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 rust-resolv-conf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-resolv-conf-0.7.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ddb62236c5a26c6d81f8fd7399b4b96c2b4162219b4557607676bb9e58952d3"

URI_x86_64_v2_rust-resolv-conf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resolv-conf+default-devel-0.7.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resolv-conf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-resolv-conf+default-devel}"
SRC_URI[x86_64_v2_rust-resolv-conf+default-devel.sha256sum] = "98641bef4f3c5b1c4987d8474331a97209e3ccb7b3ffb1bac619719c5b030159"

URI_x86_64_v2_rust-resolv-conf+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resolv-conf+system-devel-0.7.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resolv-conf+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-resolv-conf+system-devel}"
SRC_URI[x86_64_v2_rust-resolv-conf+system-devel.sha256sum] = "eb0399fdca68b9ef97fd623c77c0a21ec57a9de7b6aabdf54987a4b8b9382377"

URI_x86_64_v2_rust-resolv-conf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resolv-conf-devel-0.7.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-resolv-conf-devel}"
SRC_URI[x86_64_v2_rust-resolv-conf-devel.sha256sum] = "32951c73a2fd791572be8eea806b3e3c23d339e2b9586a1fe26a778b3f2f15bf"

URI_aarch64_rust-resolv-conf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-resolv-conf+default-devel-0.7.4-1.el10_1.noarch.rpm;name=aarch64_rust-resolv-conf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-resolv-conf+default-devel}"
SRC_URI[aarch64_rust-resolv-conf+default-devel.sha256sum] = "5dbc773cf612473a9f0c1ac2749d582bce6a6e62c7c3e072f0e86de65fae007e"

URI_aarch64_rust-resolv-conf+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-resolv-conf+system-devel-0.7.4-1.el10_1.noarch.rpm;name=aarch64_rust-resolv-conf+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-resolv-conf+system-devel}"
SRC_URI[aarch64_rust-resolv-conf+system-devel.sha256sum] = "653f29698cff1d32a54ba27e340a26bf18c8b49218376fd243fa4c20f18f3221"

URI_aarch64_rust-resolv-conf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-resolv-conf-devel-0.7.4-1.el10_1.noarch.rpm;name=aarch64_rust-resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-resolv-conf-devel}"
SRC_URI[aarch64_rust-resolv-conf-devel.sha256sum] = "89788b317a466ff1f1be9c8792e82b25979690fb7d8c55ef44f43cc6289deba8"

RDEPENDS:rust-resolv-conf+default-devel = " \
 cargo \
 rust-resolv-conf-devel \
 "
RDEPENDS:rust-resolv-conf+system-devel = " \
 cargo \
 rust-resolv-conf-devel \
 "
RDEPENDS:rust-resolv-conf-devel = " \
 cargo \
 rust \
 "
