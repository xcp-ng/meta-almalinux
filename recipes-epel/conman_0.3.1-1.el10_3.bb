# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conman"
PV = "0.3.1"
PR = "1.el10_3"
PACKAGES = " \
 conman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/conman-0.3.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd73c7f9c5f3ea0097dd74d7f933b468d372999e2036663b429362c855a0049f"

URI_x86_64_v2_conman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/conman-0.3.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_conman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conman}"
SRC_URI[x86_64_v2_conman.sha256sum] = "ec78406b04e54813861364e96b8d3d531cf28da4e19ea7ba73445b01e5b1abcc"

URI_aarch64_conman = "${EPEL_MIRROR}/aarch64/Packages/c/conman-0.3.1-1.el10_3.aarch64.rpm;name=aarch64_conman;unpack=0"
SRC_URI:append = " ${URI_aarch64_conman}"
SRC_URI[aarch64_conman.sha256sum] = "e5bc1afc9f4883b302efa1a5f7a64a0f66c21a0283028b6666132537c9b66e57"

RDEPENDS:conman = " \
 bash \
 expect \
 freeipmi \
 glibc \
 logrotate \
 perl-Getopt-Std \
 perl-interpreter \
 systemd \
 "
