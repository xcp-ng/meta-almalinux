# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana"
PV = "10.2.6"
PR = "25.el10_1"
PACKAGES = " \
 grafana \
 grafana-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-10.2.6-25.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50d4ecc0472e8992b82d7931a6a498ccb0007537bcdf737b86457e3cdd03703e"

URI_x86_64_v2_grafana = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-10.2.6-25.el10_1.x86_64_v2.rpm;name=x86_64_v2_grafana;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana}"
SRC_URI[x86_64_v2_grafana.sha256sum] = "15ec8ba469822bdfc7ce34bc1fdc9674cd7a1a96d2330ca86f3421f3984c3995"

URI_x86_64_v2_grafana-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-selinux-10.2.6-25.el10_1.x86_64_v2.rpm;name=x86_64_v2_grafana-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana-selinux}"
SRC_URI[x86_64_v2_grafana-selinux.sha256sum] = "c94c44c1abaa08ef709472b6c589b41193623a5924b4aa3af29146c700531d01"

URI_aarch64_grafana = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-10.2.6-25.el10_1.aarch64.rpm;name=aarch64_grafana;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana}"
SRC_URI[aarch64_grafana.sha256sum] = "49162bca0d8048f12dcabc95055e96aa29b16bca5d0c979cde1cffb58b1ca3ad"

URI_aarch64_grafana-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-selinux-10.2.6-25.el10_1.aarch64.rpm;name=aarch64_grafana-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana-selinux}"
SRC_URI[aarch64_grafana-selinux.sha256sum] = "a6f28777ecec4b992dbfd67d7093ff7ca97a87ff2446be26e7ce8c580846527a"

RDEPENDS:grafana = " \
 bash \
 glibc \
 grafana-selinux \
 shadow-utils \
 shared-mime-info \
 systemd \
 "
RDEPENDS:grafana-selinux = " \
 bash \
 policycoreutils-python-utils \
 virtual/selinux-policy-any \
 "
