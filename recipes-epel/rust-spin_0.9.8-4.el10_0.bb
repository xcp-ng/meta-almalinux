# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spin"
PV = "0.9.8"
PR = "4.el10_0"
PACKAGES = " \
 rust-spin+barrier-devel \
 rust-spin+default-devel \
 rust-spin+fair_mutex-devel \
 rust-spin+lazy-devel \
 rust-spin+lock_api-devel \
 rust-spin+lock_api_crate-devel \
 rust-spin+mutex-devel \
 rust-spin+once-devel \
 rust-spin+portable-atomic-devel \
 rust-spin+portable_atomic-devel \
 rust-spin+rwlock-devel \
 rust-spin+spin_mutex-devel \
 rust-spin+std-devel \
 rust-spin+ticket_mutex-devel \
 rust-spin+use_ticket_mutex-devel \
 rust-spin-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spin-0.9.8-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5f8a8e056cc23ab54082ab39c9aea07068c9e79009cf90c5d2605a5497ff8c0"

URI_x86_64_v2_rust-spin+barrier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+barrier-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+barrier-devel}"
SRC_URI[x86_64_v2_rust-spin+barrier-devel.sha256sum] = "8d51c0b3814bcbaa9af48d9cf722251262ac9e7ea7e55baf79ca4d076fc13cdd"

URI_x86_64_v2_rust-spin+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+default-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+default-devel}"
SRC_URI[x86_64_v2_rust-spin+default-devel.sha256sum] = "7632d8598419cc30238a2871335e3bdc453a5a21d8013a21ead90eeb5feba339"

URI_x86_64_v2_rust-spin+fair_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+fair_mutex-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+fair_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+fair_mutex-devel.sha256sum] = "ef0b73455e29e5bb6df2bb1296bd21cde53a700259c559df109e0ec97fb79dda"

URI_x86_64_v2_rust-spin+lazy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lazy-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+lazy-devel}"
SRC_URI[x86_64_v2_rust-spin+lazy-devel.sha256sum] = "c3b3eb9a80a5e94caa6623cda0b6a1e744a1a8039bbc02e41e4f366f751b56ba"

URI_x86_64_v2_rust-spin+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lock_api-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+lock_api-devel}"
SRC_URI[x86_64_v2_rust-spin+lock_api-devel.sha256sum] = "2236cc1a2989f4f28db4c5a330b8c65c7ad6fe558eb49cd1490f1e8da5e6019e"

URI_x86_64_v2_rust-spin+lock_api_crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+lock_api_crate-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+lock_api_crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+lock_api_crate-devel}"
SRC_URI[x86_64_v2_rust-spin+lock_api_crate-devel.sha256sum] = "a7d4de49f0f81729e6a9a5bd092a06f24a944ff91311115283dbd04502da71c0"

URI_x86_64_v2_rust-spin+mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+mutex-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+mutex-devel.sha256sum] = "77e62d8373059b59617f01853fd6f9a4fd67956b0734434f1d93c9e0a6e33842"

URI_x86_64_v2_rust-spin+once-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+once-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+once-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+once-devel}"
SRC_URI[x86_64_v2_rust-spin+once-devel.sha256sum] = "fd33c85fe4fc70cc1c397519e5e7a69b12cb56c7d9d774cf6549f75fb3fa6f44"

URI_x86_64_v2_rust-spin+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+portable-atomic-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-spin+portable-atomic-devel.sha256sum] = "7006761ad35e79ae9701c3ca8c7314c02ae5249315098d4bce0aedd2940b499e"

URI_x86_64_v2_rust-spin+portable_atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+portable_atomic-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+portable_atomic-devel}"
SRC_URI[x86_64_v2_rust-spin+portable_atomic-devel.sha256sum] = "9e740eec3fc8dd89f09e66f0b5b577fafefd4c3c24e25c0bbfbe8032c9117c94"

URI_x86_64_v2_rust-spin+rwlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+rwlock-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+rwlock-devel}"
SRC_URI[x86_64_v2_rust-spin+rwlock-devel.sha256sum] = "aeaca51d5e577885a680314bff35fccc42c7e840653d801169b8e0228842e9b6"

URI_x86_64_v2_rust-spin+spin_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+spin_mutex-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+spin_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+spin_mutex-devel.sha256sum] = "61bd7669a907938a45f7d20f9196a1ffb0a518f4fba861eee3751d999ff9fd24"

URI_x86_64_v2_rust-spin+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+std-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+std-devel}"
SRC_URI[x86_64_v2_rust-spin+std-devel.sha256sum] = "dde8783de5ee20dc1975bfcda7f016d4580ede30cef88c142e474d1e169bfce0"

URI_x86_64_v2_rust-spin+ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+ticket_mutex-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+ticket_mutex-devel.sha256sum] = "9ecc9b681d02bdbb469e11e731566cab464b5e441a6b2c289bb6ad30b89211fe"

URI_x86_64_v2_rust-spin+use_ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin+use_ticket_mutex-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin+use_ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin+use_ticket_mutex-devel.sha256sum] = "2ab425bb22aaaf2de6fda5883a4d9612cb3c0e4929465e21ba07a98cc4cabf92"

URI_x86_64_v2_rust-spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin-devel-0.9.8-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin-devel}"
SRC_URI[x86_64_v2_rust-spin-devel.sha256sum] = "d969862e4fe30d2fa590340c857db8a6ea4d328550fe18e05d4a11bd5c1baebd"

URI_aarch64_rust-spin+barrier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+barrier-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+barrier-devel}"
SRC_URI[aarch64_rust-spin+barrier-devel.sha256sum] = "46688b0ff9e638fb4e64bee5962bd0d363eee547996a713bad918cd776f15294"

URI_aarch64_rust-spin+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+default-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+default-devel}"
SRC_URI[aarch64_rust-spin+default-devel.sha256sum] = "eaae3da3d10a18ebdee68b217de68b7d302ce3fddeb001544a94940ce77f4178"

URI_aarch64_rust-spin+fair_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+fair_mutex-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+fair_mutex-devel}"
SRC_URI[aarch64_rust-spin+fair_mutex-devel.sha256sum] = "32074efa679c139ceff110cf159de038e6711e4d4c729fbb429e5e011466f702"

URI_aarch64_rust-spin+lazy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lazy-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+lazy-devel}"
SRC_URI[aarch64_rust-spin+lazy-devel.sha256sum] = "75bd7c04dd57c6ac0bcc723cbf9304d171ae568a5df13c68917130cc34474a96"

URI_aarch64_rust-spin+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lock_api-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+lock_api-devel}"
SRC_URI[aarch64_rust-spin+lock_api-devel.sha256sum] = "0b50ddeb0c013cab044a868848bf3c9c3596da342601cb0d454fb32629b8c0e3"

URI_aarch64_rust-spin+lock_api_crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+lock_api_crate-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+lock_api_crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+lock_api_crate-devel}"
SRC_URI[aarch64_rust-spin+lock_api_crate-devel.sha256sum] = "815fa274f0f564dc75ceac967f9fbacdeee7bc0745978ce73b9235828a83f368"

URI_aarch64_rust-spin+mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+mutex-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+mutex-devel}"
SRC_URI[aarch64_rust-spin+mutex-devel.sha256sum] = "120ec8671d6ce69c43202d3300e3ba655ca9475ec0abf8fad9db7724ff04a91a"

URI_aarch64_rust-spin+once-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+once-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+once-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+once-devel}"
SRC_URI[aarch64_rust-spin+once-devel.sha256sum] = "4671aa69982b9b4b793b8aa2eaaa2b008171287b78e8580d0b67798ff9249867"

URI_aarch64_rust-spin+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+portable-atomic-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+portable-atomic-devel}"
SRC_URI[aarch64_rust-spin+portable-atomic-devel.sha256sum] = "4c80097260d7ecd605fb4f3819c26276fe8a977d724b6041159a8c5ae02114a0"

URI_aarch64_rust-spin+portable_atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+portable_atomic-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+portable_atomic-devel}"
SRC_URI[aarch64_rust-spin+portable_atomic-devel.sha256sum] = "fb4edc1b6d56723cd91b8783b6b3661c29af9b645f45899948652c6da948ca06"

URI_aarch64_rust-spin+rwlock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+rwlock-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+rwlock-devel}"
SRC_URI[aarch64_rust-spin+rwlock-devel.sha256sum] = "346653ed74941cf7660d0154c59a1117966a72978e57a583b36e8ba25ea9666e"

URI_aarch64_rust-spin+spin_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+spin_mutex-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+spin_mutex-devel}"
SRC_URI[aarch64_rust-spin+spin_mutex-devel.sha256sum] = "49eb2434933c30febe891dd2255ecf423e4db1cb55c16110950b77de764682aa"

URI_aarch64_rust-spin+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+std-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+std-devel}"
SRC_URI[aarch64_rust-spin+std-devel.sha256sum] = "f778327876cad4271108749a7cbcabe86132fd432409fb338576af44c419181b"

URI_aarch64_rust-spin+ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+ticket_mutex-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin+ticket_mutex-devel.sha256sum] = "bce2b4737d7e52377b9c4310790e4fd132292071e7665184c158a4cb9386ed83"

URI_aarch64_rust-spin+use_ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin+use_ticket_mutex-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin+use_ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin+use_ticket_mutex-devel.sha256sum] = "ce8dbf66ed1ca510313730aa2e211cc8915f5d5202c4354fe65d2377c568fc0c"

URI_aarch64_rust-spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin-devel-0.9.8-4.el10_0.noarch.rpm;name=aarch64_rust-spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin-devel}"
SRC_URI[aarch64_rust-spin-devel.sha256sum] = "bb601013fbb82f227472cb4d4e17ce53fcbcff46b3d10d5fc5fa052513af5acd"

RDEPENDS:rust-spin+barrier-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+default-devel = " \
 cargo \
 rust-spin+barrier-devel \
 rust-spin+lazy-devel \
 rust-spin+lock_api-devel \
 rust-spin+mutex-devel \
 rust-spin+once-devel \
 rust-spin+rwlock-devel \
 rust-spin+spin_mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+fair_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lazy-devel = " \
 cargo \
 rust-spin+once-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lock_api-devel = " \
 cargo \
 rust-spin+lock_api_crate-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+lock_api_crate-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+mutex-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+once-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+portable-atomic-devel = " \
 cargo \
 rust-portable-atomic-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+portable_atomic-devel = " \
 cargo \
 rust-spin+portable-atomic-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+rwlock-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+spin_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+std-devel = " \
 cargo \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+ticket_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin+use_ticket_mutex-devel = " \
 cargo \
 rust-spin+mutex-devel \
 rust-spin+ticket_mutex-devel \
 rust-spin-devel \
 "
RDEPENDS:rust-spin-devel = " \
 cargo \
 rust \
 "
