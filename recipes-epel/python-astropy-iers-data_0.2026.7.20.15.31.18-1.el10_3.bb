# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-astropy-iers-data"
PV = "0.2026.7.20.15.31.18"
PR = "1.el10_3"
PACKAGES = " \
 python3-astropy-iers-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-astropy-iers-data-0.2026.7.20.15.31.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fa0e565f516d224dbf4dbea8f050cacde0ebd3186a5363cc350048e82fdc3bf"

URI_x86_64_v2_python3-astropy-iers-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-astropy-iers-data-0.2026.7.20.15.31.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-astropy-iers-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-astropy-iers-data}"
SRC_URI[x86_64_v2_python3-astropy-iers-data.sha256sum] = "236a47e5e8e0889df5665de23afc55f313b9bee116bd38f37bdf358e7e4aa83e"

URI_aarch64_python3-astropy-iers-data = "${EPEL_MIRROR}/aarch64/Packages/p/python3-astropy-iers-data-0.2026.7.20.15.31.18-1.el10_3.noarch.rpm;name=aarch64_python3-astropy-iers-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-astropy-iers-data}"
SRC_URI[aarch64_python3-astropy-iers-data.sha256sum] = "a13c3de84169bccaab8236098b14d318d072875f6aff7a79604173dd3c4b6310"

RDEPENDS:python3-astropy-iers-data = " \
 python3 \
 "
