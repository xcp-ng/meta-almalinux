# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libndp"
PV = "1.9"
PR = "2.el10"
PACKAGES = " \
 libndp \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libndp-1.9-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "decb8592a934b661781cec791cc940bf02984deff1119ce0ab19991fd6d6d578"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libndp-1.9-2.el10.x86_64_v2.rpm;name=x86_64_v2_libndp;unpack=0"
SRC_URI[x86_64_v2_libndp.sha256sum] = "ff63c97876136775ff9f3c49f7af8a09a08cec5715f9487241ed27f3140e1a0c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libndp-1.9-2.el10.aarch64.rpm;name=aarch64_libndp;unpack=0"
SRC_URI[aarch64_libndp.sha256sum] = "a65df6d94fe82250eeb8c5584ccdde1827eead0ca9791f3d51d4069b1863bbbf"

RDEPENDS:libndp = " \
 glibc \
 "
