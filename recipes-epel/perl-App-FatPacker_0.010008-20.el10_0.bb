# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-App-FatPacker"
PV = "0.010008"
PR = "20.el10_0"
PACKAGES = " \
 perl-App-FatPacker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-App-FatPacker-0.010008-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bc5deed8cced1cee4e2582c37758f038a11306f08f4347b6474c9342251f441"

URI_x86_64_v2_perl-App-FatPacker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-App-FatPacker-0.010008-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-App-FatPacker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-App-FatPacker}"
SRC_URI[x86_64_v2_perl-App-FatPacker.sha256sum] = "a38ce424c45d04568e77d5e23dbe53052a9515685fd77596ca8d2fa3fb795916"

URI_aarch64_perl-App-FatPacker = "${EPEL_MIRROR}/aarch64/Packages/p/perl-App-FatPacker-0.010008-20.el10_0.noarch.rpm;name=aarch64_perl-App-FatPacker;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-App-FatPacker}"
SRC_URI[aarch64_perl-App-FatPacker.sha256sum] = "43469ca045ec711a9ba400f85cc35b83fb20b9aaa90a21c975d99384486d7507"

RDEPENDS:perl-App-FatPacker = " \
 perl-App-FatPacker \
 perl-B \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 "
