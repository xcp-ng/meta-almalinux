# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kfilemetadata"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kfilemetadata \
 kf6-kfilemetadata-devel \
 kf6-kfilemetadata-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kfilemetadata-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d11d3fa11d0f207b0b93d87188539147350debd312ba3f6989eef0003142b499"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - kf6-kfilemetadata: libavformat.so.61()(64bit)
# - kf6-kfilemetadata: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - kf6-kfilemetadata: libavutil.so.59()(64bit)
# - kf6-kfilemetadata: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_kf6-kfilemetadata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata}"
SRC_URI[x86_64_v2_kf6-kfilemetadata.sha256sum] = "1082603210c12fea11b460013abe7396439e7a37f15d78f69142f7986b4b2622"

URI_x86_64_v2_kf6-kfilemetadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-devel}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-devel.sha256sum] = "189c728d393b768cf919b3cf76bdaeba18f5ee5a347ffed3dbd5b433d008a4dd"

URI_x86_64_v2_kf6-kfilemetadata-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kfilemetadata-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-doc}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-doc.sha256sum] = "95350d1b89992af3d9c3a5b10c72894467e2b139b2efb9c33e4ad90e0df69cc3"

URI_aarch64_kf6-kfilemetadata = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kfilemetadata;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata}"
SRC_URI[aarch64_kf6-kfilemetadata.sha256sum] = "5718dc159a9c1610922560c27896aa54c44eef4503a51c0659b2b4f7ccfd3acb"

URI_aarch64_kf6-kfilemetadata-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kfilemetadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-devel}"
SRC_URI[aarch64_kf6-kfilemetadata-devel.sha256sum] = "4a764bb3a5318f30f071b3ea538360710b47cb4c991bef801a6e5efebfe9a8c0"

URI_aarch64_kf6-kfilemetadata-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kfilemetadata-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-doc}"
SRC_URI[aarch64_kf6-kfilemetadata-doc.sha256sum] = "5be4a1ad010b24c6dc938d761d5374002c77b8be9e43065ef9d07c8fb71f646d"

RDEPENDS:kf6-kfilemetadata:x86_64_v2 = " \
 ebook-tools-libs \
 exiv2-libs \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 taglib \
"
RDEPENDS:kf6-kfilemetadata:aarch64 = " \
 ebook-tools-libs \
 exiv2-libs \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 libavformat-free \
 libavutil-free \
 libgcc \
 libstdc++ \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 taglib \
"
RDEPENDS:kf6-kfilemetadata-devel = " \
 cmake-filesystem \
 kf6-kfilemetadata \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kfilemetadata-doc = " \
 "
