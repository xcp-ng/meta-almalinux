# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-kcm"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plymouth-kcm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plymouth-kcm-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2e42768c9411f34ecd6ffe8a0341894b82698637e6e90ab8d681e346b50b9392"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-kcm-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plymouth-kcm;unpack=0"
SRC_URI[x86_64_v2_plymouth-kcm.sha256sum] = "3b45d620b93cd283379d78dc2f4860074762969e11acc75e207c262d44934ea6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plymouth-kcm-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plymouth-kcm;unpack=0"
SRC_URI[aarch64_plymouth-kcm.sha256sum] = "446b2bc1d77da4566203be1fca5aebc47861c0d3f4f38b364f31799a4a6f626c"

RDEPENDS:plymouth-kcm = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knewstuff \
 libstdc++ \
 plymouth \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
