# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmicrodns"
PV = "0.2.0"
PR = "12.el10_0"
PACKAGES = " \
 libmicrodns \
 libmicrodns-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmicrodns-0.2.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4222e954af264ac73932433566b0333097f568149ef94ce4937a20b563758bd"

URI_x86_64_v2_libmicrodns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmicrodns-0.2.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmicrodns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmicrodns}"
SRC_URI[x86_64_v2_libmicrodns.sha256sum] = "7445bf14e59c7b4dcb262a2c3ec49c3611e7789b39d1f94a37a04170a2bdb8af"

URI_x86_64_v2_libmicrodns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmicrodns-devel-0.2.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmicrodns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmicrodns-devel}"
SRC_URI[x86_64_v2_libmicrodns-devel.sha256sum] = "3001c3d753b0877a095e25ffb9cb183af49209fb7c952a656ee7cc3c8409ac69"

URI_aarch64_libmicrodns = "${EPEL_MIRROR}/aarch64/Packages/l/libmicrodns-0.2.0-12.el10_0.aarch64.rpm;name=aarch64_libmicrodns;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmicrodns}"
SRC_URI[aarch64_libmicrodns.sha256sum] = "962830609555257c205925617dab48705672a7189c0a8253001debb361a36f9d"

URI_aarch64_libmicrodns-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmicrodns-devel-0.2.0-12.el10_0.aarch64.rpm;name=aarch64_libmicrodns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmicrodns-devel}"
SRC_URI[aarch64_libmicrodns-devel.sha256sum] = "dac15461a05c0df7d70471abdd021a4d83d0f2ca674949775a65b80a244e332c"

RDEPENDS:libmicrodns = " \
 glibc \
 "
RDEPENDS:libmicrodns-devel = " \
 libmicrodns \
 pkgconf-pkg-config \
 "
