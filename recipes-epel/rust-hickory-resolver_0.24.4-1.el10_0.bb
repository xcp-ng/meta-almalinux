# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-resolver"
PV = "0.24.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-hickory-resolver+backtrace-devel \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+dns-over-native-tls-devel \
 rust-hickory-resolver+dns-over-openssl-devel \
 rust-hickory-resolver+dns-over-tls-devel \
 rust-hickory-resolver+dnssec-devel \
 rust-hickory-resolver+dnssec-openssl-devel \
 rust-hickory-resolver+resolv-conf-devel \
 rust-hickory-resolver+serde-config-devel \
 rust-hickory-resolver+serde-devel \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+testing-devel \
 rust-hickory-resolver+tokio-devel \
 rust-hickory-resolver+tokio-native-tls-devel \
 rust-hickory-resolver+tokio-openssl-devel \
 rust-hickory-resolver+tokio-runtime-devel \
 rust-hickory-resolver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-resolver-0.24.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1960bbf518271289441ae319af07b86cab1e671cc9c2aa03c202fe77def8f116"

URI_x86_64_v2_rust-hickory-resolver+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+backtrace-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+backtrace-devel.sha256sum] = "d0f1e1b75978185d144e74eee870df962527d7c6e2973591f53bc6c4dafca7e8"

URI_x86_64_v2_rust-hickory-resolver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+default-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+default-devel.sha256sum] = "d8129f163b902e7e383b1b3842097aa383d5b6d0c5f839fdee9704b8aad28b72"

URI_x86_64_v2_rust-hickory-resolver+dns-over-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dns-over-native-tls-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dns-over-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dns-over-native-tls-devel.sha256sum] = "86558e7e2e767a00eac17a64365197a07220a1629e9bbb7a71b5e652b1060e1f"

URI_x86_64_v2_rust-hickory-resolver+dns-over-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dns-over-openssl-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dns-over-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dns-over-openssl-devel.sha256sum] = "b6add4e18a72f5dab1efa1ebec5cc27db212ca9a63a3fb4d391ad50bf7e21bf9"

URI_x86_64_v2_rust-hickory-resolver+dns-over-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dns-over-tls-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dns-over-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dns-over-tls-devel.sha256sum] = "0bd083dfa89147c05edae838235c66c60e8d222ae23abc1f9ffa522fee005e40"

URI_x86_64_v2_rust-hickory-resolver+dnssec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dnssec-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dnssec-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dnssec-devel.sha256sum] = "3c405a4b6280e5ec864c9c33b7260503eb597044f06ee5c28bfeb71fc3e03718"

URI_x86_64_v2_rust-hickory-resolver+dnssec-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dnssec-openssl-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dnssec-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dnssec-openssl-devel.sha256sum] = "fffec8f4e4674075b3f02e2282647875e39542af59d170e1763f41125e53ca2b"

URI_x86_64_v2_rust-hickory-resolver+resolv-conf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+resolv-conf-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+resolv-conf-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+resolv-conf-devel.sha256sum] = "faced0bc9176987ba0b3e4f7363649dce444126fb4daec18ff12b5a743fed5d3"

URI_x86_64_v2_rust-hickory-resolver+serde-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+serde-config-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+serde-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+serde-config-devel.sha256sum] = "c936badff9855ec34e82b9cc319796c9a1b02d0cf1ca3348a57e6c2950d3abe8"

URI_x86_64_v2_rust-hickory-resolver+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+serde-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+serde-devel.sha256sum] = "2bdbd15e2152e4d88dac46bf9b916ef0c9d0aff2b146696cba54a3cda1ac5014"

URI_x86_64_v2_rust-hickory-resolver+system-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+system-config-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+system-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+system-config-devel.sha256sum] = "f1399e6201edd3ed8444683b81736769b94174531d9dc38bbba1f3f3d50e1a34"

URI_x86_64_v2_rust-hickory-resolver+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+testing-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+testing-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+testing-devel.sha256sum] = "2c8a95c20e9c47d63faa7aeacd822ef30156a600320d0bdfea34e5b90d6d865d"

URI_x86_64_v2_rust-hickory-resolver+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-devel.sha256sum] = "930a412b1261854e4a840b25a3428ff64231b45a005c61e7e64608cdbdd38b20"

URI_x86_64_v2_rust-hickory-resolver+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-native-tls-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-native-tls-devel.sha256sum] = "70661ff09e881b1d18c3139ddca56e7b8c5246f6baa8ebed27b9a41921b6798e"

URI_x86_64_v2_rust-hickory-resolver+tokio-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-openssl-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-openssl-devel.sha256sum] = "baa5034b8729710d9397e3c6a28da51d4c3a0b09ab6811b485fe7e38f3825a94"

URI_x86_64_v2_rust-hickory-resolver+tokio-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-runtime-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-runtime-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-runtime-devel.sha256sum] = "1c5cbf8d8f83ebcca143a1d8687c6ca91abca62745bbeaa9fcd55dd2d60e53ec"

URI_x86_64_v2_rust-hickory-resolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver-devel-0.24.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver-devel.sha256sum] = "e28b79f97682975583f264876f8319708a8f36f29d3eba83ff313f3138f386fd"

URI_aarch64_rust-hickory-resolver+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+backtrace-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-resolver+backtrace-devel.sha256sum] = "352e043a4365640457c402f6efd729cf0b6d4f9f6f38a8910a99cff2da201000"

URI_aarch64_rust-hickory-resolver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+default-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+default-devel}"
SRC_URI[aarch64_rust-hickory-resolver+default-devel.sha256sum] = "4b4d3323ef854ecc6cfb4d61d1b31f862794b291e0a6ac25fe404e7242f8d7c6"

URI_aarch64_rust-hickory-resolver+dns-over-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dns-over-native-tls-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dns-over-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dns-over-native-tls-devel.sha256sum] = "0b470f1a246d34fe582ae1e6935e4e46e77705c37ef927f6379b86530fd6d5ca"

URI_aarch64_rust-hickory-resolver+dns-over-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dns-over-openssl-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dns-over-openssl-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dns-over-openssl-devel.sha256sum] = "e782a4e75effda40df6c605ca5e6226557310791f20ab120b363c339e015da32"

URI_aarch64_rust-hickory-resolver+dns-over-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dns-over-tls-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dns-over-tls-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dns-over-tls-devel.sha256sum] = "b0d4be3cad56ee3e0c133e4d3a0d8706ad6b2b582d5dfbab76b0663f374b3dbb"

URI_aarch64_rust-hickory-resolver+dnssec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dnssec-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dnssec-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dnssec-devel.sha256sum] = "7fa5a74b86ee477c08e151fc19b5e4c66b92407d77ad8ea134595517a49932ce"

URI_aarch64_rust-hickory-resolver+dnssec-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dnssec-openssl-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dnssec-openssl-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dnssec-openssl-devel.sha256sum] = "eaa6ae2ba7ba8f44e228483dcb7fe7bd72e9a01df3649ee27d371c0053461ad6"

URI_aarch64_rust-hickory-resolver+resolv-conf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+resolv-conf-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+resolv-conf-devel}"
SRC_URI[aarch64_rust-hickory-resolver+resolv-conf-devel.sha256sum] = "46d203b8694ee25d304eceb31e82b9d366707392f18665b78d0a8da290d9b7b2"

URI_aarch64_rust-hickory-resolver+serde-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+serde-config-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+serde-config-devel}"
SRC_URI[aarch64_rust-hickory-resolver+serde-config-devel.sha256sum] = "f41a60f276ed29914adf2c01cbdb7b4e5d37341a815dc3ba9591c166dc855a89"

URI_aarch64_rust-hickory-resolver+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+serde-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+serde-devel}"
SRC_URI[aarch64_rust-hickory-resolver+serde-devel.sha256sum] = "f602b0e5b6bf6945d250dea765be1a6ec8c82f60b524974ca5e54447524c1cdb"

URI_aarch64_rust-hickory-resolver+system-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+system-config-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+system-config-devel}"
SRC_URI[aarch64_rust-hickory-resolver+system-config-devel.sha256sum] = "c1dba005ee6b12927967224fa7408cde48727e580edbbd546a3b42f512d18395"

URI_aarch64_rust-hickory-resolver+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+testing-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+testing-devel}"
SRC_URI[aarch64_rust-hickory-resolver+testing-devel.sha256sum] = "6a776872affd7b9e0c1ddf752c1fe8a642923d098115814c731813a91a1760c8"

URI_aarch64_rust-hickory-resolver+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-devel.sha256sum] = "8cbdb6b41d04724659c148a38a4066778b9682a33531899b1871ab66ae758ac0"

URI_aarch64_rust-hickory-resolver+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-native-tls-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-native-tls-devel.sha256sum] = "7a017be24a41944927cf35a08c9b10a5527b3b609ef2548453011385caa32239"

URI_aarch64_rust-hickory-resolver+tokio-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-openssl-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-openssl-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-openssl-devel.sha256sum] = "d9650e1ce88a9402895ef6dc80e5ad9828f1908e1d5b33d18655d3d56e725d5b"

URI_aarch64_rust-hickory-resolver+tokio-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-runtime-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-runtime-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-runtime-devel.sha256sum] = "cc3dc12c072b96e6b035483f47095d88a658f6bd6f764b7bfc26bce51228cc19"

URI_aarch64_rust-hickory-resolver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver-devel-0.24.4-1.el10_0.noarch.rpm;name=aarch64_rust-hickory-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver-devel}"
SRC_URI[aarch64_rust-hickory-resolver-devel.sha256sum] = "a174993dd8104a48251addf770ca8aa6e884af59f44b4b64d2953dc8248df93d"

RDEPENDS:rust-hickory-resolver+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto+backtrace-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+default-devel = " \
 cargo \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+tokio-runtime-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dns-over-native-tls-devel = " \
 cargo \
 rust-hickory-proto+dns-over-native-tls-devel \
 rust-hickory-resolver+dns-over-tls-devel \
 rust-hickory-resolver+tokio-native-tls-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dns-over-openssl-devel = " \
 cargo \
 rust-hickory-proto+dns-over-openssl-devel \
 rust-hickory-resolver+dns-over-tls-devel \
 rust-hickory-resolver+tokio-openssl-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dns-over-tls-devel = " \
 cargo \
 rust-hickory-resolver+tokio-runtime-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dnssec-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dnssec-openssl-devel = " \
 cargo \
 rust-hickory-proto+dnssec-openssl-devel \
 rust-hickory-resolver+dnssec-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+resolv-conf-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 "
RDEPENDS:rust-hickory-resolver+serde-config-devel = " \
 cargo \
 rust-hickory-proto+serde-config-devel \
 rust-hickory-resolver+serde-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+serde-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-hickory-resolver+system-config-devel = " \
 cargo \
 rust-hickory-resolver+resolv-conf-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+testing-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-native-tls-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-openssl-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-tokio-openssl+default-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-runtime-devel = " \
 cargo \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-resolver-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-hickory-resolver-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-proto-devel \
 rust-lru-cache+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot+default-devel \
 rust-rand0.8+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror1+default-devel \
 rust-tracing+default-devel \
 "
