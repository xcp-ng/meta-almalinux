# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pg_top"
PV = "4.1.3"
PR = "1.el10_2"
PACKAGES = " \
 pg_top \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pg_top-4.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "75b0348454b63c5e383285d595dd0775a337c1c6acbcf673785963484d61f9bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pg_top-4.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pg_top;unpack=0"
SRC_URI[x86_64_v2_pg_top.sha256sum] = "0605e244a89457e8b0b795ab7a84b17525ae387e5586d0b3df9d79f6828d44a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pg_top-4.1.3-1.el10_2.aarch64.rpm;name=aarch64_pg_top;unpack=0"
SRC_URI[aarch64_pg_top.sha256sum] = "43df39453e006cf2685250a161c57e1411e662a252f87e07a1f6a39176fed553"

RDEPENDS:pg_top = " \
 glibc \
 libpq \
 ncurses-libs \
 postgresql-server \
 "
