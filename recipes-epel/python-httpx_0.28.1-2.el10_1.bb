# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httpx"
PV = "0.28.1"
PR = "2.el10_1"
PACKAGES = " \
 python3-httpx \
 python3-httpx+brotli \
 python3-httpx+cli \
 python3-httpx+http2 \
 python3-httpx+socks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httpx-0.28.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6acaf70cd5e77d9eb89c5a564c46bb29ec4eb543030e1ebf9102244220647d4d"

URI_x86_64_v2_python3-httpx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx}"
SRC_URI[x86_64_v2_python3-httpx.sha256sum] = "6d0e1a96bd7a35dd45f3b7b080eb2ca612211d967bec93b364f6c1eb5688240a"

URI_x86_64_v2_python3-httpx+brotli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+brotli-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+brotli}"
SRC_URI[x86_64_v2_python3-httpx+brotli.sha256sum] = "8f662f9c5343a2464e9e80dd30e4496ab30dbc49e8c6fa5b8d42459e57414743"

URI_x86_64_v2_python3-httpx+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+cli-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+cli}"
SRC_URI[x86_64_v2_python3-httpx+cli.sha256sum] = "f791722a14949b1ef5d344c3fef8fc041ef14b2d84bc3462a0a93b110ce0c0b5"

URI_x86_64_v2_python3-httpx+http2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+http2-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+http2}"
SRC_URI[x86_64_v2_python3-httpx+http2.sha256sum] = "bdb00b4b685cc8b50b440b873fb5338ca0c518f7568b58acacfcb7effd7e5d2f"

URI_x86_64_v2_python3-httpx+socks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+socks-0.28.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+socks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+socks}"
SRC_URI[x86_64_v2_python3-httpx+socks.sha256sum] = "8e3d71d2443dc385c5fa5b73f19e06cffd95ce77ad8b45320ced615d4fdc77e2"

URI_aarch64_python3-httpx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx-0.28.1-2.el10_1.noarch.rpm;name=aarch64_python3-httpx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx}"
SRC_URI[aarch64_python3-httpx.sha256sum] = "54bc3eaef83c31c5616a9771bb152900371bb25fa6cf25cad6098dd26734e43a"

URI_aarch64_python3-httpx+brotli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+brotli-0.28.1-2.el10_1.noarch.rpm;name=aarch64_python3-httpx+brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+brotli}"
SRC_URI[aarch64_python3-httpx+brotli.sha256sum] = "670641dd51d1bd6d8f89a8c74349880d0446bcbff5880f7ade3f22b50ec6b062"

URI_aarch64_python3-httpx+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+cli-0.28.1-2.el10_1.noarch.rpm;name=aarch64_python3-httpx+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+cli}"
SRC_URI[aarch64_python3-httpx+cli.sha256sum] = "c4cfcc26020bd6685908f7aca174dc239ca58ecadd05eb4bf2b0f1c18a7140f8"

URI_aarch64_python3-httpx+http2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+http2-0.28.1-2.el10_1.noarch.rpm;name=aarch64_python3-httpx+http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+http2}"
SRC_URI[aarch64_python3-httpx+http2.sha256sum] = "8baa5f7bdb773a810386b2e1ab6c7f4ad617b3e9be5b7e3cb241748a4ec31cfa"

URI_aarch64_python3-httpx+socks = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+socks-0.28.1-2.el10_1.noarch.rpm;name=aarch64_python3-httpx+socks;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+socks}"
SRC_URI[aarch64_python3-httpx+socks.sha256sum] = "f2cd20f59c5f9aef80228946b543caade99c55f80faa1668f32b54016552a3ea"

RDEPENDS:python3-httpx = " \
 python3 \
 python3-anyio \
 python3-certifi \
 python3-httpcore \
 python3-idna \
 "
RDEPENDS:python3-httpx+brotli = " \
 python3 \
 python3-brotli \
 python3-httpx \
 "
RDEPENDS:python3-httpx+cli = " \
 python3 \
 python3-click \
 python3-httpx \
 python3-pygments \
 python3-rich \
 "
RDEPENDS:python3-httpx+http2 = " \
 python3 \
 python3-h2 \
 python3-httpx \
 "
RDEPENDS:python3-httpx+socks = " \
 python3 \
 python3-httpx \
 python3-socksio \
 "
