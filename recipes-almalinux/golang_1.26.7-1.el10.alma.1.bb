# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang"
PV = "1.26.7"
PR = "1.el10.alma.1"
PACKAGES = " \
 go-toolset \
 golang \
 golang-bin \
 golang-docs \
 golang-misc \
 golang-race \
 golang-src \
 golang-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-1.26.7-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "25334af32af70eebc828acb15cb6d430752f035aec3146ea13bc9715d5fae4d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-toolset-1.26.7-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_go-toolset;unpack=0"
SRC_URI[x86_64_v2_go-toolset.sha256sum] = "6e393f1191b7f95e0d5854d561c6b21c231e45928f44d1eb94653afefccf453b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-1.26.7-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang;unpack=0"
SRC_URI[x86_64_v2_golang.sha256sum] = "0a0eb814aea7aac658a534883943df8cd64bb9ab8725cf534d9cef80867e26a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-bin-1.26.7-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-bin;unpack=0"
SRC_URI[x86_64_v2_golang-bin.sha256sum] = "4e8a458a41a1b81660be0673e409ab4c0b6a707a0d733d9172399d7747d44ed7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-docs-1.26.7-1.el10.alma.1.noarch.rpm;name=x86_64_v2_golang-docs;unpack=0"
SRC_URI[x86_64_v2_golang-docs.sha256sum] = "eb8505da6f7fda5fa64e317406061c8cabe6d731958c17ac8eaa199df31dba8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-misc-1.26.7-1.el10.alma.1.noarch.rpm;name=x86_64_v2_golang-misc;unpack=0"
SRC_URI[x86_64_v2_golang-misc.sha256sum] = "369ff4f65c6acf20c826139eb4f1c29b52c882c5239be8a7a7ee6e42ab23a1b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-race-1.26.7-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-race;unpack=0"
SRC_URI[x86_64_v2_golang-race.sha256sum] = "634fd11a1df9990807e68e4f47d55d1be2a5d55056375103af2695968f305244"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-src-1.26.7-1.el10.alma.1.noarch.rpm;name=x86_64_v2_golang-src;unpack=0"
SRC_URI[x86_64_v2_golang-src.sha256sum] = "f884b7c831281735e962123b554bfa4b41cc40ae911d54a94ef1aa0ccdc1cca3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-tests-1.26.7-1.el10.alma.1.noarch.rpm;name=x86_64_v2_golang-tests;unpack=0"
SRC_URI[x86_64_v2_golang-tests.sha256sum] = "574b7543b969bd6c8c62ab1b4c0d917e1fcf9b60e04cd6bbb0144a5cf25f6c7a"
RPROVIDES:golang-tests:append:x86_64_v2 = " virtual/libtiffxx.so.6___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-toolset-1.26.7-1.el10.alma.1.aarch64.rpm;name=aarch64_go-toolset;unpack=0"
SRC_URI[aarch64_go-toolset.sha256sum] = "02a36491fccb0ba22710a78137ed95d1ee92a54b61887deea532e1270514e5be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-1.26.7-1.el10.alma.1.aarch64.rpm;name=aarch64_golang;unpack=0"
SRC_URI[aarch64_golang.sha256sum] = "29b00db804f61c6e1d0e736dbea4859abaa14a8aba8a020891a92f1c8e17222b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-bin-1.26.7-1.el10.alma.1.aarch64.rpm;name=aarch64_golang-bin;unpack=0"
SRC_URI[aarch64_golang-bin.sha256sum] = "3a0bdfbc2698f103b295315ae2efb35915b7995c3a05cd9f26e59096c3757c28"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-docs-1.26.7-1.el10.alma.1.noarch.rpm;name=aarch64_golang-docs;unpack=0"
SRC_URI[aarch64_golang-docs.sha256sum] = "eb8505da6f7fda5fa64e317406061c8cabe6d731958c17ac8eaa199df31dba8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-misc-1.26.7-1.el10.alma.1.noarch.rpm;name=aarch64_golang-misc;unpack=0"
SRC_URI[aarch64_golang-misc.sha256sum] = "369ff4f65c6acf20c826139eb4f1c29b52c882c5239be8a7a7ee6e42ab23a1b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-race-1.26.7-1.el10.alma.1.aarch64.rpm;name=aarch64_golang-race;unpack=0"
SRC_URI[aarch64_golang-race.sha256sum] = "2e07ffc1032f294fe0acedd81ae412d447311eba61f742d1c43af67a9d896e81"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-src-1.26.7-1.el10.alma.1.noarch.rpm;name=aarch64_golang-src;unpack=0"
SRC_URI[aarch64_golang-src.sha256sum] = "f884b7c831281735e962123b554bfa4b41cc40ae911d54a94ef1aa0ccdc1cca3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-tests-1.26.7-1.el10.alma.1.noarch.rpm;name=aarch64_golang-tests;unpack=0"
SRC_URI[aarch64_golang-tests.sha256sum] = "574b7543b969bd6c8c62ab1b4c0d917e1fcf9b60e04cd6bbb0144a5cf25f6c7a"
RPROVIDES:golang-tests:append:aarch64 = " virtual/libtiffxx.so.6___64bit_"

RDEPENDS:go-toolset = " \
 delve \
 golang \
 "
RDEPENDS:golang = " \
 golang-bin \
 golang-race \
 golang-src \
 openssl-devel \
 "
RDEPENDS:golang-bin = " \
 alternatives \
 bash \
 gcc \
 glibc \
 golang \
 "
RDEPENDS:golang-docs = " \
 golang \
 "
RDEPENDS:golang-misc = " \
 golang \
 "
RDEPENDS:golang-race = " \
 golang \
 "
RDEPENDS:golang-src = " \
 "
RDEPENDS:golang-tests = " \
 golang \
 "
