# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum"
PV = "0.8.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-axum+__private-devel \
 rust-axum+default-devel \
 rust-axum+form-devel \
 rust-axum+http1-devel \
 rust-axum+http2-devel \
 rust-axum+json-devel \
 rust-axum+macros-devel \
 rust-axum+matched-path-devel \
 rust-axum+multipart-devel \
 rust-axum+original-uri-devel \
 rust-axum+query-devel \
 rust-axum+serde-devel \
 rust-axum+tokio-devel \
 rust-axum+tower-http-devel \
 rust-axum+tower-log-devel \
 rust-axum+tracing-devel \
 rust-axum+ws-devel \
 rust-axum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-0.8.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf4dd7111e58231780ebec39a0e4183c32ff44f88238629f0e49e3756ed768ce"

URI_x86_64_v2_rust-axum+__private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+__private-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+__private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+__private-devel}"
SRC_URI[x86_64_v2_rust-axum+__private-devel.sha256sum] = "1e2a7a8627dbf4dfc954fd096587d599985eb6d6b80ea28f71376b7b2c3f3d26"

URI_x86_64_v2_rust-axum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+default-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+default-devel}"
SRC_URI[x86_64_v2_rust-axum+default-devel.sha256sum] = "626b57b174d7d4e22a41edea99782ea5490baca69a9f0c9c3b4e67d18cb1464a"

URI_x86_64_v2_rust-axum+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+form-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+form-devel}"
SRC_URI[x86_64_v2_rust-axum+form-devel.sha256sum] = "0e5c2a7e44a1333d8dce63b9f1d4d15bfac8cdd492ee5fa0c4022e39a38e91ed"

URI_x86_64_v2_rust-axum+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+http1-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+http1-devel}"
SRC_URI[x86_64_v2_rust-axum+http1-devel.sha256sum] = "3f37e7967e77199b8b04b41ae89b8d51d5256916e79dfd697f474a926b7b1e4c"

URI_x86_64_v2_rust-axum+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+http2-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+http2-devel}"
SRC_URI[x86_64_v2_rust-axum+http2-devel.sha256sum] = "0324c330811988d8f972037b717fb19db27b82ac949efff6b06c44f7869e80d4"

URI_x86_64_v2_rust-axum+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+json-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+json-devel}"
SRC_URI[x86_64_v2_rust-axum+json-devel.sha256sum] = "770e8e67546b54c7be9ecfd967daf945283c473d41913a98e4e02c11ca4e5852"

URI_x86_64_v2_rust-axum+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+macros-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+macros-devel}"
SRC_URI[x86_64_v2_rust-axum+macros-devel.sha256sum] = "fff65d188af456b758eb5c82f9f37c49ad3c6fbc7881336c3d3ab5abf5d9f96b"

URI_x86_64_v2_rust-axum+matched-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+matched-path-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+matched-path-devel}"
SRC_URI[x86_64_v2_rust-axum+matched-path-devel.sha256sum] = "52bc4ee85fd2046c66171222d139a52ec43e4486676c8a74eac9d15a849fc2fc"

URI_x86_64_v2_rust-axum+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+multipart-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+multipart-devel}"
SRC_URI[x86_64_v2_rust-axum+multipart-devel.sha256sum] = "b81ec263f16c2a424be232ec56051e43720b289e020e99eb778cefe75b95e456"

URI_x86_64_v2_rust-axum+original-uri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+original-uri-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+original-uri-devel}"
SRC_URI[x86_64_v2_rust-axum+original-uri-devel.sha256sum] = "c0131cec1837800f063f523cc545c8e647c89ac8ead65bd403f0c78aabdee8ec"

URI_x86_64_v2_rust-axum+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+query-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+query-devel}"
SRC_URI[x86_64_v2_rust-axum+query-devel.sha256sum] = "3776dccd8ef83f980b74fe36e4d1d314e6aa5aaf694909248b23f80bf12cef41"

URI_x86_64_v2_rust-axum+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+serde-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+serde-devel}"
SRC_URI[x86_64_v2_rust-axum+serde-devel.sha256sum] = "d20b2823955a65773047fa4bcd0c4ed31453f7264d11b3697e3c55aa3e4c9304"

URI_x86_64_v2_rust-axum+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tokio-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tokio-devel}"
SRC_URI[x86_64_v2_rust-axum+tokio-devel.sha256sum] = "f8b2a66b650ffe1cf7674b57bf87f8a8dc2855e67a80d5eab08d1d6e96da55e8"

URI_x86_64_v2_rust-axum+tower-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tower-http-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tower-http-devel}"
SRC_URI[x86_64_v2_rust-axum+tower-http-devel.sha256sum] = "f914a01fd5978f5f2b7fd65f5ca1205777ceaa21f1856e506f1755b1f98d0555"

URI_x86_64_v2_rust-axum+tower-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tower-log-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tower-log-devel}"
SRC_URI[x86_64_v2_rust-axum+tower-log-devel.sha256sum] = "f5ad9c6b81a073c0de58fc82b7a8e09cbda21f14cdcee1ab1d6cae6cad9ba313"

URI_x86_64_v2_rust-axum+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tracing-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tracing-devel}"
SRC_URI[x86_64_v2_rust-axum+tracing-devel.sha256sum] = "86e304ba2b178429cff376febd20cbd50ab5ef5fe5758c5e77a227049817ef28"

URI_x86_64_v2_rust-axum+ws-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+ws-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+ws-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+ws-devel}"
SRC_URI[x86_64_v2_rust-axum+ws-devel.sha256sum] = "12dc20a36efecad984651bbfb5d499ca12822fdd0425604d2927ac75f8d01808"

URI_x86_64_v2_rust-axum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-devel-0.8.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-devel}"
SRC_URI[x86_64_v2_rust-axum-devel.sha256sum] = "677c0dee572add30aaef74724b8db4d0df60ac7a7c5f988c3d7f327dbb65f989"

URI_aarch64_rust-axum+__private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+__private-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+__private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+__private-devel}"
SRC_URI[aarch64_rust-axum+__private-devel.sha256sum] = "cc86d8461f415d3b81c1c3a6e9cdc9dacbe447ea0a38ee62d5ae129aeb12b192"

URI_aarch64_rust-axum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+default-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+default-devel}"
SRC_URI[aarch64_rust-axum+default-devel.sha256sum] = "0f8fa77ef95ead6270e034b9317aa8b180561a76166fb42dbe01c24c63de9fa3"

URI_aarch64_rust-axum+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+form-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+form-devel}"
SRC_URI[aarch64_rust-axum+form-devel.sha256sum] = "5e74cfcc721e0c39989657b50ab48313532722a8fe300bb9275ee9d636f8ddd7"

URI_aarch64_rust-axum+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+http1-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+http1-devel}"
SRC_URI[aarch64_rust-axum+http1-devel.sha256sum] = "8f2f023bf5ddd650524ad626e39697d40b5c41540015d2752bbf96bc76bdecf4"

URI_aarch64_rust-axum+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+http2-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+http2-devel}"
SRC_URI[aarch64_rust-axum+http2-devel.sha256sum] = "1e948af067a90e2ab2762f950a3bf887b25cc9cfec39b0865874083ef2ac9584"

URI_aarch64_rust-axum+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+json-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+json-devel}"
SRC_URI[aarch64_rust-axum+json-devel.sha256sum] = "bb39df04e67d893ce32d966fef603ab7603d9c60fb5b4df95cd86b583e0bcf27"

URI_aarch64_rust-axum+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+macros-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+macros-devel}"
SRC_URI[aarch64_rust-axum+macros-devel.sha256sum] = "ca7d01fb679a0e1aa974d1cca85cc72ea29169a61bd95db4994b68bfdadc5c27"

URI_aarch64_rust-axum+matched-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+matched-path-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+matched-path-devel}"
SRC_URI[aarch64_rust-axum+matched-path-devel.sha256sum] = "7f6296bdfd15b932b7e43c16489382bee150ab9dbd1ec0faa5f00aac370cb40e"

URI_aarch64_rust-axum+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+multipart-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+multipart-devel}"
SRC_URI[aarch64_rust-axum+multipart-devel.sha256sum] = "b9f62b139a1a7aed064b3e365541f5a2d92463489ac20f749b2b950dbbdc575d"

URI_aarch64_rust-axum+original-uri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+original-uri-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+original-uri-devel}"
SRC_URI[aarch64_rust-axum+original-uri-devel.sha256sum] = "3572b4bf37554f79e8d17dd0c44b2687a72ef24d8cd6e3d4e5e1c4bbb98aa9ed"

URI_aarch64_rust-axum+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+query-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+query-devel}"
SRC_URI[aarch64_rust-axum+query-devel.sha256sum] = "08f97311bd058f8949d6646fa796bc22913380a054d7b619437d39d509621e3e"

URI_aarch64_rust-axum+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+serde-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+serde-devel}"
SRC_URI[aarch64_rust-axum+serde-devel.sha256sum] = "e82cd5a139bcc68a8387de65c219de56749a25386a806cc0b232989ee4df97f4"

URI_aarch64_rust-axum+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tokio-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tokio-devel}"
SRC_URI[aarch64_rust-axum+tokio-devel.sha256sum] = "4aaaf3c953548840f51d1c3d980f3f24fd5141cdba5168ec0b7f489b8320e34c"

URI_aarch64_rust-axum+tower-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tower-http-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tower-http-devel}"
SRC_URI[aarch64_rust-axum+tower-http-devel.sha256sum] = "98dad54b1a34df9b1d919c3802f12970d6818e41673009c68fcf5c3d3de983b7"

URI_aarch64_rust-axum+tower-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tower-log-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tower-log-devel}"
SRC_URI[aarch64_rust-axum+tower-log-devel.sha256sum] = "9f600a61dd8f11a38720b5660b90f36376908c80dc782cc52a96e36337a2703c"

URI_aarch64_rust-axum+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tracing-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tracing-devel}"
SRC_URI[aarch64_rust-axum+tracing-devel.sha256sum] = "0fa5c5e1f13528b7403dff5cb5d017737b2741a1e2272d7314ab8239cec14e2a"

URI_aarch64_rust-axum+ws-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+ws-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum+ws-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+ws-devel}"
SRC_URI[aarch64_rust-axum+ws-devel.sha256sum] = "c9873cbc32e19029c4c0249db18b61ee4aa062a8d7c09924ac5406c33e8cde92"

URI_aarch64_rust-axum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-devel-0.8.8-1.el10_2.noarch.rpm;name=aarch64_rust-axum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-devel}"
SRC_URI[aarch64_rust-axum-devel.sha256sum] = "0e2c42c47f4cd9f28e86421b94b75f5b0c6569ab7c0319f366d1f4820f7cf3b0"

RDEPENDS:rust-axum+__private-devel = " \
 cargo \
 rust-axum+http1-devel \
 rust-axum+tokio-devel \
 rust-axum-devel \
 rust-axum-macros+__private-devel \
 rust-axum-macros+default-devel \
 rust-reqwest0.12+json-devel \
 rust-reqwest0.12+multipart-devel \
 rust-reqwest0.12+stream-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-axum+default-devel = " \
 cargo \
 rust-axum+form-devel \
 rust-axum+http1-devel \
 rust-axum+json-devel \
 rust-axum+matched-path-devel \
 rust-axum+original-uri-devel \
 rust-axum+query-devel \
 rust-axum+tokio-devel \
 rust-axum+tower-log-devel \
 rust-axum+tracing-devel \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+form-devel = " \
 cargo \
 rust-axum-devel \
 rust-form_urlencoded+default-devel \
 rust-serde_path_to_error+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum+http1-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum+http2-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper+default-devel \
 rust-hyper+http2-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum+json-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-serde_path_to_error+default-devel \
 "
RDEPENDS:rust-axum+macros-devel = " \
 cargo \
 rust-axum-devel \
 rust-axum-macros+default-devel \
 "
RDEPENDS:rust-axum+matched-path-devel = " \
 cargo \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+multipart-devel = " \
 cargo \
 rust-axum-devel \
 rust-multer+default-devel \
 "
RDEPENDS:rust-axum+original-uri-devel = " \
 cargo \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+query-devel = " \
 cargo \
 rust-axum-devel \
 rust-form_urlencoded+default-devel \
 rust-serde_path_to_error+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum+serde-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-axum+tokio-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-tokio+default-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 rust-tower+make-devel \
 "
RDEPENDS:rust-axum+tower-http-devel = " \
 cargo \
 rust-axum-devel \
 rust-tower-http+add-extension-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+default-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+util-devel \
 rust-tower-http+validate-request-devel \
 "
RDEPENDS:rust-axum+tower-log-devel = " \
 cargo \
 rust-axum-devel \
 rust-tower+log-devel \
 "
RDEPENDS:rust-axum+tracing-devel = " \
 cargo \
 rust-axum-core+tracing-devel \
 rust-axum-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-axum+ws-devel = " \
 cargo \
 rust-axum+tokio-devel \
 rust-axum-devel \
 rust-base64+default-devel \
 rust-hyper+default-devel \
 rust-sha1+default-devel \
 rust-tokio-tungstenite+default-devel \
 "
RDEPENDS:rust-axum-devel = " \
 cargo \
 rust \
 rust-axum-core+default-devel \
 rust-bytes+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-itoa+default-devel \
 rust-matchit0.8+default-devel \
 rust-memchr+default-devel \
 rust-mime+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-serde_core+default-devel \
 rust-sync_wrapper+default-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
