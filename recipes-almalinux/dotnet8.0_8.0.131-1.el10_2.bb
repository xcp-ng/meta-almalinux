# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet8.0"
PV = "8.0.131"
PR = "1.el10_2"
PACKAGES = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-runtime-dbg-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-hostfxr-8.0 \
 dotnet-runtime-8.0 \
 dotnet-runtime-dbg-8.0 \
 dotnet-sdk-8.0 \
 dotnet-sdk-8.0-source-built-artifacts \
 dotnet-sdk-dbg-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet8.0-8.0.131-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "08eb5b6a47e41ac92e16699beb1ac065324a3108527ba204e91a8ac3d0f2cd3f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-8.0-8.0.31-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-8.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-8.0.sha256sum] = "a176f737e6e5a30c8faeedd4ac50ec54bdab075c4e97557ea2554fd7778645db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.31-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-8.0.sha256sum] = "cfdd0c1697c42232d1f05f7a37c87aa790e34f2918aebe32f3b23df6875280e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-8.0-8.0.31-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-8.0.sha256sum] = "6a5c18b813fb466285e7e0b39eecc75531ad26fcb716e70e47bc62e196cba257"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-8.0-8.0.31-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-apphost-pack-8.0.sha256sum] = "13cd8d18478f68057925e3d82e89c5805016e2356399aa7de0218e2f310e996b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-8.0-8.0.31-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-hostfxr-8.0.sha256sum] = "9b7182236869d4fee2557f6d7c8fc278d6a4370ffcdc00a7d40d6633f45543ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-8.0-8.0.31-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-8.0.sha256sum] = "dd317371da9b782fe4131c60ee651c829cf4baa2d81b9ecc2355be6cf29c83c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-8.0-8.0.31-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-8.0.sha256sum] = "dcf9316dab90ae400d9f89da7a42256778dbc737977d33394e2315a928590920"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-8.0-8.0.131-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-8.0.sha256sum] = "43c337293bf983e7a286f968b7ee054001223d5229a30797350f8c16972dccd0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.131-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "561af626190eca7d096555fef41e47be30c8d76cfdc36dc259471a8fbb71bada"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-8.0-8.0.131-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-8.0.sha256sum] = "4f0e3bf6ab4de48971ec97f23f736f6fd47802af332371a356f395d3a5720d74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-8.0-8.0.31-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-targeting-pack-8.0.sha256sum] = "232d5142021b8bc381794482f077c5609efd24f251a3a08c227a8f2693b847c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-8.0-8.0.131-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-8.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-templates-8.0.sha256sum] = "1aa1a902d895925803db2ee803b90b2733276b1d0c96658ee503d01fe1cd49f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-8.0-8.0.31-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-8.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-8.0.sha256sum] = "787d80887b84bc35ba1deea44a506e4f27151c940cdfb3c95dd67ddb70888487"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-8.0-8.0.31-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-8.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-dbg-8.0.sha256sum] = "2c29d78356f4329ec846e82c48a65e0d72877fa780e365939dc10c75f0f0e7c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-8.0-8.0.31-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-8.0;unpack=0"
SRC_URI[aarch64_aspnetcore-targeting-pack-8.0.sha256sum] = "bba401c359891953d98e4447b3bdb767130240db3aff0b401cf5eda75def2f93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-8.0-8.0.31-1.el10_2.aarch64.rpm;name=aarch64_dotnet-apphost-pack-8.0;unpack=0"
SRC_URI[aarch64_dotnet-apphost-pack-8.0.sha256sum] = "0085a028b1bc134daa0513c45c5d6867d5ac58816f77936308b91f68490028ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-8.0-8.0.31-1.el10_2.aarch64.rpm;name=aarch64_dotnet-hostfxr-8.0;unpack=0"
SRC_URI[aarch64_dotnet-hostfxr-8.0.sha256sum] = "d31f968752000928eff1b6613bb2b7c36c7f702cbe01abf31584f59ec4f8a455"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-8.0-8.0.31-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-8.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-8.0.sha256sum] = "586526cdc12c94ba008dae2346c3aa78a25584bdd67cf6877a6b8040f7ec2b76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-8.0-8.0.31-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-8.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-dbg-8.0.sha256sum] = "8fcf2048e4cc1ded694091a4061637fd749a1237591e804f03f6bce4c9b6812d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-8.0-8.0.131-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-8.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-8.0.sha256sum] = "2fa789966e6ef6b745c4be1db55920bcdb4c59c185ff4f11dc1b9f5d39a161f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-8.0-source-built-artifacts-8.0.131-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-8.0-source-built-artifacts;unpack=0"
SRC_URI[aarch64_dotnet-sdk-8.0-source-built-artifacts.sha256sum] = "960b7136bfd4b334e4d8888a7f9e9eddd3865b0bf5a1037c3ccddd01fe349b8f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-8.0-8.0.131-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-8.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-dbg-8.0.sha256sum] = "66ebc64c84dedd7e1ebf94f565ae093fc251e13da6c4053c7542bea08488db57"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-8.0-8.0.31-1.el10_2.aarch64.rpm;name=aarch64_dotnet-targeting-pack-8.0;unpack=0"
SRC_URI[aarch64_dotnet-targeting-pack-8.0.sha256sum] = "e16f50dcd467341d72334217673467b37f0be348035ea6c4068da4cb7f9beb9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-8.0-8.0.131-1.el10_2.aarch64.rpm;name=aarch64_dotnet-templates-8.0;unpack=0"
SRC_URI[aarch64_dotnet-templates-8.0.sha256sum] = "8f80c4062673903974448f7c2bef2425bb0fa0d98c9764ecff43c2dfe62c8d8e"

RDEPENDS:aspnetcore-runtime-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-8.0 = " \
 aspnetcore-runtime-8.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-hostfxr-8.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-8.0 = " \
 dotnet-hostfxr-8.0 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-8.0 = " \
 dotnet-runtime-8.0 \
 "
RDEPENDS:dotnet-sdk-8.0 = " \
 aspnetcore-runtime-8.0 \
 aspnetcore-targeting-pack-8.0 \
 dotnet-apphost-pack-8.0 \
 dotnet-runtime-8.0 \
 dotnet-targeting-pack-8.0 \
 dotnet-templates-8.0 \
 glibc \
 libgcc \
 libstdc++ \
 netstandard-targeting-pack-2.1 \
 "
RDEPENDS:dotnet-sdk-8.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-dbg-8.0 = " \
 dotnet-sdk-8.0 \
 "
RDEPENDS:dotnet-targeting-pack-8.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-8.0 = " \
 dotnet-host \
 "
