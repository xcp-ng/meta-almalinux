# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quickcheck_macros"
PV = "1.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-quickcheck_macros+default-devel \
 rust-quickcheck_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quickcheck_macros-1.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96408afe27879d7224a80f3a24c7c921d13faccc4f37dd149269cd2537d4783e"

URI_x86_64_v2_rust-quickcheck_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck_macros+default-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck_macros+default-devel}"
SRC_URI[x86_64_v2_rust-quickcheck_macros+default-devel.sha256sum] = "804df289101b28fc124d446cd520e8a219cd4d7c4b8aca42de6dbed6ab16ce51"

URI_x86_64_v2_rust-quickcheck_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck_macros-devel-1.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck_macros-devel}"
SRC_URI[x86_64_v2_rust-quickcheck_macros-devel.sha256sum] = "fe4566cae694058f8789321170e8181bed208ef6565ab5d5a53c6a3145d926ab"

URI_aarch64_rust-quickcheck_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck_macros+default-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-quickcheck_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck_macros+default-devel}"
SRC_URI[aarch64_rust-quickcheck_macros+default-devel.sha256sum] = "aeeb58bf0b7105ec9ea731526785730e0edb92a06b4dfb553051ad6da4e2a25f"

URI_aarch64_rust-quickcheck_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck_macros-devel-1.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-quickcheck_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck_macros-devel}"
SRC_URI[aarch64_rust-quickcheck_macros-devel.sha256sum] = "716f4e4821fc2ade5268a0a6a139509b7e35248f6daca1300ab896ad37934fc7"

RDEPENDS:rust-quickcheck_macros+default-devel = " \
 cargo \
 rust-quickcheck_macros-devel \
 "
RDEPENDS:rust-quickcheck_macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
