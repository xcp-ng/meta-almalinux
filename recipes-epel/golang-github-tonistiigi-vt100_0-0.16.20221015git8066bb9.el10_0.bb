# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-tonistiigi-vt100"
PV = "0"
PR = "0.16.20221015git8066bb9.el10_0"
PACKAGES = " \
 golang-github-tonistiigi-vt100-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-tonistiigi-vt100-0-0.16.20221015git8066bb9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13f7cd3a9b9d1d1beb5a9517e498a30fce681ae393545a09fd4bb30aed0ec8e8"

URI_aarch64_golang-github-tonistiigi-vt100-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-tonistiigi-vt100-devel-0-0.16.20221015git8066bb9.el10_0.noarch.rpm;name=aarch64_golang-github-tonistiigi-vt100-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-tonistiigi-vt100-devel}"
SRC_URI[aarch64_golang-github-tonistiigi-vt100-devel.sha256sum] = "bbe4a15b8619fa616d1e35e6fb2c53c1375d2a41e105fe967d8798353470d603"

RDEPENDS:golang-github-tonistiigi-vt100-devel = " \
 go-filesystem \
 "
