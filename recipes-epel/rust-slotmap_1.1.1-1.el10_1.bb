# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slotmap"
PV = "1.1.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-slotmap+default-devel \
 rust-slotmap+serde-devel \
 rust-slotmap+std-devel \
 rust-slotmap+unstable-devel \
 rust-slotmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slotmap-1.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91ea9bd4d2e967bad249df567b7c414519380bf6fa303f097a17cafe571c7c76"

URI_x86_64_v2_rust-slotmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap+default-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slotmap+default-devel}"
SRC_URI[x86_64_v2_rust-slotmap+default-devel.sha256sum] = "7f1d36f1748da6a8dbd28bed82be9bb44465ec4aed020c96863c6e44892acbf3"

URI_x86_64_v2_rust-slotmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap+serde-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slotmap+serde-devel}"
SRC_URI[x86_64_v2_rust-slotmap+serde-devel.sha256sum] = "a3ca27f78afb4021bda1b5dd39e8ba88de6c38bba2bebf4b6fe8e8bf462368fd"

URI_x86_64_v2_rust-slotmap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap+std-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slotmap+std-devel}"
SRC_URI[x86_64_v2_rust-slotmap+std-devel.sha256sum] = "c526163d0e0815faf3f7d20ff9b408dc8fc0647a6c324cd6adccba47ba7fa19d"

URI_x86_64_v2_rust-slotmap+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap+unstable-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slotmap+unstable-devel}"
SRC_URI[x86_64_v2_rust-slotmap+unstable-devel.sha256sum] = "8d856b7407e145a5b69e3fe0fab354cd5abc208a674678d81858188ef2279e94"

URI_x86_64_v2_rust-slotmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slotmap-devel}"
SRC_URI[x86_64_v2_rust-slotmap-devel.sha256sum] = "2bfc8741cbc22db80025a5618082416f2cf164f1bd5060cc4e77749a1d537cd9"

URI_aarch64_rust-slotmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap+default-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-slotmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slotmap+default-devel}"
SRC_URI[aarch64_rust-slotmap+default-devel.sha256sum] = "a0cc0051a205ae1e4040d8aa40e83252a215eebc13be08ef6f5680edba2304fb"

URI_aarch64_rust-slotmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap+serde-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-slotmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slotmap+serde-devel}"
SRC_URI[aarch64_rust-slotmap+serde-devel.sha256sum] = "041410bab36ca0cda4bad95a27da47c11f72f76d8dc25493713080825e0d867e"

URI_aarch64_rust-slotmap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap+std-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-slotmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slotmap+std-devel}"
SRC_URI[aarch64_rust-slotmap+std-devel.sha256sum] = "27f127aa724394c77d0c0179fb58896618e4d57e252ebeb94515cc927bba3800"

URI_aarch64_rust-slotmap+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap+unstable-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-slotmap+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slotmap+unstable-devel}"
SRC_URI[aarch64_rust-slotmap+unstable-devel.sha256sum] = "5ccac24fcfb435403a9bce6a1bef0cd33a96615552ab1b4fa2baeee51e9dce66"

URI_aarch64_rust-slotmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-slotmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slotmap-devel}"
SRC_URI[aarch64_rust-slotmap-devel.sha256sum] = "f9ea1b245b5c9b7adef756accaf9c9902e6175249fe33d51ccc46eaf2ba6b73f"

RDEPENDS:rust-slotmap+default-devel = " \
 cargo \
 rust-slotmap+std-devel \
 rust-slotmap-devel \
 "
RDEPENDS:rust-slotmap+serde-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-slotmap-devel \
 "
RDEPENDS:rust-slotmap+std-devel = " \
 cargo \
 rust-slotmap-devel \
 "
RDEPENDS:rust-slotmap+unstable-devel = " \
 cargo \
 rust-slotmap-devel \
 "
RDEPENDS:rust-slotmap-devel = " \
 cargo \
 rust \
 rust-version_check+default-devel \
 "
