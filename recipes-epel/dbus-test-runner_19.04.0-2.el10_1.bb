# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus-test-runner"
PV = "19.04.0"
PR = "2.el10_1"
PACKAGES = " \
 dbus-test-runner \
 dbus-test-runner-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dbus-test-runner-19.04.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ca634685c83f989ccd237283c6e0929f327ec877442a513ce79328974734e6c"

URI_x86_64_v2_dbus-test-runner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dbus-test-runner-19.04.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dbus-test-runner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-test-runner}"
SRC_URI[x86_64_v2_dbus-test-runner.sha256sum] = "92656322720a8c799645075147cdfb61252eea64af12175ea756660fc675707b"

URI_x86_64_v2_dbus-test-runner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dbus-test-runner-devel-19.04.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dbus-test-runner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-test-runner-devel}"
SRC_URI[x86_64_v2_dbus-test-runner-devel.sha256sum] = "834aaed178e8159d6732b7c432d4f64c85ab1b4e8746811a24667e2913a7184c"

URI_aarch64_dbus-test-runner = "${EPEL_MIRROR}/aarch64/Packages/d/dbus-test-runner-19.04.0-2.el10_1.aarch64.rpm;name=aarch64_dbus-test-runner;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-test-runner}"
SRC_URI[aarch64_dbus-test-runner.sha256sum] = "45b9d9381e6645578224376c794f084291160c5701a58e96733005216d9b6806"

URI_aarch64_dbus-test-runner-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dbus-test-runner-devel-19.04.0-2.el10_1.aarch64.rpm;name=aarch64_dbus-test-runner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-test-runner-devel}"
SRC_URI[aarch64_dbus-test-runner-devel.sha256sum] = "cf8258d39c41104464c67172616446598008974058430b08d339b98fc491ec2c"

RDEPENDS:dbus-test-runner = " \
 bash \
 dbus-daemon \
 dbus-glib \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:dbus-test-runner-devel = " \
 dbus-test-runner \
 glib2-devel \
 pkgconf-pkg-config \
 "
