# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblouis"
PV = "3.28.0"
PR = "7.el10"
PACKAGES = " \
 liblouis \
 liblouis-devel \
 liblouis-doc \
 liblouis-tables \
 liblouis-utils \
 python3-louis \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/liblouis-3.28.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb40774060c14f864118fe4a02c993839501ea9b7f269294721450b483637977"

URI_x86_64_v2_liblouis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblouis-3.28.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_liblouis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblouis}"
SRC_URI[x86_64_v2_liblouis.sha256sum] = "52aa1c5f5fddee767dfbd86e848fbaaae025ddce6e8c7c7e03e02b736c0423ae"

URI_x86_64_v2_liblouis-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liblouis-devel-3.28.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_liblouis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblouis-devel}"
SRC_URI[x86_64_v2_liblouis-devel.sha256sum] = "40b9cef899a58b2e268a2a9e912cb263c73c81f62d5f9af427144af8636d0b02"

URI_x86_64_v2_liblouis-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liblouis-doc-3.28.0-7.el10.noarch.rpm;name=x86_64_v2_liblouis-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblouis-doc}"
SRC_URI[x86_64_v2_liblouis-doc.sha256sum] = "09950809f5d81489f82e33ed0482cfd5eb8f054e62929d3b22cdb0874e37032c"

URI_x86_64_v2_liblouis-tables = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblouis-tables-3.28.0-7.el10.noarch.rpm;name=x86_64_v2_liblouis-tables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblouis-tables}"
SRC_URI[x86_64_v2_liblouis-tables.sha256sum] = "288666c6d4e832748c50f2b37ad36624ee319015b1e46af0854da6b27baf56f3"

URI_x86_64_v2_liblouis-utils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liblouis-utils-3.28.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_liblouis-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liblouis-utils}"
SRC_URI[x86_64_v2_liblouis-utils.sha256sum] = "2c5a16ef2683407d44b1f11339015ad97b948341c85aff07bf91b577060a8d0d"

URI_x86_64_v2_python3-louis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-louis-3.28.0-7.el10.noarch.rpm;name=x86_64_v2_python3-louis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-louis}"
SRC_URI[x86_64_v2_python3-louis.sha256sum] = "7da2984cf966aeeb99bf8be177aca1e8ebcfa60f6a7fca3e46fb06dc66de31e1"

URI_aarch64_liblouis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblouis-3.28.0-7.el10.aarch64.rpm;name=aarch64_liblouis;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblouis}"
SRC_URI[aarch64_liblouis.sha256sum] = "11644fe03d4d26dbbd63bdc8b9c83154385e63c8d115d2f0a5a59eecf839c73d"

URI_aarch64_liblouis-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liblouis-devel-3.28.0-7.el10.aarch64.rpm;name=aarch64_liblouis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblouis-devel}"
SRC_URI[aarch64_liblouis-devel.sha256sum] = "b3a3e8b89f8d55a128f041ff95745eb023475949debd838a5ae1bf5bb21b8a69"

URI_aarch64_liblouis-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liblouis-doc-3.28.0-7.el10.noarch.rpm;name=aarch64_liblouis-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblouis-doc}"
SRC_URI[aarch64_liblouis-doc.sha256sum] = "09950809f5d81489f82e33ed0482cfd5eb8f054e62929d3b22cdb0874e37032c"

URI_aarch64_liblouis-tables = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblouis-tables-3.28.0-7.el10.noarch.rpm;name=aarch64_liblouis-tables;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblouis-tables}"
SRC_URI[aarch64_liblouis-tables.sha256sum] = "288666c6d4e832748c50f2b37ad36624ee319015b1e46af0854da6b27baf56f3"

URI_aarch64_liblouis-utils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liblouis-utils-3.28.0-7.el10.aarch64.rpm;name=aarch64_liblouis-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_liblouis-utils}"
SRC_URI[aarch64_liblouis-utils.sha256sum] = "00a9658e3069aaead3eadd5b9cfd1ebe3c9282a00c57ea2650d9b37fe87832f9"

URI_aarch64_python3-louis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-louis-3.28.0-7.el10.noarch.rpm;name=aarch64_python3-louis;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-louis}"
SRC_URI[aarch64_python3-louis.sha256sum] = "7da2984cf966aeeb99bf8be177aca1e8ebcfa60f6a7fca3e46fb06dc66de31e1"

RDEPENDS:liblouis = " \
 glibc \
 liblouis-tables \
 "
RDEPENDS:liblouis-devel = " \
 liblouis \
 pkgconf-pkg-config \
 "
RDEPENDS:liblouis-doc = " \
 liblouis \
 "
RDEPENDS:liblouis-tables = " \
 "
RDEPENDS:liblouis-utils = " \
 glibc \
 liblouis \
 libyaml \
 "
RDEPENDS:python3-louis = " \
 liblouis \
 python3 \
 "
