# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-difference"
PV = "2.0.0"
PR = "27.el10_0"
PACKAGES = " \
 rust-difference+default-devel \
 rust-difference-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-difference-2.0.0-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9aba4d690b263afdde76e636abb1c79f9c0cbc15bdc4a2b86b008cee74639337"

URI_x86_64_v2_rust-difference+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-difference+default-devel-2.0.0-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-difference+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-difference+default-devel}"
SRC_URI[x86_64_v2_rust-difference+default-devel.sha256sum] = "db12abc95a1bb1783374ef8c76972a7f055bc197d245b2e2f713c08e67073487"

URI_x86_64_v2_rust-difference-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-difference-devel-2.0.0-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-difference-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-difference-devel}"
SRC_URI[x86_64_v2_rust-difference-devel.sha256sum] = "76409e4e14db3cceb74206234bc83ee1af377acb53eeb5acb6be5fff3a9a28e9"

URI_aarch64_rust-difference+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-difference+default-devel-2.0.0-27.el10_0.noarch.rpm;name=aarch64_rust-difference+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-difference+default-devel}"
SRC_URI[aarch64_rust-difference+default-devel.sha256sum] = "20c0e7d8319375a046bee7fea379bbd74f6ff5b310f782ce4f78efe8f42919ba"

URI_aarch64_rust-difference-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-difference-devel-2.0.0-27.el10_0.noarch.rpm;name=aarch64_rust-difference-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-difference-devel}"
SRC_URI[aarch64_rust-difference-devel.sha256sum] = "6b76aa88b7424df7df0420f2c9c59015b9e62d5948a82812f4797f1f955a8a75"

RDEPENDS:rust-difference+default-devel = " \
 cargo \
 rust-difference-devel \
 "
RDEPENDS:rust-difference-devel = " \
 cargo \
 "
