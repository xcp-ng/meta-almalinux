# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-User-Identity"
PV = "1.02"
PR = "6.el10_0"
PACKAGES = " \
 perl-User-Identity \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-User-Identity-1.02-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2395362546ee20f62cd1c2a508578fdba8a8c26612b900202a6174511ff3c9d"

URI_x86_64_v2_perl-User-Identity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-User-Identity-1.02-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-User-Identity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-User-Identity}"
SRC_URI[x86_64_v2_perl-User-Identity.sha256sum] = "11067bac455c823379f81402d7d1ab1385976ea7c0353d9c4924dcffd9b1e154"

URI_aarch64_perl-User-Identity = "${EPEL_MIRROR}/aarch64/Packages/p/perl-User-Identity-1.02-6.el10_0.noarch.rpm;name=aarch64_perl-User-Identity;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-User-Identity}"
SRC_URI[aarch64_perl-User-Identity.sha256sum] = "2aa2ed8727324ba2c2e59a9ca22729181b56d73b6a12b7dcbda620e86b2fe844"

RDEPENDS:perl-User-Identity = " \
 perl-Carp \
 perl-Geography-Countries \
 perl-Hash-Ordered \
 perl-Scalar-List-Utils \
 perl-User-Identity \
 perl-base \
 perl-libs \
 perl-overload \
 perl-vars \
 "
