# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyqt6"
PV = "6.8.0"
PR = "1.el10"
PACKAGES = " \
 python-pyqt6-doc \
 python-pyqt6-rpm-macros \
 python3-pyqt6 \
 python3-pyqt6-base \
 python3-pyqt6-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pyqt6-6.8.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd62af846fdcabde9d46d25f330337e0bb98b40131a370be49d62f7f5b712756"

URI_x86_64_v2_python-pyqt6-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python-pyqt6-doc-6.8.0-1.el10.noarch.rpm;name=x86_64_v2_python-pyqt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyqt6-doc}"
SRC_URI[x86_64_v2_python-pyqt6-doc.sha256sum] = "5d3801ffb5ff35ffc7b86ae4d729ff1d8edd6885473ec5b915549b2462294c3f"

URI_x86_64_v2_python-pyqt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-pyqt6-rpm-macros-6.8.0-1.el10.noarch.rpm;name=x86_64_v2_python-pyqt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyqt6-rpm-macros}"
SRC_URI[x86_64_v2_python-pyqt6-rpm-macros.sha256sum] = "bbf2336233c804db40942b9c17c179258171a9a46559c3ed7a749c7ec5372523"

URI_x86_64_v2_python3-pyqt6 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyqt6-6.8.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6}"
SRC_URI[x86_64_v2_python3-pyqt6.sha256sum] = "13c019399247bd7cf3ee129b9c0e9dadd9928cf26c8822a4db1e423b5567e233"

URI_x86_64_v2_python3-pyqt6-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyqt6-base-6.8.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-base}"
SRC_URI[x86_64_v2_python3-pyqt6-base.sha256sum] = "7610f133d871d66b607d56cb5ef49687f4380b3070cd1d9ec5a252d40434c598"

URI_x86_64_v2_python3-pyqt6-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyqt6-devel-6.8.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-devel}"
SRC_URI[x86_64_v2_python3-pyqt6-devel.sha256sum] = "6fc85c0e0860d68e69c134bdea06783e80b0c8c0939ee720ffaed57b9d9d7d50"

URI_aarch64_python-pyqt6-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python-pyqt6-doc-6.8.0-1.el10.noarch.rpm;name=aarch64_python-pyqt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyqt6-doc}"
SRC_URI[aarch64_python-pyqt6-doc.sha256sum] = "5d3801ffb5ff35ffc7b86ae4d729ff1d8edd6885473ec5b915549b2462294c3f"

URI_aarch64_python-pyqt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-pyqt6-rpm-macros-6.8.0-1.el10.noarch.rpm;name=aarch64_python-pyqt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyqt6-rpm-macros}"
SRC_URI[aarch64_python-pyqt6-rpm-macros.sha256sum] = "bbf2336233c804db40942b9c17c179258171a9a46559c3ed7a749c7ec5372523"

URI_aarch64_python3-pyqt6 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyqt6-6.8.0-1.el10.aarch64.rpm;name=aarch64_python3-pyqt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6}"
SRC_URI[aarch64_python3-pyqt6.sha256sum] = "d2bbd84399a138f3dd01e74e1fe263d64941ba152b0cf653fc3f42297a8de823"

URI_aarch64_python3-pyqt6-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyqt6-base-6.8.0-1.el10.aarch64.rpm;name=aarch64_python3-pyqt6-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-base}"
SRC_URI[aarch64_python3-pyqt6-base.sha256sum] = "f06e3b288fec41de441ea7bcc1d100ffc55b799a87e870f1eed323a80b851733"

URI_aarch64_python3-pyqt6-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyqt6-devel-6.8.0-1.el10.aarch64.rpm;name=aarch64_python3-pyqt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-devel}"
SRC_URI[aarch64_python3-pyqt6-devel.sha256sum] = "244f679622e53e3cbc168664a05bc7e5c15e2af37010008d6e95dfec8ccee5ce"

RDEPENDS:python-pyqt6-doc = " \
 "
RDEPENDS:python-pyqt6-rpm-macros = " \
 "
RDEPENDS:python3-pyqt6 = " \
 glibc \
 libstdc++ \
 python3 \
 python3-pyqt6-base \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtconnectivity \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtquick3d \
 qt6-qtremoteobjects \
 qt6-qtsensors \
 qt6-qtserialport \
 qt6-qtspeech \
 qt6-qtsvg \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-help \
 qt6-qtwebchannel \
 qt6-qtwebsockets \
 "
RDEPENDS:python3-pyqt6-base = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libstdc++ \
 python-pyqt6-rpm-macros \
 python3 \
 python3-dbus \
 python3-libs \
 python3-pyqt6-sip \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:python3-pyqt6-devel = " \
 python3-pyqt6 \
 qt6-qtbase-devel \
 "
