# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpmrebuild"
PV = "2.20"
PR = "3.el10_1"
PACKAGES = " \
 rpmrebuild \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpmrebuild-2.20-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3042f8e11e7c620815d9520c08d49b2f8cab75b3c8788192b32be6a6d2dd65f9"

URI_x86_64_v2_rpmrebuild = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmrebuild-2.20-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rpmrebuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmrebuild}"
SRC_URI[x86_64_v2_rpmrebuild.sha256sum] = "15505179faeef338d100f38f4b120a10c840552c9c6c589a09be7303c5ac8619"

URI_aarch64_rpmrebuild = "${EPEL_MIRROR}/aarch64/Packages/r/rpmrebuild-2.20-3.el10_1.noarch.rpm;name=aarch64_rpmrebuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmrebuild}"
SRC_URI[aarch64_rpmrebuild.sha256sum] = "d4a19abb35f4115117dfffbb2bddf1fe6b6520d33c873a4677e5a6448072bc4d"

RDEPENDS:rpmrebuild = " \
 bash \
 rpm \
 rpm-build \
 util-linux \
 virtual/coreutils \
 "
