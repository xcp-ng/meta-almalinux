# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-get-size2"
PV = "0.7.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-get-size2+bytes-devel \
 rust-get-size2+chrono-devel \
 rust-get-size2+chrono-tz-devel \
 rust-get-size2+compact-str-devel \
 rust-get-size2+default-devel \
 rust-get-size2+derive-devel \
 rust-get-size2+get-size-derive2-devel \
 rust-get-size2+hashbrown-devel \
 rust-get-size2+indexmap-devel \
 rust-get-size2+ordermap-devel \
 rust-get-size2+smallvec-devel \
 rust-get-size2+thin-vec-devel \
 rust-get-size2+url-devel \
 rust-get-size2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-get-size2-0.7.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ae9753e9be425ee6b91ffb9c0b0d4912478c8d19ca1188af62f475ee85b987c"

URI_x86_64_v2_rust-get-size2+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+bytes-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+bytes-devel}"
SRC_URI[x86_64_v2_rust-get-size2+bytes-devel.sha256sum] = "1a538fd20bd76a2f6ef1f90a8361f9cefadc3a8676e8e1fdbc7c5800418118ec"

URI_x86_64_v2_rust-get-size2+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+chrono-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+chrono-devel}"
SRC_URI[x86_64_v2_rust-get-size2+chrono-devel.sha256sum] = "a66928a3b9be055eb837134390f280cdb26c54f1f3aace0ac3767f7b7ac902e5"

URI_x86_64_v2_rust-get-size2+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+chrono-tz-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-get-size2+chrono-tz-devel.sha256sum] = "f86f62cec4719ea54e5d297215de79cc09d194a9fca147984e8aa8353e098327"

URI_x86_64_v2_rust-get-size2+compact-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+compact-str-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+compact-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+compact-str-devel}"
SRC_URI[x86_64_v2_rust-get-size2+compact-str-devel.sha256sum] = "1827253dd9075ad53d0a7b32b20e4a0a5260ab34534b195f28d05a4cd3b8de94"

URI_x86_64_v2_rust-get-size2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+default-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+default-devel}"
SRC_URI[x86_64_v2_rust-get-size2+default-devel.sha256sum] = "5d56fbbd4383cca5c4f57bcc19293f57e8eae7e19a08b9b9987d05dcd33d045e"

URI_x86_64_v2_rust-get-size2+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+derive-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+derive-devel}"
SRC_URI[x86_64_v2_rust-get-size2+derive-devel.sha256sum] = "83385675708104b7c1197d35e488c6a7a3d5a377b2d7a0e6e367d2944ac1004d"

URI_x86_64_v2_rust-get-size2+get-size-derive2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+get-size-derive2-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+get-size-derive2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+get-size-derive2-devel}"
SRC_URI[x86_64_v2_rust-get-size2+get-size-derive2-devel.sha256sum] = "c45a8c3d2f82b6aa314f1d528094fa0a4ebf3d217273ad4c715a46ea0a06f3a0"

URI_x86_64_v2_rust-get-size2+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+hashbrown-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-get-size2+hashbrown-devel.sha256sum] = "fa6e34697d9614aa450201520a8f4b743f951a7164e42ebe5f427e416f7d47d9"

URI_x86_64_v2_rust-get-size2+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+indexmap-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+indexmap-devel}"
SRC_URI[x86_64_v2_rust-get-size2+indexmap-devel.sha256sum] = "f7ac87591d6c1d99ee832eeb017584f6ec65597ecd5c49300817047a0dd5a5c3"

URI_x86_64_v2_rust-get-size2+ordermap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+ordermap-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+ordermap-devel}"
SRC_URI[x86_64_v2_rust-get-size2+ordermap-devel.sha256sum] = "b46bb62cce94222c5b14fb3767524c1a99b9a5e8977f0d0389fff4b7a0dc830f"

URI_x86_64_v2_rust-get-size2+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+smallvec-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+smallvec-devel}"
SRC_URI[x86_64_v2_rust-get-size2+smallvec-devel.sha256sum] = "d271ed944217318008273e4664d1237d809a648a0d9ba62acbf7e7ba1cc703e2"

URI_x86_64_v2_rust-get-size2+thin-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+thin-vec-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+thin-vec-devel}"
SRC_URI[x86_64_v2_rust-get-size2+thin-vec-devel.sha256sum] = "72e34f35bb6886bb9490f0e3412447b7c652124697e8e078f0e0a76fc9bf4584"

URI_x86_64_v2_rust-get-size2+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2+url-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2+url-devel}"
SRC_URI[x86_64_v2_rust-get-size2+url-devel.sha256sum] = "2010d68a69e447f40d37a9b14a7c95e3b2c30456bc37f54db3aad85c2d192dc0"

URI_x86_64_v2_rust-get-size2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size2-devel-0.7.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size2-devel}"
SRC_URI[x86_64_v2_rust-get-size2-devel.sha256sum] = "43b6591440df3beffe27d13fd4a175adb138c89ce88851b17dc6df70815d36d6"

URI_aarch64_rust-get-size2+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+bytes-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+bytes-devel}"
SRC_URI[aarch64_rust-get-size2+bytes-devel.sha256sum] = "558ecad4589434a00221499c0a1c5c1e9aefdf7e1c0ad0a89e2125ec9d0f8239"

URI_aarch64_rust-get-size2+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+chrono-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+chrono-devel}"
SRC_URI[aarch64_rust-get-size2+chrono-devel.sha256sum] = "938dbe0dddff7dc7b89b0a329c682022bb935d3a065dbb36e021a2e261b1e623"

URI_aarch64_rust-get-size2+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+chrono-tz-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+chrono-tz-devel}"
SRC_URI[aarch64_rust-get-size2+chrono-tz-devel.sha256sum] = "365c2f3bf4ce70626cecc64955d441f859ad8de56b2f8c19a2d55842cabd6012"

URI_aarch64_rust-get-size2+compact-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+compact-str-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+compact-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+compact-str-devel}"
SRC_URI[aarch64_rust-get-size2+compact-str-devel.sha256sum] = "eb4273f39a41415bb28e3935cbbd401c4494ed3f2bd8d733a19a5b054d622024"

URI_aarch64_rust-get-size2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+default-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+default-devel}"
SRC_URI[aarch64_rust-get-size2+default-devel.sha256sum] = "22506e840e5151673a4dbde900d855007416bad2591b3a49542aaa82ac33fb97"

URI_aarch64_rust-get-size2+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+derive-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+derive-devel}"
SRC_URI[aarch64_rust-get-size2+derive-devel.sha256sum] = "d4d77678728306351d2fb60edc97001b1fbbb82ae1ccb715f8616097443e767e"

URI_aarch64_rust-get-size2+get-size-derive2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+get-size-derive2-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+get-size-derive2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+get-size-derive2-devel}"
SRC_URI[aarch64_rust-get-size2+get-size-derive2-devel.sha256sum] = "725afb3f367b94fb54048157ef6b30d0d4b7e76278bf7a20782f40dc8f9af56d"

URI_aarch64_rust-get-size2+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+hashbrown-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+hashbrown-devel}"
SRC_URI[aarch64_rust-get-size2+hashbrown-devel.sha256sum] = "b9afaedc2f3aaa80781e49d107648d8db71cb00daa2719d8cd402ed84a0871d3"

URI_aarch64_rust-get-size2+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+indexmap-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+indexmap-devel}"
SRC_URI[aarch64_rust-get-size2+indexmap-devel.sha256sum] = "8882da5541896eb6691da76e8493327db12075cb40b252503c9228c013cfc070"

URI_aarch64_rust-get-size2+ordermap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+ordermap-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+ordermap-devel}"
SRC_URI[aarch64_rust-get-size2+ordermap-devel.sha256sum] = "068f39946370f81f4dcfa854903e4930e456e404dc78df500789da40b8793f42"

URI_aarch64_rust-get-size2+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+smallvec-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+smallvec-devel}"
SRC_URI[aarch64_rust-get-size2+smallvec-devel.sha256sum] = "2b434fbda40e394b75f5442af04680a4c0f7e90e74d552cab175474b33b53d06"

URI_aarch64_rust-get-size2+thin-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+thin-vec-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+thin-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+thin-vec-devel}"
SRC_URI[aarch64_rust-get-size2+thin-vec-devel.sha256sum] = "eddd27885515e4ef743ff0c681b701e2e116a677cb634c6a4c06139d9c04ce20"

URI_aarch64_rust-get-size2+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2+url-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2+url-devel}"
SRC_URI[aarch64_rust-get-size2+url-devel.sha256sum] = "3e277d767e100ba4c30db1f5fcaa87686497cc7306f481eceee4bd35cf9c7955"

URI_aarch64_rust-get-size2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size2-devel-0.7.4-1.el10_2.noarch.rpm;name=aarch64_rust-get-size2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size2-devel}"
SRC_URI[aarch64_rust-get-size2-devel.sha256sum] = "212b193c550363d8bf8c661b09679e956140eb959c7f11024a68c98b9ef7dc4a"

RDEPENDS:rust-get-size2+bytes-devel = " \
 cargo \
 rust-bytes-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+compact-str-devel = " \
 cargo \
 rust-compact_str-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+default-devel = " \
 cargo \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+derive-devel = " \
 cargo \
 rust-get-size2+get-size-derive2-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+get-size-derive2-devel = " \
 cargo \
 rust-get-size-derive2+default-devel \
 rust-get-size2-devel \
 "
RDEPENDS:rust-get-size2+hashbrown-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-get-size2+indexmap-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-get-size2+ordermap-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-get-size2+smallvec-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-get-size2+thin-vec-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-get-size2+url-devel = " \
 cargo \
 rust-get-size2-devel \
 rust-url-devel \
 "
RDEPENDS:rust-get-size2-devel = " \
 cargo \
 "
