# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hex-literal"
PV = "0.4.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-hex-literal+default-devel \
 rust-hex-literal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hex-literal-0.4.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d156ad0db6adad0bd9ab7b36c7de93f8ec06d1d6087c9d7ca016e3b43e8b8563"

URI_x86_64_v2_rust-hex-literal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal+default-devel-0.4.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex-literal+default-devel}"
SRC_URI[x86_64_v2_rust-hex-literal+default-devel.sha256sum] = "a07b1a852b40f56c1eef140f713a24a5f29e9a5e3b28cd20fb2821bf0f1f11ea"

URI_x86_64_v2_rust-hex-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal-devel-0.4.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex-literal-devel}"
SRC_URI[x86_64_v2_rust-hex-literal-devel.sha256sum] = "582067ab82ff07c801184228887aad920c71f9c538a0c038bf80d70f6140828e"

URI_aarch64_rust-hex-literal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal+default-devel-0.4.1-4.el10_0.noarch.rpm;name=aarch64_rust-hex-literal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex-literal+default-devel}"
SRC_URI[aarch64_rust-hex-literal+default-devel.sha256sum] = "7f9f74949db732fab78444eda08ef2dc2b0d88293519487090052c068f3e9a0b"

URI_aarch64_rust-hex-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal-devel-0.4.1-4.el10_0.noarch.rpm;name=aarch64_rust-hex-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex-literal-devel}"
SRC_URI[aarch64_rust-hex-literal-devel.sha256sum] = "563851a3d4579caf9de3de217d2318aa0079d9c38f93bef9ec9998a430c91ae9"

RDEPENDS:rust-hex-literal+default-devel = " \
 cargo \
 rust-hex-literal-devel \
 "
RDEPENDS:rust-hex-literal-devel = " \
 cargo \
 rust \
 "
