# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "livecd-tools"
PV = "31.0"
PR = "15.el10_0"
PACKAGES:x86_64_v2 = " \
 livecd-iso-to-mediums \
 livecd-tools \
 python-imgcreate-sysdeps \
 python3-imgcreate \
"
PACKAGES:aarch64 = " \
 livecd-tools \
 python-imgcreate-sysdeps \
 python3-imgcreate \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/livecd-tools-31.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ed036c5f1ddd2561c1091aeec85a39a64b6a06927022b5f48ae8ad84fc5fe77"

URI_x86_64_v2_livecd-iso-to-mediums = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/livecd-iso-to-mediums-31.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_livecd-iso-to-mediums;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_livecd-iso-to-mediums}"
SRC_URI[x86_64_v2_livecd-iso-to-mediums.sha256sum] = "d858e193d5376269edf170dc74a32ea3c234665b38b23eb0955a3db0ee781b4e"

URI_x86_64_v2_livecd-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/livecd-tools-31.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_livecd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_livecd-tools}"
SRC_URI[x86_64_v2_livecd-tools.sha256sum] = "70cfeee25049a6ef1048b87ada58f6cd17614ad0415d60fab9c1c22c9d56a03c"

URI_x86_64_v2_python-imgcreate-sysdeps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-imgcreate-sysdeps-31.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-imgcreate-sysdeps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-imgcreate-sysdeps}"
SRC_URI[x86_64_v2_python-imgcreate-sysdeps.sha256sum] = "60b79cbe9256a664e499bc9226ec7f5eac279b1df1baceca241939a06ffec1ae"

URI_x86_64_v2_python3-imgcreate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-imgcreate-31.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-imgcreate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-imgcreate}"
SRC_URI[x86_64_v2_python3-imgcreate.sha256sum] = "db725262a311a1a30f3f061fb9b47980e774eabdd0277f22c530a8ee9e66e9fb"

URI_aarch64_livecd-tools = "${EPEL_MIRROR}/aarch64/Packages/l/livecd-tools-31.0-15.el10_0.aarch64.rpm;name=aarch64_livecd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_livecd-tools}"
SRC_URI[aarch64_livecd-tools.sha256sum] = "89fa23c00a28247ddebee85560a11b13e3439775beae60f898310ee1f3ccad12"

URI_aarch64_python-imgcreate-sysdeps = "${EPEL_MIRROR}/aarch64/Packages/p/python-imgcreate-sysdeps-31.0-15.el10_0.aarch64.rpm;name=aarch64_python-imgcreate-sysdeps;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-imgcreate-sysdeps}"
SRC_URI[aarch64_python-imgcreate-sysdeps.sha256sum] = "29c39ccb382d2331e76bca7464d2d89a3f85a9f3d7a5b014e19fdb675337f413"

URI_aarch64_python3-imgcreate = "${EPEL_MIRROR}/aarch64/Packages/p/python3-imgcreate-31.0-15.el10_0.aarch64.rpm;name=aarch64_python3-imgcreate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-imgcreate}"
SRC_URI[aarch64_python3-imgcreate.sha256sum] = "08bc763f867ea048aa94973d993406f267bf06d7574b24555c2968d98252453a"

RDEPENDS:livecd-iso-to-mediums = " \
 bash \
 python-imgcreate-sysdeps \
 "
RDEPENDS:livecd-tools:x86_64_v2 = " \
 livecd-iso-to-mediums \
 python3 \
 python3-imgcreate \
"
RDEPENDS:livecd-tools:aarch64 = " \
 python3 \
 python3-imgcreate \
"
RDEPENDS:python-imgcreate-sysdeps:x86_64_v2 = " \
 cryptsetup \
 dosfstools \
 dracut \
 dracut-live \
 dumpet \
 e2fsprogs \
 isomd5sum \
 lorax \
 parted \
 policycoreutils \
 rsync \
 selinux-policy-targeted \
 squashfs-tools \
 sssd-client \
 syslinux \
 syslinux-extlinux \
 syslinux-nonlinux \
 util-linux \
 virtual/coreutils \
 xorriso \
"
RDEPENDS:python-imgcreate-sysdeps:aarch64 = " \
 cryptsetup \
 dosfstools \
 dracut \
 dracut-live \
 dumpet \
 e2fsprogs \
 isomd5sum \
 lorax \
 parted \
 policycoreutils \
 rsync \
 selinux-policy-targeted \
 squashfs-tools \
 sssd-client \
 util-linux \
 virtual/coreutils \
 xorriso \
"
RDEPENDS:python3-imgcreate = " \
 python-imgcreate-sysdeps \
 python3 \
 python3-dbus \
 python3-dnf \
 python3-kickstart \
 python3-libselinux \
 python3-pyparted \
 python3-urlgrabber \
 "
