# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nano"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-nano \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-nano-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4142b7e355e3492fb60ad60e26b2a45d36db7bb75627a591aeea96c4ff698da"

URI_x86_64_v2_plasma-nano = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nano-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nano;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nano}"
SRC_URI[x86_64_v2_plasma-nano.sha256sum] = "6c7d05ecd7e5c8d6011a530887acb2582b00dd64a3adfaf8f08e18c8bcbca23e"

URI_aarch64_plasma-nano = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nano-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-nano;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nano}"
SRC_URI[aarch64_plasma-nano.sha256sum] = "e0cf332fb8c4e7d7a985d6f85cd73ed0ed2a57bfad95250233c9c2d53d975536"

RDEPENDS:plasma-nano = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kwayland \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
