# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fail2ban"
PV = "1.1.0"
PR = "6.el10_0"
PACKAGES = " \
 fail2ban \
 fail2ban-all \
 fail2ban-firewalld \
 fail2ban-hostsdeny \
 fail2ban-mail \
 fail2ban-selinux \
 fail2ban-sendmail \
 fail2ban-server \
 fail2ban-systemd \
 fail2ban-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fail2ban-1.1.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5667cbefed38fef5f686ea36771c6b1ecd52051e2db7262d4152349c12ed47d9"

URI_x86_64_v2_fail2ban = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban}"
SRC_URI[x86_64_v2_fail2ban.sha256sum] = "7964a6253895ea184ea3c4b342cd15094028c6d31177517c3d0d585c5cc1f860"

URI_x86_64_v2_fail2ban-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-all-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban-all}"
SRC_URI[x86_64_v2_fail2ban-all.sha256sum] = "dac2603d153c487454208d6d3251722ba5b9621a2c3ea3e7e56d455d9a862490"

URI_x86_64_v2_fail2ban-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-firewalld-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban-firewalld}"
SRC_URI[x86_64_v2_fail2ban-firewalld.sha256sum] = "5e7d4b95a4e317c0e81ef34124b5fe2685a8b0426a28ed6e9c6f699d96d279a3"

URI_x86_64_v2_fail2ban-hostsdeny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-hostsdeny-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban-hostsdeny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban-hostsdeny}"
SRC_URI[x86_64_v2_fail2ban-hostsdeny.sha256sum] = "ed3970ea1942f22b4f80d416b5739e9ea08cfdc0337513d98fbbf530402a85a9"

URI_x86_64_v2_fail2ban-mail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-mail-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban-mail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban-mail}"
SRC_URI[x86_64_v2_fail2ban-mail.sha256sum] = "35209739a48545dea1a71de3f35c3b6fb23f83cc94175444f2dcc4efd53e3b9a"

URI_x86_64_v2_fail2ban-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-selinux-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban-selinux}"
SRC_URI[x86_64_v2_fail2ban-selinux.sha256sum] = "8e6635ae9214c277dd600310a75dba9a7b9446fd8f9e80b1b35f423ef33009b1"

URI_x86_64_v2_fail2ban-sendmail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-sendmail-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban-sendmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban-sendmail}"
SRC_URI[x86_64_v2_fail2ban-sendmail.sha256sum] = "6a20c463078c8a76d6ad2668bd62aa974ef1c31d85d33441ef7fb04181413b55"

URI_x86_64_v2_fail2ban-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-server-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban-server}"
SRC_URI[x86_64_v2_fail2ban-server.sha256sum] = "6c9c200f892c2cd89969ec2324748d74688d22e9165cf95a869d7ee887886439"

URI_x86_64_v2_fail2ban-systemd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-systemd-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban-systemd}"
SRC_URI[x86_64_v2_fail2ban-systemd.sha256sum] = "5ce8e816208e61d8b949cc722011ec8ccf2c6a853bf570f0259ba8ed7afc7437"

URI_x86_64_v2_fail2ban-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fail2ban-tests-1.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fail2ban-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fail2ban-tests}"
SRC_URI[x86_64_v2_fail2ban-tests.sha256sum] = "9f459fd956b6264a64942d27cedc50a03098cfea1cfdda18c640b2b0c8e8affe"

URI_aarch64_fail2ban = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban}"
SRC_URI[aarch64_fail2ban.sha256sum] = "cc6d467d8eeca76f8dabf9289113522710088db3d59a2bd7fe2c7fefc0291001"

URI_aarch64_fail2ban-all = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-all-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban-all}"
SRC_URI[aarch64_fail2ban-all.sha256sum] = "c0903e985b3510b968d19f189dc5f0b4d370406507633e083c31312be94572a7"

URI_aarch64_fail2ban-firewalld = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-firewalld-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban-firewalld}"
SRC_URI[aarch64_fail2ban-firewalld.sha256sum] = "9414b9a3c6463f92267450c680423e8116dfecdecf71fa4d63c88591dbeadd55"

URI_aarch64_fail2ban-hostsdeny = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-hostsdeny-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban-hostsdeny;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban-hostsdeny}"
SRC_URI[aarch64_fail2ban-hostsdeny.sha256sum] = "87da4cdbd25941798a0d4ae784c66a31a1f1c2b29c28dc9fd19f5eb07307586a"

URI_aarch64_fail2ban-mail = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-mail-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban-mail;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban-mail}"
SRC_URI[aarch64_fail2ban-mail.sha256sum] = "3209de83b9576b4cbdf2283a14fd40da42299b38726d84dc237d4fcf783e5222"

URI_aarch64_fail2ban-selinux = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-selinux-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban-selinux}"
SRC_URI[aarch64_fail2ban-selinux.sha256sum] = "82ed1811f3ef20724ac9dff7af8e6c59a1ea43b6744b0fe5ac90650a711e6593"

URI_aarch64_fail2ban-sendmail = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-sendmail-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban-sendmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban-sendmail}"
SRC_URI[aarch64_fail2ban-sendmail.sha256sum] = "f0f17e5dc7658056fb91111cc71bd2a8a0b8ce77e4854dcdfcf87d7c4b267313"

URI_aarch64_fail2ban-server = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-server-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban-server}"
SRC_URI[aarch64_fail2ban-server.sha256sum] = "5cf1b351abb1572e75b8d7da5a045417b89bad69bca5a94f4e8e6aa2bc1c83ef"

URI_aarch64_fail2ban-systemd = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-systemd-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban-systemd}"
SRC_URI[aarch64_fail2ban-systemd.sha256sum] = "8af85dba5c6a9f274f554605840cfb6eebf0c8ae421279aee3c03ade1868b602"

URI_aarch64_fail2ban-tests = "${EPEL_MIRROR}/aarch64/Packages/f/fail2ban-tests-1.1.0-6.el10_0.noarch.rpm;name=aarch64_fail2ban-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_fail2ban-tests}"
SRC_URI[aarch64_fail2ban-tests.sha256sum] = "d494516313e05623bb90adc3173e61a495ed2adec2cc9372b2ef0c195e107086"

RDEPENDS:fail2ban = " \
 fail2ban-firewalld \
 fail2ban-sendmail \
 fail2ban-server \
 "
RDEPENDS:fail2ban-all = " \
 fail2ban-firewalld \
 fail2ban-hostsdeny \
 fail2ban-mail \
 fail2ban-sendmail \
 fail2ban-server \
 perl-interpreter \
 python3-inotify \
 whois \
 "
RDEPENDS:fail2ban-firewalld = " \
 fail2ban-server \
 firewalld \
 "
RDEPENDS:fail2ban-hostsdeny = " \
 ed \
 fail2ban-server \
 tcp_wrappers \
 "
RDEPENDS:fail2ban-mail = " \
 fail2ban-server \
 s-nail \
 "
RDEPENDS:fail2ban-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
RDEPENDS:fail2ban-sendmail = " \
 fail2ban-server \
 virtual//usr/sbin/sendmail \
 "
RDEPENDS:fail2ban-server = " \
 bash \
 fail2ban-selinux \
 nftables \
 python3 \
 python3-systemd \
 systemd \
 "
RDEPENDS:fail2ban-systemd = " \
 fail2ban-server \
 "
RDEPENDS:fail2ban-tests = " \
 fail2ban-server \
 python3 \
 "
