# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "guacamole-server"
PV = "1.6.0"
PR = "1.el10_0"
PACKAGES = " \
 guacd \
 libguac \
 libguac-client-kubernetes \
 libguac-client-rdp \
 libguac-client-ssh \
 libguac-client-telnet \
 libguac-client-vnc \
 libguac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/guacamole-server-1.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f14daae2b7c6551e0b330cac9c3580b6671ce2c14d7e8597174bab0fc4b78c98"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - guacd: libavcodec.so.61()(64bit)
# - guacd: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - guacd: libavformat.so.61()(64bit)
# - guacd: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - guacd: libavutil.so.59()(64bit)
# - guacd: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - guacd: libswscale.so.8()(64bit)
# - guacd: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_guacd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/guacd-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_guacd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guacd}"
SRC_URI[x86_64_v2_guacd.sha256sum] = "6e781264a4f4e0158ec8447852c71c8e9250293ad8948dc3f11643e2ba31f791"

URI_x86_64_v2_libguac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac}"
SRC_URI[x86_64_v2_libguac.sha256sum] = "b5e488b205ff0f7a52fda4d11ec94fdc4ef17b18c65225b3a1db8824f530bb73"

URI_x86_64_v2_libguac-client-kubernetes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-kubernetes-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-kubernetes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-kubernetes}"
SRC_URI[x86_64_v2_libguac-client-kubernetes.sha256sum] = "d45b52a9fa695f463f11cd2f2ef288c022af0ac9d838a111faffa738b4dab3d1"

URI_x86_64_v2_libguac-client-rdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-rdp-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-rdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-rdp}"
SRC_URI[x86_64_v2_libguac-client-rdp.sha256sum] = "69b2872165d043e73e498be41f277c0115defff31e6cff00d9cb89e6bbec2cb2"

URI_x86_64_v2_libguac-client-ssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-ssh-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-ssh}"
SRC_URI[x86_64_v2_libguac-client-ssh.sha256sum] = "f0722b19be41b12ff90e5f122a66beed427cabe69b10e6ee4004fec02ce0f80a"

URI_x86_64_v2_libguac-client-telnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-telnet-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-telnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-telnet}"
SRC_URI[x86_64_v2_libguac-client-telnet.sha256sum] = "72561e7db96f0af92573fbe4bc213713caa6cfef4f7914c98fb92f3b80b13f83"

URI_x86_64_v2_libguac-client-vnc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-client-vnc-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-client-vnc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-client-vnc}"
SRC_URI[x86_64_v2_libguac-client-vnc.sha256sum] = "7195c09ab0b60bc2ec3431047f2c110949d37fe2802083237a82d71fdb1df9be"

URI_x86_64_v2_libguac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libguac-devel-1.6.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libguac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguac-devel}"
SRC_URI[x86_64_v2_libguac-devel.sha256sum] = "208b188f7212b82b830f9e7345d24e5389466cc5eb50b413a4923a20ca46800f"

URI_aarch64_guacd = "${EPEL_MIRROR}/aarch64/Packages/g/guacd-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_guacd;unpack=0"
SRC_URI:append = " ${URI_aarch64_guacd}"
SRC_URI[aarch64_guacd.sha256sum] = "651a3c7ec4f595f249f45e0cdad096a15e0ae442a3a1b80b68bccc102688cc61"

URI_aarch64_libguac = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_libguac;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac}"
SRC_URI[aarch64_libguac.sha256sum] = "59620bdddfcef186584653395932269d2955d5b9d9544ff491454015cdbe395a"

URI_aarch64_libguac-client-kubernetes = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-kubernetes-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_libguac-client-kubernetes;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-kubernetes}"
SRC_URI[aarch64_libguac-client-kubernetes.sha256sum] = "484ccff8b9768f41809be109c92ffa6db00cea59bbf245fa6d16063a6d46b801"

URI_aarch64_libguac-client-rdp = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-rdp-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_libguac-client-rdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-rdp}"
SRC_URI[aarch64_libguac-client-rdp.sha256sum] = "1c0dd2105eccb164fb8f78edf3b0843f4bfc068fd08e1aee9d59aba8dc94a626"

URI_aarch64_libguac-client-ssh = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-ssh-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_libguac-client-ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-ssh}"
SRC_URI[aarch64_libguac-client-ssh.sha256sum] = "4fd6de13e256e779a4e2f05e214baca5996ed6646614f8cac3906fe50ea36486"

URI_aarch64_libguac-client-telnet = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-telnet-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_libguac-client-telnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-telnet}"
SRC_URI[aarch64_libguac-client-telnet.sha256sum] = "d7c1635e88cf67c938ea954ab891a1adb72431fea9db87d89d443e4bc62524aa"

URI_aarch64_libguac-client-vnc = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-client-vnc-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_libguac-client-vnc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-client-vnc}"
SRC_URI[aarch64_libguac-client-vnc.sha256sum] = "099b6bc44f3b1c443261465ab62e300b6b7f03fb44db497aa47b024209f3312d"

URI_aarch64_libguac-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libguac-devel-1.6.0-1.el10_0.aarch64.rpm;name=aarch64_libguac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguac-devel}"
SRC_URI[aarch64_libguac-devel.sha256sum] = "a22f91a6a85e2b7e0907aead9c7921a467d16793e8537b4393bf0c966feefeac"

RDEPENDS:guacd:x86_64_v2 = " \
 bash \
 cairo \
 glibc \
 libguac \
 libjpeg-turbo \
 libwebp \
 openssl-libs \
 shadow-utils \
 systemd \
"
RDEPENDS:guacd:aarch64 = " \
 bash \
 cairo \
 glibc \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libguac \
 libjpeg-turbo \
 libswscale-free \
 libwebp \
 openssl-libs \
 shadow-utils \
 systemd \
"
RDEPENDS:libguac = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libjpeg-turbo \
 libogg \
 libpng \
 libvorbis \
 libwebp \
 openssl-libs \
 pango \
 uuid \
 "
RDEPENDS:libguac-client-kubernetes = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libvorbis \
 libwebp \
 libwebsockets \
 openssl-libs \
 pango \
 uuid \
 "
RDEPENDS:libguac-client-rdp = " \
 cairo \
 freerdp2-libs \
 glibc \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libssh2 \
 libvorbis \
 libwebp \
 libwinpr2 \
 openssl-libs \
 uuid \
 "
RDEPENDS:libguac-client-ssh = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libssh2 \
 libvorbis \
 libwebp \
 openssl-libs \
 pango \
 uuid \
 "
RDEPENDS:libguac-client-telnet = " \
 cairo \
 glib2 \
 glibc \
 harfbuzz \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libtelnet \
 libvorbis \
 libwebp \
 openssl-libs \
 pango \
 uuid \
 "
RDEPENDS:libguac-client-vnc = " \
 cairo \
 glibc \
 libguac \
 libjpeg-turbo \
 libogg \
 libpng \
 libssh2 \
 libvncserver \
 libvorbis \
 libwebp \
 openssl-libs \
 pulseaudio-libs \
 uuid \
 "
RDEPENDS:libguac-devel = " \
 libguac \
 "
