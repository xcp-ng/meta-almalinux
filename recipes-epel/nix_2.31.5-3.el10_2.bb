# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nix"
PV = "2.31.5"
PR = "3.el10_2"
PACKAGES = " \
 nix \
 nix-core \
 nix-daemon \
 nix-devel \
 nix-doc \
 nix-filesystem \
 nix-legacy \
 nix-libs \
 nix-system \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nix-2.31.5-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "37d535d4996eceacab1ddc5b0de8198d5afb1e350d574b6f8a2c12070cd29b8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-2.31.5-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix;unpack=0"
SRC_URI[x86_64_v2_nix.sha256sum] = "c554002fad4e23e8edb3759f3b53cb88c8582ab9b9fbe7f858a463c25fee6748"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-core-2.31.5-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix-core;unpack=0"
SRC_URI[x86_64_v2_nix-core.sha256sum] = "042435ea542c9e2069e2d1890bc0e76cd4e28178a3cf4fa61e6556ae4b5d676e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-daemon-2.31.5-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nix-daemon;unpack=0"
SRC_URI[x86_64_v2_nix-daemon.sha256sum] = "169ded6675e8b6096e219330c9852ea7521233711143d4945edefb55bcf5f05b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-devel-2.31.5-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix-devel;unpack=0"
SRC_URI[x86_64_v2_nix-devel.sha256sum] = "3b26fdd6b9d136e35e32b435da9db60a103331bffb2d64d66c585db152179008"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-doc-2.31.5-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nix-doc;unpack=0"
SRC_URI[x86_64_v2_nix-doc.sha256sum] = "6547347d57177dec87e87b22760ee8d79c9d2bd4154afdbce6c665b8b742c8d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-filesystem-2.31.5-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nix-filesystem;unpack=0"
SRC_URI[x86_64_v2_nix-filesystem.sha256sum] = "0c6291522f08a35c61c4da772c3f148aa426be713f1152c06be0ff902f6a895f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-legacy-2.31.5-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nix-legacy;unpack=0"
SRC_URI[x86_64_v2_nix-legacy.sha256sum] = "76e468e811879264db1bae794430ebf1d0c65a07788b377ba3229ccc2b6fc163"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-libs-2.31.5-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix-libs;unpack=0"
SRC_URI[x86_64_v2_nix-libs.sha256sum] = "b8ed26ebe78a07b7cdf8c0b736c9a6441c609fc7e67b9b8c2e389eb5409c690b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-system-2.31.5-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nix-system;unpack=0"
SRC_URI[x86_64_v2_nix-system.sha256sum] = "127e46279c3d9e86d036abd26266e76811bb68e365f3caf7a0c5c2fc9ae3cddd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nix-2.31.5-3.el10_2.aarch64.rpm;name=aarch64_nix;unpack=0"
SRC_URI[aarch64_nix.sha256sum] = "503b1ac1734453912ed69d687b06189d2268b8737a4a48a61f8974659eb3eeb0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nix-core-2.31.5-3.el10_2.aarch64.rpm;name=aarch64_nix-core;unpack=0"
SRC_URI[aarch64_nix-core.sha256sum] = "86f9cefa9ef5332a1acb2731847061fbe063ba965cb950b0f7f4327c3d73f5f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nix-daemon-2.31.5-3.el10_2.noarch.rpm;name=aarch64_nix-daemon;unpack=0"
SRC_URI[aarch64_nix-daemon.sha256sum] = "1753be4fc85f461cbb136566dd4e68ce661a39e618c2535be9d59645ee8cdc62"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nix-devel-2.31.5-3.el10_2.aarch64.rpm;name=aarch64_nix-devel;unpack=0"
SRC_URI[aarch64_nix-devel.sha256sum] = "3d3f292204eaaf640fb2c33fac212788b6a6e18fb0ad09143b4169f89ae17954"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nix-doc-2.31.5-3.el10_2.noarch.rpm;name=aarch64_nix-doc;unpack=0"
SRC_URI[aarch64_nix-doc.sha256sum] = "0627001b8336b7c90c1a843d03fd8ef478f52676b7fd7d8f0703d496f04b6618"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nix-filesystem-2.31.5-3.el10_2.noarch.rpm;name=aarch64_nix-filesystem;unpack=0"
SRC_URI[aarch64_nix-filesystem.sha256sum] = "3337158c33629dfc1db373fad0447cb8a4586cbbcc1e9e02813fedb6668f0ca5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nix-legacy-2.31.5-3.el10_2.noarch.rpm;name=aarch64_nix-legacy;unpack=0"
SRC_URI[aarch64_nix-legacy.sha256sum] = "c313642a816ad7c185a3f1f95221a20a7dadafdcd98e73887cb3ced5b79bcb6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nix-libs-2.31.5-3.el10_2.aarch64.rpm;name=aarch64_nix-libs;unpack=0"
SRC_URI[aarch64_nix-libs.sha256sum] = "e379ccad5edd46431dc4af28ae1a31cb96a91f3be3521f7cbd804349a31d7045"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nix-system-2.31.5-3.el10_2.noarch.rpm;name=aarch64_nix-system;unpack=0"
SRC_URI[aarch64_nix-system.sha256sum] = "fe3f656c2337b2a1620f16a28d7f6723170de01c1073057793a3943491d5a917"

RDEPENDS:nix = " \
 nix-core \
 nix-system \
 "
RDEPENDS:nix-core = " \
 gc \
 glibc \
 libgcc \
 libstdc++ \
 nix-libs \
 "
RDEPENDS:nix-daemon = " \
 bash \
 nix-core \
 nix-system \
 systemd \
 "
RDEPENDS:nix-devel:x86_64_v2 = " \
 blake3-devel \
 brotli-devel \
 gc-devel \
 json-devel \
 libarchive-devel \
 libcpuid-devel \
 libcurl-devel \
 libgit2_1.9-devel \
 libseccomp-devel \
 libsodium-devel \
 lowdown-devel \
 nix-devel \
 nix-libs \
 openssl-devel \
 pkgconf-pkg-config \
 readline-devel \
 sqlite-devel \
"
RDEPENDS:nix-devel:aarch64 = " \
 blake3-devel \
 brotli-devel \
 gc-devel \
 json-devel \
 libarchive-devel \
 libcurl-devel \
 libgit2_1.9-devel \
 libseccomp-devel \
 libsodium-devel \
 lowdown-devel \
 nix-devel \
 nix-libs \
 openssl-devel \
 pkgconf-pkg-config \
 readline-devel \
 sqlite-devel \
"
RDEPENDS:nix-doc = " \
 "
RDEPENDS:nix-filesystem = " \
 "
RDEPENDS:nix-legacy = " \
 nix-core \
 "
RDEPENDS:nix-libs:x86_64_v2 = " \
 blake3 \
 boost-context \
 boost-iostreams \
 boost-url \
 gc \
 glibc \
 libarchive \
 libbrotli \
 libcpuid \
 libgcc \
 libgit2_1.9 \
 libseccomp \
 libsodium \
 libstdc++ \
 lowdown-libs \
 openssl-libs \
 readline \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:nix-libs:aarch64 = " \
 blake3 \
 boost-context \
 boost-iostreams \
 boost-url \
 gc \
 glibc \
 libarchive \
 libbrotli \
 libgcc \
 libgit2_1.9 \
 libseccomp \
 libsodium \
 libstdc++ \
 lowdown-libs \
 openssl-libs \
 readline \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:nix-system = " \
 nix-filesystem \
 "
