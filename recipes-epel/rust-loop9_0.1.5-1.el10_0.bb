# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-loop9"
PV = "0.1.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-loop9+default-devel \
 rust-loop9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-loop9-0.1.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db813d61815dcc90d01fe3ae6273c341482a5aa098d2ec5a062ffa2a4b7a7d48"

URI_x86_64_v2_rust-loop9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-loop9+default-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-loop9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-loop9+default-devel}"
SRC_URI[x86_64_v2_rust-loop9+default-devel.sha256sum] = "9f300d62b3a98a164fc21dc46af308caca5c39cbc23c60b80d7a9741ce4f25b8"

URI_x86_64_v2_rust-loop9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-loop9-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-loop9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-loop9-devel}"
SRC_URI[x86_64_v2_rust-loop9-devel.sha256sum] = "8973da31eb6ef09cfb5524d9ce274efed84dfe66d4558b123ef21762969ef743"

URI_aarch64_rust-loop9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-loop9+default-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-loop9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-loop9+default-devel}"
SRC_URI[aarch64_rust-loop9+default-devel.sha256sum] = "bbe815445a0a8f83ac061c9d2baf841cad86ca24b435b2f45da5eec4fdc94cd6"

URI_aarch64_rust-loop9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-loop9-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-loop9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-loop9-devel}"
SRC_URI[aarch64_rust-loop9-devel.sha256sum] = "b8ccfd9204279c971216a8282e9d4187f71a259391c5776cebd7049fbb24f20a"

RDEPENDS:rust-loop9+default-devel = " \
 cargo \
 rust-loop9-devel \
 "
RDEPENDS:rust-loop9-devel = " \
 cargo \
 rust-imgref+default-devel \
 "
