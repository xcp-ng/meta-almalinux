# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getopts"
PV = "0.2.24"
PR = "1.el10_0"
PACKAGES = " \
 rust-getopts+default-devel \
 rust-getopts+unicode-devel \
 rust-getopts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getopts-0.2.24-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03562f102715655d2e6e21e8745258798a45f7a7edd777e6c28774c32cdd06a4"

URI_x86_64_v2_rust-getopts+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getopts+default-devel-0.2.24-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getopts+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getopts+default-devel}"
SRC_URI[x86_64_v2_rust-getopts+default-devel.sha256sum] = "92765acdf7f5530e101cfc5ab502a07dcb52b22930991103d47ec335d7f5a0b8"

URI_x86_64_v2_rust-getopts+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getopts+unicode-devel-0.2.24-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getopts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getopts+unicode-devel}"
SRC_URI[x86_64_v2_rust-getopts+unicode-devel.sha256sum] = "0b7bec0f6c81e91d4cb73ed848634bae01b8354aa7cf11fe66cc12bf946e2bab"

URI_x86_64_v2_rust-getopts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getopts-devel-0.2.24-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getopts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getopts-devel}"
SRC_URI[x86_64_v2_rust-getopts-devel.sha256sum] = "dda1286d2529102cbb2444c4d4a4883588ba433fe08e2ff94bd7cd683f5ea371"

URI_aarch64_rust-getopts+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getopts+default-devel-0.2.24-1.el10_0.noarch.rpm;name=aarch64_rust-getopts+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getopts+default-devel}"
SRC_URI[aarch64_rust-getopts+default-devel.sha256sum] = "c87eda3d0bd7a701fdde55283b88cb345f72cece03a85d88acda5d5f75ebd0a8"

URI_aarch64_rust-getopts+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getopts+unicode-devel-0.2.24-1.el10_0.noarch.rpm;name=aarch64_rust-getopts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getopts+unicode-devel}"
SRC_URI[aarch64_rust-getopts+unicode-devel.sha256sum] = "f951743be9857a0cf4142b52b56aa778321448597b94f4b703c3adabe31bca2a"

URI_aarch64_rust-getopts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getopts-devel-0.2.24-1.el10_0.noarch.rpm;name=aarch64_rust-getopts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getopts-devel}"
SRC_URI[aarch64_rust-getopts-devel.sha256sum] = "cdf5fa303a961b2ffa180d8ea1123f62b268931793f6608fd936f19fc5bafce0"

RDEPENDS:rust-getopts+default-devel = " \
 cargo \
 rust-getopts+unicode-devel \
 rust-getopts-devel \
 "
RDEPENDS:rust-getopts+unicode-devel = " \
 cargo \
 rust-getopts-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-getopts-devel = " \
 cargo \
 rust \
 "
