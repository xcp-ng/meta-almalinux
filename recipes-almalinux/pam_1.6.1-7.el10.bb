# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam"
PV = "1.6.1"
PR = "7.el10"
PACKAGES = " \
 pam \
 pam-devel \
 pam-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pam-1.6.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "093bd136970434ea05642a58761ec0c144c72e13780dd0cfd2a697478626c321"

URI_x86_64_v2_pam = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-1.6.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam}"
SRC_URI[x86_64_v2_pam.sha256sum] = "332e5ef7ff3314621ccab948143b4915ddd48dd101da3353cf7230177d7b340a"

URI_x86_64_v2_pam-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam-devel-1.6.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_pam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-devel}"
SRC_URI[x86_64_v2_pam-devel.sha256sum] = "09d9ed8cf90e3ab8d7f5638f5c1287292fb281fec8f187f137fae9a2a2f6e692"

URI_x86_64_v2_pam-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-libs-1.6.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_pam-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-libs}"
SRC_URI[x86_64_v2_pam-libs.sha256sum] = "d76438e3add23e41a80599bb0de479fe9c20c0f6c9d5d061dcbfe15f210ea16a"

URI_aarch64_pam = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-1.6.1-7.el10.aarch64.rpm;name=aarch64_pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam}"
SRC_URI[aarch64_pam.sha256sum] = "4ba8943bfd5fbd91c123bb886fd9aee7e09a95b3f601ef8c353f4920102ed741"

URI_aarch64_pam-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam-devel-1.6.1-7.el10.aarch64.rpm;name=aarch64_pam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-devel}"
SRC_URI[aarch64_pam-devel.sha256sum] = "98c82f107d4c809c575b5876daea21f23511d30a42f82d784410cf090325aaf1"

URI_aarch64_pam-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-libs-1.6.1-7.el10.aarch64.rpm;name=aarch64_pam-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-libs}"
SRC_URI[aarch64_pam-libs.sha256sum] = "36be0d7d7bbfec76044b76e65ef5acad4b70717093ee8ccb996f493861fde13f"

RDEPENDS:pam = " \
 audit-libs \
 authselect \
 bash \
 gdbm \
 gdbm-libs \
 glibc \
 libeconf \
 libpwquality \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 setup \
 "
RDEPENDS:pam-devel = " \
 pam-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pam-libs = " \
 audit-libs \
 glibc \
 libeconf \
 "
