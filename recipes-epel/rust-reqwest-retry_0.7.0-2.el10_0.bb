# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-retry"
PV = "0.7.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-reqwest-retry+default-devel \
 rust-reqwest-retry+tracing-devel \
 rust-reqwest-retry-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-retry-0.7.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d155b78976867d4608e0f66dfc50c66515fe7c32b06e480fadf60d7ea01f5326"

URI_x86_64_v2_rust-reqwest-retry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry+default-devel-0.7.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry+default-devel.sha256sum] = "9ecd5eaaa187e1262de6f4a2526e493379a5c846ce2f7c351ead5549766032c2"

URI_x86_64_v2_rust-reqwest-retry+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry+tracing-devel-0.7.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry+tracing-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry+tracing-devel.sha256sum] = "4f62586777bf597e4f3fd876a052125bdb239dfaf2cbcd6aa9b0eda5fc3a55f0"

URI_x86_64_v2_rust-reqwest-retry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry-devel-0.7.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry-devel.sha256sum] = "ce3cd132843859dae25133227451381b70b7b17a2af8e89936e0d60be740b83f"

URI_aarch64_rust-reqwest-retry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry+default-devel-0.7.0-2.el10_0.noarch.rpm;name=aarch64_rust-reqwest-retry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry+default-devel}"
SRC_URI[aarch64_rust-reqwest-retry+default-devel.sha256sum] = "bc9bf6bf10443d5f51f6459ff7ae024ac59e7c46790903b89c2befd38f9e579d"

URI_aarch64_rust-reqwest-retry+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry+tracing-devel-0.7.0-2.el10_0.noarch.rpm;name=aarch64_rust-reqwest-retry+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry+tracing-devel}"
SRC_URI[aarch64_rust-reqwest-retry+tracing-devel.sha256sum] = "8bcc9d30033be0266e043832d8ece8f3747d491af96ac4a689586711f96169db"

URI_aarch64_rust-reqwest-retry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry-devel-0.7.0-2.el10_0.noarch.rpm;name=aarch64_rust-reqwest-retry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry-devel}"
SRC_URI[aarch64_rust-reqwest-retry-devel.sha256sum] = "007410e438e7673e6c7cb522bcfb57322bb2e1273f7de4528f39492f332e1542"

RDEPENDS:rust-reqwest-retry+default-devel = " \
 cargo \
 rust-reqwest-retry+tracing-devel \
 rust-reqwest-retry-devel \
 "
RDEPENDS:rust-reqwest-retry+tracing-devel = " \
 cargo \
 rust-reqwest-retry-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-reqwest-retry-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-futures+default-devel \
 rust-http+default-devel \
 rust-hyper+default-devel \
 rust-reqwest-devel \
 rust-reqwest-middleware+default-devel \
 rust-retry-policies+default-devel \
 rust-thiserror1+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
