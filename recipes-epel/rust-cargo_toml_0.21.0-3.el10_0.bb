# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_toml"
PV = "0.21.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-cargo_toml+default-devel \
 rust-cargo_toml+features-devel \
 rust-cargo_toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_toml-0.21.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32c5a3d6b9cc88490235ed4e608503deed604e1bb601e81b1abd1073aa243cf7"

URI_x86_64_v2_rust-cargo_toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml+default-devel-0.21.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml+default-devel.sha256sum] = "bc8e5ff92863b9d1ae3299081d498c5c0744f223b231e56479844db9cf6025e8"

URI_x86_64_v2_rust-cargo_toml+features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml+features-devel-0.21.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml+features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml+features-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml+features-devel.sha256sum] = "2228a030364588aaf50a4391247bf533d146f848b7f4f07a7babd6fdefc3f86b"

URI_x86_64_v2_rust-cargo_toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml-devel-0.21.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml-devel.sha256sum] = "c10aa0d547a42e7cfefc1288a4c1456d2cb9a9ddeb6ae1b0b5c0c5501f8eff3e"

URI_aarch64_rust-cargo_toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml+default-devel-0.21.0-3.el10_0.noarch.rpm;name=aarch64_rust-cargo_toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml+default-devel}"
SRC_URI[aarch64_rust-cargo_toml+default-devel.sha256sum] = "e066e7deb2eadc349c14cceba67f879d7bf8066669e29507313d8788e8b03eca"

URI_aarch64_rust-cargo_toml+features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml+features-devel-0.21.0-3.el10_0.noarch.rpm;name=aarch64_rust-cargo_toml+features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml+features-devel}"
SRC_URI[aarch64_rust-cargo_toml+features-devel.sha256sum] = "db9a81b3eebd1a9b7dd48776dd32350ea4830aee2738b9da70bc2ad5e4069fa9"

URI_aarch64_rust-cargo_toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml-devel-0.21.0-3.el10_0.noarch.rpm;name=aarch64_rust-cargo_toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml-devel}"
SRC_URI[aarch64_rust-cargo_toml-devel.sha256sum] = "d6d0ec40b385ddc4f832c3061b5a3e58cef3368858e9706077d5b09516cbaf0a"

RDEPENDS:rust-cargo_toml+default-devel = " \
 cargo \
 rust-cargo_toml-devel \
 "
RDEPENDS:rust-cargo_toml+features-devel = " \
 cargo \
 rust-cargo_toml-devel \
 "
RDEPENDS:rust-cargo_toml-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-toml+default-devel \
 "
