# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-alecthomas-units"
PV = "0"
PR = "0.23.20240609git9a357b5.el10_0"
PACKAGES = " \
 golang-github-alecthomas-units-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-alecthomas-units-0-0.23.20240609git9a357b5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcb0d206d656766a2499fa837b9a90ff2cbb22e713475baddaa6c7753e3191b3"

URI_aarch64_golang-github-alecthomas-units-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-alecthomas-units-devel-0-0.23.20240609git9a357b5.el10_0.noarch.rpm;name=aarch64_golang-github-alecthomas-units-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-alecthomas-units-devel}"
SRC_URI[aarch64_golang-github-alecthomas-units-devel.sha256sum] = "fd96d8d782a820de9e3d2507e38fb6a40107847b28ae38fdcf08691e7aa30279"

RDEPENDS:golang-github-alecthomas-units-devel = " \
 go-filesystem \
 "
