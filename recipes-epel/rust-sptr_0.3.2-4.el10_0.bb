# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sptr"
PV = "0.3.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-sptr+default-devel \
 rust-sptr+opaque_fn-devel \
 rust-sptr+uptr-devel \
 rust-sptr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sptr-0.3.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8089bee931416377d3cd7da83194b30714d63021a140479be4613e74ec0aa1e4"

URI_x86_64_v2_rust-sptr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sptr+default-devel-0.3.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sptr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sptr+default-devel}"
SRC_URI[x86_64_v2_rust-sptr+default-devel.sha256sum] = "70405c7d8b4eb84a27cf34e7d0dd0b848cd1ac3566ac2bc15e52b2080089f0cb"

URI_x86_64_v2_rust-sptr+opaque_fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sptr+opaque_fn-devel-0.3.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sptr+opaque_fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sptr+opaque_fn-devel}"
SRC_URI[x86_64_v2_rust-sptr+opaque_fn-devel.sha256sum] = "8502f1aed197180ad7fb2af2b72fb0254aa18e5865c8d0145432b672db64cefd"

URI_x86_64_v2_rust-sptr+uptr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sptr+uptr-devel-0.3.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sptr+uptr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sptr+uptr-devel}"
SRC_URI[x86_64_v2_rust-sptr+uptr-devel.sha256sum] = "dd2a44efa07bc53731683ebe920a4c27cbc841a46b114007681eb5d5daec06fe"

URI_x86_64_v2_rust-sptr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sptr-devel-0.3.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sptr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sptr-devel}"
SRC_URI[x86_64_v2_rust-sptr-devel.sha256sum] = "b4e28d41170825ed35849b258c5a09d2f0c062be076a3db8008bc60bfbe23951"

URI_aarch64_rust-sptr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sptr+default-devel-0.3.2-4.el10_0.noarch.rpm;name=aarch64_rust-sptr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sptr+default-devel}"
SRC_URI[aarch64_rust-sptr+default-devel.sha256sum] = "957c68723c17a23c2eb5f84e38f128e304c8883430bdd79484bbbb1015b8810c"

URI_aarch64_rust-sptr+opaque_fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sptr+opaque_fn-devel-0.3.2-4.el10_0.noarch.rpm;name=aarch64_rust-sptr+opaque_fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sptr+opaque_fn-devel}"
SRC_URI[aarch64_rust-sptr+opaque_fn-devel.sha256sum] = "25da4fef39c1b9743a1419a4c2773c8385d8083b937509d631235ec149180f1f"

URI_aarch64_rust-sptr+uptr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sptr+uptr-devel-0.3.2-4.el10_0.noarch.rpm;name=aarch64_rust-sptr+uptr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sptr+uptr-devel}"
SRC_URI[aarch64_rust-sptr+uptr-devel.sha256sum] = "ab0bff8bf4c9665891fa61f98e4c781bc64dc73b13078c46029d48b9260e2681"

URI_aarch64_rust-sptr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sptr-devel-0.3.2-4.el10_0.noarch.rpm;name=aarch64_rust-sptr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sptr-devel}"
SRC_URI[aarch64_rust-sptr-devel.sha256sum] = "e48ce0aac5b5d22aede0ffd737b293466d4c1011ea1c280e0af1c8126f05fec5"

RDEPENDS:rust-sptr+default-devel = " \
 cargo \
 rust-sptr-devel \
 "
RDEPENDS:rust-sptr+opaque_fn-devel = " \
 cargo \
 rust-sptr-devel \
 "
RDEPENDS:rust-sptr+uptr-devel = " \
 cargo \
 rust-sptr-devel \
 "
RDEPENDS:rust-sptr-devel = " \
 cargo \
 "
