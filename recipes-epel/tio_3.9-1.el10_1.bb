# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tio"
PV = "3.9"
PR = "1.el10_1"
PACKAGES = " \
 tio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tio-3.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2ba9c1336d13feb7da122774b36b79a18fc56fd7afa5c1aea6e262de19c43d6"

URI_x86_64_v2_tio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tio-3.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tio}"
SRC_URI[x86_64_v2_tio.sha256sum] = "4544a93e54cc0b16f10a9b078d7700886e9a54eba22b7b32f1dfa004f8bed2ff"

URI_aarch64_tio = "${EPEL_MIRROR}/aarch64/Packages/t/tio-3.9-1.el10_1.aarch64.rpm;name=aarch64_tio;unpack=0"
SRC_URI:append = " ${URI_aarch64_tio}"
SRC_URI[aarch64_tio.sha256sum] = "cc0cac7bc930ac30dc2a6525a6a4e406eb780a18a118af1bbf4b2da60570987e"

RDEPENDS:tio = " \
 glib2 \
 glibc \
 lua-libs \
 "
