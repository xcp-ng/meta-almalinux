# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-global-executor2"
PV = "2.4.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-global-executor2+async-io-devel \
 rust-async-global-executor2+default-devel \
 rust-async-global-executor2+tokio-crate-devel \
 rust-async-global-executor2+tokio-devel \
 rust-async-global-executor2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-global-executor2-2.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a15cf94f57f76045085d91db86768a96b725ec04a2226b2d0ee6512212e48801"

URI_x86_64_v2_rust-async-global-executor2+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor2+async-io-devel-2.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor2+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor2+async-io-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor2+async-io-devel.sha256sum] = "c5fc78dc048c7056b9a7c695772597d0db80fdee7f876c0481b8a83ca5b04588"

URI_x86_64_v2_rust-async-global-executor2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor2+default-devel-2.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor2+default-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor2+default-devel.sha256sum] = "e7f99d81c19413892cb7ca1d2bb97d349968c428e9f093480a582f4cfb04cbd3"

URI_x86_64_v2_rust-async-global-executor2+tokio-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor2+tokio-crate-devel-2.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor2+tokio-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor2+tokio-crate-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor2+tokio-crate-devel.sha256sum] = "3251cd0a1e341b81db836c4397b5a2c171944ab8a6cf56539019286c9dcbce87"

URI_x86_64_v2_rust-async-global-executor2+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor2+tokio-devel-2.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor2+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor2+tokio-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor2+tokio-devel.sha256sum] = "896da191d240a721266123bf25bae409cf30d9fbe5b9889288216590a009fdeb"

URI_x86_64_v2_rust-async-global-executor2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-global-executor2-devel-2.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-global-executor2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-global-executor2-devel}"
SRC_URI[x86_64_v2_rust-async-global-executor2-devel.sha256sum] = "8bb8290624743074791891cfc1a03534dceef57f9eb4dc820d5eeb551d8c19d0"

URI_aarch64_rust-async-global-executor2+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor2+async-io-devel-2.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-async-global-executor2+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor2+async-io-devel}"
SRC_URI[aarch64_rust-async-global-executor2+async-io-devel.sha256sum] = "268a1d21b45b3a1128e6180338e1eb52a6a0b15dbf6be68dfa7614f72a3095df"

URI_aarch64_rust-async-global-executor2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor2+default-devel-2.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-async-global-executor2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor2+default-devel}"
SRC_URI[aarch64_rust-async-global-executor2+default-devel.sha256sum] = "e78ca233f8b38c61bdc739f576368fb0c89b3ee3a89588feac6e0b9d23156182"

URI_aarch64_rust-async-global-executor2+tokio-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor2+tokio-crate-devel-2.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-async-global-executor2+tokio-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor2+tokio-crate-devel}"
SRC_URI[aarch64_rust-async-global-executor2+tokio-crate-devel.sha256sum] = "1e142df5913f2be878a9232a4012f5f4f30e9845a076f9281e00143c8b759546"

URI_aarch64_rust-async-global-executor2+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor2+tokio-devel-2.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-async-global-executor2+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor2+tokio-devel}"
SRC_URI[aarch64_rust-async-global-executor2+tokio-devel.sha256sum] = "ac47bc37425d50a235222cd0665021d5cf27dc492b6230b0c134c815f9f66102"

URI_aarch64_rust-async-global-executor2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-global-executor2-devel-2.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-async-global-executor2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-global-executor2-devel}"
SRC_URI[aarch64_rust-async-global-executor2-devel.sha256sum] = "089889743028595417eb5fa23abc063282a6579009ce3c6931c0a66ffdec9838"

RDEPENDS:rust-async-global-executor2+async-io-devel = " \
 cargo \
 rust-async-global-executor2-devel \
 rust-async-io+default-devel \
 "
RDEPENDS:rust-async-global-executor2+default-devel = " \
 cargo \
 rust-async-global-executor2+async-io-devel \
 rust-async-global-executor2-devel \
 "
RDEPENDS:rust-async-global-executor2+tokio-crate-devel = " \
 cargo \
 rust-async-global-executor2-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-async-global-executor2+tokio-devel = " \
 cargo \
 rust-async-global-executor2+tokio-crate-devel \
 rust-async-global-executor2-devel \
 "
RDEPENDS:rust-async-global-executor2-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-executor+default-devel \
 rust-async-lock+default-devel \
 rust-blocking+default-devel \
 rust-futures-lite+default-devel \
 rust-once_cell+default-devel \
 "
