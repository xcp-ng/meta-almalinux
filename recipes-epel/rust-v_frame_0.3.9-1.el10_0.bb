# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-v_frame"
PV = "0.3.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-v_frame+default-devel \
 rust-v_frame+serde-devel \
 rust-v_frame+serialize-devel \
 rust-v_frame-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-v_frame-0.3.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b8a9cbb25a32b517cb87a8677b22d0730f5a13bb9bce5cd9a941d9316c9981d"

URI_x86_64_v2_rust-v_frame+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+default-devel-0.3.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+default-devel}"
SRC_URI[x86_64_v2_rust-v_frame+default-devel.sha256sum] = "be2acaa8f18efa8d14e4f87d0276b06dda8b79dcb7143babdb0ba9c3fef8b2d1"

URI_x86_64_v2_rust-v_frame+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+serde-devel-0.3.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+serde-devel}"
SRC_URI[x86_64_v2_rust-v_frame+serde-devel.sha256sum] = "1cbdadea1851585b45f257e30903db51a828f2ebbe174e71ae0f0fa9dfbb4e08"

URI_x86_64_v2_rust-v_frame+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+serialize-devel-0.3.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+serialize-devel}"
SRC_URI[x86_64_v2_rust-v_frame+serialize-devel.sha256sum] = "39d7d164ccd7af55bc333fea5cc5b5131f2926b27c4f2012c44da07e6cfdc7f3"

URI_x86_64_v2_rust-v_frame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame-devel-0.3.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame-devel}"
SRC_URI[x86_64_v2_rust-v_frame-devel.sha256sum] = "eb4ba888ea5887e578a9e091d3a1ba65c354ab57b0be0ac382a63cf2390a8f18"

URI_aarch64_rust-v_frame+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+default-devel-0.3.9-1.el10_0.noarch.rpm;name=aarch64_rust-v_frame+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+default-devel}"
SRC_URI[aarch64_rust-v_frame+default-devel.sha256sum] = "886f2cf2995df8b7029f310b15165ea52586d6a83920eb590bb7ce4d693c3a77"

URI_aarch64_rust-v_frame+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+serde-devel-0.3.9-1.el10_0.noarch.rpm;name=aarch64_rust-v_frame+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+serde-devel}"
SRC_URI[aarch64_rust-v_frame+serde-devel.sha256sum] = "9336524682a607deb34df3f4f9a3cef437fdcd644051490feb8e22514ffef3b8"

URI_aarch64_rust-v_frame+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+serialize-devel-0.3.9-1.el10_0.noarch.rpm;name=aarch64_rust-v_frame+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+serialize-devel}"
SRC_URI[aarch64_rust-v_frame+serialize-devel.sha256sum] = "6a73d7423350ae892df9c3b9feb0b6184bb2bd23fc6bfa99d1d76fd5e59d91bc"

URI_aarch64_rust-v_frame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame-devel-0.3.9-1.el10_0.noarch.rpm;name=aarch64_rust-v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame-devel}"
SRC_URI[aarch64_rust-v_frame-devel.sha256sum] = "4dfb7520f564d6cf547688aab82a554ce271c5f6da3e0275620c7430e68067f9"

RDEPENDS:rust-v_frame+default-devel = " \
 cargo \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame+serialize-devel = " \
 cargo \
 rust-aligned-vec+serde-devel \
 rust-v_frame+serde-devel \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame-devel = " \
 cargo \
 rust \
 rust-aligned-vec+default-devel \
 rust-num-traits+default-devel \
 "
