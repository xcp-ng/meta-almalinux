# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_stacker"
PV = "0.1.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_stacker+default-devel \
 rust-serde_stacker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_stacker-0.1.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f104cb6f51cd4aa65825c416974b951eeaafffaecaefe4fb5d94acd46cb11000"

URI_x86_64_v2_rust-serde_stacker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_stacker+default-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_stacker+default-devel}"
SRC_URI[x86_64_v2_rust-serde_stacker+default-devel.sha256sum] = "ed7ebab21cf09dff420c973c0d4c302aef06a330a4e78dba8d99823722adb321"

URI_x86_64_v2_rust-serde_stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_stacker-devel-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_stacker-devel}"
SRC_URI[x86_64_v2_rust-serde_stacker-devel.sha256sum] = "606eb8201b8f93267ee3ffdcec33c9cb84ad5dbfd01797ce6c0d2d96907e9b27"

URI_aarch64_rust-serde_stacker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_stacker+default-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-serde_stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_stacker+default-devel}"
SRC_URI[aarch64_rust-serde_stacker+default-devel.sha256sum] = "42cbdad9883cca13368c340cf50c25ede541d3ef229becaed34ceba9cce0a3bc"

URI_aarch64_rust-serde_stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_stacker-devel-0.1.14-1.el10_0.noarch.rpm;name=aarch64_rust-serde_stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_stacker-devel}"
SRC_URI[aarch64_rust-serde_stacker-devel.sha256sum] = "a2d56801d398fa2ca60b228b4caf2160c849b7f7063c0d62af0230c85195b4c2"

RDEPENDS:rust-serde_stacker+default-devel = " \
 cargo \
 rust-serde_stacker-devel \
 "
RDEPENDS:rust-serde_stacker-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-stacker+default-devel \
 "
