# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusqlite"
PV = "0.31.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-rusqlite+array-devel \
 rust-rusqlite+backup-devel \
 rust-rusqlite+blob-devel \
 rust-rusqlite+buildtime_bindgen-devel \
 rust-rusqlite+chrono-devel \
 rust-rusqlite+collation-devel \
 rust-rusqlite+column_decltype-devel \
 rust-rusqlite+csv-devel \
 rust-rusqlite+csvtab-devel \
 rust-rusqlite+default-devel \
 rust-rusqlite+extra_check-devel \
 rust-rusqlite+functions-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite+i128_blob-devel \
 rust-rusqlite+limits-devel \
 rust-rusqlite+load_extension-devel \
 rust-rusqlite+modern-full-devel \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite+release_memory-devel \
 rust-rusqlite+serde_json-devel \
 rust-rusqlite+serialize-devel \
 rust-rusqlite+series-devel \
 rust-rusqlite+session-devel \
 rust-rusqlite+time-devel \
 rust-rusqlite+trace-devel \
 rust-rusqlite+unlock_notify-devel \
 rust-rusqlite+url-devel \
 rust-rusqlite+uuid-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite+window-devel \
 rust-rusqlite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusqlite-0.31.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "143654025375eb01b71563a9940fe01bb6082220ce2406552d1efe7e2cece054"

URI_x86_64_v2_rust-rusqlite+array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+array-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+array-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+array-devel.sha256sum] = "566a9305075c33439900623fd17f1236ea68b9b2fcfea3ebf698294da459f590"

URI_x86_64_v2_rust-rusqlite+backup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+backup-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+backup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+backup-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+backup-devel.sha256sum] = "48e092ecc9526db07b2c997501e12ca463fe16959036b553a1d341b842675162"

URI_x86_64_v2_rust-rusqlite+blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+blob-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+blob-devel.sha256sum] = "7e2b74830df84ca06df4e87a69604dbca78b70a1007834a5367db8c1eb75c615"

URI_x86_64_v2_rust-rusqlite+buildtime_bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+buildtime_bindgen-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+buildtime_bindgen-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+buildtime_bindgen-devel.sha256sum] = "0607a9f374e88491eaea25e6a4ee8d1917efc12b655e7f0c1ee4bb0b9be942c9"

URI_x86_64_v2_rust-rusqlite+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+chrono-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+chrono-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+chrono-devel.sha256sum] = "527f8212e53496d487f031666e81fb0d1d52fecf147b3d52636725821a94efd0"

URI_x86_64_v2_rust-rusqlite+collation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+collation-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+collation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+collation-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+collation-devel.sha256sum] = "dc99e4ce1eb6258b1310979600e59b2ba9b1f3f9a8eac750bf391f7763cecd35"

URI_x86_64_v2_rust-rusqlite+column_decltype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+column_decltype-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+column_decltype-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+column_decltype-devel.sha256sum] = "c9cb2c6ce028e3f09076368776c7a35712c9c8db1a9851628b622acdf7a68b25"

URI_x86_64_v2_rust-rusqlite+csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+csv-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+csv-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+csv-devel.sha256sum] = "8c889d765243ec723d1336223a0723d429884ae71c5a8ce498c0bd8cd9a6e858"

URI_x86_64_v2_rust-rusqlite+csvtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+csvtab-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+csvtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+csvtab-devel.sha256sum] = "517e69899ff545e19e92e30dc2577c0091e299049b3c27fca8afd50491e1c91b"

URI_x86_64_v2_rust-rusqlite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+default-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+default-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+default-devel.sha256sum] = "d217c729586711d9ac9dd1de7434339194debc38755dc03332db537f78f4198d"

URI_x86_64_v2_rust-rusqlite+extra_check-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+extra_check-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+extra_check-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+extra_check-devel.sha256sum] = "e332f180d2b5fed529646f5f09a6cb1cb530379082bc09cf587fcf07861faab8"

URI_x86_64_v2_rust-rusqlite+functions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+functions-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+functions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+functions-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+functions-devel.sha256sum] = "df6c342e376268c7cb7bd47f7e1852e9f3d6478e9670698a7455f169605e1a66"

URI_x86_64_v2_rust-rusqlite+hooks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+hooks-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+hooks-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+hooks-devel.sha256sum] = "6f57d40cb12d3cbfc92ce8028a09737b917c3713995a0a26e6a56b9334e514c8"

URI_x86_64_v2_rust-rusqlite+i128_blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+i128_blob-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+i128_blob-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+i128_blob-devel.sha256sum] = "f15077674abacefbdf4d6559aecd0a86439fd64a5cded0e2ca3b609e52bfefe4"

URI_x86_64_v2_rust-rusqlite+limits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+limits-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+limits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+limits-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+limits-devel.sha256sum] = "7399a523703f54f7ee9b3de3e7db214d56ec1e2f11cc026e27aa142e1c1bc202"

URI_x86_64_v2_rust-rusqlite+load_extension-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+load_extension-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+load_extension-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+load_extension-devel.sha256sum] = "e070d565719b2e18cc6ed24b43f3e2f3ae53b8a930e512f7f72b865a7ee951cc"

URI_x86_64_v2_rust-rusqlite+modern-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+modern-full-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+modern-full-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+modern-full-devel.sha256sum] = "bdb3e370c49f8eb6d6583cd0914cfaecaba26ceb92b3665dd28e4dc1a1e05097"

URI_x86_64_v2_rust-rusqlite+modern_sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+modern_sqlite-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+modern_sqlite-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+modern_sqlite-devel.sha256sum] = "21c2e34a4a968aa2c42682e7398e1b28ef286b26eb920b5d1d4586b5ad76e7d2"

URI_x86_64_v2_rust-rusqlite+release_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+release_memory-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+release_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+release_memory-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+release_memory-devel.sha256sum] = "d30c28398ca51aa99e182ef31c3d044e119ca8aa7cf04f4afdac689da6ef3de6"

URI_x86_64_v2_rust-rusqlite+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+serde_json-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+serde_json-devel.sha256sum] = "6461b398e24c57ea0a0b0eab0d1ea0f46403cae3b45887dcb14bcfd2cd9b928e"

URI_x86_64_v2_rust-rusqlite+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+serialize-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+serialize-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+serialize-devel.sha256sum] = "743cb696622f2af450778186df6f69c6d5e9f71d7bc0a2fdd03fad43a9b3dada"

URI_x86_64_v2_rust-rusqlite+series-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+series-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+series-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+series-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+series-devel.sha256sum] = "a606b1efe109110424f531aa2c632457a2dca1f09e1d99aa1053cbe6bfb5d80a"

URI_x86_64_v2_rust-rusqlite+session-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+session-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+session-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+session-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+session-devel.sha256sum] = "c39c7e63c198661d120b59fc662473c8a61189f3227bc66da0a6d37aa16d3177"

URI_x86_64_v2_rust-rusqlite+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+time-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+time-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+time-devel.sha256sum] = "5392d55eae6782bc953387347a3dc5fb0c9698a489b1ed372a5f965ebc6ca79c"

URI_x86_64_v2_rust-rusqlite+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+trace-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+trace-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+trace-devel.sha256sum] = "fea2dfc890f2c34a473d7928bda11ab2a3235b5ef43ae99ea7179c1d41ac4ccb"

URI_x86_64_v2_rust-rusqlite+unlock_notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+unlock_notify-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+unlock_notify-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+unlock_notify-devel.sha256sum] = "9490681b744eabb6d95c4dacaf152a5fec9f91dc629f6721557b94e2b002fd8a"

URI_x86_64_v2_rust-rusqlite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+url-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+url-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+url-devel.sha256sum] = "a066ff38018a9186ec1c1807dbc37ad924f0e9495502fb083a3bcc698fd6eb4a"

URI_x86_64_v2_rust-rusqlite+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+uuid-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+uuid-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+uuid-devel.sha256sum] = "7dc5a2950d44b412acf85e1bc7a02545a2edea62131195f4277f8e044ac1c403"

URI_x86_64_v2_rust-rusqlite+vtab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+vtab-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+vtab-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+vtab-devel.sha256sum] = "67a557d0f11ac2a45c66a212feee36e665a10765e9b20275d04086f22c058633"

URI_x86_64_v2_rust-rusqlite+window-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite+window-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite+window-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite+window-devel}"
SRC_URI[x86_64_v2_rust-rusqlite+window-devel.sha256sum] = "43d488b2ef38ab552977e8ccb25c4c0509b429bd7dff99c6d42056dd0496dfeb"

URI_x86_64_v2_rust-rusqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusqlite-devel-0.31.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusqlite-devel}"
SRC_URI[x86_64_v2_rust-rusqlite-devel.sha256sum] = "e8f71a16bb59815f9d96a5c0955fcef65dd1809e90d409952108aa144c2f2cfa"

URI_aarch64_rust-rusqlite+array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+array-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+array-devel}"
SRC_URI[aarch64_rust-rusqlite+array-devel.sha256sum] = "dbefb053ef449c65d2f571af32deead04d2bd423547d96eb767c9d72872880f0"

URI_aarch64_rust-rusqlite+backup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+backup-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+backup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+backup-devel}"
SRC_URI[aarch64_rust-rusqlite+backup-devel.sha256sum] = "a0d3580e0fe7bf96c99584454ff1fd28219fd2f99b291b03ed655ddeac5c0458"

URI_aarch64_rust-rusqlite+blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+blob-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+blob-devel}"
SRC_URI[aarch64_rust-rusqlite+blob-devel.sha256sum] = "23bff425cadd35bd26a018df30ead3acd8878d7093717c65b2ef3ef862a468ac"

URI_aarch64_rust-rusqlite+buildtime_bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+buildtime_bindgen-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+buildtime_bindgen-devel}"
SRC_URI[aarch64_rust-rusqlite+buildtime_bindgen-devel.sha256sum] = "ce764f5af0394e93ae47ca3a33486fd841cce38d6caeaf0891c70438f8f7313b"

URI_aarch64_rust-rusqlite+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+chrono-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+chrono-devel}"
SRC_URI[aarch64_rust-rusqlite+chrono-devel.sha256sum] = "32ceb6c8caf834922c8338459157ec80f6773cb3af12c6d2c383d6ca4426c994"

URI_aarch64_rust-rusqlite+collation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+collation-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+collation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+collation-devel}"
SRC_URI[aarch64_rust-rusqlite+collation-devel.sha256sum] = "bf5dd6d5457750656ca48a57406343548ca5c771a7d3166e584110715ec7b1fe"

URI_aarch64_rust-rusqlite+column_decltype-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+column_decltype-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+column_decltype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+column_decltype-devel}"
SRC_URI[aarch64_rust-rusqlite+column_decltype-devel.sha256sum] = "842c294888e6cf795f0e3dcb23495562b8b1e7381dde4d9a3645e460613205b3"

URI_aarch64_rust-rusqlite+csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+csv-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+csv-devel}"
SRC_URI[aarch64_rust-rusqlite+csv-devel.sha256sum] = "82773a6a4113bdabeda4e94e154562331139f44066bb868681ea6d200110d6ad"

URI_aarch64_rust-rusqlite+csvtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+csvtab-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+csvtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+csvtab-devel}"
SRC_URI[aarch64_rust-rusqlite+csvtab-devel.sha256sum] = "1d1eeabbce8639e76d88d3f22d2dc3f8346144a76f4711194b6c9deeaa3fd31a"

URI_aarch64_rust-rusqlite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+default-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+default-devel}"
SRC_URI[aarch64_rust-rusqlite+default-devel.sha256sum] = "df5af9d95790cb8a7a1fb07b4ca650c45d7dc30aa0237df7816b683ca1ab341f"

URI_aarch64_rust-rusqlite+extra_check-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+extra_check-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+extra_check-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+extra_check-devel}"
SRC_URI[aarch64_rust-rusqlite+extra_check-devel.sha256sum] = "c2eb66af8f536b9b6aa1146c9beecbf2076a3d527835b60eda785dc4d875006e"

URI_aarch64_rust-rusqlite+functions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+functions-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+functions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+functions-devel}"
SRC_URI[aarch64_rust-rusqlite+functions-devel.sha256sum] = "69cb5749ec1ad7e1b9dc19c7d482f187735bd59794a52c953c073c599491f441"

URI_aarch64_rust-rusqlite+hooks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+hooks-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+hooks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+hooks-devel}"
SRC_URI[aarch64_rust-rusqlite+hooks-devel.sha256sum] = "b2ce1a06d7d441e1d40c723a8ab85a3de3a9c59cfef2bb50779d74543931aebe"

URI_aarch64_rust-rusqlite+i128_blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+i128_blob-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+i128_blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+i128_blob-devel}"
SRC_URI[aarch64_rust-rusqlite+i128_blob-devel.sha256sum] = "5e69637f93ededded07a5483b0f64e49120dd909aae67599a811439390790221"

URI_aarch64_rust-rusqlite+limits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+limits-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+limits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+limits-devel}"
SRC_URI[aarch64_rust-rusqlite+limits-devel.sha256sum] = "d26839dfa6cbb5e02c536295b4a0837bb27bc60769d8e7108e85b36708bae4ea"

URI_aarch64_rust-rusqlite+load_extension-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+load_extension-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+load_extension-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+load_extension-devel}"
SRC_URI[aarch64_rust-rusqlite+load_extension-devel.sha256sum] = "d02a829ed3c357c22d13b76ae067c66ae08509e8966da2f8e32b1c03771b0785"

URI_aarch64_rust-rusqlite+modern-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+modern-full-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+modern-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+modern-full-devel}"
SRC_URI[aarch64_rust-rusqlite+modern-full-devel.sha256sum] = "d2010898573257c5a66093599d57c69d763ae8682baf85ff780f666b3236b01d"

URI_aarch64_rust-rusqlite+modern_sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+modern_sqlite-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+modern_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+modern_sqlite-devel}"
SRC_URI[aarch64_rust-rusqlite+modern_sqlite-devel.sha256sum] = "3bee4867973ac7d136c16229f6a451d00f1430b12c777dd0847234ac14f2e13a"

URI_aarch64_rust-rusqlite+release_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+release_memory-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+release_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+release_memory-devel}"
SRC_URI[aarch64_rust-rusqlite+release_memory-devel.sha256sum] = "c54cfb55b351f1c6ec45e1ed5cbcb8f4fd0719eec0536e63232c5dfad2b1763f"

URI_aarch64_rust-rusqlite+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+serde_json-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+serde_json-devel}"
SRC_URI[aarch64_rust-rusqlite+serde_json-devel.sha256sum] = "fb854f0f82024061a651b20dabc60287464129c9a3c38123c1d974e29f01b501"

URI_aarch64_rust-rusqlite+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+serialize-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+serialize-devel}"
SRC_URI[aarch64_rust-rusqlite+serialize-devel.sha256sum] = "e481e392e196f3e066b8ebb6f769277bd5178e13b58b2dd0c023e640ab6baa55"

URI_aarch64_rust-rusqlite+series-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+series-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+series-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+series-devel}"
SRC_URI[aarch64_rust-rusqlite+series-devel.sha256sum] = "592e4911ec24b637074b49d542369982c8c4fb3a5e9d0090f3cd945be7ed7abc"

URI_aarch64_rust-rusqlite+session-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+session-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+session-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+session-devel}"
SRC_URI[aarch64_rust-rusqlite+session-devel.sha256sum] = "abf0247daadd6b1b27a5a2115a9980bf26a9b40a0c9c6f8eec6ec0651202881b"

URI_aarch64_rust-rusqlite+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+time-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+time-devel}"
SRC_URI[aarch64_rust-rusqlite+time-devel.sha256sum] = "012c6fc862a7ff4bb54faf8e08b5c8987200fce20143349e28ba2ca00169ec52"

URI_aarch64_rust-rusqlite+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+trace-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+trace-devel}"
SRC_URI[aarch64_rust-rusqlite+trace-devel.sha256sum] = "f4b572b5a66dbfa5710a6e58a55e1d1ca0a124752de832d03e86c317a3e12b31"

URI_aarch64_rust-rusqlite+unlock_notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+unlock_notify-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+unlock_notify-devel}"
SRC_URI[aarch64_rust-rusqlite+unlock_notify-devel.sha256sum] = "234cbd7675b737b85e3e6418ffbe286a73220f44723ef5fdc36698c3791e3f19"

URI_aarch64_rust-rusqlite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+url-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+url-devel}"
SRC_URI[aarch64_rust-rusqlite+url-devel.sha256sum] = "726ce114bcd314b1a18c57ee148951cdff7e0aa8a2f1db07d2365456b9ca92e3"

URI_aarch64_rust-rusqlite+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+uuid-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+uuid-devel}"
SRC_URI[aarch64_rust-rusqlite+uuid-devel.sha256sum] = "4734ff1a58a0fd48b2cc62b3845d98970829e12ae91644398fec6223cd0ad736"

URI_aarch64_rust-rusqlite+vtab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+vtab-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+vtab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+vtab-devel}"
SRC_URI[aarch64_rust-rusqlite+vtab-devel.sha256sum] = "e68954bd42681ae168ac78aa380e87d3020db5f178b49606490ff5878d283c14"

URI_aarch64_rust-rusqlite+window-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite+window-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite+window-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite+window-devel}"
SRC_URI[aarch64_rust-rusqlite+window-devel.sha256sum] = "7f98d7608e21a5bd7b0ce3da2437ea5dc23c6cbe1ba5f46473cd21cb979fd28a"

URI_aarch64_rust-rusqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusqlite-devel-0.31.0-4.el10_0.noarch.rpm;name=aarch64_rust-rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusqlite-devel}"
SRC_URI[aarch64_rust-rusqlite-devel.sha256sum] = "1dd9dd2b711793c3ca2aaf811a89eb8efba86bb0d67270c779d3db004c2fc881"

RDEPENDS:rust-rusqlite+array-devel = " \
 cargo \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+backup-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+blob-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+buildtime_bindgen-devel = " \
 cargo \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+collation-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+column_decltype-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+csvtab-devel = " \
 cargo \
 rust-rusqlite+csv-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+default-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+extra_check-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+functions-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+hooks-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+i128_blob-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+limits-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+load_extension-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+modern-full-devel = " \
 cargo \
 rust-rusqlite+array-devel \
 rust-rusqlite+backup-devel \
 rust-rusqlite+blob-devel \
 rust-rusqlite+chrono-devel \
 rust-rusqlite+collation-devel \
 rust-rusqlite+column_decltype-devel \
 rust-rusqlite+csvtab-devel \
 rust-rusqlite+extra_check-devel \
 rust-rusqlite+functions-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite+i128_blob-devel \
 rust-rusqlite+limits-devel \
 rust-rusqlite+load_extension-devel \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite+serde_json-devel \
 rust-rusqlite+series-devel \
 rust-rusqlite+time-devel \
 rust-rusqlite+trace-devel \
 rust-rusqlite+unlock_notify-devel \
 rust-rusqlite+url-devel \
 rust-rusqlite+uuid-devel \
 rust-rusqlite+vtab-devel \
 rust-rusqlite+window-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+modern_sqlite-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+release_memory-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+serde_json-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rusqlite+serialize-devel = " \
 cargo \
 rust-rusqlite+modern_sqlite-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+series-devel = " \
 cargo \
 rust-rusqlite+vtab-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+session-devel = " \
 cargo \
 rust-libsqlite3-sys+session-devel \
 rust-rusqlite+hooks-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+time-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-rusqlite+trace-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+unlock_notify-devel = " \
 cargo \
 rust-libsqlite3-sys+unlock_notify-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+url-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-rusqlite+uuid-devel = " \
 cargo \
 rust-rusqlite-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-rusqlite+vtab-devel = " \
 cargo \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite+window-devel = " \
 cargo \
 rust-rusqlite+functions-devel \
 rust-rusqlite-devel \
 "
RDEPENDS:rust-rusqlite-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-fallible-iterator+default-devel \
 rust-fallible-streaming-iterator+default-devel \
 rust-hashlink+default-devel \
 rust-libsqlite3-sys+default-devel \
 rust-smallvec+default-devel \
 "
