# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "editline"
PV = "1.17.1"
PR = "9.el10_1"
PACKAGES = " \
 editline \
 editline-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/editline-1.17.1-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48494f108c72c9daff4f8f009e9781b5450caa8a59c7ab6c1819f25efdd5be82"

URI_x86_64_v2_editline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/editline-1.17.1-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_editline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_editline}"
SRC_URI[x86_64_v2_editline.sha256sum] = "cd111e5c77cad1a377d85a26c14849f24c555563e94726c16898bea94930408b"

URI_x86_64_v2_editline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/editline-devel-1.17.1-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_editline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_editline-devel}"
SRC_URI[x86_64_v2_editline-devel.sha256sum] = "ec88a084bb9f28c822e4d2ddd2f98416b3471890c0a760c5d0b4d38ef12109a5"

URI_aarch64_editline = "${EPEL_MIRROR}/aarch64/Packages/e/editline-1.17.1-9.el10_1.aarch64.rpm;name=aarch64_editline;unpack=0"
SRC_URI:append = " ${URI_aarch64_editline}"
SRC_URI[aarch64_editline.sha256sum] = "324c94efe90adc9678ba60bc00831c266aa918937c5521a592b1739136127c84"

URI_aarch64_editline-devel = "${EPEL_MIRROR}/aarch64/Packages/e/editline-devel-1.17.1-9.el10_1.aarch64.rpm;name=aarch64_editline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_editline-devel}"
SRC_URI[aarch64_editline-devel.sha256sum] = "f0dd6c0576c46710a4ddc1f63859173518b695f2af1d9d4e6de533c5a3a73404"

RDEPENDS:editline = " \
 glibc \
 "
RDEPENDS:editline-devel = " \
 editline \
 pkgconf-pkg-config \
 "
