# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytemuck"
PV = "1.25.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-bytemuck+aarch64_simd-devel \
 rust-bytemuck+align_offset-devel \
 rust-bytemuck+alloc_uninit-devel \
 rust-bytemuck+avx512_simd-devel \
 rust-bytemuck+bytemuck_derive-devel \
 rust-bytemuck+const_zeroed-devel \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-bytemuck+extern_crate_std-devel \
 rust-bytemuck+impl_core_error-devel \
 rust-bytemuck+min_const_generics-devel \
 rust-bytemuck+must_cast-devel \
 rust-bytemuck+must_cast_extra-devel \
 rust-bytemuck+nightly_stdsimd-devel \
 rust-bytemuck+track_caller-devel \
 rust-bytemuck+transparentwrapper_extra-devel \
 rust-bytemuck+unsound_ptr_pod_impl-devel \
 rust-bytemuck+zeroable_atomics-devel \
 rust-bytemuck+zeroable_maybe_uninit-devel \
 rust-bytemuck+zeroable_unwind_fn-devel \
 rust-bytemuck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytemuck-1.25.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fea33295d711568bd89b45c600c7b2c4708e10bc4ef38b5735a8e87a5278afa6"

URI_x86_64_v2_rust-bytemuck+aarch64_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+aarch64_simd-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+aarch64_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+aarch64_simd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+aarch64_simd-devel.sha256sum] = "b52daba2ac5e77e9d3554ca29a1cd76c327500751d330e532237e66e960623f9"

URI_x86_64_v2_rust-bytemuck+align_offset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+align_offset-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+align_offset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+align_offset-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+align_offset-devel.sha256sum] = "363a9e19bad9a35a9968d55870a48a7af745d5c7b4192124150b65fd7984e488"

URI_x86_64_v2_rust-bytemuck+alloc_uninit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+alloc_uninit-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+alloc_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+alloc_uninit-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+alloc_uninit-devel.sha256sum] = "d7767d7ad0f519e8b0954c326dc99d79f175dc6bf9401c4a60b942b71667e471"

URI_x86_64_v2_rust-bytemuck+avx512_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+avx512_simd-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+avx512_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+avx512_simd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+avx512_simd-devel.sha256sum] = "e8c5263934362955217bca641cb2f95543cc0850b082f278fe75bde47795ea0d"

URI_x86_64_v2_rust-bytemuck+bytemuck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+bytemuck_derive-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+bytemuck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+bytemuck_derive-devel.sha256sum] = "40db8eb348c91e79d6d46360e879ac6338d36bf4a66f74572a4f85daf40c53bb"

URI_x86_64_v2_rust-bytemuck+const_zeroed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+const_zeroed-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+const_zeroed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+const_zeroed-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+const_zeroed-devel.sha256sum] = "04edc4a62ae262a2fb4ada76c91381d9404852c39f25856b9cabb2758b9720dc"

URI_x86_64_v2_rust-bytemuck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+default-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+default-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+default-devel.sha256sum] = "387fe03d1bf167ebe6058f2b59ed6dc55b7ebe681d59b512d10816fc83401768"

URI_x86_64_v2_rust-bytemuck+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+derive-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+derive-devel.sha256sum] = "c391e314b54436cd54ff7252c93f710f15290d2ded34d6216f00bd3ed41d8cce"

URI_x86_64_v2_rust-bytemuck+extern_crate_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+extern_crate_alloc-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+extern_crate_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+extern_crate_alloc-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+extern_crate_alloc-devel.sha256sum] = "5bace49ad38a6d1ad8869e5cdd67a06da38a378af5e2f719e9731df8d0b038a1"

URI_x86_64_v2_rust-bytemuck+extern_crate_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+extern_crate_std-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+extern_crate_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+extern_crate_std-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+extern_crate_std-devel.sha256sum] = "15e6d8dbc6e23f36499903edb8d4be2f4bee8f82d03219af541aec67b610b4ce"

URI_x86_64_v2_rust-bytemuck+impl_core_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+impl_core_error-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+impl_core_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+impl_core_error-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+impl_core_error-devel.sha256sum] = "e4300167d3013e1d0e852cf688812df1218f20b342354e12775c58631d1009bd"

URI_x86_64_v2_rust-bytemuck+min_const_generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+min_const_generics-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+min_const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+min_const_generics-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+min_const_generics-devel.sha256sum] = "b15413ec45cf382fb20005c4a1ca33a2989d87e702feab2743b119b8c2452a0e"

URI_x86_64_v2_rust-bytemuck+must_cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+must_cast-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+must_cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+must_cast-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+must_cast-devel.sha256sum] = "9d5b61c467ad8d0416302e2ad55d1c8a24120c4af5ff151046bd494f77b81607"

URI_x86_64_v2_rust-bytemuck+must_cast_extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+must_cast_extra-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+must_cast_extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+must_cast_extra-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+must_cast_extra-devel.sha256sum] = "bf9608afb69268e0990625460ce4aef2e9324382218d28f2acf8fa9d084f54ad"

URI_x86_64_v2_rust-bytemuck+nightly_stdsimd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+nightly_stdsimd-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+nightly_stdsimd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+nightly_stdsimd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+nightly_stdsimd-devel.sha256sum] = "474887f73bec30e0d27f7b7e7d341168a26ca1d39df6cfe25aa35028d2357257"

URI_x86_64_v2_rust-bytemuck+track_caller-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+track_caller-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+track_caller-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+track_caller-devel.sha256sum] = "a391a44c86caa5adda741408d75e2d192effab60027d58c09a66a8a27c041510"

URI_x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+transparentwrapper_extra-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel.sha256sum] = "c192f9f6ebb758b446584aab9765efc60973dc2c14a82e86b613a3294c81b251"

URI_x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+unsound_ptr_pod_impl-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel.sha256sum] = "06a717e9c79029e3fcd54ece5f8a747e1d3cf712d0fa73de62b3a89f3142dedd"

URI_x86_64_v2_rust-bytemuck+zeroable_atomics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_atomics-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_atomics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_atomics-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_atomics-devel.sha256sum] = "10cbe82843cfd25db399f3913aab929ce66b760df1af72d1a33e1817726e0918"

URI_x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_maybe_uninit-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel.sha256sum] = "6148472ea6bd9dbf562217cd9fe996d09a3540960a2b6e86473dd7860550c087"

URI_x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_unwind_fn-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel.sha256sum] = "aff2c8eef5b82da751227a0ef3785e8daa7fe5eddfd436e8c79238a53ccb9a18"

URI_x86_64_v2_rust-bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck-devel-1.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck-devel}"
SRC_URI[x86_64_v2_rust-bytemuck-devel.sha256sum] = "643872fa93f528bcc8ed1ae6d258488fba9233841fb690c618027fc0b626d60f"

URI_aarch64_rust-bytemuck+aarch64_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+aarch64_simd-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+aarch64_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+aarch64_simd-devel}"
SRC_URI[aarch64_rust-bytemuck+aarch64_simd-devel.sha256sum] = "ef40acff0aa0468285c1b084289f69a051f59377e4d1e22e9f514a71140d40cd"

URI_aarch64_rust-bytemuck+align_offset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+align_offset-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+align_offset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+align_offset-devel}"
SRC_URI[aarch64_rust-bytemuck+align_offset-devel.sha256sum] = "2cdd099c015f654ad81caf55deb4c65fbcfd03d025ac0d7d4f0188d6c002372a"

URI_aarch64_rust-bytemuck+alloc_uninit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+alloc_uninit-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+alloc_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+alloc_uninit-devel}"
SRC_URI[aarch64_rust-bytemuck+alloc_uninit-devel.sha256sum] = "cde4a42a33f95e1820baabbaf419bc9d8162995d49e69e4deb8cc60b71efaeaa"

URI_aarch64_rust-bytemuck+avx512_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+avx512_simd-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+avx512_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+avx512_simd-devel}"
SRC_URI[aarch64_rust-bytemuck+avx512_simd-devel.sha256sum] = "4b237731c0d8663e9dd9e8ced77cdf6af57866538166d9b2607800367323e3ec"

URI_aarch64_rust-bytemuck+bytemuck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+bytemuck_derive-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+bytemuck_derive-devel}"
SRC_URI[aarch64_rust-bytemuck+bytemuck_derive-devel.sha256sum] = "78148e87902e64c853d3e451a7baf5284e482f4ea0224217230bb9a2173d1a30"

URI_aarch64_rust-bytemuck+const_zeroed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+const_zeroed-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+const_zeroed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+const_zeroed-devel}"
SRC_URI[aarch64_rust-bytemuck+const_zeroed-devel.sha256sum] = "01baae769acee83583561930dbfd820ad2bbe47ca3dcb336a1b05a3ab9741ef2"

URI_aarch64_rust-bytemuck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+default-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+default-devel}"
SRC_URI[aarch64_rust-bytemuck+default-devel.sha256sum] = "9cd1c2886cff1ad369505b780732d47d6cfb2d2ddf04bf50d0e0c106241a4025"

URI_aarch64_rust-bytemuck+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+derive-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+derive-devel}"
SRC_URI[aarch64_rust-bytemuck+derive-devel.sha256sum] = "84294d4bb4a418a7633653cc62866a4c6cbbe139d92111481fed959c602a7376"

URI_aarch64_rust-bytemuck+extern_crate_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+extern_crate_alloc-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+extern_crate_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+extern_crate_alloc-devel}"
SRC_URI[aarch64_rust-bytemuck+extern_crate_alloc-devel.sha256sum] = "7a6d4d69c2062aa55233015648162544e255a4875f045de046d79f29848d096b"

URI_aarch64_rust-bytemuck+extern_crate_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+extern_crate_std-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+extern_crate_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+extern_crate_std-devel}"
SRC_URI[aarch64_rust-bytemuck+extern_crate_std-devel.sha256sum] = "0e3bc8cd548ef6610d56b3361a511c82678d486090c2a171a03d8871e7957a2e"

URI_aarch64_rust-bytemuck+impl_core_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+impl_core_error-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+impl_core_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+impl_core_error-devel}"
SRC_URI[aarch64_rust-bytemuck+impl_core_error-devel.sha256sum] = "e7da6b44f0171a962697f82c8e1cacdb1d37f86f0a57d7e0dbd8af25d3c26dbf"

URI_aarch64_rust-bytemuck+min_const_generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+min_const_generics-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+min_const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+min_const_generics-devel}"
SRC_URI[aarch64_rust-bytemuck+min_const_generics-devel.sha256sum] = "e3aaca86480b21728abe45430d465f14ff5754863286715255d3a01c72bb4e89"

URI_aarch64_rust-bytemuck+must_cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+must_cast-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+must_cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+must_cast-devel}"
SRC_URI[aarch64_rust-bytemuck+must_cast-devel.sha256sum] = "960a4c195e673abc2226a84df3bd934864d0b4516a6d6b60b485e6ac55a5abb4"

URI_aarch64_rust-bytemuck+must_cast_extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+must_cast_extra-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+must_cast_extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+must_cast_extra-devel}"
SRC_URI[aarch64_rust-bytemuck+must_cast_extra-devel.sha256sum] = "553277b922111f8a5a750685b6d10eee8660f8d3409ed11cb00532084103594d"

URI_aarch64_rust-bytemuck+nightly_stdsimd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+nightly_stdsimd-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+nightly_stdsimd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+nightly_stdsimd-devel}"
SRC_URI[aarch64_rust-bytemuck+nightly_stdsimd-devel.sha256sum] = "fb9907168aca0ca728fae3ee35b3214493f827ffcfa3d5ec3dde7d79e32335b7"

URI_aarch64_rust-bytemuck+track_caller-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+track_caller-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+track_caller-devel}"
SRC_URI[aarch64_rust-bytemuck+track_caller-devel.sha256sum] = "917d8129a7d3ccfd7b5d73aac701722af077100c8a62dd7098a9000464ae5fbb"

URI_aarch64_rust-bytemuck+transparentwrapper_extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+transparentwrapper_extra-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+transparentwrapper_extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+transparentwrapper_extra-devel}"
SRC_URI[aarch64_rust-bytemuck+transparentwrapper_extra-devel.sha256sum] = "c241b771574590aee5195443fe64c2acaf770b2091d2d14548d0ae2bc99a373b"

URI_aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+unsound_ptr_pod_impl-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel}"
SRC_URI[aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel.sha256sum] = "6428555d9b9efbdce31124b0bc673a3b00a63d5e553abc8e297077f2567535e6"

URI_aarch64_rust-bytemuck+zeroable_atomics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_atomics-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_atomics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_atomics-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_atomics-devel.sha256sum] = "f5a384ddbc8874915e93ff390a823dabb2902c16d12a8d048d6c8b37f47f22a7"

URI_aarch64_rust-bytemuck+zeroable_maybe_uninit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_maybe_uninit-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_maybe_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_maybe_uninit-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_maybe_uninit-devel.sha256sum] = "b5ddbd7dc370c7ea09b78292f640a17c1ec4224ebc6bf7dbcfbad4b05ca18a11"

URI_aarch64_rust-bytemuck+zeroable_unwind_fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_unwind_fn-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_unwind_fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_unwind_fn-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_unwind_fn-devel.sha256sum] = "da528ac63eeb0149c82396b880999f540e182cd88559153b1431137b12247265"

URI_aarch64_rust-bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck-devel-1.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck-devel}"
SRC_URI[aarch64_rust-bytemuck-devel.sha256sum] = "14f7fc4c49b01260f8268ccf379aa809b00f55ce459513dabef7cafc2a94da60"

RDEPENDS:rust-bytemuck+aarch64_simd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+align_offset-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+alloc_uninit-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+avx512_simd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+bytemuck_derive-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-bytemuck_derive+default-devel \
 "
RDEPENDS:rust-bytemuck+const_zeroed-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+default-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+derive-devel = " \
 cargo \
 rust-bytemuck+bytemuck_derive-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+extern_crate_alloc-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+extern_crate_std-devel = " \
 cargo \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+impl_core_error-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+min_const_generics-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+must_cast-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+must_cast_extra-devel = " \
 cargo \
 rust-bytemuck+must_cast-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+nightly_stdsimd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+track_caller-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+transparentwrapper_extra-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+unsound_ptr_pod_impl-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_atomics-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_maybe_uninit-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_unwind_fn-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck-devel = " \
 cargo \
 "
