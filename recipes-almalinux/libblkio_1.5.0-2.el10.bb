# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libblkio"
PV = "1.5.0"
PR = "2.el10"
PACKAGES = " \
 libblkio \
 libblkio-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libblkio-1.5.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb97fb4e238d1d3f3865de456fb6b43ffd9457607ff8e9d58a9d454950448d49"

URI_x86_64_v2_libblkio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblkio-1.5.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libblkio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkio}"
SRC_URI[x86_64_v2_libblkio.sha256sum] = "057ef73b3aab9ee62f4677430f15d14f0640169044ecaa8778bfe1ea994b6b8e"

URI_x86_64_v2_libblkio-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libblkio-devel-1.5.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libblkio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkio-devel}"
SRC_URI[x86_64_v2_libblkio-devel.sha256sum] = "b5c0f06a7746b4593e2dd66fc355a1f0b4dcdf5a00f4f2fc7e2905b324f0055e"

URI_aarch64_libblkio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblkio-1.5.0-2.el10.aarch64.rpm;name=aarch64_libblkio;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkio}"
SRC_URI[aarch64_libblkio.sha256sum] = "206a2f6d11426dce9c21166d0642a8ad16616d2bc7995862150897ec607b43f6"

URI_aarch64_libblkio-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libblkio-devel-1.5.0-2.el10.aarch64.rpm;name=aarch64_libblkio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkio-devel}"
SRC_URI[aarch64_libblkio-devel.sha256sum] = "c88504cfd4663aca4788741cc4b152b2978ad7e0dcbc6a8c63af04a2d4e413f6"

RDEPENDS:libblkio = " \
 glibc \
 libgcc \
 "
RDEPENDS:libblkio-devel = " \
 libblkio \
 pkgconf-pkg-config \
 "
