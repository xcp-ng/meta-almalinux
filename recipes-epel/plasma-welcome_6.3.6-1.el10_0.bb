# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-welcome"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-welcome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-welcome-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fc1821d9f2f936d306c65e4a500450bfddd69c6a540cea0966e253de457bd1d"

URI_x86_64_v2_plasma-welcome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-welcome-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-welcome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-welcome}"
SRC_URI[x86_64_v2_plasma-welcome.sha256sum] = "97a33fa316d6abb15539a404c01dbc594b47182a9796a81275026c8fbd66a01d"

URI_aarch64_plasma-welcome = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-welcome-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-welcome;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-welcome}"
SRC_URI[aarch64_plasma-welcome.sha256sum] = "d77f742b1394452ec8c0f19ecba93ae7aae2e83c2660b40d5dd033d703d37a10"

RDEPENDS:plasma-welcome = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
