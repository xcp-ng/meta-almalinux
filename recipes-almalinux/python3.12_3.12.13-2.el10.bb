# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.12"
PV = "3.12.13"
PR = "2.el10"
PACKAGES = " \
 python-unversioned-command \
 python3 \
 python3-debug \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python3.12-3.12.13-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "880e33127a9f040510e7ee784955f627abe23c29f21d607effc03b6dafa64f18"

URI_x86_64_v2_python-unversioned-command = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-unversioned-command-3.12.13-2.el10.noarch.rpm;name=x86_64_v2_python-unversioned-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-unversioned-command}"
SRC_URI[x86_64_v2_python-unversioned-command.sha256sum] = "8c1dd37d4ab1dd30edea4cd8c39c07b6ecfcdda84594bfb5f204ce13d46b5d76"

URI_x86_64_v2_python3 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-3.12.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3}"
SRC_URI[x86_64_v2_python3.sha256sum] = "1d64f6e366cf2f5edec606d6aa5ea457bee539390dc17827fd41ca23f3131016"

URI_x86_64_v2_python3-debug = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-debug-3.12.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debug}"
SRC_URI[x86_64_v2_python3-debug.sha256sum] = "7d36f9c2f607eb9e017b87660c02e1487764a5b419338576a79fc3c70d41432b"

URI_x86_64_v2_python3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-devel-3.12.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-devel}"
SRC_URI[x86_64_v2_python3-devel.sha256sum] = "a7318fad2bf6afbe4818928e4c30a94968288704ebe0d7ba6429fe6285afe16a"

URI_x86_64_v2_python3-idle = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-idle-3.12.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-idle}"
SRC_URI[x86_64_v2_python3-idle.sha256sum] = "cf2c3f219f32b7c24add6be7c0bea69400c39f8b816c53c05702e2ebb113dfe8"

URI_x86_64_v2_python3-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libs-3.12.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libs}"
SRC_URI[x86_64_v2_python3-libs.sha256sum] = "7f8a0f993544fa944659350d8e3b438e08aab2e27f05a34dd46532db9c445e60"

URI_x86_64_v2_python3-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-test-3.12.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-test}"
SRC_URI[x86_64_v2_python3-test.sha256sum] = "6b260483c66a5f6e35b73889157b149e5f29fb8addef2fd328d051be958216cc"

URI_x86_64_v2_python3-tkinter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tkinter-3.12.13-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tkinter}"
SRC_URI[x86_64_v2_python3-tkinter.sha256sum] = "cb20d24a97f01ed333cf3fbd5e52de38860db9f1e0c5826abc06723bd93dd2b4"

URI_aarch64_python-unversioned-command = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-unversioned-command-3.12.13-2.el10.noarch.rpm;name=aarch64_python-unversioned-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-unversioned-command}"
SRC_URI[aarch64_python-unversioned-command.sha256sum] = "8c1dd37d4ab1dd30edea4cd8c39c07b6ecfcdda84594bfb5f204ce13d46b5d76"

URI_aarch64_python3 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-3.12.13-2.el10.aarch64.rpm;name=aarch64_python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3}"
SRC_URI[aarch64_python3.sha256sum] = "a082d8e9ec8147000f917c0b4fd78615274c343f0c6a4ad14c01fe6dd311ea5f"

URI_aarch64_python3-debug = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-debug-3.12.13-2.el10.aarch64.rpm;name=aarch64_python3-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debug}"
SRC_URI[aarch64_python3-debug.sha256sum] = "56e10358801b10e66bd731fc478018ac198ef41a0bbdefc6c247c38ea0d9c44e"

URI_aarch64_python3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-devel-3.12.13-2.el10.aarch64.rpm;name=aarch64_python3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-devel}"
SRC_URI[aarch64_python3-devel.sha256sum] = "e7d78e555bb2f6364d7fe786aa31fdd92261c8028e519dc84b7a9f4c3f954cd8"

URI_aarch64_python3-idle = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-idle-3.12.13-2.el10.aarch64.rpm;name=aarch64_python3-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-idle}"
SRC_URI[aarch64_python3-idle.sha256sum] = "628d03c0cbcc82875c66f8b9312f901257567e1e4a4d1c3575c2f17d421458c2"

URI_aarch64_python3-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libs-3.12.13-2.el10.aarch64.rpm;name=aarch64_python3-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libs}"
SRC_URI[aarch64_python3-libs.sha256sum] = "213cfdb66abd7373f6deb03d9475879e2e926fda8898821bf934343e9ba05075"

URI_aarch64_python3-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-test-3.12.13-2.el10.aarch64.rpm;name=aarch64_python3-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-test}"
SRC_URI[aarch64_python3-test.sha256sum] = "6e9b9f477a14018bf55358379dd168ffb0487748737a1a7e3e7a815b054e43e6"

URI_aarch64_python3-tkinter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tkinter-3.12.13-2.el10.aarch64.rpm;name=aarch64_python3-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tkinter}"
SRC_URI[aarch64_python3-tkinter.sha256sum] = "f00ce622e24383c00979a8617aa7c5d6f0f3328c3adae2cd9140f3eef583b148"

RDEPENDS:python-unversioned-command = " \
 python3 \
 "
RDEPENDS:python3 = " \
 glibc \
 python3-libs \
 "
RDEPENDS:python3-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-devel \
 python3-idle \
 python3-libs \
 python3-test \
 python3-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3 \
 python3-libs \
 python3-rpm-generators \
 python3-rpm-macros \
 "
RDEPENDS:python3-idle = " \
 python3 \
 python3-tkinter \
 "
RDEPENDS:python3-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libxcrypt \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-test = " \
 bash \
 glibc \
 python3 \
 python3-libs \
 python3-setuptools-wheel \
 python3-wheel-wheel \
 "
RDEPENDS:python3-tkinter = " \
 glibc \
 python3 \
 tcl \
 tk \
 "
