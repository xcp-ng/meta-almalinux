# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "irqbalance"
PE = "2"
PV = "1.9.4"
PR = "2.el10"
PACKAGES = " \
 irqbalance \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/irqbalance-1.9.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac0ba6969a0c047f2ce17b8295aeb34b49e56793a1af4427dd8e6b81de9d375f"

URI_x86_64_v2_irqbalance = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/irqbalance-1.9.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_irqbalance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_irqbalance}"
SRC_URI[x86_64_v2_irqbalance.sha256sum] = "db3a5fcbf5a3a65974a812df4a5772450981d81ef08e905eb504b6aa50a0d0eb"

URI_aarch64_irqbalance = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/irqbalance-1.9.4-2.el10.aarch64.rpm;name=aarch64_irqbalance;unpack=0"
SRC_URI:append = " ${URI_aarch64_irqbalance}"
SRC_URI[aarch64_irqbalance.sha256sum] = "14a66ed6e288be535407d1d7db1453da67cce329266251480f09e839b6c86521"

RDEPENDS:irqbalance = " \
 bash \
 glib2 \
 glibc \
 libcap-ng \
 ncurses-libs \
 numactl-libs \
 systemd-libs \
 "
