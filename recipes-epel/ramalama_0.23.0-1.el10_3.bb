# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ramalama"
PV = "0.23.0"
PR = "1.el10_3"
PACKAGES = " \
 ramalama \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ramalama-0.23.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b1dcbcaf82134eefc703274fbfa131ee26cbee0506cf2bd1c81e27822d6ba08"

URI_x86_64_v2_ramalama = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ramalama-0.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ramalama;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ramalama}"
SRC_URI[x86_64_v2_ramalama.sha256sum] = "8a5ebbe8f129935e83f8a665346df31f5e54517fd0f86222623c1d91676a09ee"

URI_aarch64_ramalama = "${EPEL_MIRROR}/aarch64/Packages/r/ramalama-0.23.0-1.el10_3.noarch.rpm;name=aarch64_ramalama;unpack=0"
SRC_URI:append = " ${URI_aarch64_ramalama}"
SRC_URI[aarch64_ramalama.sha256sum] = "07cdea75618db28983eeef5f32aec647c3a68e0957b75b8ce45c1b7427e1519d"

RDEPENDS:ramalama = " \
 podman \
 python3 \
 python3-argcomplete \
 python3-jinja2 \
 python3-pyyaml \
 "
