# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-Element-Extended"
PV = "1.18"
PR = "33.el10_0"
PACKAGES = " \
 perl-HTML-Element-Extended \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-Element-Extended-1.18-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1791cb0e88f583752880cfcdee5b94126fb9a167750c0444a863fac0e999abd"

URI_x86_64_v2_perl-HTML-Element-Extended = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-Element-Extended-1.18-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-Element-Extended;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-Element-Extended}"
SRC_URI[x86_64_v2_perl-HTML-Element-Extended.sha256sum] = "64ebcb1045ba8aaee9a8c11fab58bb732d92a3fe743021b92c32ebe0459611dc"

URI_aarch64_perl-HTML-Element-Extended = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-Element-Extended-1.18-33.el10_0.noarch.rpm;name=aarch64_perl-HTML-Element-Extended;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-Element-Extended}"
SRC_URI[aarch64_perl-HTML-Element-Extended.sha256sum] = "22b99cbb4f16aa69ab7011a920adf84e9810b372552300a0995c6f1dae6ee0a0"

RDEPENDS:perl-HTML-Element-Extended = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-HTML-Element-Extended \
 perl-HTML-Tree \
 perl-Tie \
 perl-libs \
 perl-vars \
 "
