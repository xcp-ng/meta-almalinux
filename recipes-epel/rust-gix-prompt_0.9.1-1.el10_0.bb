# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-prompt"
PV = "0.9.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-prompt+default-devel \
 rust-gix-prompt-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-gix-prompt-0.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "276f03cf62ef43f4c542d151177919484a04b405cbff9070c4ba7df7b9ee3ce9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-prompt+default-devel-0.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-prompt+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-prompt+default-devel.sha256sum] = "ac13e5de8214994dee4f304927569d9f83199bd15dc99a5b8c962d35504b02df"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-prompt-devel-0.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-prompt-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-prompt-devel.sha256sum] = "7a2e4c4665c362ae6e17078c478fc0ea95608ad7f1be8e4c2fa3a4971495140c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-prompt+default-devel-0.9.1-1.el10_0.noarch.rpm;name=aarch64_rust-gix-prompt+default-devel;unpack=0"
SRC_URI[aarch64_rust-gix-prompt+default-devel.sha256sum] = "40ef1cc69626acc8b620f1bb814b9b0fdbe1f70d9d4e6cc9fe5b587470341d48"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-prompt-devel-0.9.1-1.el10_0.noarch.rpm;name=aarch64_rust-gix-prompt-devel;unpack=0"
SRC_URI[aarch64_rust-gix-prompt-devel.sha256sum] = "bb423c0dea64ad134989ad142b43ef4b72c9a5b895bcd8ca127b60406bf8eac9"

RDEPENDS:rust-gix-prompt+default-devel = " \
 cargo \
 rust-gix-prompt-devel \
 "
RDEPENDS:rust-gix-prompt-devel = " \
 cargo \
 rust \
 rust-gix-command+default-devel \
 rust-gix-config-value+default-devel \
 rust-parking_lot+default-devel \
 rust-rustix+default-devel \
 rust-rustix+termios-devel \
 rust-thiserror+default-devel \
 "
