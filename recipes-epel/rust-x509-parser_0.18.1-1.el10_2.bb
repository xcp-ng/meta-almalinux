# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x509-parser"
PV = "0.18.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-x509-parser+default-devel \
 rust-x509-parser+ring-devel \
 rust-x509-parser+validate-devel \
 rust-x509-parser+verify-devel \
 rust-x509-parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x509-parser-0.18.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "082d191cfb1afda4096d1770079a27ddfed2d928aae3deef862e33eee2631bd8"

URI_x86_64_v2_rust-x509-parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+default-devel-0.18.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+default-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+default-devel.sha256sum] = "8bc689949f20c17fb6b0ed48674ee33c4ccdcf6722294be8db9c15c527e3bba9"

URI_x86_64_v2_rust-x509-parser+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+ring-devel-0.18.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+ring-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+ring-devel.sha256sum] = "56bc6f10d48908856d9eb6ec087594ba2c3c4c2d8d6ff1443deafed1b21b85ad"

URI_x86_64_v2_rust-x509-parser+validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+validate-devel-0.18.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+validate-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+validate-devel.sha256sum] = "0242ec3dddc4c47b16c5ddfeee2909e686dc6d37bf9e68d5b3f6708137f017a0"

URI_x86_64_v2_rust-x509-parser+verify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser+verify-devel-0.18.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser+verify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser+verify-devel}"
SRC_URI[x86_64_v2_rust-x509-parser+verify-devel.sha256sum] = "6833b76cd2345479f8f5a10f93c396e6e7550bf1e751029f2a4856386e8c08c5"

URI_x86_64_v2_rust-x509-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x509-parser-devel-0.18.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x509-parser-devel}"
SRC_URI[x86_64_v2_rust-x509-parser-devel.sha256sum] = "1ae3f346e8fc8283ba8004f52c1be4c1cb25fa31963276f7cbb3a6b9c978cbbf"

URI_aarch64_rust-x509-parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+default-devel-0.18.1-1.el10_2.noarch.rpm;name=aarch64_rust-x509-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+default-devel}"
SRC_URI[aarch64_rust-x509-parser+default-devel.sha256sum] = "11e216c406412b12bcc44cef11a40527bc306edf9ca88eade930e6101433fa08"

URI_aarch64_rust-x509-parser+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+ring-devel-0.18.1-1.el10_2.noarch.rpm;name=aarch64_rust-x509-parser+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+ring-devel}"
SRC_URI[aarch64_rust-x509-parser+ring-devel.sha256sum] = "a06cea95797b7654a70f6bbfad8e2c2ff71a1cbd847a71ef1c6480c56b05d4bb"

URI_aarch64_rust-x509-parser+validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+validate-devel-0.18.1-1.el10_2.noarch.rpm;name=aarch64_rust-x509-parser+validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+validate-devel}"
SRC_URI[aarch64_rust-x509-parser+validate-devel.sha256sum] = "ea86b3f4d5387c059f9cca296692e410e394fe63d099c7b053f5fc7cdc49d9d4"

URI_aarch64_rust-x509-parser+verify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser+verify-devel-0.18.1-1.el10_2.noarch.rpm;name=aarch64_rust-x509-parser+verify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser+verify-devel}"
SRC_URI[aarch64_rust-x509-parser+verify-devel.sha256sum] = "1c7bb5faa6e92e3af48970160d8ed76a1031de0cd329defb3a367d55fff86762"

URI_aarch64_rust-x509-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x509-parser-devel-0.18.1-1.el10_2.noarch.rpm;name=aarch64_rust-x509-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x509-parser-devel}"
SRC_URI[aarch64_rust-x509-parser-devel.sha256sum] = "d71ade23f0384e26e9e4c71ad8dc9a51441ebddd32f7daec866e17e797893b54"

RDEPENDS:rust-x509-parser+default-devel = " \
 cargo \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser+validate-devel = " \
 cargo \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser+verify-devel = " \
 cargo \
 rust-x509-parser+ring-devel \
 rust-x509-parser-devel \
 "
RDEPENDS:rust-x509-parser-devel = " \
 cargo \
 rust \
 rust-asn1-rs+datetime-devel \
 rust-asn1-rs+default-devel \
 rust-data-encoding+default-devel \
 rust-der-parser+bigint-devel \
 rust-der-parser+default-devel \
 rust-lazy_static+default-devel \
 rust-nom7+default-devel \
 rust-oid-registry+crypto-devel \
 rust-oid-registry+default-devel \
 rust-oid-registry+x509-devel \
 rust-oid-registry+x962-devel \
 rust-rusticata-macros+default-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 "
