# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-terminal-exec"
PV = "0.13.2"
PR = "1.el10_1"
PACKAGES = " \
 xdg-terminal-exec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xdg-terminal-exec-0.13.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1d52903c306dbc43935474f63eb63d0b69bde7d4286c427860ed0399a2cba7d"

URI_x86_64_v2_xdg-terminal-exec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdg-terminal-exec-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_xdg-terminal-exec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-terminal-exec}"
SRC_URI[x86_64_v2_xdg-terminal-exec.sha256sum] = "37a5a0edca731799dd18e490be5f5b1899d9f074961a07253edf40b320458c70"

URI_aarch64_xdg-terminal-exec = "${EPEL_MIRROR}/aarch64/Packages/x/xdg-terminal-exec-0.13.2-1.el10_1.noarch.rpm;name=aarch64_xdg-terminal-exec;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-terminal-exec}"
SRC_URI[aarch64_xdg-terminal-exec.sha256sum] = "4d99a8620a76c61de96cd3f6b279bddc03ed2986809881658886278abaee4f5c"

RDEPENDS:xdg-terminal-exec = " \
 bash \
 "
