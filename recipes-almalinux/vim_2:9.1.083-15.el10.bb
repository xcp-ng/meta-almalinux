# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim"
PE = "2"
PV = "9.1.083"
PR = "15.el10"
PACKAGES = " \
 vim-X11 \
 vim-common \
 vim-data \
 vim-enhanced \
 vim-filesystem \
 vim-minimal \
 xxd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/vim-9.1.083-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04ba6937d7b5073db4090e347b455cb87511cc1c14670434ddf9b9e351785055"

URI_x86_64_v2_vim-X11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-X11-9.1.083-15.el10.x86_64_v2.rpm;name=x86_64_v2_vim-X11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-X11}"
SRC_URI[x86_64_v2_vim-X11.sha256sum] = "2e2e98bc6e71897a4fed7d52a5991a2b4d85b96029aa951927a195892920a2ec"
RPROVIDES:vim-X11:x86_64_v2 = "virtual/vim-enhanced_or_vim-X11"

URI_x86_64_v2_vim-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-common-9.1.083-15.el10.x86_64_v2.rpm;name=x86_64_v2_vim-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-common}"
SRC_URI[x86_64_v2_vim-common.sha256sum] = "551d5b6e24619290d8679e813f0f3982e933dd97396515839363418c56ebe218"

URI_x86_64_v2_vim-data = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-data-9.1.083-15.el10.noarch.rpm;name=x86_64_v2_vim-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-data}"
SRC_URI[x86_64_v2_vim-data.sha256sum] = "0abae4dfa079743fe800b32bad5c11c19e6a1f5802f6246a7e65c383b774509f"

URI_x86_64_v2_vim-enhanced = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vim-enhanced-9.1.083-15.el10.x86_64_v2.rpm;name=x86_64_v2_vim-enhanced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-enhanced}"
SRC_URI[x86_64_v2_vim-enhanced.sha256sum] = "22b2a6d7ba570041b0f11f537f8edac5a483c08eba7909cfbfdd4c9b8072b93d"
RPROVIDES:vim-enhanced:x86_64_v2 = "virtual/vim-enhanced_or_vim-X11"

URI_x86_64_v2_vim-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-filesystem-9.1.083-15.el10.noarch.rpm;name=x86_64_v2_vim-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-filesystem}"
SRC_URI[x86_64_v2_vim-filesystem.sha256sum] = "4455cb20801c883daa7a4e4a847a439d455509fe30d2747c9526bc4909f44830"

URI_x86_64_v2_vim-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vim-minimal-9.1.083-15.el10.x86_64_v2.rpm;name=x86_64_v2_vim-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-minimal}"
SRC_URI[x86_64_v2_vim-minimal.sha256sum] = "bc4d842e6220c1917c0fa92e23850478499ed00355d8735e3ef4428f731fa725"

URI_x86_64_v2_xxd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xxd-9.1.083-15.el10.x86_64_v2.rpm;name=x86_64_v2_xxd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xxd}"
SRC_URI[x86_64_v2_xxd.sha256sum] = "ac2760fc02fabd399cc4457f25beb395f5216d96c55ef0d8a331455ccc082443"

URI_aarch64_vim-X11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-X11-9.1.083-15.el10.aarch64.rpm;name=aarch64_vim-X11;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-X11}"
SRC_URI[aarch64_vim-X11.sha256sum] = "28af4de49e71fd0792714db48e30a7fa27ab5ef4f51d68e2dbed712da9192ce6"
RPROVIDES:vim-X11:aarch64 = "virtual/vim-enhanced_or_vim-X11"

URI_aarch64_vim-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-common-9.1.083-15.el10.aarch64.rpm;name=aarch64_vim-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-common}"
SRC_URI[aarch64_vim-common.sha256sum] = "6b541f40537bc1b1ad83e37cfd9765f3b1e98c8c60c22dc20cd5ef383b1ccfc9"

URI_aarch64_vim-data = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-data-9.1.083-15.el10.noarch.rpm;name=aarch64_vim-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-data}"
SRC_URI[aarch64_vim-data.sha256sum] = "0abae4dfa079743fe800b32bad5c11c19e6a1f5802f6246a7e65c383b774509f"

URI_aarch64_vim-enhanced = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vim-enhanced-9.1.083-15.el10.aarch64.rpm;name=aarch64_vim-enhanced;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-enhanced}"
SRC_URI[aarch64_vim-enhanced.sha256sum] = "dc21be6b59bf140e945246502565401873c03d49a169be89dffdf1493f423a25"
RPROVIDES:vim-enhanced:aarch64 = "virtual/vim-enhanced_or_vim-X11"

URI_aarch64_vim-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-filesystem-9.1.083-15.el10.noarch.rpm;name=aarch64_vim-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-filesystem}"
SRC_URI[aarch64_vim-filesystem.sha256sum] = "4455cb20801c883daa7a4e4a847a439d455509fe30d2747c9526bc4909f44830"

URI_aarch64_vim-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vim-minimal-9.1.083-15.el10.aarch64.rpm;name=aarch64_vim-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-minimal}"
SRC_URI[aarch64_vim-minimal.sha256sum] = "04bf484689b86dc14ec27b0ca9c07c4883f48a74f1e56b701f721569bb10b97f"

URI_aarch64_xxd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xxd-9.1.083-15.el10.aarch64.rpm;name=aarch64_xxd;unpack=0"
SRC_URI:append = " ${URI_aarch64_xxd}"
SRC_URI[aarch64_xxd.sha256sum] = "e4b94fc5e707835e8398aab03635a26c38b3d7c0068730864783f9e583905dcc"

RDEPENDS:vim-X11 = " \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libICE \
 libSM \
 libX11 \
 libXt \
 libacl \
 libattr \
 libcanberra \
 libselinux \
 ncurses-libs \
 pango \
 vim-common \
 "
RDEPENDS:vim-common = " \
 bash \
 vim-data \
 vim-filesystem \
 xxd \
 "
RDEPENDS:vim-data = " \
 "
RDEPENDS:vim-enhanced = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-common \
 which \
 "
RDEPENDS:vim-filesystem = " \
 "
RDEPENDS:vim-minimal = " \
 bash \
 glibc \
 libacl \
 libselinux \
 ncurses-libs \
 vim-data \
 "
RDEPENDS:xxd = " \
 glibc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/vim-enhanced_or_vim-X11"

PROVIDES:append:aarch64 = " rpm/virtual/vim-enhanced_or_vim-X11"
