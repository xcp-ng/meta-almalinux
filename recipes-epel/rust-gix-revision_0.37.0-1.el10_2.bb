# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-revision"
PV = "0.37.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-revision+default-devel \
 rust-gix-revision+describe-devel \
 rust-gix-revision+document-features-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision+serde-devel \
 rust-gix-revision-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-revision-0.37.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c390ef2dfd783b287070a36a4b00184afefb47a333f18f6cb2c12894dffe62c"

URI_x86_64_v2_rust-gix-revision+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+default-devel-0.37.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+default-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+default-devel.sha256sum] = "32a71bed42533840a8b3e771cef62a5308b7dabfdebc9a8969ec73c3ec70bf8f"

URI_x86_64_v2_rust-gix-revision+describe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+describe-devel-0.37.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+describe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+describe-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+describe-devel.sha256sum] = "acf2e7aaaf63dbb3b29c948780d6bd6b5eeb4e52b2ce6aa0daa878578cda3883"

URI_x86_64_v2_rust-gix-revision+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+document-features-devel-0.37.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+document-features-devel.sha256sum] = "9bcdb1a505c807a0d5c16ae58c189bbf72bceb3ffcc82274962bffb8f67433f8"

URI_x86_64_v2_rust-gix-revision+merge_base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+merge_base-devel-0.37.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+merge_base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+merge_base-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+merge_base-devel.sha256sum] = "09f1553700baea67240f4ac5cfe049c653d5907e04bbf66dee233d2fa9be4efc"

URI_x86_64_v2_rust-gix-revision+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+serde-devel-0.37.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+serde-devel.sha256sum] = "1eee9d635c9b1ea55314569a190ace92fbd2d835d3c9575d0d85765e0aaa5760"

URI_x86_64_v2_rust-gix-revision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision-devel-0.37.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision-devel}"
SRC_URI[x86_64_v2_rust-gix-revision-devel.sha256sum] = "22ba281a1489169b5f12b7464801e12ef7313f45c6e3e26f089caa45a6a19cbc"

URI_aarch64_rust-gix-revision+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+default-devel-0.37.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-revision+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+default-devel}"
SRC_URI[aarch64_rust-gix-revision+default-devel.sha256sum] = "e9d94ae288135f87f94de8ada891bf32a5b154e74ea531c0e28954a2cba48a78"

URI_aarch64_rust-gix-revision+describe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+describe-devel-0.37.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-revision+describe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+describe-devel}"
SRC_URI[aarch64_rust-gix-revision+describe-devel.sha256sum] = "e92796788b2aabb626f6d0cb846335b602534dac498af4dfecda34483c571152"

URI_aarch64_rust-gix-revision+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+document-features-devel-0.37.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-revision+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+document-features-devel}"
SRC_URI[aarch64_rust-gix-revision+document-features-devel.sha256sum] = "b51860f7a97cfa66e9849b6cfd38197b1ea1faf40e3dd715c74e6e69424caf4e"

URI_aarch64_rust-gix-revision+merge_base-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+merge_base-devel-0.37.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-revision+merge_base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+merge_base-devel}"
SRC_URI[aarch64_rust-gix-revision+merge_base-devel.sha256sum] = "1e76f8e30a4d3175cad2c4bce7d6085a335feb101a251e40502e65e79adb609e"

URI_aarch64_rust-gix-revision+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+serde-devel-0.37.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-revision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+serde-devel}"
SRC_URI[aarch64_rust-gix-revision+serde-devel.sha256sum] = "c4f73d0faba68e36f1b7ad46a3c3b3c1efefdd2ce64e91f2061b2025cf805a1c"

URI_aarch64_rust-gix-revision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision-devel-0.37.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-revision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision-devel}"
SRC_URI[aarch64_rust-gix-revision-devel.sha256sum] = "34906782aa5176463cb2de7b92661117d1bff61c7741c74ed42c617655e4f997"

RDEPENDS:rust-gix-revision+default-devel = " \
 cargo \
 rust-gix-revision+describe-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision+describe-devel = " \
 cargo \
 rust-gix-hashtable+default-devel \
 rust-gix-revision-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-revision+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision+merge_base-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-gix-revision-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-revision+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-revision-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-revision-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-thiserror+default-devel \
 "
