# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memmem"
PV = "0.1.1"
PR = "8.el10_0"
PACKAGES = " \
 rust-memmem+default-devel \
 rust-memmem-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memmem-0.1.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "172f4198fd1331da0bb0890e1132e6bf363031b9cc196e8b4f596b1ccf5ab772"

URI_x86_64_v2_rust-memmem+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmem+default-devel-0.1.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmem+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmem+default-devel}"
SRC_URI[x86_64_v2_rust-memmem+default-devel.sha256sum] = "41b3e0f9d6b0afa0b1fd4ce10b884753fa91da6efade8814cdb69d4a92de36b3"

URI_x86_64_v2_rust-memmem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmem-devel-0.1.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmem-devel}"
SRC_URI[x86_64_v2_rust-memmem-devel.sha256sum] = "21dfdb830c26cf4dada1095cefc624bebb9e78205431397116cac3148a58181e"

URI_aarch64_rust-memmem+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmem+default-devel-0.1.1-8.el10_0.noarch.rpm;name=aarch64_rust-memmem+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmem+default-devel}"
SRC_URI[aarch64_rust-memmem+default-devel.sha256sum] = "4d12a600826a6a9399ff9155d4a036a8dedb71f8fb1c5bfcce34d6b61b24cd6e"

URI_aarch64_rust-memmem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmem-devel-0.1.1-8.el10_0.noarch.rpm;name=aarch64_rust-memmem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmem-devel}"
SRC_URI[aarch64_rust-memmem-devel.sha256sum] = "bab26f5b609f46f3b21d6ab46bc7b6dcf4b4acc41fc3269c312224a78bc36ea7"

RDEPENDS:rust-memmem+default-devel = " \
 cargo \
 rust-memmem-devel \
 "
RDEPENDS:rust-memmem-devel = " \
 cargo \
 "
