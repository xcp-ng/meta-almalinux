# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qttools"
PV = "6.8.1"
PR = "3.el10"
PACKAGES = " \
 qt6-assistant \
 qt6-designer \
 qt6-doctools \
 qt6-linguist \
 qt6-qdbusviewer \
 qt6-qttools \
 qt6-qttools-common \
 qt6-qttools-devel \
 qt6-qttools-examples \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 qt6-qttools-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qttools-6.8.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7694ced407690ac5318a4af1888d2b8a8c96a9f6767e4156a162e19e0b2717a"

URI_x86_64_v2_qt6-assistant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-assistant-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-assistant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-assistant}"
SRC_URI[x86_64_v2_qt6-assistant.sha256sum] = "d05a8895f9e02cff5cde082bd5eefc33b9e4df0bc36cbb8ba822d0bc31a5c6d7"

URI_x86_64_v2_qt6-designer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-designer-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-designer}"
SRC_URI[x86_64_v2_qt6-designer.sha256sum] = "29b66685e59fea6eb8b02cbcbefdaf7c2c01f4d75c5dfaeca1f22f41bff372cd"

URI_x86_64_v2_qt6-doctools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-doctools-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-doctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-doctools}"
SRC_URI[x86_64_v2_qt6-doctools.sha256sum] = "070b6d8435332b0e846188a9c8cb2362e64670cfffe7ac5c8ae5a36abc157a73"

URI_x86_64_v2_qt6-linguist = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-linguist-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-linguist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-linguist}"
SRC_URI[x86_64_v2_qt6-linguist.sha256sum] = "e6f113be7aee47a75a79c338d314bcc8854c723123033d0a301b904a7491de94"

URI_x86_64_v2_qt6-qdbusviewer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qdbusviewer-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qdbusviewer}"
SRC_URI[x86_64_v2_qt6-qdbusviewer.sha256sum] = "0cb419f96a5b6df61df9b4f26b2347471668e171e74aa0f190e83a4a6e0666fa"

URI_x86_64_v2_qt6-qttools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools}"
SRC_URI[x86_64_v2_qt6-qttools.sha256sum] = "05e8ef62a6266235241cd0d6ca28980c5845142326bb15824266d46a4b99e80b"

URI_x86_64_v2_qt6-qttools-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-common-6.8.1-3.el10.noarch.rpm;name=x86_64_v2_qt6-qttools-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-common}"
SRC_URI[x86_64_v2_qt6-qttools-common.sha256sum] = "bcf9998384d7149d2f4ec5fb2441d4a18c1cd7d4f19781ff5493e2d7840b2b18"

URI_x86_64_v2_qt6-qttools-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-devel-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-devel}"
SRC_URI[x86_64_v2_qt6-qttools-devel.sha256sum] = "e65a9b6b56d456e9cc7e0d54801b705223522a711c964081ae30d37733aaed0a"

URI_x86_64_v2_qt6-qttools-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qttools-examples-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-examples}"
SRC_URI[x86_64_v2_qt6-qttools-examples.sha256sum] = "752cdf54e4169322f2e8d0720835e25c3259b12dd9b414ac826949f34280468a"

URI_x86_64_v2_qt6-qttools-libs-designer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-designer-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-libs-designer}"
SRC_URI[x86_64_v2_qt6-qttools-libs-designer.sha256sum] = "f94a8306e22204b4885fd5c1261759dde97f462efda70e42054e4e983d7f83b2"

URI_x86_64_v2_qt6-qttools-libs-designercomponents = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-designercomponents-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-libs-designercomponents}"
SRC_URI[x86_64_v2_qt6-qttools-libs-designercomponents.sha256sum] = "5ca9575600c93fde821bc18acf423716b0835807d2e56b05facc86a2d22ae26d"

URI_x86_64_v2_qt6-qttools-libs-help = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qttools-libs-help-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-libs-help}"
SRC_URI[x86_64_v2_qt6-qttools-libs-help.sha256sum] = "6fef914c72e9d010926569a3ef6c7701e8644992dc39ad0a0195eaed6c494d1e"

URI_x86_64_v2_qt6-qttools-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qttools-static-6.8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qttools-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qttools-static}"
SRC_URI[x86_64_v2_qt6-qttools-static.sha256sum] = "dcbf0a58f6d4c413ebe5a657a01fc78f4c42646dbd95c3d1257f991f231e65e4"

URI_aarch64_qt6-assistant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-assistant-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-assistant;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-assistant}"
SRC_URI[aarch64_qt6-assistant.sha256sum] = "9a8a02d77dec04ab357b16d561e881cea9ecb49c97ec3f563256834aeaa2524a"

URI_aarch64_qt6-designer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-designer-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-designer}"
SRC_URI[aarch64_qt6-designer.sha256sum] = "ebdbc24d988b1752cd54e4a65f0cba869e624db965b4afbae3c70c7d2175dd84"

URI_aarch64_qt6-doctools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-doctools-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-doctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-doctools}"
SRC_URI[aarch64_qt6-doctools.sha256sum] = "63229f85666e8ce012e598bce84216f3bfcec332a7d5991bd7979532f98afab3"

URI_aarch64_qt6-linguist = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-linguist-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-linguist;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-linguist}"
SRC_URI[aarch64_qt6-linguist.sha256sum] = "1b5b2bbdfec206d810bbcb2c03afa9e9d0b0e569151edb548268990dc30cbfdb"

URI_aarch64_qt6-qdbusviewer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qdbusviewer-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qdbusviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qdbusviewer}"
SRC_URI[aarch64_qt6-qdbusviewer.sha256sum] = "209f5bfcbd5c1c575aa560c74f7ce7d5b6916b992bb833d5b538619ef4c3b113"

URI_aarch64_qt6-qttools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qttools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools}"
SRC_URI[aarch64_qt6-qttools.sha256sum] = "81f89fc73fa7195b57cbb21e22fc59afa32dfe65568f7e36b8805db2d60b1d75"

URI_aarch64_qt6-qttools-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-common-6.8.1-3.el10.noarch.rpm;name=aarch64_qt6-qttools-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-common}"
SRC_URI[aarch64_qt6-qttools-common.sha256sum] = "bcf9998384d7149d2f4ec5fb2441d4a18c1cd7d4f19781ff5493e2d7840b2b18"

URI_aarch64_qt6-qttools-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-devel-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qttools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-devel}"
SRC_URI[aarch64_qt6-qttools-devel.sha256sum] = "77f4eebaf0ea70f8314d6a4aa59dbd238b96df03b5a6b9f9a84c253676499739"

URI_aarch64_qt6-qttools-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qttools-examples-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qttools-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-examples}"
SRC_URI[aarch64_qt6-qttools-examples.sha256sum] = "c4fd49b71697c7faa0e2f27a2c496111d9ca6fe0e3752e04c84b962342fc7734"

URI_aarch64_qt6-qttools-libs-designer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-libs-designer-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qttools-libs-designer;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-libs-designer}"
SRC_URI[aarch64_qt6-qttools-libs-designer.sha256sum] = "22bdac1c5e2881716ef17e1f1e413f82efa35860e30113e0cadd42b3514dd3ed"

URI_aarch64_qt6-qttools-libs-designercomponents = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-libs-designercomponents-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qttools-libs-designercomponents;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-libs-designercomponents}"
SRC_URI[aarch64_qt6-qttools-libs-designercomponents.sha256sum] = "de09f64699c56f81e49a268aec5ee7461529227cdd23dd5baa6656434e8cf06a"

URI_aarch64_qt6-qttools-libs-help = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qttools-libs-help-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qttools-libs-help;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-libs-help}"
SRC_URI[aarch64_qt6-qttools-libs-help.sha256sum] = "be275e4a20d9beb3225f339d4b9e37f09a8738ba862b145e79fa69adfe836acb"

URI_aarch64_qt6-qttools-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qttools-static-6.8.1-3.el10.aarch64.rpm;name=aarch64_qt6-qttools-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qttools-static}"
SRC_URI[aarch64_qt6-qttools-static.sha256sum] = "6e59223eb8fbc4e75b9ce686d60f714aa013335843fd42bab3dcd9a679c4e6c9"

RDEPENDS:qt6-assistant = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-designer = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 "
RDEPENDS:qt6-doctools = " \
 clang-libs \
 glibc \
 libstdc++ \
 llvm-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-linguist = " \
 clang-libs \
 glibc \
 libstdc++ \
 llvm-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qdbusviewer = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools-common = " \
 "
RDEPENDS:qt6-qttools-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-designer \
 qt6-doctools \
 qt6-linguist \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qttools \
 qt6-qttools-devel \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-qttools-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools \
 qt6-qttools-common \
 qt6-qttools-libs-help \
 "
RDEPENDS:qt6-qttools-libs-designer = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools-libs-designercomponents = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 qt6-qttools-libs-designer \
 "
RDEPENDS:qt6-qttools-libs-help = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-common \
 "
RDEPENDS:qt6-qttools-static = " \
 qt6-qttools-devel \
 "
