# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rgb"
PV = "0.8.53"
PR = "1.el10_2"
PACKAGES = " \
 rust-rgb+argb-devel \
 rust-rgb+as-bytes-devel \
 rust-rgb+bytemuck-devel \
 rust-rgb+checked_fns-devel \
 rust-rgb+default-devel \
 rust-rgb+grb-devel \
 rust-rgb+serde-devel \
 rust-rgb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rgb-0.8.53-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ad5fe9dd9aa26dbe101e57e2fdfb7e2c85d005966ee835720f00590f9ad3550"

URI_x86_64_v2_rust-rgb+argb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+argb-devel-0.8.53-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+argb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+argb-devel}"
SRC_URI[x86_64_v2_rust-rgb+argb-devel.sha256sum] = "bfec261f2379a22297ecb81764175b4b389252a5575303b3bf88b4499bbd4ce2"

URI_x86_64_v2_rust-rgb+as-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+as-bytes-devel-0.8.53-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+as-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+as-bytes-devel}"
SRC_URI[x86_64_v2_rust-rgb+as-bytes-devel.sha256sum] = "822aba69c8302c84af0e68a7e6d55f50639f6d1c8ec71760c9d47b9a30bf9126"

URI_x86_64_v2_rust-rgb+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+bytemuck-devel-0.8.53-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-rgb+bytemuck-devel.sha256sum] = "221732db859bdd2540ae54682025e50a14cfd3dfabb24fd9b377650f7cf8dcec"

URI_x86_64_v2_rust-rgb+checked_fns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+checked_fns-devel-0.8.53-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+checked_fns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+checked_fns-devel}"
SRC_URI[x86_64_v2_rust-rgb+checked_fns-devel.sha256sum] = "0cdc900311b1e6144ae4d0565cde5a3e6931dcd459a073e78552c09690ba6215"

URI_x86_64_v2_rust-rgb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+default-devel-0.8.53-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+default-devel}"
SRC_URI[x86_64_v2_rust-rgb+default-devel.sha256sum] = "23addf2fee610ca887c6779fd23e09a1849047ffc28535ddca1e004d2175fe25"

URI_x86_64_v2_rust-rgb+grb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+grb-devel-0.8.53-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+grb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+grb-devel}"
SRC_URI[x86_64_v2_rust-rgb+grb-devel.sha256sum] = "c700a20935dcd11bae9842c7a270d650ea852a1de522c1aaac752b6688de4e3c"

URI_x86_64_v2_rust-rgb+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb+serde-devel-0.8.53-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb+serde-devel}"
SRC_URI[x86_64_v2_rust-rgb+serde-devel.sha256sum] = "e9d11bd3b13f36144590b01611dfcb37ca19264ab347da30ff30c411df978d19"

URI_x86_64_v2_rust-rgb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rgb-devel-0.8.53-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rgb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rgb-devel}"
SRC_URI[x86_64_v2_rust-rgb-devel.sha256sum] = "294bd87ed888e07c879f2a00612b3ee9c5f26edf0aefd8d3945bc16f918b27d7"

URI_aarch64_rust-rgb+argb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+argb-devel-0.8.53-1.el10_2.noarch.rpm;name=aarch64_rust-rgb+argb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+argb-devel}"
SRC_URI[aarch64_rust-rgb+argb-devel.sha256sum] = "29d048363267376b7567d43912fa9cebd5a179305925963464d7dee538c9da64"

URI_aarch64_rust-rgb+as-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+as-bytes-devel-0.8.53-1.el10_2.noarch.rpm;name=aarch64_rust-rgb+as-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+as-bytes-devel}"
SRC_URI[aarch64_rust-rgb+as-bytes-devel.sha256sum] = "0b08c6967bf6b1a301daed4279511095338c6b38b4e00fbd550ede413a66edf2"

URI_aarch64_rust-rgb+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+bytemuck-devel-0.8.53-1.el10_2.noarch.rpm;name=aarch64_rust-rgb+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+bytemuck-devel}"
SRC_URI[aarch64_rust-rgb+bytemuck-devel.sha256sum] = "f7bfbc1bddfd44375a6380c8e1325271b032c43173f93d49b3f77ac8ad57f27f"

URI_aarch64_rust-rgb+checked_fns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+checked_fns-devel-0.8.53-1.el10_2.noarch.rpm;name=aarch64_rust-rgb+checked_fns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+checked_fns-devel}"
SRC_URI[aarch64_rust-rgb+checked_fns-devel.sha256sum] = "21cd789e1b8531c934243202edf604c06a911fd8e95bc69de304bb7a77a490b8"

URI_aarch64_rust-rgb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+default-devel-0.8.53-1.el10_2.noarch.rpm;name=aarch64_rust-rgb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+default-devel}"
SRC_URI[aarch64_rust-rgb+default-devel.sha256sum] = "26fe63adb6caefc44884a2dacfed6f9bdc4744843330399d8fb08d3fd76aefd2"

URI_aarch64_rust-rgb+grb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+grb-devel-0.8.53-1.el10_2.noarch.rpm;name=aarch64_rust-rgb+grb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+grb-devel}"
SRC_URI[aarch64_rust-rgb+grb-devel.sha256sum] = "230affadbd5105eaf50d67ef39c536a2dfb406812902713c8ffdd80c6ce92609"

URI_aarch64_rust-rgb+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb+serde-devel-0.8.53-1.el10_2.noarch.rpm;name=aarch64_rust-rgb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb+serde-devel}"
SRC_URI[aarch64_rust-rgb+serde-devel.sha256sum] = "6fb030be128dd798338749738fc5fb6d10e3ace0961ef850bfd522ec508c6749"

URI_aarch64_rust-rgb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rgb-devel-0.8.53-1.el10_2.noarch.rpm;name=aarch64_rust-rgb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rgb-devel}"
SRC_URI[aarch64_rust-rgb-devel.sha256sum] = "a4a67bd8c3dafdee9e298baf490d17374206183de4e8b9d4351ddb9e1803d050"

RDEPENDS:rust-rgb+argb-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+as-bytes-devel = " \
 cargo \
 rust-rgb+bytemuck-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+checked_fns-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+default-devel = " \
 cargo \
 rust-rgb+argb-devel \
 rust-rgb+as-bytes-devel \
 rust-rgb+grb-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+grb-devel = " \
 cargo \
 rust-rgb-devel \
 "
RDEPENDS:rust-rgb+serde-devel = " \
 cargo \
 rust-rgb-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rgb-devel = " \
 cargo \
 rust \
 "
