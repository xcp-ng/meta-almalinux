# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fltk"
PV = "1.3.11"
PR = "1.el10_0"
PACKAGES = " \
 fltk \
 fltk-devel \
 fltk-fluid \
 fltk-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fltk-1.3.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61589a222256678613438363020e28dd0f2c873b6b3d5537c3e69990c0785997"

URI_x86_64_v2_fltk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-1.3.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk}"
SRC_URI[x86_64_v2_fltk.sha256sum] = "650ae714f89e509928441b3aa98b911bfd7d60b7bb3f2f7d6b153ba52a68fb1c"

URI_x86_64_v2_fltk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-devel-1.3.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk-devel}"
SRC_URI[x86_64_v2_fltk-devel.sha256sum] = "d28c634ed0b3c6c0749bbb2334719bd444e37a859a2d24bf05fd3bddbd922b73"

URI_x86_64_v2_fltk-fluid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-fluid-1.3.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk-fluid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk-fluid}"
SRC_URI[x86_64_v2_fltk-fluid.sha256sum] = "d61953106a42fe2b3d631cd1867a6c7e856e2f394a69e1d4a35ea38c2e9e5cab"

URI_x86_64_v2_fltk-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fltk-static-1.3.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fltk-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fltk-static}"
SRC_URI[x86_64_v2_fltk-static.sha256sum] = "0e3247e4aa42e2a259dc0d50b04b65be124a8547efc62d7d12f8f180da0dca3e"

URI_aarch64_fltk = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-1.3.11-1.el10_0.aarch64.rpm;name=aarch64_fltk;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk}"
SRC_URI[aarch64_fltk.sha256sum] = "19c166c634d6ed9c79f84a4308911f277b06ea930cd34f04ae85847067126f66"

URI_aarch64_fltk-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-devel-1.3.11-1.el10_0.aarch64.rpm;name=aarch64_fltk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk-devel}"
SRC_URI[aarch64_fltk-devel.sha256sum] = "28f642b58cd09678eca2d2a26ff28f97574b7003361b6a9672f4ea0e813f57aa"

URI_aarch64_fltk-fluid = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-fluid-1.3.11-1.el10_0.aarch64.rpm;name=aarch64_fltk-fluid;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk-fluid}"
SRC_URI[aarch64_fltk-fluid.sha256sum] = "0003eb6129d18df9e204caf3e28a073dd360a4c608afba646b192bc5c9f6983b"

URI_aarch64_fltk-static = "${EPEL_MIRROR}/aarch64/Packages/f/fltk-static-1.3.11-1.el10_0.aarch64.rpm;name=aarch64_fltk-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_fltk-static}"
SRC_URI[aarch64_fltk-static.sha256sum] = "38e97c0a584e1cb7e9657bb15c159f3db30ecaf6b46a420cdb7c0975b5c94beb"

RDEPENDS:fltk = " \
 fontconfig \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXft \
 libXinerama \
 libXrender \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 "
RDEPENDS:fltk-devel = " \
 bash \
 cmake-filesystem \
 fltk \
 fontconfig-devel \
 libICE-devel \
 libSM-devel \
 libX11-devel \
 libXft-devel \
 libXt-devel \
 libglvnd-devel \
 libjpeg-turbo-devel \
 libpng-devel \
 libstdc++-devel \
 mesa-libGLU-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:fltk-fluid = " \
 fltk \
 fltk-devel \
 fontconfig \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXft \
 libXinerama \
 libXrender \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 "
RDEPENDS:fltk-static = " \
 fltk-devel \
 "
