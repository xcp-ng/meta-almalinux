# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive-new"
PV = "0.6.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-derive-new+default-devel \
 rust-derive-new+std-devel \
 rust-derive-new-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive-new-0.6.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b23d9ba7c92a3ae8d7156c1cedec56405e7e91979d259c7349a0094877279bae"

URI_x86_64_v2_rust-derive-new+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-new+default-devel-0.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-new+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-new+default-devel}"
SRC_URI[x86_64_v2_rust-derive-new+default-devel.sha256sum] = "2312e1f58d7535e13dc9f8f98a4ba172058c0c139e689f6dd32ad5abbb2f3648"

URI_x86_64_v2_rust-derive-new+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-new+std-devel-0.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-new+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-new+std-devel}"
SRC_URI[x86_64_v2_rust-derive-new+std-devel.sha256sum] = "d2fd35a6de8e6f193a30ffaece6e4c71376ef301c137946395dacc3133e85438"

URI_x86_64_v2_rust-derive-new-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-new-devel-0.6.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-new-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-new-devel}"
SRC_URI[x86_64_v2_rust-derive-new-devel.sha256sum] = "6bcc7d83ec92190f9853855b3ac962908928e3a7260bf55ad3100c01a9d97e33"

URI_aarch64_rust-derive-new+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-new+default-devel-0.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-new+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-new+default-devel}"
SRC_URI[aarch64_rust-derive-new+default-devel.sha256sum] = "3cfdbbaf4b77d5763d3378bf448e525945f4c0f65ecf54e4124396d8c86ecac6"

URI_aarch64_rust-derive-new+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-new+std-devel-0.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-new+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-new+std-devel}"
SRC_URI[aarch64_rust-derive-new+std-devel.sha256sum] = "46602bbb533cd7893f028ed90e74b9073a6171eac41a2b80d4cad54c6568f569"

URI_aarch64_rust-derive-new-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-new-devel-0.6.0-1.el10_0.noarch.rpm;name=aarch64_rust-derive-new-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-new-devel}"
SRC_URI[aarch64_rust-derive-new-devel.sha256sum] = "00342a72377bc6a2f2cfce29353847e6cf2d2e6775ab7fe04a7bc72323740de1"

RDEPENDS:rust-derive-new+default-devel = " \
 cargo \
 rust-derive-new+std-devel \
 rust-derive-new-devel \
 "
RDEPENDS:rust-derive-new+std-devel = " \
 cargo \
 rust-derive-new-devel \
 "
RDEPENDS:rust-derive-new-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
