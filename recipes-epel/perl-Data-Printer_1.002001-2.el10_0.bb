# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Printer"
PV = "1.002001"
PR = "2.el10_0"
PACKAGES = " \
 perl-Data-Printer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Printer-1.002001-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edeb1219c57c355f276a182f4df31f45c7e7bdc9248be1ebf86b764e5eb56148"

URI_x86_64_v2_perl-Data-Printer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Printer-1.002001-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Printer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Printer}"
SRC_URI[x86_64_v2_perl-Data-Printer.sha256sum] = "888ab3409feaa292023530f367226936802189fa7b2ae150c51e6c1e9fe35c7b"

URI_aarch64_perl-Data-Printer = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Printer-1.002001-2.el10_0.noarch.rpm;name=aarch64_perl-Data-Printer;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Printer}"
SRC_URI[aarch64_perl-Data-Printer.sha256sum] = "61378bd80df46c7baeff97c6c3db9e9ac80b3c0f091625b047c73861e92c9e36"

RDEPENDS:perl-Data-Printer = " \
 perl-B \
 perl-Data-Printer \
 perl-Fcntl \
 perl-File-HomeDir \
 perl-Hash-Util-FieldHash \
 perl-Package-Stash \
 perl-Scalar-List-Utils \
 perl-Term-ANSIColor \
 perl-constant \
 perl-libs \
 perl-mro \
 perl-version \
 "
