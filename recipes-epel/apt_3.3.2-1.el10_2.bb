# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apt"
PV = "3.3.2"
PR = "1.el10_2"
PACKAGES = " \
 apt \
 apt-apidoc \
 apt-devel \
 apt-doc \
 apt-libs \
 apt-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apt-3.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f83a86e51d67dcd914c45919134289fa5aa661b3ce70c16a7337b2c4852efa4"

URI_x86_64_v2_apt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-3.3.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt}"
SRC_URI[x86_64_v2_apt.sha256sum] = "72351ae8255825ef94062df0929ab8f8aecd6bf5693e177d073607471ea6699d"

URI_x86_64_v2_apt-apidoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-apidoc-3.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_apt-apidoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-apidoc}"
SRC_URI[x86_64_v2_apt-apidoc.sha256sum] = "7b860a0b2256ee47b18956fa8e318f279530deea010775dc74f223cc9bdb9a91"

URI_x86_64_v2_apt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-devel-3.3.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-devel}"
SRC_URI[x86_64_v2_apt-devel.sha256sum] = "22367ca39cd06a210403d474ba1dc3ac59ae646e42f9c956e2d916369eff63c6"

URI_x86_64_v2_apt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-doc-3.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_apt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-doc}"
SRC_URI[x86_64_v2_apt-doc.sha256sum] = "69cba5e7e16af307505957b7255769ddd1bc31d102d5ce6b4e8d5e4967589161"

URI_x86_64_v2_apt-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-libs-3.3.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-libs}"
SRC_URI[x86_64_v2_apt-libs.sha256sum] = "f356b876aefc264d4c1964ccf44fc38d7486a42859a89427185198670a74667e"

URI_x86_64_v2_apt-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apt-utils-3.3.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apt-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apt-utils}"
SRC_URI[x86_64_v2_apt-utils.sha256sum] = "9532f4d2d351226fe8238e1a3c1c4ad5ade7cd33e40616399f1fff82d2d39216"

URI_aarch64_apt = "${EPEL_MIRROR}/aarch64/Packages/a/apt-3.3.2-1.el10_2.aarch64.rpm;name=aarch64_apt;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt}"
SRC_URI[aarch64_apt.sha256sum] = "094188657fce0f9023e6ee95a3651a2dcb32beab48a9c9eaa6f68792ec8e21c0"

URI_aarch64_apt-apidoc = "${EPEL_MIRROR}/aarch64/Packages/a/apt-apidoc-3.3.2-1.el10_2.noarch.rpm;name=aarch64_apt-apidoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-apidoc}"
SRC_URI[aarch64_apt-apidoc.sha256sum] = "a1c543bf74c07ad14d1d01feceb8fae994a80055a2a2f7de278f263c92095ec8"

URI_aarch64_apt-devel = "${EPEL_MIRROR}/aarch64/Packages/a/apt-devel-3.3.2-1.el10_2.aarch64.rpm;name=aarch64_apt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-devel}"
SRC_URI[aarch64_apt-devel.sha256sum] = "3f42a4f1ddb2c02211bbd6fd5ba2d0c809f9770e06b95cc695c1e044c6d63c07"

URI_aarch64_apt-doc = "${EPEL_MIRROR}/aarch64/Packages/a/apt-doc-3.3.2-1.el10_2.noarch.rpm;name=aarch64_apt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-doc}"
SRC_URI[aarch64_apt-doc.sha256sum] = "5d2ae66c43ac2f6af46f8d5eea3a069ac259ed7747eec63003af1f2c3cf2ee9d"

URI_aarch64_apt-libs = "${EPEL_MIRROR}/aarch64/Packages/a/apt-libs-3.3.2-1.el10_2.aarch64.rpm;name=aarch64_apt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-libs}"
SRC_URI[aarch64_apt-libs.sha256sum] = "a1cdd8527acdb9e01c8a6ea8e72c6098860c93ffc733dff1a6f87c3d59223179"

URI_aarch64_apt-utils = "${EPEL_MIRROR}/aarch64/Packages/a/apt-utils-3.3.2-1.el10_2.aarch64.rpm;name=aarch64_apt-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_apt-utils}"
SRC_URI[aarch64_apt-utils.sha256sum] = "3d284603a250c9f0abf0f5019b9739a8a46fe872e3dcf011814461a6008cf8dd"

RDEPENDS:apt = " \
 apt-libs \
 bash \
 dpkg \
 glibc \
 libgcc \
 libseccomp \
 libstdc++ \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:apt-apidoc = " \
 "
RDEPENDS:apt-devel = " \
 apt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:apt-doc = " \
 "
RDEPENDS:apt-libs = " \
 bzip2-libs \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 openssl-libs \
 systemd-libs \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apt-utils = " \
 apt \
 apt-libs \
 glibc \
 libdb \
 libgcc \
 libstdc++ \
 "
