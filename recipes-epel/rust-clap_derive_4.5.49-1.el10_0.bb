# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_derive"
PV = "4.5.49"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive+raw-deprecated-devel \
 rust-clap_derive+unstable-markdown-devel \
 rust-clap_derive+unstable-v5-devel \
 rust-clap_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_derive-4.5.49-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86460da342974474f1a2a676cadd33792462e9d35f7ab30d62740eb5f4f72fef"

URI_x86_64_v2_rust-clap_derive+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+debug-devel-4.5.49-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+debug-devel.sha256sum] = "9cd201953cfe6d1bf0485eb7e317d1c5c71d6a4bb3b5972d75629dddf5d7efc4"

URI_x86_64_v2_rust-clap_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+default-devel-4.5.49-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+default-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+default-devel.sha256sum] = "ff501472a484ad53339efc525d50af8219bf98f15d6874ef857cebdbdcb83872"

URI_x86_64_v2_rust-clap_derive+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+deprecated-devel-4.5.49-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+deprecated-devel.sha256sum] = "f8085087eb005955f89ae264dfac6ecfcbd720c0dac022ab01d9313ab56efb32"

URI_x86_64_v2_rust-clap_derive+raw-deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+raw-deprecated-devel-4.5.49-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+raw-deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+raw-deprecated-devel.sha256sum] = "99a2d5d506855c5726d1d5b96af249c4e95158f6541d2417f069fdcfa6bb3b86"

URI_x86_64_v2_rust-clap_derive+unstable-markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-markdown-devel-4.5.49-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+unstable-markdown-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-markdown-devel.sha256sum] = "bce979a8f36d2755cee459f314389e7b62d70a0f42769e4f2a442b5be0b69813"

URI_x86_64_v2_rust-clap_derive+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive+unstable-v5-devel-4.5.49-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap_derive+unstable-v5-devel.sha256sum] = "320957bab42cbdc9ca0828aefd4bafa1257836ed59fe107aef99af8ee66a4401"

URI_x86_64_v2_rust-clap_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_derive-devel-4.5.49-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_derive-devel}"
SRC_URI[x86_64_v2_rust-clap_derive-devel.sha256sum] = "f634eca05e5c4da2bc8430e8acd06ee7f229b97f4f5ecb265e7bd3d320605653"

URI_aarch64_rust-clap_derive+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+debug-devel-4.5.49-1.el10_0.noarch.rpm;name=aarch64_rust-clap_derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+debug-devel}"
SRC_URI[aarch64_rust-clap_derive+debug-devel.sha256sum] = "7b2128fb11fd19c99ebd8ef7ce3f2d40171da58a9990b7dda8315c1bb58ad049"

URI_aarch64_rust-clap_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+default-devel-4.5.49-1.el10_0.noarch.rpm;name=aarch64_rust-clap_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+default-devel}"
SRC_URI[aarch64_rust-clap_derive+default-devel.sha256sum] = "187687daeaa67c766cf2acb293a3c102fdabb83fb2ce71863ded15d717bc4dc1"

URI_aarch64_rust-clap_derive+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+deprecated-devel-4.5.49-1.el10_0.noarch.rpm;name=aarch64_rust-clap_derive+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+deprecated-devel}"
SRC_URI[aarch64_rust-clap_derive+deprecated-devel.sha256sum] = "666cf0610702b1d8f3f300ed8e0beb91aeaaec3c861fb5d63c608fab8f79e5c2"

URI_aarch64_rust-clap_derive+raw-deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+raw-deprecated-devel-4.5.49-1.el10_0.noarch.rpm;name=aarch64_rust-clap_derive+raw-deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+raw-deprecated-devel}"
SRC_URI[aarch64_rust-clap_derive+raw-deprecated-devel.sha256sum] = "b3a1ff235c5b6b98714c39eb829a521f9796d25f316f8b534b4279085155a601"

URI_aarch64_rust-clap_derive+unstable-markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-markdown-devel-4.5.49-1.el10_0.noarch.rpm;name=aarch64_rust-clap_derive+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+unstable-markdown-devel}"
SRC_URI[aarch64_rust-clap_derive+unstable-markdown-devel.sha256sum] = "5e44e5bbe5435325b162f0978e56a477610390640f47bfbea593ed70b0fff4ab"

URI_aarch64_rust-clap_derive+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive+unstable-v5-devel-4.5.49-1.el10_0.noarch.rpm;name=aarch64_rust-clap_derive+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap_derive+unstable-v5-devel.sha256sum] = "417240d7f57dc3442932726a85203e103e9cef5e0e6e63987d9e6073274a0039"

URI_aarch64_rust-clap_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_derive-devel-4.5.49-1.el10_0.noarch.rpm;name=aarch64_rust-clap_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_derive-devel}"
SRC_URI[aarch64_rust-clap_derive-devel.sha256sum] = "858dd51c9fa37ee985482b70c08fafc70aefac862d0ae0da9d7fa49fec51a1a7"

RDEPENDS:rust-clap_derive+debug-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+default-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+deprecated-devel = " \
 cargo \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+raw-deprecated-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive+unstable-markdown-devel = " \
 cargo \
 rust-anstyle+default-devel \
 rust-clap_derive-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-clap_derive+unstable-v5-devel = " \
 cargo \
 rust-clap_derive+deprecated-devel \
 rust-clap_derive-devel \
 "
RDEPENDS:rust-clap_derive-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
