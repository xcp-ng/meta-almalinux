# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgdiplus"
PV = "6.2"
PR = "2.el10_2"
PACKAGES = " \
 libgdiplus \
 libgdiplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgdiplus-6.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cf047c07066ec94a32398bc615b753ee7e6cb4599c8b2d6b49dfee45ea294f2"

URI_x86_64_v2_libgdiplus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgdiplus-6.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgdiplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgdiplus}"
SRC_URI[x86_64_v2_libgdiplus.sha256sum] = "5a6cc87a45e9dfe2c0441816ec8c9b314c71504e0a5b00e4ec05f77c3244cc5c"

URI_x86_64_v2_libgdiplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgdiplus-devel-6.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgdiplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgdiplus-devel}"
SRC_URI[x86_64_v2_libgdiplus-devel.sha256sum] = "ef98e95f27d62fc9242cb7496f9adf5a2dadf21a54dc32df2945abed844f7e81"

URI_aarch64_libgdiplus = "${EPEL_MIRROR}/aarch64/Packages/l/libgdiplus-6.2-2.el10_2.aarch64.rpm;name=aarch64_libgdiplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgdiplus}"
SRC_URI[aarch64_libgdiplus.sha256sum] = "4699003fe6dbb60503170aa0f1f28621cb0e7c822ef157f46d9f0f19cc93ebe3"

URI_aarch64_libgdiplus-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgdiplus-devel-6.2-2.el10_2.aarch64.rpm;name=aarch64_libgdiplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgdiplus-devel}"
SRC_URI[aarch64_libgdiplus-devel.sha256sum] = "827a42671513c3f6a1e7059739bb6f2b2bfe756364b0a2f45dc585d3261c8921"

RDEPENDS:libgdiplus = " \
 cairo \
 fontconfig \
 freetype \
 giflib \
 glib2 \
 glibc \
 harfbuzz \
 libX11 \
 libexif \
 libjpeg-turbo \
 libpng \
 libtiff \
 pango \
 "
RDEPENDS:libgdiplus-devel = " \
 glib2-devel \
 libgdiplus \
 pkgconf-pkg-config \
 "
