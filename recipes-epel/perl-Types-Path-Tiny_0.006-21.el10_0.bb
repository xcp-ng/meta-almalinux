# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Types-Path-Tiny"
PV = "0.006"
PR = "21.el10_0"
PACKAGES = " \
 perl-Types-Path-Tiny \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Types-Path-Tiny-0.006-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "209c323043a17e7a0c219d7661d2f18146350ce3658905ad2a98bae8a555720e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Types-Path-Tiny-0.006-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Types-Path-Tiny;unpack=0"
SRC_URI[x86_64_v2_perl-Types-Path-Tiny.sha256sum] = "794a7ff44c46135641ea0b6e356afffa4f47a76bec2187eefd2acb2ad162d6ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Types-Path-Tiny-0.006-21.el10_0.noarch.rpm;name=aarch64_perl-Types-Path-Tiny;unpack=0"
SRC_URI[aarch64_perl-Types-Path-Tiny.sha256sum] = "597e509dd4ed56eb77a959e23343955b2d41a027156f8682a58cf3dcb7ce65a9"

RDEPENDS:perl-Types-Path-Tiny = " \
 perl-Path-Tiny \
 perl-Type-Tiny \
 perl-libs \
 "
