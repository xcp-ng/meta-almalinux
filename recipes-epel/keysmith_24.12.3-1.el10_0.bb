# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keysmith"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 keysmith \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keysmith-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49e98d07ad9ed406177ac30ac7c7122b6a0b9f4cacd01eaeedd60e1c1ef5724f"

URI_x86_64_v2_keysmith = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keysmith-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keysmith;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keysmith}"
SRC_URI[x86_64_v2_keysmith.sha256sum] = "37276f304f370b2f37e672b4609ce5597ba5a0fb6315bd28348c9f8a5aaeae8f"

URI_aarch64_keysmith = "${EPEL_MIRROR}/aarch64/Packages/k/keysmith-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_keysmith;unpack=0"
SRC_URI:append = " ${URI_aarch64_keysmith}"
SRC_URI[aarch64_keysmith.sha256sum] = "10ba04f7f0e52db91028fc7e46fa6bb1b5bb072ae388ba3e01e23e137bd0c5e4"

RDEPENDS:keysmith = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kwindowsystem \
 kf6-qqc2-desktop-style \
 libsodium \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
