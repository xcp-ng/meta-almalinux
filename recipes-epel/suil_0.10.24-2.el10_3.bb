# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "suil"
PV = "0.10.24"
PR = "2.el10_3"
PACKAGES = " \
 suil \
 suil-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/suil-0.10.24-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d32c46389aa719345e0b2edc6b1f85abebc83e6c9d61a77c68791717e90ce4f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suil-0.10.24-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suil;unpack=0"
SRC_URI[x86_64_v2_suil.sha256sum] = "e7cc28993a2d793869ba88234034d73f39352fe25b97a4ffde3ae0ef71d3242f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suil-devel-0.10.24-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suil-devel;unpack=0"
SRC_URI[x86_64_v2_suil-devel.sha256sum] = "a4ffbff61b48155d8b178983a7dcaa4e156cf11df8ac541d3352bfa83f4fa004"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suil-0.10.24-2.el10_3.aarch64.rpm;name=aarch64_suil;unpack=0"
SRC_URI[aarch64_suil.sha256sum] = "1c264d1a8dc6ddfebf6f915378ab51c4fb9512765125d4c3225fb1062a558ffd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/suil-devel-0.10.24-2.el10_3.aarch64.rpm;name=aarch64_suil-devel;unpack=0"
SRC_URI[aarch64_suil-devel.sha256sum] = "39f32b677a4a81861357b6c226d6dae4ba61b557a73f6afbc031c760574c9e6a"

RDEPENDS:suil = " \
 glibc \
 "
RDEPENDS:suil-devel = " \
 lv2-devel \
 pkgconf-pkg-config \
 suil \
 "
