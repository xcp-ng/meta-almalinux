# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qstat"
PV = "2.17"
PR = "13.el10_0"
PACKAGES = " \
 qstat \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qstat-2.17-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f05f75aa5381fd1f4a7268a93fa20892fabab75431b4bf806681e57ef4a6e1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qstat-2.17-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qstat;unpack=0"
SRC_URI[x86_64_v2_qstat.sha256sum] = "42b8571deebb493ada0613bd76d3dfdb82cf5197bc19f100524b2a1ad68bc728"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qstat-2.17-13.el10_0.aarch64.rpm;name=aarch64_qstat;unpack=0"
SRC_URI[aarch64_qstat.sha256sum] = "ca6c3ab5b3aa944e6c26e20da60d809a631846dc729c377c518ce6a5a2b7ce12"

RDEPENDS:qstat = " \
 glibc \
 "
