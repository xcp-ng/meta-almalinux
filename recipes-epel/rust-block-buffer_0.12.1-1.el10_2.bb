# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-block-buffer"
PV = "0.12.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-block-buffer+default-devel \
 rust-block-buffer+zeroize-devel \
 rust-block-buffer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-block-buffer-0.12.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02c9834d9ab70b1629c4705e7be5a87038d68bfd7eeee0301c8725750b791a1b"

URI_x86_64_v2_rust-block-buffer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer+default-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer+default-devel}"
SRC_URI[x86_64_v2_rust-block-buffer+default-devel.sha256sum] = "c26bf5f1a00f649f0c186dc2e1d88844ca0cf70086fb64573ed6ce687fee814c"

URI_x86_64_v2_rust-block-buffer+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer+zeroize-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer+zeroize-devel}"
SRC_URI[x86_64_v2_rust-block-buffer+zeroize-devel.sha256sum] = "1bb65a96f2cb7f81e3625594591b182bd09044a4bf00d351d5ebf50a97847d5b"

URI_x86_64_v2_rust-block-buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer-devel-0.12.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer-devel}"
SRC_URI[x86_64_v2_rust-block-buffer-devel.sha256sum] = "69f24fc56c42feaa1e7ac94b05a0db5a3b4655157e88851225b9e5bb9a144e37"

URI_aarch64_rust-block-buffer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer+default-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-block-buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer+default-devel}"
SRC_URI[aarch64_rust-block-buffer+default-devel.sha256sum] = "14be6c6d0a805bded8df94c34d640eaf58819887904dd44cb7e3dee5c74d7aca"

URI_aarch64_rust-block-buffer+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer+zeroize-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-block-buffer+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer+zeroize-devel}"
SRC_URI[aarch64_rust-block-buffer+zeroize-devel.sha256sum] = "1184efeaad74dfc5e0591d99c0e65a5da07f986d13eefcf6470d402c1e3e6177"

URI_aarch64_rust-block-buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer-devel-0.12.1-1.el10_2.noarch.rpm;name=aarch64_rust-block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer-devel}"
SRC_URI[aarch64_rust-block-buffer-devel.sha256sum] = "1a92748c0fc445460118e72e05871684bc256a0e64f122575e0a2910b4d684f1"

RDEPENDS:rust-block-buffer+default-devel = " \
 cargo \
 rust-block-buffer-devel \
 "
RDEPENDS:rust-block-buffer+zeroize-devel = " \
 cargo \
 rust-block-buffer-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-block-buffer-devel = " \
 cargo \
 rust \
 rust-hybrid-array+default-devel \
 "
