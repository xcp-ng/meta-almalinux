# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-refact"
PV = "0.3.0.2"
PR = "29.el10_0"
PACKAGES = " \
 ghc-refact \
 ghc-refact-devel \
 ghc-refact-doc \
 ghc-refact-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-refact-0.3.0.2-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb763cd4e13d3d39956995d9dc8f419f7e6af662ae6a3c8300aa544266912959"

URI_x86_64_v2_ghc-refact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-refact-0.3.0.2-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-refact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-refact}"
SRC_URI[x86_64_v2_ghc-refact.sha256sum] = "d7b574f73c79a71f738c46f16591f926774a2dc13d3f9e63a00019546ee0518b"

URI_x86_64_v2_ghc-refact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-refact-devel-0.3.0.2-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-refact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-refact-devel}"
SRC_URI[x86_64_v2_ghc-refact-devel.sha256sum] = "3ee2ee05602fd31ee5879e84d543d89c0702c1132400bfec3be0f7378717d36c"

URI_x86_64_v2_ghc-refact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-refact-doc-0.3.0.2-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-refact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-refact-doc}"
SRC_URI[x86_64_v2_ghc-refact-doc.sha256sum] = "3c2b85466b015dde4abd071019b7d1a45a1c52db91e3eecd0233da5bb6d2b4a1"

URI_x86_64_v2_ghc-refact-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-refact-prof-0.3.0.2-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-refact-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-refact-prof}"
SRC_URI[x86_64_v2_ghc-refact-prof.sha256sum] = "bd8ff3e74135d016c452c871690f6534a2a31afc4fb51d09892e7410d93458ca"

URI_aarch64_ghc-refact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-refact-0.3.0.2-29.el10_0.aarch64.rpm;name=aarch64_ghc-refact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-refact}"
SRC_URI[aarch64_ghc-refact.sha256sum] = "f89f4a1ba5e38ddd1cb8f3f5ceb167e195b44ee74426953c454c7b6f9ac0b869"

URI_aarch64_ghc-refact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-refact-devel-0.3.0.2-29.el10_0.aarch64.rpm;name=aarch64_ghc-refact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-refact-devel}"
SRC_URI[aarch64_ghc-refact-devel.sha256sum] = "1d7142de315803dd9c03d7ee8384618e5a49cf9d40f214b1cc68ddb30ed71780"

URI_aarch64_ghc-refact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-refact-doc-0.3.0.2-29.el10_0.noarch.rpm;name=aarch64_ghc-refact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-refact-doc}"
SRC_URI[aarch64_ghc-refact-doc.sha256sum] = "2ebbdafcf41945695d5aa997fa2bb24c93fcc57d408ca3db82596e0713321b20"

URI_aarch64_ghc-refact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-refact-prof-0.3.0.2-29.el10_0.aarch64.rpm;name=aarch64_ghc-refact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-refact-prof}"
SRC_URI[aarch64_ghc-refact-prof.sha256sum] = "4b9f69d4b1557b0d80994b9a7209913bbd891e86582eff2aea444b1e94159890"

RDEPENDS:ghc-refact = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-refact-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-refact \
 "
RDEPENDS:ghc-refact-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-refact-prof = " \
 ghc-base-prof \
 ghc-refact-devel \
 "
