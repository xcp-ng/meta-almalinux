# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-process_executer"
PV = "4.0.2"
PR = "1.el10_2"
PACKAGES = " \
 rubygem-process_executer \
 rubygem-process_executer-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-process_executer-4.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "591339254ddaa9db83492626b411f2b4d85d813219e9dccba5c5db2775632c14"

URI_x86_64_v2_rubygem-process_executer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-process_executer-4.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-process_executer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-process_executer}"
SRC_URI[x86_64_v2_rubygem-process_executer.sha256sum] = "72431a98a0047ef5adbe4aae36da70481cc1331c7806fc57bbd59496f883fdd4"

URI_x86_64_v2_rubygem-process_executer-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-process_executer-doc-4.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-process_executer-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-process_executer-doc}"
SRC_URI[x86_64_v2_rubygem-process_executer-doc.sha256sum] = "67c40d859740af5daf488a7efe44989876e20b66baa50e3f0cb62a052300f632"

URI_aarch64_rubygem-process_executer = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-process_executer-4.0.2-1.el10_2.noarch.rpm;name=aarch64_rubygem-process_executer;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-process_executer}"
SRC_URI[aarch64_rubygem-process_executer.sha256sum] = "fe3037730bd28d0c255bad2466fad48b43255cb5d861b557036ecbec74eee226"

URI_aarch64_rubygem-process_executer-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-process_executer-doc-4.0.2-1.el10_2.noarch.rpm;name=aarch64_rubygem-process_executer-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-process_executer-doc}"
SRC_URI[aarch64_rubygem-process_executer-doc.sha256sum] = "74baca3c695e556744fa43e8699108af4af3bc670247134c0a8a570f06884860"

RDEPENDS:rubygem-process_executer = " \
 rubygem-track_open_instances \
 rubygems \
 "
RDEPENDS:rubygem-process_executer-doc = " \
 rubygem-process_executer \
 "
