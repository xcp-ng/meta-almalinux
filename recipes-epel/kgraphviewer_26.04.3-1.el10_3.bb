# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgraphviewer"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kgraphviewer \
 kgraphviewer-devel \
 kgraphviewer-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgraphviewer-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "677a773f08aa24386ec314c139f3f1932df277b9f0ad775c0ef80d08b020e201"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - kgraphviewer-libs: libcgraph.so.6()(64bit)
# - kgraphviewer-libs: libgvc.so.6()(64bit)
# - kgraphviewer: graphviz

URI_x86_64_v2_kgraphviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgraphviewer}"
SRC_URI[x86_64_v2_kgraphviewer.sha256sum] = "92c674d18a269ace4499d0dca031446af54fb54fdd945b4e9e7298d536116faa"

URI_x86_64_v2_kgraphviewer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgraphviewer-devel}"
SRC_URI[x86_64_v2_kgraphviewer-devel.sha256sum] = "df957eca63a1a363621a64b27b991c16a1b67cdfc35a65dde43ae4522619afac"

URI_x86_64_v2_kgraphviewer-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgraphviewer-libs}"
SRC_URI[x86_64_v2_kgraphviewer-libs.sha256sum] = "6524ef992c4364252010f629a474723885f7c4565aedf2851735661e11bd2874"

URI_aarch64_kgraphviewer = "${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kgraphviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgraphviewer}"
SRC_URI[aarch64_kgraphviewer.sha256sum] = "d628e0e3cff0fdad59f2206ad72e74e6ceced730e9daa236147343829291dece"

URI_aarch64_kgraphviewer-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kgraphviewer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgraphviewer-devel}"
SRC_URI[aarch64_kgraphviewer-devel.sha256sum] = "e9b4c50a184eef7cee4e32bcd06654786cfb84f8121600d2501c2fbc566dd9d8"

URI_aarch64_kgraphviewer-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kgraphviewer-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgraphviewer-libs}"
SRC_URI[aarch64_kgraphviewer-libs.sha256sum] = "348d7950d7a31693da18e9d863d03282473f575993bcf15c48b2ceeb842378d8"

RDEPENDS:kgraphviewer:x86_64_v2 = " \
 glibc \
 graphviz \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kgraphviewer-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
"
RDEPENDS:kgraphviewer:aarch64 = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kgraphviewer-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
"
RDEPENDS:kgraphviewer-devel = " \
 cmake \
 cmake-filesystem \
 kgraphviewer-libs \
 "
RDEPENDS:kgraphviewer-libs:x86_64_v2 = " \
 glibc \
 graphviz \
 kde-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
RDEPENDS:kgraphviewer-libs:aarch64 = " \
 glibc \
 kde-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
