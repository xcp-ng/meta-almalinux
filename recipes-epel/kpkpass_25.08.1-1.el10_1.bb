# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpkpass"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kpkpass \
 kpkpass-devel \
 kpkpass-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpkpass-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87af2bf89fd9fa00b6e8b623f9c54a76bb3ea828c4d392b65f9c420fd072c940"

URI_x86_64_v2_kpkpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass}"
SRC_URI[x86_64_v2_kpkpass.sha256sum] = "7d130e9ed98c0595e490b3c86e722e8e00c01a0abc9f16ad670bcdc0ba17fe00"

URI_x86_64_v2_kpkpass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass-devel}"
SRC_URI[x86_64_v2_kpkpass-devel.sha256sum] = "cdc87f7336ad9d2f110e3dacb9781cdcdee122eca4427720b4c8fb6bf0bcd7d5"

URI_x86_64_v2_kpkpass-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kpkpass-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpkpass-doc}"
SRC_URI[x86_64_v2_kpkpass-doc.sha256sum] = "f41ffd0359b6b6622dc33ad857b9a78a538b7bb4e2b1540794405376c4e5353e"

URI_aarch64_kpkpass = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kpkpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass}"
SRC_URI[aarch64_kpkpass.sha256sum] = "4a9ccf93bc7ed0ad7fa4654c2c21c581ec6698a4c696d9c02b17fc2b950883a0"

URI_aarch64_kpkpass-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kpkpass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass-devel}"
SRC_URI[aarch64_kpkpass-devel.sha256sum] = "b5196cbced95cb220c1e288242b1767b90a6f398521088f693d7634e172469b2"

URI_aarch64_kpkpass-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kpkpass-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpkpass-doc}"
SRC_URI[aarch64_kpkpass-doc.sha256sum] = "7bad7bbdb30971459ff1de20f3350824e6da3885d3d794f0830db095cf6a336b"

RDEPENDS:kpkpass = " \
 glibc \
 kf6-karchive \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpkpass-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 kpkpass \
 "
RDEPENDS:kpkpass-doc = " \
 "
