# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXScrnSaver"
PV = "1.2.4"
PR = "1.el10_1"
PACKAGES = " \
 libXScrnSaver \
 libXScrnSaver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libXScrnSaver-1.2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c02c1f967578efcfa56365b02c844e04bd569eeac3d8497b50a08f60b59b994b"

URI_x86_64_v2_libXScrnSaver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXScrnSaver-1.2.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXScrnSaver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXScrnSaver}"
SRC_URI[x86_64_v2_libXScrnSaver.sha256sum] = "5a734b966d99e0bedeccd26efc3b296d4880201e143b2ce6f2c4142e2be91c42"

URI_x86_64_v2_libXScrnSaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXScrnSaver-devel-1.2.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXScrnSaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXScrnSaver-devel}"
SRC_URI[x86_64_v2_libXScrnSaver-devel.sha256sum] = "0096c8c812d3fa05062aa66be917ca2ffb506181a781d8a7aa1510e8e0872f48"

URI_aarch64_libXScrnSaver = "${EPEL_MIRROR}/aarch64/Packages/l/libXScrnSaver-1.2.4-1.el10_1.aarch64.rpm;name=aarch64_libXScrnSaver;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXScrnSaver}"
SRC_URI[aarch64_libXScrnSaver.sha256sum] = "202b6e333ff8c3a341c08bdf92195b68665c54bbdeaa5034c6d1127dec50534e"

URI_aarch64_libXScrnSaver-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXScrnSaver-devel-1.2.4-1.el10_1.aarch64.rpm;name=aarch64_libXScrnSaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXScrnSaver-devel}"
SRC_URI[aarch64_libXScrnSaver-devel.sha256sum] = "64676a7cc4e882c557b412bff1a4ae158e07770e0deca991945eaef83ebeb7a8"

RDEPENDS:libXScrnSaver = " \
 glibc \
 libX11 \
 libXext \
 "
RDEPENDS:libXScrnSaver-devel = " \
 libX11-devel \
 libXScrnSaver \
 libXext-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
