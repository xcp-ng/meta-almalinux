# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-idna"
PV = "3.7"
PR = "6.el10_2"
PACKAGES = " \
 python3-idna \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-idna-3.7-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "843fad9d7907e35174b7fb5a9f66433140180a63b2fbeac34a879b5ca1d8caae"

URI_x86_64_v2_python3-idna = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-idna-3.7-6.el10_2.noarch.rpm;name=x86_64_v2_python3-idna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-idna}"
SRC_URI[x86_64_v2_python3-idna.sha256sum] = "f19d8229b047cbda17f4e61fba52cf30be1bff6378bc22f58adcbb497584f8a9"

URI_aarch64_python3-idna = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-idna-3.7-6.el10_2.noarch.rpm;name=aarch64_python3-idna;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-idna}"
SRC_URI[aarch64_python3-idna.sha256sum] = "f19d8229b047cbda17f4e61fba52cf30be1bff6378bc22f58adcbb497584f8a9"

RDEPENDS:python3-idna = " \
 python3 \
 "
