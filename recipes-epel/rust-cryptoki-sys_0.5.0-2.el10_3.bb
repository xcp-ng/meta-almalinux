# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cryptoki-sys"
PV = "0.5.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-cryptoki-sys+bindgen-devel \
 rust-cryptoki-sys+default-devel \
 rust-cryptoki-sys+generate-bindings-devel \
 rust-cryptoki-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cryptoki-sys-0.5.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc1f0256aebb4d6218304664e0d7e29fc3402c08991a993d3e9abe5acfd50490"

URI_x86_64_v2_rust-cryptoki-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-sys+bindgen-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-cryptoki-sys+bindgen-devel.sha256sum] = "5cb44f3a46d7accaa839ad0a764cdb2632505e9f4b9a90b740c8ccc9812c2381"

URI_x86_64_v2_rust-cryptoki-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-sys+default-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki-sys+default-devel}"
SRC_URI[x86_64_v2_rust-cryptoki-sys+default-devel.sha256sum] = "c78095bde75816a447bb6857eb1dabd973c9c2283f631209dcd587ea8654ff62"

URI_x86_64_v2_rust-cryptoki-sys+generate-bindings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-sys+generate-bindings-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-sys+generate-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki-sys+generate-bindings-devel}"
SRC_URI[x86_64_v2_rust-cryptoki-sys+generate-bindings-devel.sha256sum] = "ef7d2867bbea5cde00e354e07067ea29c477b9a8caeb50fcddd1c7ad26b650d8"

URI_x86_64_v2_rust-cryptoki-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-sys-devel-0.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cryptoki-sys-devel}"
SRC_URI[x86_64_v2_rust-cryptoki-sys-devel.sha256sum] = "d4d20c4c023b023df43603e1855358c7cd383e3e1af0195771126931e15b583a"

URI_aarch64_rust-cryptoki-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-sys+bindgen-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-cryptoki-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki-sys+bindgen-devel}"
SRC_URI[aarch64_rust-cryptoki-sys+bindgen-devel.sha256sum] = "b01167188cee69c1046495cdd814fdeb2335b58f70bb9b9eeee19fe7b2ecae35"

URI_aarch64_rust-cryptoki-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-sys+default-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-cryptoki-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki-sys+default-devel}"
SRC_URI[aarch64_rust-cryptoki-sys+default-devel.sha256sum] = "c44072590d294f8b1cec16ee608cbd0db56925c26c0dcfbbec46122f3f321e79"

URI_aarch64_rust-cryptoki-sys+generate-bindings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-sys+generate-bindings-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-cryptoki-sys+generate-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki-sys+generate-bindings-devel}"
SRC_URI[aarch64_rust-cryptoki-sys+generate-bindings-devel.sha256sum] = "2888059a556e7b8276098ef94ca13302453cdb06bc8a1cca7c26cdceddf421d2"

URI_aarch64_rust-cryptoki-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-sys-devel-0.5.0-2.el10_3.noarch.rpm;name=aarch64_rust-cryptoki-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cryptoki-sys-devel}"
SRC_URI[aarch64_rust-cryptoki-sys-devel.sha256sum] = "8ea2f215accee4898b49334be14af3fa1b0b4a2e94548e6bfff7db7e06440390"

RDEPENDS:rust-cryptoki-sys+bindgen-devel = " \
 cargo \
 rust-cryptoki-sys-devel \
 "
RDEPENDS:rust-cryptoki-sys+default-devel = " \
 cargo \
 rust-cryptoki-sys-devel \
 "
RDEPENDS:rust-cryptoki-sys+generate-bindings-devel = " \
 cargo \
 rust-cryptoki-sys-devel \
 "
RDEPENDS:rust-cryptoki-sys-devel = " \
 bash \
 cargo \
 rust \
 rust-bindgen+default-devel \
 rust-libloading0.8+default-devel \
 "
