# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wlcs"
PV = "1.8.1"
PR = "9.el10_2"
PACKAGES = " \
 wlcs \
 wlcs-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/wlcs-1.8.1-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "792c3955d44a87ce99cae4e92fad632ae0d000f14a20b30cee8ce7f3ee94afc0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlcs-1.8.1-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlcs;unpack=0"
SRC_URI[x86_64_v2_wlcs.sha256sum] = "71f396cd676f84a7e0c99d54a2f810d18f18519caedcbfccc5de9a5741e92098"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlcs-devel-1.8.1-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlcs-devel;unpack=0"
SRC_URI[x86_64_v2_wlcs-devel.sha256sum] = "7fa4508053816badc1bf76f9cc2b198110654428eece3e952e742c32bc6e5ac7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wlcs-1.8.1-9.el10_2.aarch64.rpm;name=aarch64_wlcs;unpack=0"
SRC_URI[aarch64_wlcs.sha256sum] = "3ac30b0245019948f856d4279b4294615fb0a2601b8a05960a8569c31e92eb70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wlcs-devel-1.8.1-9.el10_2.aarch64.rpm;name=aarch64_wlcs-devel;unpack=0"
SRC_URI[aarch64_wlcs-devel.sha256sum] = "b3b8751f24b9feb5dabe6e497a44b66aa74f4276818f0e0d281e755096e71079"

RDEPENDS:wlcs = " \
 glibc \
 gmock \
 gtest \
 libasan \
 libgcc \
 libstdc++ \
 libtsan \
 libubsan \
 libwayland-client \
 libwayland-server \
 "
RDEPENDS:wlcs-devel = " \
 pkgconf-pkg-config \
 wayland-devel \
 wlcs \
 "
