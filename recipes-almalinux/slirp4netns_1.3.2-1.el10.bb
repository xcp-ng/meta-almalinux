# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "slirp4netns"
PV = "1.3.2"
PR = "1.el10"
PACKAGES = " \
 slirp4netns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/slirp4netns-1.3.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0766a1224d4500e56e26cbe82aa1b5988a13752ad95286ba10f2236dff1d67fc"

URI_x86_64_v2_slirp4netns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/slirp4netns-1.3.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_slirp4netns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slirp4netns}"
SRC_URI[x86_64_v2_slirp4netns.sha256sum] = "a49dfa45643b7a008d7121f3a7f16107601b39b2da262b0af53530b994e4ab38"

URI_aarch64_slirp4netns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/slirp4netns-1.3.2-1.el10.aarch64.rpm;name=aarch64_slirp4netns;unpack=0"
SRC_URI:append = " ${URI_aarch64_slirp4netns}"
SRC_URI[aarch64_slirp4netns.sha256sum] = "f13023d6df27b4748b2848fdd3d699d1ad2506c46652d94b2730c378891ea929"

RDEPENDS:slirp4netns = " \
 glib2 \
 glibc \
 libseccomp \
 libslirp \
 "
