# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openldap"
PV = "2.6.13"
PR = "1.el10"
PACKAGES = " \
 openldap \
 openldap-clients \
 openldap-compat \
 openldap-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openldap-2.6.13-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e35943a918b0081089bd554627e544ab5c700a2958323756fd213dcb2473dfc4"

URI_x86_64_v2_openldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-2.6.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap}"
SRC_URI[x86_64_v2_openldap.sha256sum] = "7d9c79ccd4d5fe2968dfaef69f7f9d8d1a03d7d44529dd0fef2928e7f67e0f77"

URI_x86_64_v2_openldap-clients = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-clients-2.6.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-clients}"
SRC_URI[x86_64_v2_openldap-clients.sha256sum] = "0488c825919a0637e4966fc9bd60e4808deb8d42bf035c219a3084e5002fb998"

URI_x86_64_v2_openldap-compat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-compat-2.6.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-compat}"
SRC_URI[x86_64_v2_openldap-compat.sha256sum] = "26b120459042c7fff7881ec9dcc6c3bed93c994e435c3dfaa85ed970c5c37491"

URI_x86_64_v2_openldap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openldap-devel-2.6.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-devel}"
SRC_URI[x86_64_v2_openldap-devel.sha256sum] = "ff142163fe5f8e16aa5ddd675911c460f18e129fcb59cc32cc7f596da5729857"

URI_aarch64_openldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-2.6.13-1.el10.aarch64.rpm;name=aarch64_openldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap}"
SRC_URI[aarch64_openldap.sha256sum] = "c12948ce6f19a38aa445457b39d3b152b086503412e174395aa3aec671220671"

URI_aarch64_openldap-clients = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-clients-2.6.13-1.el10.aarch64.rpm;name=aarch64_openldap-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-clients}"
SRC_URI[aarch64_openldap-clients.sha256sum] = "5a80da754a1674b9224fce7bbe67f16fbb017fb7fc35968fdd5876cdbf66a583"

URI_aarch64_openldap-compat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-compat-2.6.13-1.el10.aarch64.rpm;name=aarch64_openldap-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-compat}"
SRC_URI[aarch64_openldap-compat.sha256sum] = "9b48d3654b77cab757f132750fd92603e8e130ac324f0c6d26ea64c647b76485"

URI_aarch64_openldap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openldap-devel-2.6.13-1.el10.aarch64.rpm;name=aarch64_openldap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-devel}"
SRC_URI[aarch64_openldap-devel.sha256sum] = "9b903a2328480fab03e9c3bbe334b3b349e47ad32797763625adc5ddd013989b"

RDEPENDS:openldap = " \
 cyrus-sasl-lib \
 glibc \
 libevent \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:openldap-clients = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 "
RDEPENDS:openldap-compat = " \
 glibc \
 openldap \
 "
RDEPENDS:openldap-devel = " \
 cyrus-sasl-devel \
 openldap \
 openldap-devel \
 pkgconf-pkg-config \
 "
