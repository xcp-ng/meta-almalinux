# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wget"
PV = "1.24.5"
PR = "8.el10"
PACKAGES = " \
 wget \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wget-1.24.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9ae38e39e3faf3ecfc3878056fe9a70ea3d0652cd9ebdd806e0a74619f1f6c09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wget-1.24.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_wget;unpack=0"
SRC_URI[x86_64_v2_wget.sha256sum] = "06678276ad4c6c65bb89801f18349c99c56102b18753aabb13c117e72e82e305"
RPROVIDES:wget:append:x86_64_v2 = " virtual/wget_or_curl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wget-1.24.5-8.el10.aarch64.rpm;name=aarch64_wget;unpack=0"
SRC_URI[aarch64_wget.sha256sum] = "68da26a5150dec0344f0c9fd2e5fdf407dcdabee60be89cdee38c711eb890d1a"
RPROVIDES:wget:append:aarch64 = " virtual/wget_or_curl"

RDEPENDS:wget = " \
 glibc \
 gnutls \
 libidn2 \
 libpsl \
 libuuid \
 pcre2 \
 zlib-ng-compat \
 "
