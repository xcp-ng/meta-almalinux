# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "roctracer"
PV = "7.2.2"
PR = "3.el10_3"
PACKAGES:x86_64_v2 = " \
 roctracer \
 roctracer-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/roctracer-7.2.2-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a71c3dd70ad47db829fcdf83dbe266e17a258b1655e6ff4649b532578498ea8"

URI_x86_64_v2_roctracer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roctracer-7.2.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_roctracer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_roctracer}"
SRC_URI[x86_64_v2_roctracer.sha256sum] = "a1c20fa45e5b56325809f2be9e88fa57ac0497b558112e9f6afa07051af76f68"

URI_x86_64_v2_roctracer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roctracer-devel-7.2.2-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_roctracer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_roctracer-devel}"
SRC_URI[x86_64_v2_roctracer-devel.sha256sum] = "229f08e828514074fbb63305f89e7f2a639ce712454174db5041bc6534e5b44c"

RDEPENDS:roctracer = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-filesystem \
 rocm-hip \
 rocm-runtime \
 "
RDEPENDS:roctracer-devel = " \
 rocm-filesystem \
 roctracer \
 "
