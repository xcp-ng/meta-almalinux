# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libqb"
PV = "2.0.8"
PR = "6.el10"
PACKAGES = " \
 libqb \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libqb-2.0.8-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fa8b67201d44bfd3ba38aa0ff303143f83cd28fad8d81aef0d950ba3c754840c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libqb-2.0.8-6.el10.x86_64_v2.rpm;name=x86_64_v2_libqb;unpack=0"
SRC_URI[x86_64_v2_libqb.sha256sum] = "33033d0dc3de2cc3321244c00a6e56a8c4cc72327b510b297243a28ca265e4e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libqb-2.0.8-6.el10.aarch64.rpm;name=aarch64_libqb;unpack=0"
SRC_URI[aarch64_libqb.sha256sum] = "0b47aa2191ff5998def5c9a75bbf92dc4de250dba9af759f94c71010fb78cd5b"

RDEPENDS:libqb = " \
 glibc \
 "
