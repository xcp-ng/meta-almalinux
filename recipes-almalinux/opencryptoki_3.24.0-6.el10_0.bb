# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencryptoki"
PV = "3.24.0"
PR = "6.el10_0"
PACKAGES:x86_64_v2 = " \
 opencryptoki \
 opencryptoki-ccatok \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"
PACKAGES:aarch64 = " \
 opencryptoki \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/opencryptoki-3.24.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9e75f77fecc6d2a43b1821a07295b0cb4efcb0c0151df6e72e33f26bf23e864"

URI_x86_64_v2_opencryptoki = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-3.24.0-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_opencryptoki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki}"
SRC_URI[x86_64_v2_opencryptoki.sha256sum] = "38f92ba230f0026195cc82c044a3806f3baceb8cb4cd64b8b9e01a8de77767be"

URI_x86_64_v2_opencryptoki-ccatok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-ccatok-3.24.0-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-ccatok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-ccatok}"
SRC_URI[x86_64_v2_opencryptoki-ccatok.sha256sum] = "4c240513f7d38f0f234a586ea9d9b3f20dc9ab0775843db637477d4249c2cfee"
RPROVIDES:opencryptoki-ccatok:x86_64_v2 = "virtual/opencryptoki_token_"

URI_x86_64_v2_opencryptoki-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/opencryptoki-devel-3.24.0-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-devel}"
SRC_URI[x86_64_v2_opencryptoki-devel.sha256sum] = "82ffb58e5383e63bc3e0861b90e08e868f2adde537ba527ca8494dea08a39ff7"

URI_x86_64_v2_opencryptoki-icsftok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-icsftok-3.24.0-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-icsftok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-icsftok}"
SRC_URI[x86_64_v2_opencryptoki-icsftok.sha256sum] = "e717e774c0d30db4838c3b0c5e26e92223964b669e239bc10db39d1ccb6d945b"
RPROVIDES:opencryptoki-icsftok:x86_64_v2 = "virtual/opencryptoki_token_"

URI_x86_64_v2_opencryptoki-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-libs-3.24.0-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-libs}"
SRC_URI[x86_64_v2_opencryptoki-libs.sha256sum] = "074feb6e2578e5b7fe14ba2bf198f31dfc67eeef3d4eef7c4e72b26610238609"

URI_x86_64_v2_opencryptoki-swtok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-swtok-3.24.0-6.el10_0.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-swtok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencryptoki-swtok}"
SRC_URI[x86_64_v2_opencryptoki-swtok.sha256sum] = "761e19dcfbb9994b062d4ed81f1a115e1ab54d0e6ab68426c1e202e95b3a2ac2"
RPROVIDES:opencryptoki-swtok:x86_64_v2 = "virtual/opencryptoki_token_"

URI_aarch64_opencryptoki = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-3.24.0-6.el10_0.aarch64.rpm;name=aarch64_opencryptoki;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki}"
SRC_URI[aarch64_opencryptoki.sha256sum] = "87e957ffb6cecc7dc03ff8922980dd85c67e0245934bf12616f1414a58aee1a1"

URI_aarch64_opencryptoki-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/opencryptoki-devel-3.24.0-6.el10_0.aarch64.rpm;name=aarch64_opencryptoki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-devel}"
SRC_URI[aarch64_opencryptoki-devel.sha256sum] = "896b0e0e47b902073b2291a077649cb1dad67f2518beb18a4b5fab4ffcd4021f"

URI_aarch64_opencryptoki-icsftok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-icsftok-3.24.0-6.el10_0.aarch64.rpm;name=aarch64_opencryptoki-icsftok;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-icsftok}"
SRC_URI[aarch64_opencryptoki-icsftok.sha256sum] = "c4fed3e9a1284b0557836f441e50d69ed04ac4d8dd81cdec9bb38abcbae4b1a4"
RPROVIDES:opencryptoki-icsftok:aarch64 = "virtual/opencryptoki_token_"

URI_aarch64_opencryptoki-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-libs-3.24.0-6.el10_0.aarch64.rpm;name=aarch64_opencryptoki-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-libs}"
SRC_URI[aarch64_opencryptoki-libs.sha256sum] = "4f00d9ce25b990a5afee8e4dc736f2cbe5392a5e076576dade370f725fe17ac8"

URI_aarch64_opencryptoki-swtok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-swtok-3.24.0-6.el10_0.aarch64.rpm;name=aarch64_opencryptoki-swtok;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencryptoki-swtok}"
SRC_URI[aarch64_opencryptoki-swtok.sha256sum] = "c6b3b042d8e5154485eb1c1448fa3b549071a1aae1f872c905a74881b40b8c3d"
RPROVIDES:opencryptoki-swtok:aarch64 = "virtual/opencryptoki_token_"

RDEPENDS:opencryptoki = " \
 bash \
 diffutils \
 glibc \
 libcap \
 opencryptoki-libs \
 openssl-libs \
 selinux-policy \
 systemd \
 virtual/coreutils \
 virtual/opencryptoki_token_ \
 "
RDEPENDS:opencryptoki-ccatok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-devel = " \
 opencryptoki-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:opencryptoki-icsftok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-libs = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:opencryptoki-swtok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/opencryptoki_token_"

PROVIDES:append:aarch64 = " rpm/virtual/opencryptoki_token_"
