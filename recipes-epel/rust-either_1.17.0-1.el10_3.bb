# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-either"
PV = "1.17.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-either+default-devel \
 rust-either+serde-devel \
 rust-either+std-devel \
 rust-either+use_std-devel \
 rust-either-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-either-1.17.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "31e891056a9f92072b38dfa8bc02c485b45d3ecc87fb53e09b79045cfbc8c71d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+default-devel-1.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either+default-devel.sha256sum] = "b445b8f7a309ce795281af0ae9f169675a29e3f9da80f6959d6d8792e50f9bbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+serde-devel-1.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either+serde-devel.sha256sum] = "4ff2b49a93077502c868418bd8b2d285a67e17390774925194ef4d483fb33151"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+std-devel-1.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either+std-devel.sha256sum] = "8fcb933bd4bc0e45b50b40a6090903925e5df4d48fc4e74833e00eb182ced581"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+use_std-devel-1.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+use_std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either+use_std-devel.sha256sum] = "3981ba205e91a7453af59c036561f31f188247f4f615f85b80af7603ed901fd9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either-devel-1.17.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either-devel;unpack=0"
SRC_URI[x86_64_v2_rust-either-devel.sha256sum] = "101c649e459f38bc27abd163733b9825f2238d4bab540e24378b2be193617191"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either+default-devel-1.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-either+default-devel;unpack=0"
SRC_URI[aarch64_rust-either+default-devel.sha256sum] = "642b9573879086cecf8618c64ea4f316a6be5828a304cec7ea8368b6d5652965"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either+serde-devel-1.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-either+serde-devel;unpack=0"
SRC_URI[aarch64_rust-either+serde-devel.sha256sum] = "9c0289a459c06a2d20f497b0db2065c7a5407195651df975d2c62288deb3b088"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either+std-devel-1.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-either+std-devel;unpack=0"
SRC_URI[aarch64_rust-either+std-devel.sha256sum] = "764467e668966609c8f2dc48a3979e3d9195a927fe62015b0035ce769a728433"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either+use_std-devel-1.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-either+use_std-devel;unpack=0"
SRC_URI[aarch64_rust-either+use_std-devel.sha256sum] = "66bc21231b082fd102db4cbdc484e81ce6073db358b5f63db904774df5bdf891"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-either-devel-1.17.0-1.el10_3.noarch.rpm;name=aarch64_rust-either-devel;unpack=0"
SRC_URI[aarch64_rust-either-devel.sha256sum] = "9cf10d520e862a13a651e7621353acb8123c239d34bc4c8dc78b178b0e51cff9"

RDEPENDS:rust-either+default-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either+serde-devel = " \
 cargo \
 rust-either-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-either+std-devel = " \
 cargo \
 rust-either-devel \
 "
RDEPENDS:rust-either+use_std-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either-devel = " \
 cargo \
 rust \
 "
