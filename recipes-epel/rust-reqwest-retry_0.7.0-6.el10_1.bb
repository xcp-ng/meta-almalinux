# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-retry"
PV = "0.7.0"
PR = "6.el10_1"
PACKAGES = " \
 rust-reqwest-retry+default-devel \
 rust-reqwest-retry+tracing-devel \
 rust-reqwest-retry-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-retry-0.7.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb8848a259388429e67223ef2afebea6dc384dee4349c4334e590919c57dc9ee"

URI_x86_64_v2_rust-reqwest-retry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry+default-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry+default-devel.sha256sum] = "55813b1a9d0ede4f4b4d0e84be7719111dd416a15bf62420d484c462b6badbd5"

URI_x86_64_v2_rust-reqwest-retry+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry+tracing-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry+tracing-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry+tracing-devel.sha256sum] = "efeb21ae4915a7680c930852fd18c54a26c6cbb71b20c4764ff1649764ce0c3b"

URI_x86_64_v2_rust-reqwest-retry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry-devel.sha256sum] = "017b5da9df17a61e4312b79d81c1fe1b2fd8dc0ce4438e3a766e70f046057a1e"

URI_aarch64_rust-reqwest-retry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry+default-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-reqwest-retry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry+default-devel}"
SRC_URI[aarch64_rust-reqwest-retry+default-devel.sha256sum] = "69a8a4b00154b1ac9fdf4d6a66dbea100b65cf7ce7c6b330a7be173a956517e1"

URI_aarch64_rust-reqwest-retry+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry+tracing-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-reqwest-retry+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry+tracing-devel}"
SRC_URI[aarch64_rust-reqwest-retry+tracing-devel.sha256sum] = "0604a2d3c3cbd032a704abdc8e7e172955884d4425d9ed060f81b3f1cca6b6e1"

URI_aarch64_rust-reqwest-retry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-reqwest-retry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry-devel}"
SRC_URI[aarch64_rust-reqwest-retry-devel.sha256sum] = "1237ce5533ceeccd339771eb5852b46799e193c593077c9d643a260942b5d505"

RDEPENDS:rust-reqwest-retry+default-devel = " \
 cargo \
 rust-reqwest-retry+tracing-devel \
 rust-reqwest-retry-devel \
 "
RDEPENDS:rust-reqwest-retry+tracing-devel = " \
 cargo \
 rust-reqwest-retry-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-reqwest-retry-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-futures+default-devel \
 rust-http+default-devel \
 rust-hyper+default-devel \
 rust-reqwest-devel \
 rust-reqwest-middleware+default-devel \
 rust-retry-policies+default-devel \
 rust-thiserror1+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
