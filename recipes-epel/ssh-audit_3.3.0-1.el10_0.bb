# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ssh-audit"
PV = "3.3.0"
PR = "1.el10_0"
PACKAGES = " \
 ssh-audit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/ssh-audit-3.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64bf9d24df6ed7252de3033156a44e65a6efe36ca5850d34ee7253d648e6538a"

URI_x86_64_v2_ssh-audit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ssh-audit-3.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ssh-audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ssh-audit}"
SRC_URI[x86_64_v2_ssh-audit.sha256sum] = "de6799a1084e5f56f404a16e0850b505aa3847252f01844baf101a2a0ae3a3d1"

URI_aarch64_ssh-audit = "${EPEL_MIRROR}/aarch64/Packages/s/ssh-audit-3.3.0-1.el10_0.noarch.rpm;name=aarch64_ssh-audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ssh-audit}"
SRC_URI[aarch64_ssh-audit.sha256sum] = "0e2cb1a7fbe79811abfbbbb77b9c15be9e29a4219961807eb22338c1d9c3fa6c"

RDEPENDS:ssh-audit = " \
 python3 \
 "
