# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBD-SQLite"
PV = "1.74"
PR = "6.el10"
PACKAGES = " \
 perl-DBD-SQLite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-DBD-SQLite-1.74-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50a306a797e6025d381fe7a7cc9a363fdd4a9f3d3c3b4055bbae1d7829855ae6"

URI_x86_64_v2_perl-DBD-SQLite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBD-SQLite-1.74-6.el10.x86_64_v2.rpm;name=x86_64_v2_perl-DBD-SQLite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DBD-SQLite}"
SRC_URI[x86_64_v2_perl-DBD-SQLite.sha256sum] = "53d1522dc7009c5032e21d3a3662a221fd82713e72a2fe8aa8d1963b6b8b2f7f"

URI_aarch64_perl-DBD-SQLite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBD-SQLite-1.74-6.el10.aarch64.rpm;name=aarch64_perl-DBD-SQLite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DBD-SQLite}"
SRC_URI[aarch64_perl-DBD-SQLite.sha256sum] = "e58fe3d725514968d25f367ba9187c8239492f00602cf69e1590cd63938823ec"

RDEPENDS:perl-DBD-SQLite = " \
 glibc \
 perl-DBD-SQLite \
 perl-DBI \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-base \
 perl-constant \
 perl-libs \
 perl-locale \
 sqlite-libs \
 "
