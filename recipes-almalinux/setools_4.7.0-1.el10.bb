# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setools"
PV = "4.7.0"
PR = "1.el10"
PACKAGES = " \
 python3-setools \
 setools \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/setools-4.7.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfc89e194912a4e40c1212f0c44c9dcda78c5385a76a8007b9d8c8eaaff8309e"

URI_x86_64_v2_python3-setools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-setools-4.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-setools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setools}"
SRC_URI[x86_64_v2_python3-setools.sha256sum] = "d5c4bf733a985942209071da6b75491e7c026a595c9d8512c9c6464ae7e7ff41"

URI_x86_64_v2_setools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-4.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_setools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools}"
SRC_URI[x86_64_v2_setools.sha256sum] = "570339350476f1ed353478c62fd749bdd81d3e173d83d2601798ed92f2d01d39"

URI_x86_64_v2_setools-console = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/setools-console-4.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-console}"
SRC_URI[x86_64_v2_setools-console.sha256sum] = "7cfedd3b9cc3862f620800cd73a88d18cebda045c2c02ab158cbe4df949182d5"

URI_x86_64_v2_setools-console-analyses = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-console-analyses-4.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console-analyses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-console-analyses}"
SRC_URI[x86_64_v2_setools-console-analyses.sha256sum] = "bd668569bc36dbcafcfe8eef790e2c964bfe8f2f48c3ec2cb5eaa07d2a16d0b4"

URI_x86_64_v2_setools-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-gui-4.7.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_setools-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-gui}"
SRC_URI[x86_64_v2_setools-gui.sha256sum] = "7ac49662bd10ebdb2685b05938ee00e85f99e508c704adce596711f11c0ba191"

URI_aarch64_python3-setools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-setools-4.7.0-1.el10.aarch64.rpm;name=aarch64_python3-setools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setools}"
SRC_URI[aarch64_python3-setools.sha256sum] = "6ad3199783de10188e29a520c163f88914feaae626a499276f2aac2697d43265"

URI_aarch64_setools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-4.7.0-1.el10.aarch64.rpm;name=aarch64_setools;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools}"
SRC_URI[aarch64_setools.sha256sum] = "0bc617375f840738e72f862595679e0215732d2be21bc942bd547a2cbdb05de1"

URI_aarch64_setools-console = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/setools-console-4.7.0-1.el10.aarch64.rpm;name=aarch64_setools-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-console}"
SRC_URI[aarch64_setools-console.sha256sum] = "a3c26e1eaa0f5f702b69c58ecbef5b94840fe18d6e92d79a1721e6e19f83ee92"

URI_aarch64_setools-console-analyses = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-console-analyses-4.7.0-1.el10.aarch64.rpm;name=aarch64_setools-console-analyses;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-console-analyses}"
SRC_URI[aarch64_setools-console-analyses.sha256sum] = "cf36a40dae2f14a8c2470a9e296a2805bc4fb96054a2c5c048f7ae4e83359784"

URI_aarch64_setools-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-gui-4.7.0-1.el10.aarch64.rpm;name=aarch64_setools-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-gui}"
SRC_URI[aarch64_setools-gui.sha256sum] = "b7fce4e7d5b5e0d33185796660475e9dc22d8c8e4e66ea67605908b9cfacec64"

RDEPENDS:python3-setools = " \
 glibc \
 libselinux \
 libsepol \
 python3 \
 "
RDEPENDS:setools = " \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "
RDEPENDS:setools-console = " \
 libselinux \
 python3 \
 python3-setools \
 "
RDEPENDS:setools-console-analyses = " \
 libselinux \
 python3 \
 python3-networkx \
 python3-setools \
 "
RDEPENDS:setools-gui = " \
 python3 \
 python3-networkx \
 python3-pyqt6 \
 python3-pyqt6-sip \
 python3-setools \
 "
