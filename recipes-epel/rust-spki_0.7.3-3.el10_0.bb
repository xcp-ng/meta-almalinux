# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spki"
PV = "0.7.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-spki+alloc-devel \
 rust-spki+arbitrary-devel \
 rust-spki+base64-devel \
 rust-spki+default-devel \
 rust-spki+fingerprint-devel \
 rust-spki+pem-devel \
 rust-spki+sha2-devel \
 rust-spki+std-devel \
 rust-spki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spki-0.7.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "088dab880fdd9c602775a9ef735cc0bb1593bb22fa7802ad43fe7bbeea406631"

URI_x86_64_v2_rust-spki+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+alloc-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+alloc-devel}"
SRC_URI[x86_64_v2_rust-spki+alloc-devel.sha256sum] = "d4f784d0077681979ce88cc5bb37f736a6866dbdcbba1aeb4af81cd700014ec2"

URI_x86_64_v2_rust-spki+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+arbitrary-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-spki+arbitrary-devel.sha256sum] = "4a1aa22437b393a07f71282a35110018c182311664474e18e3a1ae14e4514b24"

URI_x86_64_v2_rust-spki+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+base64-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+base64-devel}"
SRC_URI[x86_64_v2_rust-spki+base64-devel.sha256sum] = "800d4464c74c73ef60390fd495faf276e5fe1f39143a1ab3255fa9898e423711"

URI_x86_64_v2_rust-spki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+default-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+default-devel}"
SRC_URI[x86_64_v2_rust-spki+default-devel.sha256sum] = "70d7d7e25cbbbe9971eff5cb09110331f981c524e0a3a9a52c1ad45a893d2404"

URI_x86_64_v2_rust-spki+fingerprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+fingerprint-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+fingerprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+fingerprint-devel}"
SRC_URI[x86_64_v2_rust-spki+fingerprint-devel.sha256sum] = "6a1f59e72d0591173c28d67a32860c43db8859d5b46457277e44d276048f7aa3"

URI_x86_64_v2_rust-spki+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+pem-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+pem-devel}"
SRC_URI[x86_64_v2_rust-spki+pem-devel.sha256sum] = "2ee3ff8c085e0bae3c60c352035226c8cbda93b269f9246834a04cdda2e43bea"

URI_x86_64_v2_rust-spki+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+sha2-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+sha2-devel}"
SRC_URI[x86_64_v2_rust-spki+sha2-devel.sha256sum] = "75d3e8dfd6bacffa8ad95d001840b196cd6c0b05069b0e413072d0b8367ce3bb"

URI_x86_64_v2_rust-spki+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+std-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+std-devel}"
SRC_URI[x86_64_v2_rust-spki+std-devel.sha256sum] = "533aacffd96dcac00a2cc9dfbc9e13e6dcc7e2b30fdb4c7a8bd40c3d4c703676"

URI_x86_64_v2_rust-spki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki-devel-0.7.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki-devel}"
SRC_URI[x86_64_v2_rust-spki-devel.sha256sum] = "a720f22bb3f3b76afd9e3b07f9890eb8849b9e8696bd8599608dc331b6f5e7eb"

URI_aarch64_rust-spki+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+alloc-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-spki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+alloc-devel}"
SRC_URI[aarch64_rust-spki+alloc-devel.sha256sum] = "00cea149b217ef29df7ac77772513df99cccf3b4179131359cdd5597762c83bd"

URI_aarch64_rust-spki+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+arbitrary-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-spki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+arbitrary-devel}"
SRC_URI[aarch64_rust-spki+arbitrary-devel.sha256sum] = "391d2dc77accba392e0f0388e974405cdd9603d146064760c3229044e61cea30"

URI_aarch64_rust-spki+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+base64-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-spki+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+base64-devel}"
SRC_URI[aarch64_rust-spki+base64-devel.sha256sum] = "a74b43b08c94759f142d4d6386a753e022913200a71f26f339fe98bde8db530a"

URI_aarch64_rust-spki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+default-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-spki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+default-devel}"
SRC_URI[aarch64_rust-spki+default-devel.sha256sum] = "0ad8b854fd1157d615256528b61f712965596381ba7f3ab40ca09a6e4d94d9d5"

URI_aarch64_rust-spki+fingerprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+fingerprint-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-spki+fingerprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+fingerprint-devel}"
SRC_URI[aarch64_rust-spki+fingerprint-devel.sha256sum] = "8f5936e9f1f3018b74812eb185aae4232e2723f214682ee73a9c05d73e34f972"

URI_aarch64_rust-spki+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+pem-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-spki+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+pem-devel}"
SRC_URI[aarch64_rust-spki+pem-devel.sha256sum] = "6026d695c61e58a14f2025ef1fea7d81f137b2575805f005c1da10c80573a63d"

URI_aarch64_rust-spki+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+sha2-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-spki+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+sha2-devel}"
SRC_URI[aarch64_rust-spki+sha2-devel.sha256sum] = "93733b7f86708b501470b906c8b53f5b755e109a966da71cdb609dffd6893777"

URI_aarch64_rust-spki+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+std-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-spki+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+std-devel}"
SRC_URI[aarch64_rust-spki+std-devel.sha256sum] = "24424d5b2132421efc7ef524f58ca7c18f5ab30c346d62d8cc81cebec72a3ea3"

URI_aarch64_rust-spki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki-devel-0.7.3-3.el10_0.noarch.rpm;name=aarch64_rust-spki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki-devel}"
SRC_URI[aarch64_rust-spki-devel.sha256sum] = "dcc20f6731a7ce6d86e98b51a900139f2ed7f4ad9b7f5bd4c04b132bbc396e79"

RDEPENDS:rust-spki+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-base64ct-devel \
 rust-der+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-der+arbitrary-devel \
 rust-spki+std-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+base64-devel = " \
 cargo \
 rust-base64ct-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+default-devel = " \
 cargo \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+fingerprint-devel = " \
 cargo \
 rust-spki+sha2-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+pem-devel = " \
 cargo \
 rust-der+pem-devel \
 rust-spki+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+sha2-devel = " \
 cargo \
 rust-sha2-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+std-devel = " \
 cargo \
 rust-der+std-devel \
 rust-spki+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki-devel = " \
 cargo \
 rust \
 rust-der+default-devel \
 rust-der+oid-devel \
 "
