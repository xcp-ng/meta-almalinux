# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "less"
PV = "661"
PR = "3.el10"
PACKAGES = " \
 less \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/less-661-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ab1f54197add456b588044fbe40b1922c9e22466d9a6a1d2abc1912d6e19321"

URI_x86_64_v2_less = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/less-661-3.el10.x86_64_v2.rpm;name=x86_64_v2_less;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_less}"
SRC_URI[x86_64_v2_less.sha256sum] = "e6c0cc1d4578bcdfe5ac028a53e3ebaae446b2a39256641938c94a65b1e353fa"

URI_aarch64_less = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/less-661-3.el10.aarch64.rpm;name=aarch64_less;unpack=0"
SRC_URI:append = " ${URI_aarch64_less}"
SRC_URI[aarch64_less.sha256sum] = "b563af29d3ea1a1fa2666292d947e26a3815befd610df0d9394a3ec433d5ea2d"

RDEPENDS:less = " \
 bash \
 glibc \
 ncurses-libs \
 "
