# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tio"
PV = "3.9"
PR = "1.el10_0"
PACKAGES = " \
 tio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tio-3.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "467e0d972f983f1db5b591c31acf11c53854cbe4ac6d95e35fffdfbe0dcadd5e"

URI_x86_64_v2_tio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tio-3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tio}"
SRC_URI[x86_64_v2_tio.sha256sum] = "56e9295ac76f5689f8fa77e22f852a90b9415864b286493d3ca5b21f300281d0"

URI_aarch64_tio = "${EPEL_MIRROR}/aarch64/Packages/t/tio-3.9-1.el10_0.aarch64.rpm;name=aarch64_tio;unpack=0"
SRC_URI:append = " ${URI_aarch64_tio}"
SRC_URI[aarch64_tio.sha256sum] = "a7ed7b2e17c66bf16dda12d085a7b74147cd4ec861484155f273502b3d153ec9"

RDEPENDS:tio = " \
 glib2 \
 glibc \
 lua-libs \
 "
