# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-bom"
PV = "2.0.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-unicode-bom+default-devel \
 rust-unicode-bom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-bom-2.0.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d652fbf8ccd400fd8bb935484518720ede7019a5fe7e0e770c56a3489551eada"

URI_x86_64_v2_rust-unicode-bom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bom+default-devel-2.0.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bom+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-bom+default-devel.sha256sum] = "3254033c64f8f5f76d3fdd2bd98dd9c5f114d6b7aa9a74b398277379ea8483ba"

URI_x86_64_v2_rust-unicode-bom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bom-devel-2.0.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bom-devel}"
SRC_URI[x86_64_v2_rust-unicode-bom-devel.sha256sum] = "99b57a494e9de8e45f45ce698c259e6872271367845f98d157252e411cbe0386"

URI_aarch64_rust-unicode-bom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bom+default-devel-2.0.3-3.el10_0.noarch.rpm;name=aarch64_rust-unicode-bom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bom+default-devel}"
SRC_URI[aarch64_rust-unicode-bom+default-devel.sha256sum] = "258d43a124767bf47d3fac6277295e4e9c574f7d39207777ff45961600ff2bd1"

URI_aarch64_rust-unicode-bom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bom-devel-2.0.3-3.el10_0.noarch.rpm;name=aarch64_rust-unicode-bom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bom-devel}"
SRC_URI[aarch64_rust-unicode-bom-devel.sha256sum] = "af33d304033ccd3b2c4d5a73d10c57605d3ef86b8851b17ad63dc1f94365ce98"

RDEPENDS:rust-unicode-bom+default-devel = " \
 cargo \
 rust-unicode-bom-devel \
 "
RDEPENDS:rust-unicode-bom-devel = " \
 cargo \
 "
