# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-render"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-below-render+default-devel \
 rust-below-render-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-render-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3b2aa8fc9ac1eedc5dc23687514d81ea25f6f876fd15d435d7eaf9f4428dac4"

URI_x86_64_v2_rust-below-render+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-render+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-render+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-render+default-devel}"
SRC_URI[x86_64_v2_rust-below-render+default-devel.sha256sum] = "4a9622cd413de00c3c6413df6963e7aedbbfc3c644d9c8dea723cac5319817c4"

URI_x86_64_v2_rust-below-render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-render-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-render-devel}"
SRC_URI[x86_64_v2_rust-below-render-devel.sha256sum] = "e7e98d14d265b1feff4b07dc7a766165c1dfd384fbb1c387991f44dbc7d0c531"

URI_aarch64_rust-below-render+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-render+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-render+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-render+default-devel}"
SRC_URI[aarch64_rust-below-render+default-devel.sha256sum] = "b3c451eab56e22075a91d3d94e732e8f204f87c71835ac368dcef57cce31adf5"

URI_aarch64_rust-below-render-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-render-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-render-devel}"
SRC_URI[aarch64_rust-below-render-devel.sha256sum] = "f208590dd44f2010d60028c4ccfec927d65c3f28db1db84afa38fb701767763f"

RDEPENDS:rust-below-render+default-devel = " \
 cargo \
 rust-below-render-devel \
 "
RDEPENDS:rust-below-render-devel = " \
 cargo \
 rust-below-common+default-devel \
 rust-below-model+default-devel \
 "
