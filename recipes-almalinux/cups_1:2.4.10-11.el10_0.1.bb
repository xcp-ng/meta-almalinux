# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cups"
PE = "1"
PV = "2.4.10"
PR = "11.el10_0.1"
PACKAGES = " \
 cups \
 cups-client \
 cups-devel \
 cups-filesystem \
 cups-ipptool \
 cups-libs \
 cups-lpd \
 cups-printerapp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cups-2.4.10-11.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9945396233fcb8854eac8741950345aad68cb963fe14886c0ef36f19b08e646"

URI_x86_64_v2_cups = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_cups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups}"
SRC_URI[x86_64_v2_cups.sha256sum] = "ef2e47ce333559a50f04d60bd9b8cde627bba1073bd3848be1cf9c9e868f56fd"

URI_x86_64_v2_cups-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-client-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_cups-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-client}"
SRC_URI[x86_64_v2_cups-client.sha256sum] = "ef33e6fc265ba5370bba096d95656ada5313d8a295d810da9b1004cf045f2d6e"

URI_x86_64_v2_cups-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-devel-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_cups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-devel}"
SRC_URI[x86_64_v2_cups-devel.sha256sum] = "49e0c0cdf995ce0720597bfe70f819d0ffda8ef6eda3726a39f6487a6a9e1ac6"

URI_x86_64_v2_cups-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cups-filesystem-2.4.10-11.el10_0.1.noarch.rpm;name=x86_64_v2_cups-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-filesystem}"
SRC_URI[x86_64_v2_cups-filesystem.sha256sum] = "0a57c29c2d81aeb9fcc53bc8dd11b2a0086b7ef4582b0bfb3ce29e9af931975f"

URI_x86_64_v2_cups-ipptool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-ipptool-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_cups-ipptool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-ipptool}"
SRC_URI[x86_64_v2_cups-ipptool.sha256sum] = "65e3b016b7350ba0b41a262acbe01eebb11ef6ca6576745623ecf863e0114870"

URI_x86_64_v2_cups-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cups-libs-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_cups-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-libs}"
SRC_URI[x86_64_v2_cups-libs.sha256sum] = "58c7c8706d7739d814e4d9465419a35a32fb60ff430b203032aba10140dbb720"

URI_x86_64_v2_cups-lpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-lpd-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_cups-lpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-lpd}"
SRC_URI[x86_64_v2_cups-lpd.sha256sum] = "d168134a859fdc62f42f9ca0dccb498b1782f67186d062e4b0249150d2e15e43"

URI_x86_64_v2_cups-printerapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-printerapp-2.4.10-11.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_cups-printerapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-printerapp}"
SRC_URI[x86_64_v2_cups-printerapp.sha256sum] = "6f5d2ad8f6855b052c6561e200f59e908c8e2454c567bed5d3c20340e84bc251"

URI_aarch64_cups = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-2.4.10-11.el10_0.1.aarch64.rpm;name=aarch64_cups;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups}"
SRC_URI[aarch64_cups.sha256sum] = "ac375c6fbda446f2a04b7ce864184c6830477944a765503f38cab0fb3de1d3e8"

URI_aarch64_cups-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-client-2.4.10-11.el10_0.1.aarch64.rpm;name=aarch64_cups-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-client}"
SRC_URI[aarch64_cups-client.sha256sum] = "1ca9083d06aa50177db6c1ec10b323873443598972c4e9c2cc4ac1fa3137652c"

URI_aarch64_cups-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-devel-2.4.10-11.el10_0.1.aarch64.rpm;name=aarch64_cups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-devel}"
SRC_URI[aarch64_cups-devel.sha256sum] = "3480107757ebd5e72b8ce8f64704ddbd299d0808df78d84201f1b7df0bfba206"

URI_aarch64_cups-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cups-filesystem-2.4.10-11.el10_0.1.noarch.rpm;name=aarch64_cups-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-filesystem}"
SRC_URI[aarch64_cups-filesystem.sha256sum] = "0a57c29c2d81aeb9fcc53bc8dd11b2a0086b7ef4582b0bfb3ce29e9af931975f"

URI_aarch64_cups-ipptool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-ipptool-2.4.10-11.el10_0.1.aarch64.rpm;name=aarch64_cups-ipptool;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-ipptool}"
SRC_URI[aarch64_cups-ipptool.sha256sum] = "4fe59a465d2b424da08fe2c7741a7a4164e3465f0f3a30cc436269fcef10f719"

URI_aarch64_cups-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cups-libs-2.4.10-11.el10_0.1.aarch64.rpm;name=aarch64_cups-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-libs}"
SRC_URI[aarch64_cups-libs.sha256sum] = "cd1ed3f5e359428415923a0f610493ff008a002789d54c896b6250db5d93cf1e"

URI_aarch64_cups-lpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-lpd-2.4.10-11.el10_0.1.aarch64.rpm;name=aarch64_cups-lpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-lpd}"
SRC_URI[aarch64_cups-lpd.sha256sum] = "a2be4b518643312cd2c61558cf331d47ee88896e749b0cac2efc7d5e5e1408be"

URI_aarch64_cups-printerapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-printerapp-2.4.10-11.el10_0.1.aarch64.rpm;name=aarch64_cups-printerapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-printerapp}"
SRC_URI[aarch64_cups-printerapp.sha256sum] = "7d097a2120783df97b3158f82dfff32ff6433e66f72afbf322766f6fcaaad34e"

RDEPENDS:cups = " \
 acl \
 audit-libs \
 avahi-libs \
 bash \
 cups-client \
 cups-filesystem \
 cups-filters \
 cups-libs \
 dbus \
 dbus-libs \
 glibc \
 grep \
 krb5-libs \
 libacl \
 libgcc \
 libselinux \
 libstdc++ \
 libusb1 \
 pam-libs \
 python3 \
 sed \
 systemd \
 systemd-libs \
 "
RDEPENDS:cups-client = " \
 alternatives \
 bash \
 cups-libs \
 glibc \
 "
RDEPENDS:cups-devel = " \
 avahi-devel \
 bash \
 cups-libs \
 gnutls-devel \
 krb5-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:cups-filesystem = " \
 "
RDEPENDS:cups-ipptool = " \
 avahi \
 avahi-libs \
 cups-libs \
 glibc \
 "
RDEPENDS:cups-libs = " \
 avahi-libs \
 cups-filesystem \
 glibc \
 gnutls \
 krb5-libs \
 zlib-ng-compat \
 "
RDEPENDS:cups-lpd = " \
 bash \
 cups \
 cups-libs \
 glibc \
 "
RDEPENDS:cups-printerapp = " \
 avahi \
 avahi-libs \
 cups-libs \
 glibc \
 pam-libs \
 "
