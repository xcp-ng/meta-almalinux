# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mrack"
PV = "1.23.4"
PR = "1.el10_1"
PACKAGES = " \
 mrack \
 mrack-cli \
 python3-mrack-aws \
 python3-mrack-beaker \
 python3-mrack-openstack \
 python3-mrack-podman \
 python3-mrack-virt \
 python3-mracklib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mrack-1.23.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e1560ccdd7538bc719182fd255b6f1e89777e50540f860a3a6962bf9e2a2c71"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-mracklib: sshpass

URI_x86_64_v2_mrack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mrack-1.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mrack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrack}"
SRC_URI[x86_64_v2_mrack.sha256sum] = "0624465d94277408f447cbbf70f87a58454a01b77b10f691deca4ee9a9fe5237"

URI_x86_64_v2_mrack-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mrack-cli-1.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mrack-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrack-cli}"
SRC_URI[x86_64_v2_mrack-cli.sha256sum] = "25df7088210cd5a01e354541c790ebc7311323286c14f5507db4ac2cfa52955b"

URI_x86_64_v2_python3-mrack-aws = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-aws-1.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-aws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-aws}"
SRC_URI[x86_64_v2_python3-mrack-aws.sha256sum] = "d2c12d661d8360a703f5cfaf8b98e4229c4efebdcafc59eb26c7f504ea114a11"

URI_x86_64_v2_python3-mrack-beaker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-beaker-1.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-beaker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-beaker}"
SRC_URI[x86_64_v2_python3-mrack-beaker.sha256sum] = "e55c68bd7c18476ba9b700e4dc4143b3acb382bc208380dad4b26bf4f18aed29"

URI_x86_64_v2_python3-mrack-openstack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-openstack-1.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-openstack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-openstack}"
SRC_URI[x86_64_v2_python3-mrack-openstack.sha256sum] = "8d48d85c65f8e7e6057c0e9ea2e07a0b8c62d3eb2408c8bdcec4aa28f678a2ca"

URI_x86_64_v2_python3-mrack-podman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-podman-1.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-podman}"
SRC_URI[x86_64_v2_python3-mrack-podman.sha256sum] = "1fe2a00f68d53598dc77aaf93786c7bf71b91a46890c3f0f444d720ad6670b45"

URI_x86_64_v2_python3-mrack-virt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-virt-1.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-virt}"
SRC_URI[x86_64_v2_python3-mrack-virt.sha256sum] = "344bba65efbae60d3ec39812f2477b19041e779b0ba7e9602ff8e16942992e72"

URI_x86_64_v2_python3-mracklib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mracklib-1.23.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mracklib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mracklib}"
SRC_URI[x86_64_v2_python3-mracklib.sha256sum] = "63eb87a1f366ac914693324f85c197b8a0ff2ad1b94a1e6f84561b5868d75893"

URI_aarch64_mrack = "${EPEL_MIRROR}/aarch64/Packages/m/mrack-1.23.4-1.el10_1.noarch.rpm;name=aarch64_mrack;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrack}"
SRC_URI[aarch64_mrack.sha256sum] = "ecd429090475a7516fefc300b73f8c013cc302b22cd657cbb50099b98106705b"

URI_aarch64_mrack-cli = "${EPEL_MIRROR}/aarch64/Packages/m/mrack-cli-1.23.4-1.el10_1.noarch.rpm;name=aarch64_mrack-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrack-cli}"
SRC_URI[aarch64_mrack-cli.sha256sum] = "e6e7fa8496f940e809db033daa1b832d6dc8e0076537b7972c86f027b130399c"

URI_aarch64_python3-mrack-aws = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-aws-1.23.4-1.el10_1.noarch.rpm;name=aarch64_python3-mrack-aws;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-aws}"
SRC_URI[aarch64_python3-mrack-aws.sha256sum] = "162ac050c56f989b0a4280069306668620ef5c4a7dc1b1960e65dbdb62eef498"

URI_aarch64_python3-mrack-beaker = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-beaker-1.23.4-1.el10_1.noarch.rpm;name=aarch64_python3-mrack-beaker;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-beaker}"
SRC_URI[aarch64_python3-mrack-beaker.sha256sum] = "9ab7c67506d43d51c649227c64c718da3292f6811ebfd9238dd5eec742d41270"

URI_aarch64_python3-mrack-openstack = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-openstack-1.23.4-1.el10_1.noarch.rpm;name=aarch64_python3-mrack-openstack;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-openstack}"
SRC_URI[aarch64_python3-mrack-openstack.sha256sum] = "476e96ce168ccfc8130a0f272059cc38f7bc75b01026884c925a5a58eecf1e61"

URI_aarch64_python3-mrack-podman = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-podman-1.23.4-1.el10_1.noarch.rpm;name=aarch64_python3-mrack-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-podman}"
SRC_URI[aarch64_python3-mrack-podman.sha256sum] = "c2c2e0a63812b32b99184f5d7cd5f0b326f693c31a01159e7a8acc667911f205"

URI_aarch64_python3-mrack-virt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-virt-1.23.4-1.el10_1.noarch.rpm;name=aarch64_python3-mrack-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-virt}"
SRC_URI[aarch64_python3-mrack-virt.sha256sum] = "5309d0e881331f78e97d9974604a1d584c9c70c1a412a31e2de698ea6b5594bf"

URI_aarch64_python3-mracklib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mracklib-1.23.4-1.el10_1.noarch.rpm;name=aarch64_python3-mracklib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mracklib}"
SRC_URI[aarch64_python3-mracklib.sha256sum] = "a8d67d961d365fa323c544806249d2a28ebebd08c7153eadf140592b102238b6"

RDEPENDS:mrack = " \
 mrack-cli \
 python3-mrack-aws \
 python3-mrack-beaker \
 python3-mrack-openstack \
 python3-mrack-podman \
 python3-mrack-virt \
 python3-mracklib \
 "
RDEPENDS:mrack-cli = " \
 python3 \
 python3-click \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-aws = " \
 python3 \
 python3-boto3 \
 python3-botocore \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-beaker = " \
 beaker-client \
 python3 \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-openstack = " \
 python3 \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-podman = " \
 podman \
 python3 \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-virt = " \
 python3 \
 python3-mracklib \
 testcloud \
 "
RDEPENDS:python3-mracklib:x86_64_v2 = " \
 python3 \
 python3-pyyaml \
"
RDEPENDS:python3-mracklib:aarch64 = " \
 python3 \
 python3-pyyaml \
 sshpass \
"
