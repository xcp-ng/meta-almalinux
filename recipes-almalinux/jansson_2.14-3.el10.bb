# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jansson"
PV = "2.14"
PR = "3.el10"
PACKAGES = " \
 jansson \
 jansson-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/jansson-2.14-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "133ffcba890aca09004bf521eff4e6bfea5685654c9b7cca080e40f676c6157a"

URI_x86_64_v2_jansson = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/jansson-2.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_jansson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jansson}"
SRC_URI[x86_64_v2_jansson.sha256sum] = "4d09bfe8a603488dd6943dd9936cd5fd16e3f9f5068516c4a982a6ff61280fa2"

URI_x86_64_v2_jansson-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jansson-devel-2.14-3.el10.x86_64_v2.rpm;name=x86_64_v2_jansson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jansson-devel}"
SRC_URI[x86_64_v2_jansson-devel.sha256sum] = "d11d8a2684570228716e3931cb7545fde3cba39702a7081ceae5268e82578388"

URI_aarch64_jansson = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/jansson-2.14-3.el10.aarch64.rpm;name=aarch64_jansson;unpack=0"
SRC_URI:append = " ${URI_aarch64_jansson}"
SRC_URI[aarch64_jansson.sha256sum] = "395c65895de76a35a0063dfffb360e361b5f2c3dce35d8cd306d9a72e3690c8e"

URI_aarch64_jansson-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jansson-devel-2.14-3.el10.aarch64.rpm;name=aarch64_jansson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jansson-devel}"
SRC_URI[aarch64_jansson-devel.sha256sum] = "3e16196ac8ce7fe5f95452b0e0aff46b4a4cd42c809be96b786c6407f0a2512f"

RDEPENDS:jansson = " \
 glibc \
 "
RDEPENDS:jansson-devel = " \
 jansson \
 pkgconf-pkg-config \
 "
