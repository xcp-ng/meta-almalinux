# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qca"
PV = "2.3.10"
PR = "1.el10_1"
PACKAGES = " \
 qca-qt5 \
 qca-qt5-cyrus-sasl \
 qca-qt5-devel \
 qca-qt5-gcrypt \
 qca-qt5-gnupg \
 qca-qt5-logger \
 qca-qt5-nss \
 qca-qt5-ossl \
 qca-qt5-pkcs11 \
 qca-qt5-softstore \
 qca-qt6 \
 qca-qt6-cyrus-sasl \
 qca-qt6-devel \
 qca-qt6-gcrypt \
 qca-qt6-gnupg \
 qca-qt6-logger \
 qca-qt6-nss \
 qca-qt6-ossl \
 qca-qt6-pkcs11 \
 qca-qt6-softstore \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qca-2.3.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee57100f532a707dcc9565ce3683e41407adcb0eac227b140b514964d218172d"

URI_x86_64_v2_qca-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5}"
SRC_URI[x86_64_v2_qca-qt5.sha256sum] = "287a427dc8a789387a8a2cf0af79015ac0a2251a047131cfc74e84aef3cd3db8"

URI_x86_64_v2_qca-qt5-cyrus-sasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-cyrus-sasl-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-cyrus-sasl}"
SRC_URI[x86_64_v2_qca-qt5-cyrus-sasl.sha256sum] = "78a3bf7c94f02d20df681f8eb8f5a44e3bd358f324265d5269d435d86e0023c1"

URI_x86_64_v2_qca-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-devel-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-devel}"
SRC_URI[x86_64_v2_qca-qt5-devel.sha256sum] = "063c791007dd87e6dc0c1b45e095b84e89199298399d0c2fd6a9933a1cbdd694"

URI_x86_64_v2_qca-qt5-gcrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-gcrypt-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-gcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-gcrypt}"
SRC_URI[x86_64_v2_qca-qt5-gcrypt.sha256sum] = "8e07f141c022f03947e6ec669a80736cad3b1c5806981ac3d9d5742fbc1e4944"

URI_x86_64_v2_qca-qt5-gnupg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-gnupg-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-gnupg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-gnupg}"
SRC_URI[x86_64_v2_qca-qt5-gnupg.sha256sum] = "87974a0b7fe1c85af2e216d8a33c732de59cc86b9aedbd72f8dd5ca9acb96bd0"

URI_x86_64_v2_qca-qt5-logger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-logger-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-logger}"
SRC_URI[x86_64_v2_qca-qt5-logger.sha256sum] = "92090bca86a0299a60374c616bd8d537b89de56e87e984008ea476096b062609"

URI_x86_64_v2_qca-qt5-nss = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-nss-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-nss}"
SRC_URI[x86_64_v2_qca-qt5-nss.sha256sum] = "d46c9461e088cc17ee6a6abfa0b3b5efd09ffc3c0d9dcb67d2aa85d23c1a64e2"

URI_x86_64_v2_qca-qt5-ossl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-ossl-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-ossl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-ossl}"
SRC_URI[x86_64_v2_qca-qt5-ossl.sha256sum] = "19197d8c2e4503b7396c3f616e020b5a8cce96632d0a5e13d78cc79388736e7c"

URI_x86_64_v2_qca-qt5-pkcs11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-pkcs11-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-pkcs11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-pkcs11}"
SRC_URI[x86_64_v2_qca-qt5-pkcs11.sha256sum] = "492eada0cd578c28e31be000a5e491c853b0ef04f127445f2f2e90393bf35190"

URI_x86_64_v2_qca-qt5-softstore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt5-softstore-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt5-softstore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt5-softstore}"
SRC_URI[x86_64_v2_qca-qt5-softstore.sha256sum] = "1a992102b3822c2aa8001ad970bbfd4a861d629c873807ab68c361cec52e2318"

URI_x86_64_v2_qca-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6}"
SRC_URI[x86_64_v2_qca-qt6.sha256sum] = "42dfdd9adeaf0c71dce213ec7bc753e707f8fb7fa7036fec325f0b71f9ff83d6"

URI_x86_64_v2_qca-qt6-cyrus-sasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-cyrus-sasl-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-cyrus-sasl}"
SRC_URI[x86_64_v2_qca-qt6-cyrus-sasl.sha256sum] = "af2a8107ec36a899e9741d991226da92d0b5b1e8d14089561ecec17138cd9934"

URI_x86_64_v2_qca-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-devel-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-devel}"
SRC_URI[x86_64_v2_qca-qt6-devel.sha256sum] = "17015913ccff329818fa32ae3bfd83cc7810e326be8a5bdc9883abb4b68e77f6"

URI_x86_64_v2_qca-qt6-gcrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-gcrypt-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-gcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-gcrypt}"
SRC_URI[x86_64_v2_qca-qt6-gcrypt.sha256sum] = "0a0f4aad49bbd202a21b81b6986e490445550c5a1798654dad354c03e358163e"

URI_x86_64_v2_qca-qt6-gnupg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-gnupg-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-gnupg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-gnupg}"
SRC_URI[x86_64_v2_qca-qt6-gnupg.sha256sum] = "332d494588fb42d913f3c7db6fc523b6c549d336ac5e1cbb3d875522e0cc22f9"

URI_x86_64_v2_qca-qt6-logger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-logger-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-logger}"
SRC_URI[x86_64_v2_qca-qt6-logger.sha256sum] = "69660928027788e6e38437cac69afedde89e26f6e82410a02fa9874124c9aa14"

URI_x86_64_v2_qca-qt6-nss = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-nss-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-nss}"
SRC_URI[x86_64_v2_qca-qt6-nss.sha256sum] = "051ecfd051078c56b12be5873449f5e8fdfcb82bfbe32da53d35c3f5097b8a9c"

URI_x86_64_v2_qca-qt6-ossl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-ossl-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-ossl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-ossl}"
SRC_URI[x86_64_v2_qca-qt6-ossl.sha256sum] = "21b8639bbc877fff41e6b1dec1446324330a84018ccd079c7dd844db1f8a81c3"

URI_x86_64_v2_qca-qt6-pkcs11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-pkcs11-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-pkcs11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-pkcs11}"
SRC_URI[x86_64_v2_qca-qt6-pkcs11.sha256sum] = "0378b01982ef9ccb9f3cb3ea8eb4a7d291e931be025e4cb9501b5fe4997cb224"

URI_x86_64_v2_qca-qt6-softstore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qca-qt6-softstore-2.3.10-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qca-qt6-softstore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qca-qt6-softstore}"
SRC_URI[x86_64_v2_qca-qt6-softstore.sha256sum] = "ae86174dc538995f1457dadb734c27597ae5e344352dab980194a1144946ab2c"

URI_aarch64_qca-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5}"
SRC_URI[aarch64_qca-qt5.sha256sum] = "981993464e2bacd9e0f850b6f916b73950da438c75cb0c14d29a8608e55ec8e4"

URI_aarch64_qca-qt5-cyrus-sasl = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-cyrus-sasl-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5-cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-cyrus-sasl}"
SRC_URI[aarch64_qca-qt5-cyrus-sasl.sha256sum] = "c55ef8a586dfe8825aa36e08c823c7cff80b9e672667871013edbc9338792b1d"

URI_aarch64_qca-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-devel-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-devel}"
SRC_URI[aarch64_qca-qt5-devel.sha256sum] = "fe978e82ae61bb12951888bf94b5e7765704673ddb06872e7294dce60e2d4ffa"

URI_aarch64_qca-qt5-gcrypt = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-gcrypt-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5-gcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-gcrypt}"
SRC_URI[aarch64_qca-qt5-gcrypt.sha256sum] = "52b62f1c95d32351c4c1235855b0319e144a25aea62a957317c3c87809bf1289"

URI_aarch64_qca-qt5-gnupg = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-gnupg-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5-gnupg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-gnupg}"
SRC_URI[aarch64_qca-qt5-gnupg.sha256sum] = "d45723203f6eaa9e9870e040c1bae5ece90ba7f9edec43e59f35c5bcf440f737"

URI_aarch64_qca-qt5-logger = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-logger-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-logger}"
SRC_URI[aarch64_qca-qt5-logger.sha256sum] = "9cd7bdf9b1b78768c17a90e71a8b597b26efc836a1bc0a0a32724ef78c34c75c"

URI_aarch64_qca-qt5-nss = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-nss-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5-nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-nss}"
SRC_URI[aarch64_qca-qt5-nss.sha256sum] = "9b7fe1a2d566ad4e6352242e46cd2dd4193ddbb5f22190ec4d20c2e9c594363e"

URI_aarch64_qca-qt5-ossl = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-ossl-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5-ossl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-ossl}"
SRC_URI[aarch64_qca-qt5-ossl.sha256sum] = "0210783483e8d0df63aa935605d55403b2742b86d410b1456b3a9fa814cd58c0"

URI_aarch64_qca-qt5-pkcs11 = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-pkcs11-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5-pkcs11;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-pkcs11}"
SRC_URI[aarch64_qca-qt5-pkcs11.sha256sum] = "499a474343fc2774f945f16959fb1e443e120d6e9d0d86ec1780bd9fad08f1ad"

URI_aarch64_qca-qt5-softstore = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt5-softstore-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt5-softstore;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt5-softstore}"
SRC_URI[aarch64_qca-qt5-softstore.sha256sum] = "472ee6b82ea72493a83571e01b65fbc39933f4c8f73e624ccba4c543dc22ad3e"

URI_aarch64_qca-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6}"
SRC_URI[aarch64_qca-qt6.sha256sum] = "3c1ff80273dc75ac78fec352ce9ce2e25177bb3ddf73435813397b3af1806248"

URI_aarch64_qca-qt6-cyrus-sasl = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-cyrus-sasl-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6-cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-cyrus-sasl}"
SRC_URI[aarch64_qca-qt6-cyrus-sasl.sha256sum] = "c8283f89ed1cf7a48d960c66658bb091768228b46ecae544c9d153280c4c76c2"

URI_aarch64_qca-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-devel-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-devel}"
SRC_URI[aarch64_qca-qt6-devel.sha256sum] = "335e452f01271826025450b691de493d1448d41486126e95e2caf1c16b1b47fb"

URI_aarch64_qca-qt6-gcrypt = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-gcrypt-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6-gcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-gcrypt}"
SRC_URI[aarch64_qca-qt6-gcrypt.sha256sum] = "9b7a72c3db5071c482011825d565009f651422f88246ee108a8ad712d1e39a2f"

URI_aarch64_qca-qt6-gnupg = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-gnupg-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6-gnupg;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-gnupg}"
SRC_URI[aarch64_qca-qt6-gnupg.sha256sum] = "5e787e9e819bbe3932ccf6363c46a28eccc00da767aebcb9c3340d1cc7849c86"

URI_aarch64_qca-qt6-logger = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-logger-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-logger}"
SRC_URI[aarch64_qca-qt6-logger.sha256sum] = "8ea9bfc1985d20ea5c42799f0e33b6a4d303fce7756acda3e1e76eb952862373"

URI_aarch64_qca-qt6-nss = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-nss-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6-nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-nss}"
SRC_URI[aarch64_qca-qt6-nss.sha256sum] = "34b646a0ef79415946ca1b998fa7ad3deac7958cb73f131c0d8194abeef80636"

URI_aarch64_qca-qt6-ossl = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-ossl-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6-ossl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-ossl}"
SRC_URI[aarch64_qca-qt6-ossl.sha256sum] = "65e9a713e97a0ed46afb50994903d6f43b44b7545e713f6c0690b1124c91925c"

URI_aarch64_qca-qt6-pkcs11 = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-pkcs11-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6-pkcs11;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-pkcs11}"
SRC_URI[aarch64_qca-qt6-pkcs11.sha256sum] = "451b9ccd1994db7a9e8ccabe74b6e10e607e6ba92898931f24477e0a2f5c106d"

URI_aarch64_qca-qt6-softstore = "${EPEL_MIRROR}/aarch64/Packages/q/qca-qt6-softstore-2.3.10-1.el10_1.aarch64.rpm;name=aarch64_qca-qt6-softstore;unpack=0"
SRC_URI:append = " ${URI_aarch64_qca-qt6-softstore}"
SRC_URI[aarch64_qca-qt6-softstore.sha256sum] = "9d004750a7101bd9cb6168896f0b00dcaac591cf43b6bd92bd2894d9aaf80da6"

RDEPENDS:qca-qt5 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-cyrus-sasl = " \
 cyrus-sasl-lib \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qca-qt5 \
 qt5-qtbase-devel \
 "
RDEPENDS:qca-qt5-gcrypt = " \
 glibc \
 libgcc \
 libgcrypt \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-gnupg = " \
 glibc \
 gnupg2 \
 libgcc \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-logger = " \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-nss = " \
 glibc \
 libgcc \
 libstdc++ \
 nss \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-ossl = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-pkcs11 = " \
 glibc \
 libgcc \
 libstdc++ \
 pkcs11-helper \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt5-softstore = " \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt5 \
 qt5-qtbase \
 "
RDEPENDS:qca-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-cyrus-sasl = " \
 cyrus-sasl-lib \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qca-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:qca-qt6-gcrypt = " \
 glibc \
 libgcc \
 libgcrypt \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-gnupg = " \
 glibc \
 gnupg2 \
 libgcc \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-logger = " \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-nss = " \
 glibc \
 libgcc \
 libstdc++ \
 nss \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-ossl = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-pkcs11 = " \
 glibc \
 libgcc \
 libstdc++ \
 pkcs11-helper \
 qca-qt6 \
 qt6-qtbase \
 "
RDEPENDS:qca-qt6-softstore = " \
 glibc \
 libgcc \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 "
