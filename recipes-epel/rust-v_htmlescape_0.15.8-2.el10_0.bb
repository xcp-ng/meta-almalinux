# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-v_htmlescape"
PV = "0.15.8"
PR = "2.el10_0"
PACKAGES = " \
 rust-v_htmlescape+buf-min-devel \
 rust-v_htmlescape+bytes-buf-devel \
 rust-v_htmlescape+default-devel \
 rust-v_htmlescape-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-v_htmlescape-0.15.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "187e41cac6b57e7c1c43d8a596e6adc50f3a4df0991c786cdf7fa23069a56d34"

URI_x86_64_v2_rust-v_htmlescape+buf-min-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_htmlescape+buf-min-devel-0.15.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_htmlescape+buf-min-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_htmlescape+buf-min-devel}"
SRC_URI[x86_64_v2_rust-v_htmlescape+buf-min-devel.sha256sum] = "039fc0c416f5f05ecab247106d68178ff2ac38615c5cb49d77f3acf19a6413e1"

URI_x86_64_v2_rust-v_htmlescape+bytes-buf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_htmlescape+bytes-buf-devel-0.15.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_htmlescape+bytes-buf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_htmlescape+bytes-buf-devel}"
SRC_URI[x86_64_v2_rust-v_htmlescape+bytes-buf-devel.sha256sum] = "eb2229df59eeb6881f99b55b9637eeaecad61b5577857ef056c6c1493e47b5fd"

URI_x86_64_v2_rust-v_htmlescape+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_htmlescape+default-devel-0.15.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_htmlescape+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_htmlescape+default-devel}"
SRC_URI[x86_64_v2_rust-v_htmlescape+default-devel.sha256sum] = "c8cf47da6b1e382c010a451452babcb98a39617184d2a47c2ac4edf21f5ccc98"

URI_x86_64_v2_rust-v_htmlescape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_htmlescape-devel-0.15.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_htmlescape-devel}"
SRC_URI[x86_64_v2_rust-v_htmlescape-devel.sha256sum] = "3057b3a8a697ea4bd9ac3b034721dcf8ee4fd1d473f9ba71bc0b96af5dee3ded"

URI_aarch64_rust-v_htmlescape+buf-min-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_htmlescape+buf-min-devel-0.15.8-2.el10_0.noarch.rpm;name=aarch64_rust-v_htmlescape+buf-min-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_htmlescape+buf-min-devel}"
SRC_URI[aarch64_rust-v_htmlescape+buf-min-devel.sha256sum] = "e07ac2044bc68ba3f3636fb170db8e16fec24950494c5f4266bec15b3e95af1e"

URI_aarch64_rust-v_htmlescape+bytes-buf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_htmlescape+bytes-buf-devel-0.15.8-2.el10_0.noarch.rpm;name=aarch64_rust-v_htmlescape+bytes-buf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_htmlescape+bytes-buf-devel}"
SRC_URI[aarch64_rust-v_htmlescape+bytes-buf-devel.sha256sum] = "9b66bfbda0b0e43d413a2467bdfb29d206f9471b1cbe04a900879cd525ca9981"

URI_aarch64_rust-v_htmlescape+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_htmlescape+default-devel-0.15.8-2.el10_0.noarch.rpm;name=aarch64_rust-v_htmlescape+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_htmlescape+default-devel}"
SRC_URI[aarch64_rust-v_htmlescape+default-devel.sha256sum] = "03f8de34b1218d8e344b1c8e49c0c1a424ba33deb2da566fb4e768a49cbf96fc"

URI_aarch64_rust-v_htmlescape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_htmlescape-devel-0.15.8-2.el10_0.noarch.rpm;name=aarch64_rust-v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_htmlescape-devel}"
SRC_URI[aarch64_rust-v_htmlescape-devel.sha256sum] = "674010ac6dbf4779d2d6fcf05a2a949da1b8a537795f8375e94a49609323be2d"

RDEPENDS:rust-v_htmlescape+buf-min-devel = " \
 cargo \
 rust-buf-min+default-devel \
 rust-v_htmlescape-devel \
 "
RDEPENDS:rust-v_htmlescape+bytes-buf-devel = " \
 cargo \
 rust-v_htmlescape+buf-min-devel \
 rust-v_htmlescape-devel \
 "
RDEPENDS:rust-v_htmlescape+default-devel = " \
 cargo \
 rust-v_htmlescape-devel \
 "
RDEPENDS:rust-v_htmlescape-devel = " \
 cargo \
 "
