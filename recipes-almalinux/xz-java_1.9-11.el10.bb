# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xz-java"
PV = "1.9"
PR = "11.el10"
PACKAGES = " \
 xz-java \
 xz-java-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xz-java-1.9-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9805a0a48043937665d00211f480983b75d69da4b87e9120d68885dffeb6a967"

URI_x86_64_v2_xz-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xz-java-1.9-11.el10.noarch.rpm;name=x86_64_v2_xz-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz-java}"
SRC_URI[x86_64_v2_xz-java.sha256sum] = "4eadd47efd97684d445006a96dfaf34ec59496a09c61fe033dfd1c38164313be"

URI_x86_64_v2_xz-java-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xz-java-javadoc-1.9-11.el10.noarch.rpm;name=x86_64_v2_xz-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz-java-javadoc}"
SRC_URI[x86_64_v2_xz-java-javadoc.sha256sum] = "0e00d1fffb8273ccd9c0d6d8694045d83b16029f87f18eb81bf9f5b643c8b9c9"

URI_aarch64_xz-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xz-java-1.9-11.el10.noarch.rpm;name=aarch64_xz-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz-java}"
SRC_URI[aarch64_xz-java.sha256sum] = "4eadd47efd97684d445006a96dfaf34ec59496a09c61fe033dfd1c38164313be"

URI_aarch64_xz-java-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xz-java-javadoc-1.9-11.el10.noarch.rpm;name=aarch64_xz-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz-java-javadoc}"
SRC_URI[aarch64_xz-java-javadoc.sha256sum] = "0e00d1fffb8273ccd9c0d6d8694045d83b16029f87f18eb81bf9f5b643c8b9c9"

RDEPENDS:xz-java = " \
 javapackages-filesystem \
 "
RDEPENDS:xz-java-javadoc = " \
 javapackages-filesystem \
 "
