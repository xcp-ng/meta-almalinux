# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreen"
PE = "1"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kscreen \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kscreen-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e6a15720941c7d7e79a1e79563d2c49e4833022816a31121e4f46734afedfb80"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreen-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreen;unpack=0"
SRC_URI[x86_64_v2_kscreen.sha256sum] = "f7bc5faaeb39860547d7fd095fe006e2d0d65b511e3b56d5035ee5e4fe2a0407"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kscreen-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kscreen;unpack=0"
SRC_URI[aarch64_kscreen.sha256sum] = "579e7a4bb59ee414d7a5d3b6dbac05212df5768ef103f3cffe6e1cfab9d04731"

RDEPENDS:kscreen = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwindowsystem \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
