# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-mg"
PV = "0.20050109"
PR = "35.el10"
PACKAGES = " \
 hunspell-mg \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-mg-0.20050109-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7eed5f1b3ca6484f71f14f6578dc96cbe990af34ee77cbb9643f70b64f58212"

URI_x86_64_v2_hunspell-mg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-mg-0.20050109-35.el10.noarch.rpm;name=x86_64_v2_hunspell-mg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-mg}"
SRC_URI[x86_64_v2_hunspell-mg.sha256sum] = "0a820789c16320792d95a28436dbb7c2d59f6bc3fa7673563f0ab74a008a9034"

URI_aarch64_hunspell-mg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-mg-0.20050109-35.el10.noarch.rpm;name=aarch64_hunspell-mg;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-mg}"
SRC_URI[aarch64_hunspell-mg.sha256sum] = "0a820789c16320792d95a28436dbb7c2d59f6bc3fa7673563f0ab74a008a9034"

RDEPENDS:hunspell-mg = " \
 hunspell-filesystem \
 "
