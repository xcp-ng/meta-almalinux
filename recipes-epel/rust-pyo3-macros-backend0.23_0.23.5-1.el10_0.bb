# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend0.23"
PV = "0.23.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-macros-backend0.23+default-devel \
 rust-pyo3-macros-backend0.23+experimental-async-devel \
 rust-pyo3-macros-backend0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend0.23-0.23.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0969dc08149019d30d6e6128f30d3f1aeae84319bde2730cbaed837786d6fe0"

URI_x86_64_v2_rust-pyo3-macros-backend0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.23+default-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.23+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.23+default-devel.sha256sum] = "6e12de85fdaa731bd62e57714fd5bd5441240744b90236c723860f863bb1485d"

URI_x86_64_v2_rust-pyo3-macros-backend0.23+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.23+experimental-async-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.23+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.23+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.23+experimental-async-devel.sha256sum] = "c0eb94ce6d5d6a651571e46f4799a985bcd2eb7b26f817cb8a3a27a0109bb141"

URI_x86_64_v2_rust-pyo3-macros-backend0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.23-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.23-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.23-devel.sha256sum] = "230c7ff0f23b9efcf76ef0589eaeb9556e69539006a693ed104d47588bf2b729"

URI_aarch64_rust-pyo3-macros-backend0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.23+default-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.23+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.23+default-devel.sha256sum] = "a1e9190d21e2411947ffe4369325f5bd13f7462946c7020b6f1bbd0a5eccad86"

URI_aarch64_rust-pyo3-macros-backend0.23+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.23+experimental-async-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.23+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.23+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.23+experimental-async-devel.sha256sum] = "fea7069d4aefe6975f5d2b898b61ddec6e8dec2dd44d8a3eb54181336a4ced9e"

URI_aarch64_rust-pyo3-macros-backend0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.23-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.23-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.23-devel.sha256sum] = "4016525195c1b1262e151d9de8d635966078210ad7ca4f265a714aaedbfd61de"

RDEPENDS:rust-pyo3-macros-backend0.23+default-devel = " \
 cargo \
 rust-pyo3-macros-backend0.23-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.23+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.23-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.23-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-pyo3-build-config0.23+default-devel \
 rust-pyo3-build-config0.23+resolve-config-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
