# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lockdev"
PV = "1.0.4"
PR = "0.46.20111007git.el10"
PACKAGES = " \
 lockdev \
 lockdev-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lockdev-1.0.4-0.46.20111007git.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26f1a55202c76faca8d2e24e48d789657e86c2f7b885f7788261221f2256cffb"

URI_x86_64_v2_lockdev = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lockdev-1.0.4-0.46.20111007git.el10.x86_64_v2.rpm;name=x86_64_v2_lockdev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lockdev}"
SRC_URI[x86_64_v2_lockdev.sha256sum] = "624dd1320dfae8f382ee796a159fcaa83fb49bae1f402117ad502cf421ecfed0"

URI_x86_64_v2_lockdev-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/lockdev-devel-1.0.4-0.46.20111007git.el10.x86_64_v2.rpm;name=x86_64_v2_lockdev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lockdev-devel}"
SRC_URI[x86_64_v2_lockdev-devel.sha256sum] = "d659b6211494657ea3c559569e5f34b578a2748e07d62e3878984e6af7ac7496"

URI_aarch64_lockdev = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lockdev-1.0.4-0.46.20111007git.el10.aarch64.rpm;name=aarch64_lockdev;unpack=0"
SRC_URI:append = " ${URI_aarch64_lockdev}"
SRC_URI[aarch64_lockdev.sha256sum] = "893cc23c552d84cc3f619facadb06a8e8d04c53f73f37f17a383e48881eb4324"

URI_aarch64_lockdev-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/lockdev-devel-1.0.4-0.46.20111007git.el10.aarch64.rpm;name=aarch64_lockdev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lockdev-devel}"
SRC_URI[aarch64_lockdev-devel.sha256sum] = "b1b9ca69b1af638cd05150072723cc8de5b8267a811edb44e4332d4b46f96d59"

RDEPENDS:lockdev = " \
 bash \
 glibc \
 shadow-utils \
 systemd \
 "
RDEPENDS:lockdev-devel = " \
 lockdev \
 pkgconf-pkg-config \
 "
