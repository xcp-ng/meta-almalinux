# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Perl4-CoreLibs"
PV = "0.005"
PR = "7.el10_0"
PACKAGES = " \
 perl-Perl4-CoreLibs \
 perl-Perl4-CoreLibs-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Perl4-CoreLibs-0.005-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c15bcc9a4c7c43efb2babca6e18792a8947fc40fe6400b88e28bb3a6e20b351e"

URI_x86_64_v2_perl-Perl4-CoreLibs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl4-CoreLibs-0.005-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Perl4-CoreLibs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl4-CoreLibs}"
SRC_URI[x86_64_v2_perl-Perl4-CoreLibs.sha256sum] = "6304d638d623bb774764eb930b3124f46fe4376ab5af0e0db661ebbb6c229d17"

URI_x86_64_v2_perl-Perl4-CoreLibs-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl4-CoreLibs-tests-0.005-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Perl4-CoreLibs-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl4-CoreLibs-tests}"
SRC_URI[x86_64_v2_perl-Perl4-CoreLibs-tests.sha256sum] = "f46b4859b7d1ca935d525e3abb0e40a22c219432bce5ee1b29d98c14afda0fa0"

URI_aarch64_perl-Perl4-CoreLibs = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl4-CoreLibs-0.005-7.el10_0.noarch.rpm;name=aarch64_perl-Perl4-CoreLibs;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl4-CoreLibs}"
SRC_URI[aarch64_perl-Perl4-CoreLibs.sha256sum] = "bb867b5c6d00cfb00c9b0b3b7150296fafb2dd52f701270db428d840cd48ccdb"

URI_aarch64_perl-Perl4-CoreLibs-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl4-CoreLibs-tests-0.005-7.el10_0.noarch.rpm;name=aarch64_perl-Perl4-CoreLibs-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl4-CoreLibs-tests}"
SRC_URI[aarch64_perl-Perl4-CoreLibs-tests.sha256sum] = "199f2631a2cf4fd46a46475c9af4c2ca189ae3b50ef9aec2444f596c95eb210d"

RDEPENDS:perl-Perl4-CoreLibs = " \
 hostname \
 perl-File-Find \
 perl-IPC-Open3 \
 perl-Socket \
 perl-Sys-Syslog \
 perl-Text-ParseWords \
 perl-Time-Local \
 perl-libs \
 "
RDEPENDS:perl-Perl4-CoreLibs-tests = " \
 bash \
 perl-IO \
 perl-Perl4-CoreLibs \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
