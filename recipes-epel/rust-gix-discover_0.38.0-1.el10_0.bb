# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-discover"
PV = "0.38.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-discover+default-devel \
 rust-gix-discover-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-discover-0.38.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6928155395545ac458eee799954b5b2214909a36a2daa446191f5e56d0db07b5"

URI_x86_64_v2_rust-gix-discover+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover+default-devel-0.38.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover+default-devel}"
SRC_URI[x86_64_v2_rust-gix-discover+default-devel.sha256sum] = "d3e4ce3692a8e4650c973f213c9d2e05dcbe362753df9c41ce24d60227ed753d"

URI_x86_64_v2_rust-gix-discover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-discover-devel-0.38.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-discover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-discover-devel}"
SRC_URI[x86_64_v2_rust-gix-discover-devel.sha256sum] = "07a4fbb4abba53adfc5a6d87d7b22b6940680d8dd0c8dd3912f055947b3788a7"

URI_aarch64_rust-gix-discover+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover+default-devel-0.38.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-discover+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover+default-devel}"
SRC_URI[aarch64_rust-gix-discover+default-devel.sha256sum] = "9b5efe189c39950563cd4a9cc92db3cbca04e2a3b15dac3bd6411515f1aa9ddc"

URI_aarch64_rust-gix-discover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-discover-devel-0.38.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-discover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-discover-devel}"
SRC_URI[aarch64_rust-gix-discover-devel.sha256sum] = "6c985c263b6500bd4ef0a1c7c1d33ab86b21cbb4fded037bdd7ba0c1fa6aa8d3"

RDEPENDS:rust-gix-discover+default-devel = " \
 cargo \
 rust-gix-discover-devel \
 "
RDEPENDS:rust-gix-discover-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-path+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-sec+default-devel \
 rust-thiserror+default-devel \
 "
