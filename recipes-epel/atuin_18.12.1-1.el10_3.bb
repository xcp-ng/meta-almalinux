# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "atuin"
PV = "18.12.1"
PR = "1.el10_3"
PACKAGES = " \
 atuin \
 atuin-all-users \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/atuin-18.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "087cdfb1eb647dd558e304aefc70bc168e3126afd885f9672583f80bb26aa180"

URI_x86_64_v2_atuin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atuin-18.12.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atuin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atuin}"
SRC_URI[x86_64_v2_atuin.sha256sum] = "0ac825bacfbd86d6a6e6ab20f7cd4a7705bc3829eb08091e0ff7df92f0906989"

URI_x86_64_v2_atuin-all-users = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atuin-all-users-18.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_atuin-all-users;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atuin-all-users}"
SRC_URI[x86_64_v2_atuin-all-users.sha256sum] = "3f3f91487ab8485d7701d6ed5c143b8d85a6eab8693f70aad6b4f0d864f1cba5"

URI_aarch64_atuin = "${EPEL_MIRROR}/aarch64/Packages/a/atuin-18.12.1-1.el10_3.aarch64.rpm;name=aarch64_atuin;unpack=0"
SRC_URI:append = " ${URI_aarch64_atuin}"
SRC_URI[aarch64_atuin.sha256sum] = "fdabeb0933cec91b6280e39efd86c12bf8294907a7a94ca3c345ba8d95e02c20"

URI_aarch64_atuin-all-users = "${EPEL_MIRROR}/aarch64/Packages/a/atuin-all-users-18.12.1-1.el10_3.noarch.rpm;name=aarch64_atuin-all-users;unpack=0"
SRC_URI:append = " ${URI_aarch64_atuin-all-users}"
SRC_URI[aarch64_atuin-all-users.sha256sum] = "7ad1f7d7910ec2e94b33d3f2cdba166f3bd9fea94c09883d083f60b49c5b1d04"

RDEPENDS:atuin = " \
 glibc \
 libgcc \
 sqlite-libs \
 "
RDEPENDS:atuin-all-users = " \
 atuin \
 "
