# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zabbix7.0"
PV = "7.0.20"
PR = "1.el10_0"
PACKAGES = " \
 zabbix7.0 \
 zabbix7.0-agent \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-dbfiles-sqlite3 \
 zabbix7.0-proxy \
 zabbix7.0-proxy-mysql \
 zabbix7.0-proxy-pgsql \
 zabbix7.0-proxy-sqlite3 \
 zabbix7.0-selinux \
 zabbix7.0-server \
 zabbix7.0-server-mysql \
 zabbix7.0-server-pgsql \
 zabbix7.0-web \
 zabbix7.0-web-mysql \
 zabbix7.0-web-pgsql \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zabbix7.0-7.0.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdd75fb52969195d26731b0c5882f06afd372877ae9991fbc286d28a6a1f039c"

URI_x86_64_v2_zabbix7.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-7.0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0}"
SRC_URI[x86_64_v2_zabbix7.0.sha256sum] = "b9e9fe2f4e8c3144d3718c8eb6bde37b19dfb8203c42913ef289509c1381fe9a"

URI_x86_64_v2_zabbix7.0-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-agent-7.0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-agent}"
SRC_URI[x86_64_v2_zabbix7.0-agent.sha256sum] = "17d3c89e6f151d672094b079161b5f5ac5e3362e16299d729cad8ee98cb5207e"

URI_x86_64_v2_zabbix7.0-dbfiles-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-mysql-7.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-mysql.sha256sum] = "985c49d908475029eca5d1da3e1ce7d91d8d8d3873ce87056379ff8edfb5afb5"

URI_x86_64_v2_zabbix7.0-dbfiles-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-pgsql-7.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-pgsql.sha256sum] = "b5884a42d31033084e5b448b5746f7acdaec2138b544e45848fe59e52641337a"

URI_x86_64_v2_zabbix7.0-dbfiles-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-dbfiles-sqlite3-7.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-dbfiles-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-dbfiles-sqlite3}"
SRC_URI[x86_64_v2_zabbix7.0-dbfiles-sqlite3.sha256sum] = "1e797c0ca0cc6c9c228ec6fa594928b8f8a49d03dd5705d2920cae75f0d47341"

URI_x86_64_v2_zabbix7.0-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-7.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy}"
SRC_URI[x86_64_v2_zabbix7.0-proxy.sha256sum] = "8cb6a6b1316b9fd3e1777687641fb6ca50e8f509d05313500d4fc2227bbfa28d"

URI_x86_64_v2_zabbix7.0-proxy-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-mysql-7.0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-mysql.sha256sum] = "e942fe715722f6bfdcb17988e3b6aef0b6e24289c5a81443b2d1c90633521aee"
RPROVIDES:zabbix7.0-proxy-mysql:x86_64_v2 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0.alma_altarch"

URI_x86_64_v2_zabbix7.0-proxy-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-pgsql-7.0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-pgsql.sha256sum] = "7dba5740da9a08ff450771df5d953bb4a16a072ae1673987eef298b27dd08e46"
RPROVIDES:zabbix7.0-proxy-pgsql:x86_64_v2 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0.alma_altarch"

URI_x86_64_v2_zabbix7.0-proxy-sqlite3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-proxy-sqlite3-7.0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-proxy-sqlite3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-proxy-sqlite3}"
SRC_URI[x86_64_v2_zabbix7.0-proxy-sqlite3.sha256sum] = "e47dc18439b36755d5ae4e28f89e00ee222c82abe070df296f9058b719ca609b"
RPROVIDES:zabbix7.0-proxy-sqlite3:x86_64_v2 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0.alma_altarch"

URI_x86_64_v2_zabbix7.0-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-selinux-7.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-selinux}"
SRC_URI[x86_64_v2_zabbix7.0-selinux.sha256sum] = "df85b90b42c5b938045431c66824843b5995dcb6553bfeb76274b9c34a6dfac6"

URI_x86_64_v2_zabbix7.0-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-7.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server}"
SRC_URI[x86_64_v2_zabbix7.0-server.sha256sum] = "5595fad451aad0fe6f5e510631b38e889b77f394ecacc5806d7f29b8d2a00eb3"

URI_x86_64_v2_zabbix7.0-server-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-mysql-7.0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-server-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-server-mysql.sha256sum] = "b1a726f39d4114edd18bcf652bec752eddc8d4677059c43dd9a32877cada65f8"
RPROVIDES:zabbix7.0-server-mysql:x86_64_v2 = "virtual/zabbix7.0-server-implementation_eq_7.0.20-1.el10_0.alma_altarch"

URI_x86_64_v2_zabbix7.0-server-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-server-pgsql-7.0.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zabbix7.0-server-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-server-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-server-pgsql.sha256sum] = "548b60149f2d49af58a164b7bf11803dd81bf6233543e87528004be1f8c5e7df"
RPROVIDES:zabbix7.0-server-pgsql:x86_64_v2 = "virtual/zabbix7.0-server-implementation_eq_7.0.20-1.el10_0.alma_altarch"

URI_x86_64_v2_zabbix7.0-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-7.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web}"
SRC_URI[x86_64_v2_zabbix7.0-web.sha256sum] = "a78a7bc96e7f8b40a034eb22ac45fee90208adee65f0587cfb7f93db2a457b13"

URI_x86_64_v2_zabbix7.0-web-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-mysql-7.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web-mysql}"
SRC_URI[x86_64_v2_zabbix7.0-web-mysql.sha256sum] = "78690e14951ea68715dab7067c60127d93784218633449eae8b3df3beaa87a12"
RPROVIDES:zabbix7.0-web-mysql:x86_64_v2 = "virtual/zabbix7.0-web-database_eq_7.0.20-1.el10_0.alma_altarch"

URI_x86_64_v2_zabbix7.0-web-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zabbix7.0-web-pgsql-7.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zabbix7.0-web-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zabbix7.0-web-pgsql}"
SRC_URI[x86_64_v2_zabbix7.0-web-pgsql.sha256sum] = "f84aa7764234975f8627d4463eff37ff313679781f228a4ab7a19d671f32bd53"
RPROVIDES:zabbix7.0-web-pgsql:x86_64_v2 = "virtual/zabbix7.0-web-database_eq_7.0.20-1.el10_0.alma_altarch"

URI_aarch64_zabbix7.0 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-7.0.20-1.el10_0.aarch64.rpm;name=aarch64_zabbix7.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0}"
SRC_URI[aarch64_zabbix7.0.sha256sum] = "8f9028e265264998af09360bd7d8b77c283c2dadad2ca4bd8fc1715a5915ef31"

URI_aarch64_zabbix7.0-agent = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-agent-7.0.20-1.el10_0.aarch64.rpm;name=aarch64_zabbix7.0-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-agent}"
SRC_URI[aarch64_zabbix7.0-agent.sha256sum] = "e655cc42861bc6f8e298b043b60fd37ca28a2cd7d5e93fb0969ff1d297404737"

URI_aarch64_zabbix7.0-dbfiles-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-mysql-7.0.20-1.el10_0.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-mysql}"
SRC_URI[aarch64_zabbix7.0-dbfiles-mysql.sha256sum] = "768d33f2e079ccae358ffdc7b613c113563a1106a8793c5528a142baad1dea17"

URI_aarch64_zabbix7.0-dbfiles-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-pgsql-7.0.20-1.el10_0.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-pgsql}"
SRC_URI[aarch64_zabbix7.0-dbfiles-pgsql.sha256sum] = "41f3632530d42ee901c47b87e869e2ab23db57823ec42b6623702653b27ebdff"

URI_aarch64_zabbix7.0-dbfiles-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-dbfiles-sqlite3-7.0.20-1.el10_0.noarch.rpm;name=aarch64_zabbix7.0-dbfiles-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-dbfiles-sqlite3}"
SRC_URI[aarch64_zabbix7.0-dbfiles-sqlite3.sha256sum] = "be447c30f604c256fbe6f4895ba636e5cdc5270ff6bfdb72727f76691fd3b5f4"

URI_aarch64_zabbix7.0-proxy = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-7.0.20-1.el10_0.noarch.rpm;name=aarch64_zabbix7.0-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy}"
SRC_URI[aarch64_zabbix7.0-proxy.sha256sum] = "6038ed32057f54de9e730609c2f7c2825118e51ec913bde5c7bd73ed2e1f1616"

URI_aarch64_zabbix7.0-proxy-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-mysql-7.0.20-1.el10_0.aarch64.rpm;name=aarch64_zabbix7.0-proxy-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-mysql}"
SRC_URI[aarch64_zabbix7.0-proxy-mysql.sha256sum] = "12c4bfbc000b1b182f8e0160498da37fb735fbaa7f3dbc1064e9b2c70eb6052e"
RPROVIDES:zabbix7.0-proxy-mysql:aarch64 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0"

URI_aarch64_zabbix7.0-proxy-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-pgsql-7.0.20-1.el10_0.aarch64.rpm;name=aarch64_zabbix7.0-proxy-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-pgsql}"
SRC_URI[aarch64_zabbix7.0-proxy-pgsql.sha256sum] = "876a3a76c0d304db048616f36795903ba34e6e2ffecace315b057305b4b9557a"
RPROVIDES:zabbix7.0-proxy-pgsql:aarch64 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0"

URI_aarch64_zabbix7.0-proxy-sqlite3 = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-proxy-sqlite3-7.0.20-1.el10_0.aarch64.rpm;name=aarch64_zabbix7.0-proxy-sqlite3;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-proxy-sqlite3}"
SRC_URI[aarch64_zabbix7.0-proxy-sqlite3.sha256sum] = "14a65b3725e249d2678471354c6fe5b60f9981befc0cbc3553f27818056aa40f"
RPROVIDES:zabbix7.0-proxy-sqlite3:aarch64 = "virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0"

URI_aarch64_zabbix7.0-selinux = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-selinux-7.0.20-1.el10_0.noarch.rpm;name=aarch64_zabbix7.0-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-selinux}"
SRC_URI[aarch64_zabbix7.0-selinux.sha256sum] = "d03933bb03318108bd172a5b512d45ee4b36bdbf3099c77ced396300826e35d9"

URI_aarch64_zabbix7.0-server = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-7.0.20-1.el10_0.noarch.rpm;name=aarch64_zabbix7.0-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server}"
SRC_URI[aarch64_zabbix7.0-server.sha256sum] = "de6522e8a46b8ae84a08a40872393d3dfddb20cd18f1d0c4b93f3d83fb9d3882"

URI_aarch64_zabbix7.0-server-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-mysql-7.0.20-1.el10_0.aarch64.rpm;name=aarch64_zabbix7.0-server-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server-mysql}"
SRC_URI[aarch64_zabbix7.0-server-mysql.sha256sum] = "96eef53fbd4f1a91ab24b7cc730a90a572a1eac5990ae813c981e5702480d9b9"
RPROVIDES:zabbix7.0-server-mysql:aarch64 = "virtual/zabbix7.0-server-implementation_eq_7.0.20-1.el10_0"

URI_aarch64_zabbix7.0-server-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-server-pgsql-7.0.20-1.el10_0.aarch64.rpm;name=aarch64_zabbix7.0-server-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-server-pgsql}"
SRC_URI[aarch64_zabbix7.0-server-pgsql.sha256sum] = "a78414ca42890c479352ba34cd1491b1ed8e6417f30cc9d3949e0b6d082b8654"
RPROVIDES:zabbix7.0-server-pgsql:aarch64 = "virtual/zabbix7.0-server-implementation_eq_7.0.20-1.el10_0"

URI_aarch64_zabbix7.0-web = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-7.0.20-1.el10_0.noarch.rpm;name=aarch64_zabbix7.0-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web}"
SRC_URI[aarch64_zabbix7.0-web.sha256sum] = "bed6890b8ab29f5b678cb9564e87c1d37a6d2e42cb96d275358983c1e681166d"

URI_aarch64_zabbix7.0-web-mysql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-mysql-7.0.20-1.el10_0.noarch.rpm;name=aarch64_zabbix7.0-web-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web-mysql}"
SRC_URI[aarch64_zabbix7.0-web-mysql.sha256sum] = "d08fbaf192edee19001372368f9889dce3c2336087916621ffa9120695392641"
RPROVIDES:zabbix7.0-web-mysql:aarch64 = "virtual/zabbix7.0-web-database_eq_7.0.20-1.el10_0"

URI_aarch64_zabbix7.0-web-pgsql = "${EPEL_MIRROR}/aarch64/Packages/z/zabbix7.0-web-pgsql-7.0.20-1.el10_0.noarch.rpm;name=aarch64_zabbix7.0-web-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_zabbix7.0-web-pgsql}"
SRC_URI[aarch64_zabbix7.0-web-pgsql.sha256sum] = "65a4ad8f4277b928eefadfec7e3d089b7ab434728ad0d0ae3336f96e1d25ad86"
RPROVIDES:zabbix7.0-web-pgsql:aarch64 = "virtual/zabbix7.0-web-database_eq_7.0.20-1.el10_0"

RDEPENDS:zabbix7.0 = " \
 glibc \
 libxml2 \
 logrotate \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-selinux \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-agent = " \
 bash \
 glibc \
 openldap \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-dbfiles-mysql = " \
 "
RDEPENDS:zabbix7.0-dbfiles-pgsql = " \
 "
RDEPENDS:zabbix7.0-dbfiles-sqlite3 = " \
 "
RDEPENDS:zabbix7.0-proxy:x86_64_v2 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-proxy:aarch64 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-proxy-mysql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 mariadb-connector-c \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-proxy-pgsql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libpq \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-proxy-sqlite3 = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 sqlite-libs \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0-dbfiles-sqlite3 \
 zabbix7.0-proxy \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:zabbix7.0-server:x86_64_v2 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 traceroute \
 virtual/zabbix7.0-server-implementation_eq_7.0.20-1.el10_0.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-server:aarch64 = " \
 bash \
 fping \
 shadow-utils \
 systemd \
 traceroute \
 virtual/zabbix7.0-server-implementation_eq_7.0.20-1.el10_0 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-server-mysql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libssh2 \
 libxml2 \
 mariadb-connector-c \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zabbix7.0-dbfiles-mysql \
 zabbix7.0-server \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-server-pgsql = " \
 OpenIPMI-libs \
 alternatives \
 bash \
 glibc \
 libevent \
 libpq \
 libssh2 \
 libxml2 \
 net-snmp-libs \
 openldap \
 openssl-libs \
 pcre2 \
 unixODBC \
 virtual/libcurl.so.4___64bit_ \
 zabbix7.0 \
 zabbix7.0-dbfiles-pgsql \
 zabbix7.0-server \
 zlib-ng-compat \
 "
RDEPENDS:zabbix7.0-web:x86_64_v2 = " \
 bash \
 dejavu-sans-fonts \
 js-jquery \
 php-bcmath \
 php-common \
 php-fpm \
 php-gd \
 php-ldap \
 php-mbstring \
 php-xml \
 virtual/zabbix7.0-web-database_eq_7.0.20-1.el10_0.alma_altarch \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-web:aarch64 = " \
 bash \
 dejavu-sans-fonts \
 js-jquery \
 php-bcmath \
 php-common \
 php-fpm \
 php-gd \
 php-ldap \
 php-mbstring \
 php-xml \
 virtual/zabbix7.0-web-database_eq_7.0.20-1.el10_0 \
 zabbix7.0 \
"
RDEPENDS:zabbix7.0-web-mysql = " \
 php-mysqlnd \
 zabbix7.0-web \
 "
RDEPENDS:zabbix7.0-web-pgsql = " \
 php-pgsql \
 zabbix7.0-web \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0.alma_altarch rpm/virtual/zabbix7.0-server-implementation_eq_7.0.20-1.el10_0.alma_altarch rpm/virtual/zabbix7.0-web-database_eq_7.0.20-1.el10_0.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/zabbix7.0-proxy-implementation_eq_7.0.20-1.el10_0 rpm/virtual/zabbix7.0-server-implementation_eq_7.0.20-1.el10_0 rpm/virtual/zabbix7.0-web-database_eq_7.0.20-1.el10_0"
