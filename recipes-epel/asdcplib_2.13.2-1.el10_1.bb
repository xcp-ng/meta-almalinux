# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "asdcplib"
PV = "2.13.2"
PR = "1.el10_1"
PACKAGES = " \
 asdcplib \
 asdcplib-devel \
 asdcplib-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/asdcplib-2.13.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ba553724d60ec41f0e904ac05641e9eab80056013c2ecd82de9d638ba3f5ee7"

URI_x86_64_v2_asdcplib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-2.13.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asdcplib}"
SRC_URI[x86_64_v2_asdcplib.sha256sum] = "2bce4374e41fd5925032d72139b919a3eb2ffb303546de202d1775ec8b0553d1"

URI_x86_64_v2_asdcplib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-devel-2.13.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asdcplib-devel}"
SRC_URI[x86_64_v2_asdcplib-devel.sha256sum] = "22cd9b60842b5a7fd5a78ee78abe2dae7c2e5a09e8648a7fa20026d7287024c5"

URI_x86_64_v2_asdcplib-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-tools-2.13.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asdcplib-tools}"
SRC_URI[x86_64_v2_asdcplib-tools.sha256sum] = "557904248c5c20264b2ed368c781a6a3b07a6f3aca5a482a69dba2360959782d"

URI_aarch64_asdcplib = "${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-2.13.2-1.el10_1.aarch64.rpm;name=aarch64_asdcplib;unpack=0"
SRC_URI:append = " ${URI_aarch64_asdcplib}"
SRC_URI[aarch64_asdcplib.sha256sum] = "35ecd0258511e55ebc6a382bfc4a711224662cf38006e54bf72590cd11b61e27"

URI_aarch64_asdcplib-devel = "${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-devel-2.13.2-1.el10_1.aarch64.rpm;name=aarch64_asdcplib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_asdcplib-devel}"
SRC_URI[aarch64_asdcplib-devel.sha256sum] = "081f844cb515ecaf3c4c0eb69bf99fe1b153202ed16bb4520beba9bdc06a942b"

URI_aarch64_asdcplib-tools = "${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-tools-2.13.2-1.el10_1.aarch64.rpm;name=aarch64_asdcplib-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_asdcplib-tools}"
SRC_URI[aarch64_asdcplib-tools.sha256sum] = "dc4d1acb6b0a3fac13624993da6c1ae28944d76dafe0d3d1cb408a5abc7f0813"

RDEPENDS:asdcplib = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 xerces-c \
 "
RDEPENDS:asdcplib-devel = " \
 asdcplib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:asdcplib-tools = " \
 asdcplib \
 glibc \
 libgcc \
 libstdc++ \
 "
