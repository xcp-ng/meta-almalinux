# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-secret-service"
PV = "5.1.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-secret-service+crypto-openssl-devel \
 rust-secret-service+crypto-rust-devel \
 rust-secret-service+default-devel \
 rust-secret-service+rt-async-io-crypto-openssl-devel \
 rust-secret-service+rt-async-io-crypto-rust-devel \
 rust-secret-service+rt-tokio-crypto-openssl-devel \
 rust-secret-service+rt-tokio-crypto-rust-devel \
 rust-secret-service-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-secret-service-5.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5574a8d2e357a679a1d3e02743db67111afe2ccfdea39688f84df38d70637f16"

URI_x86_64_v2_rust-secret-service+crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+crypto-openssl-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-secret-service+crypto-openssl-devel.sha256sum] = "78f30a14af5d2f2b8f5b5b3817fbf253cae5134da7e49240433b737609eabfd7"

URI_x86_64_v2_rust-secret-service+crypto-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+crypto-rust-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+crypto-rust-devel}"
SRC_URI[x86_64_v2_rust-secret-service+crypto-rust-devel.sha256sum] = "9c371aa5323e0e08227ad86cbd35520bb378e9ad835e0eb822f43b92f8854544"

URI_x86_64_v2_rust-secret-service+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+default-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+default-devel}"
SRC_URI[x86_64_v2_rust-secret-service+default-devel.sha256sum] = "44327df5de359ecaa6637e8ee1f8c4ebf45798bd25001bc6c7e3a325323c28e4"

URI_x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-async-io-crypto-openssl-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel.sha256sum] = "1bacf6208a7105795162823af32d1d88254baba2b2d4835926eae1be5e41708d"

URI_x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-async-io-crypto-rust-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel}"
SRC_URI[x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel.sha256sum] = "e76ba037b0ad1a9c439a85496de61ad28a7f29aaacd066d6e11a0815020bdc02"

URI_x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-tokio-crypto-openssl-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel.sha256sum] = "a83060b6d897f05f7acdf4f51b4474c2eebf4c3e420ba1e119be1c8e43bfc641"

URI_x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-tokio-crypto-rust-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel}"
SRC_URI[x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel.sha256sum] = "b430e3a1de6e6dc79f41b158ca7b6aaf486f1a65e8525d5fd2013b82637e2644"

URI_x86_64_v2_rust-secret-service-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service-devel-5.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service-devel}"
SRC_URI[x86_64_v2_rust-secret-service-devel.sha256sum] = "ac296c328ff692e2294fb2b891b41d26bc3688ce44de36b746f4344cffe198e4"

URI_aarch64_rust-secret-service+crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+crypto-openssl-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-secret-service+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+crypto-openssl-devel}"
SRC_URI[aarch64_rust-secret-service+crypto-openssl-devel.sha256sum] = "798b637a36236ac09df165af85a881e90967de0ac7eaf93170e03fa9d04a22f4"

URI_aarch64_rust-secret-service+crypto-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+crypto-rust-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-secret-service+crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+crypto-rust-devel}"
SRC_URI[aarch64_rust-secret-service+crypto-rust-devel.sha256sum] = "d11a55a771e775b68ba1a3f7faf7729b3a7b61f693e3fddb83a4ac429b7d6851"

URI_aarch64_rust-secret-service+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+default-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-secret-service+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+default-devel}"
SRC_URI[aarch64_rust-secret-service+default-devel.sha256sum] = "959fcef4752e6c36623fe19bd8457062caa34fb36359b70c28a9bd3b46fea8e2"

URI_aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-async-io-crypto-openssl-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel}"
SRC_URI[aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel.sha256sum] = "9af1591176eaae219fb24624f887fc87e0f044464dbda5de46990bf7bf18c409"

URI_aarch64_rust-secret-service+rt-async-io-crypto-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-async-io-crypto-rust-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-secret-service+rt-async-io-crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+rt-async-io-crypto-rust-devel}"
SRC_URI[aarch64_rust-secret-service+rt-async-io-crypto-rust-devel.sha256sum] = "e1f5eccec8b69acb38fc3c3a1ce4fd767ee4b57dbcfbc5cc50270d02fff1e357"

URI_aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-tokio-crypto-openssl-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel}"
SRC_URI[aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel.sha256sum] = "e36bd2c148baf1ee4f203cc2b51000899a672c3a5dd6c64f33abc0a24c144d96"

URI_aarch64_rust-secret-service+rt-tokio-crypto-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-tokio-crypto-rust-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-secret-service+rt-tokio-crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+rt-tokio-crypto-rust-devel}"
SRC_URI[aarch64_rust-secret-service+rt-tokio-crypto-rust-devel.sha256sum] = "3e7c1c8ac4aad17704b32bd696426e0aee2d2d468a1f088cf43a3eea5281434a"

URI_aarch64_rust-secret-service-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service-devel-5.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-secret-service-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service-devel}"
SRC_URI[aarch64_rust-secret-service-devel.sha256sum] = "bcdf113ee509abe92600f76324daa6f89597e7e2c6fa3ab6317394a15b4dc311"

RDEPENDS:rust-secret-service+crypto-openssl-devel = " \
 cargo \
 rust-openssl+default-devel \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+crypto-rust-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-cbc+alloc-devel \
 rust-cbc+block-padding-devel \
 rust-cbc+default-devel \
 rust-hkdf+default-devel \
 rust-secret-service-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-secret-service+default-devel = " \
 cargo \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+rt-async-io-crypto-openssl-devel = " \
 cargo \
 rust-secret-service+crypto-openssl-devel \
 rust-secret-service-devel \
 rust-zbus+async-io-devel \
 "
RDEPENDS:rust-secret-service+rt-async-io-crypto-rust-devel = " \
 cargo \
 rust-secret-service+crypto-rust-devel \
 rust-secret-service-devel \
 rust-zbus+async-io-devel \
 "
RDEPENDS:rust-secret-service+rt-tokio-crypto-openssl-devel = " \
 cargo \
 rust-secret-service+crypto-openssl-devel \
 rust-secret-service-devel \
 rust-zbus+tokio-devel \
 "
RDEPENDS:rust-secret-service+rt-tokio-crypto-rust-devel = " \
 cargo \
 rust-secret-service+crypto-rust-devel \
 rust-secret-service-devel \
 rust-zbus+tokio-devel \
 "
RDEPENDS:rust-secret-service-devel = " \
 cargo \
 rust \
 rust-futures-util+default-devel \
 rust-generic-array+default-devel \
 rust-getrandom0.2+default-devel \
 rust-num+default-devel \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-zbus+blocking-api-devel \
 rust-zbus-devel \
 "
