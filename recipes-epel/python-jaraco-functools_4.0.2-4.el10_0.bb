# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jaraco-functools"
PV = "4.0.2"
PR = "4.el10_0"
PACKAGES = " \
 python3-jaraco-functools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jaraco-functools-4.0.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f82053d0de0a550a41961c4d52b28b935275a52be5e1b6c43b84a7d93e4a03b"

URI_x86_64_v2_python3-jaraco-functools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jaraco-functools-4.0.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jaraco-functools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jaraco-functools}"
SRC_URI[x86_64_v2_python3-jaraco-functools.sha256sum] = "a2f6f5fe2c22fd34a9563f969d03a493817ce43f5b79a57830860a9caa03f625"

URI_aarch64_python3-jaraco-functools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jaraco-functools-4.0.2-4.el10_0.noarch.rpm;name=aarch64_python3-jaraco-functools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jaraco-functools}"
SRC_URI[aarch64_python3-jaraco-functools.sha256sum] = "a4b6684da9cc912ac5f96e27a86851d28c90a6881df10855c54b170143ce58a6"

RDEPENDS:python3-jaraco-functools = " \
 python3 \
 python3-more-itertools \
 "
