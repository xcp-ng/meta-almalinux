# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "printer-driver-brlaser"
PV = "6.2.7"
PR = "1.el10_1"
PACKAGES = " \
 printer-driver-brlaser \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/printer-driver-brlaser-6.2.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2376c616f747e6a0fae4f07a030739e32b2231751312e2a4caa09a594c88ee0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/printer-driver-brlaser-6.2.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_printer-driver-brlaser;unpack=0"
SRC_URI[x86_64_v2_printer-driver-brlaser.sha256sum] = "0f160e2023e0608f1537c65eb53b8deb0967cadd6e1c4f3588ddc9e579af0b35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/printer-driver-brlaser-6.2.7-1.el10_1.aarch64.rpm;name=aarch64_printer-driver-brlaser;unpack=0"
SRC_URI[aarch64_printer-driver-brlaser.sha256sum] = "d6330fa9c4feda56d6b369876c9ccade82574e2d4ad2f5d9efcf088cbcae22f1"

RDEPENDS:printer-driver-brlaser = " \
 cups-filesystem \
 cups-libs \
 ghostscript \
 glibc \
 libgcc \
 libstdc++ \
 "
