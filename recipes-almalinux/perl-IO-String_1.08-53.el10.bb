# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-String"
PV = "1.08"
PR = "53.el10"
PACKAGES = " \
 perl-IO-String \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-IO-String-1.08-53.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68bda380844b5ff8c23938cc6f1e8c95576d69c6cda5fdc15941c50b95522b47"

URI_x86_64_v2_perl-IO-String = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-IO-String-1.08-53.el10.noarch.rpm;name=x86_64_v2_perl-IO-String;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-String}"
SRC_URI[x86_64_v2_perl-IO-String.sha256sum] = "26eb10e95745934dedd2355a77e0eea89d67d55936cc7fa4f10ef00c51b37ef8"

URI_aarch64_perl-IO-String = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-IO-String-1.08-53.el10.noarch.rpm;name=aarch64_perl-IO-String;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-String}"
SRC_URI[aarch64_perl-IO-String.sha256sum] = "26eb10e95745934dedd2355a77e0eea89d67d55936cc7fa4f10ef00c51b37ef8"

RDEPENDS:perl-IO-String = " \
 perl-Data-Dumper \
 perl-IO \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
