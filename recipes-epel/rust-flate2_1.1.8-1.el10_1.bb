# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-flate2"
PV = "1.1.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-flate2+any_c_zlib-devel \
 rust-flate2+any_impl-devel \
 rust-flate2+any_zlib-devel \
 rust-flate2+default-devel \
 rust-flate2+document-features-devel \
 rust-flate2+libz-ng-sys-devel \
 rust-flate2+libz-sys-devel \
 rust-flate2+miniz-sys-devel \
 rust-flate2+miniz_oxide-devel \
 rust-flate2+rust_backend-devel \
 rust-flate2+zlib-default-devel \
 rust-flate2+zlib-devel \
 rust-flate2+zlib-ng-devel \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-flate2-1.1.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8a468ca5b1649633a4c5a5bc95921fce508198cfe17302a64c771399e8bf145"

URI_x86_64_v2_rust-flate2+any_c_zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+any_c_zlib-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+any_c_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+any_c_zlib-devel}"
SRC_URI[x86_64_v2_rust-flate2+any_c_zlib-devel.sha256sum] = "4f8a9073a516b6b04130df92fc9ce4a5e9f349412db0313d5a9ed3ab0ff70548"

URI_x86_64_v2_rust-flate2+any_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+any_impl-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+any_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+any_impl-devel}"
SRC_URI[x86_64_v2_rust-flate2+any_impl-devel.sha256sum] = "7697cedd1f076c02b0ea22068559232d4e1a5382eebc635424bc7e1b493ce131"

URI_x86_64_v2_rust-flate2+any_zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+any_zlib-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+any_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+any_zlib-devel}"
SRC_URI[x86_64_v2_rust-flate2+any_zlib-devel.sha256sum] = "ed207b29e20b2e804c016d2076e1a510d161aff29e12e84102c69e2f8b40cd40"

URI_x86_64_v2_rust-flate2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+default-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+default-devel}"
SRC_URI[x86_64_v2_rust-flate2+default-devel.sha256sum] = "b7f936ee3f682afa7d1e777c33a1f50326ee8e9c6576a44b7a4318f425c47bbb"

URI_x86_64_v2_rust-flate2+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+document-features-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+document-features-devel}"
SRC_URI[x86_64_v2_rust-flate2+document-features-devel.sha256sum] = "0f5f014f9ee12c9b297eca215d2f738535181b275543cd04999baa5e4387dfa1"

URI_x86_64_v2_rust-flate2+libz-ng-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+libz-ng-sys-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+libz-ng-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+libz-ng-sys-devel.sha256sum] = "9f5e526454786c92963f393a17081d8be2e4c64d13928350b08fa38cbd65490b"

URI_x86_64_v2_rust-flate2+libz-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+libz-sys-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+libz-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+libz-sys-devel.sha256sum] = "e06eedd76581cf00d0a4723b42fa29635f6e87861a2098af2238c0d176f2206f"

URI_x86_64_v2_rust-flate2+miniz-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+miniz-sys-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+miniz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+miniz-sys-devel}"
SRC_URI[x86_64_v2_rust-flate2+miniz-sys-devel.sha256sum] = "6620e96e965578420f88edd888341698f8571103d4e07af2f8897a9b3c11f1f3"

URI_x86_64_v2_rust-flate2+miniz_oxide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+miniz_oxide-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+miniz_oxide-devel}"
SRC_URI[x86_64_v2_rust-flate2+miniz_oxide-devel.sha256sum] = "51646ffc6d40b92832044d9d60d5d704d24ef04e8c1ce628128b6af5684e8fd3"

URI_x86_64_v2_rust-flate2+rust_backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+rust_backend-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+rust_backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+rust_backend-devel}"
SRC_URI[x86_64_v2_rust-flate2+rust_backend-devel.sha256sum] = "c3a8727cb9e8ea5b2749bdaba508ac3a34b0732468a36ba1dd16cd98cb4947e0"

URI_x86_64_v2_rust-flate2+zlib-default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-default-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-default-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-default-devel.sha256sum] = "d937158985b12833568e760501aeedbcc8b95edc5cb34757d073ba42f8d6cf04"

URI_x86_64_v2_rust-flate2+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-devel.sha256sum] = "3ec675e6cbc9c207ec8fae9fe14ec730e18341d326712cbbefda54998bdc6034"

URI_x86_64_v2_rust-flate2+zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-ng-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-ng-devel.sha256sum] = "8e104b9a5efa6c0e54816125ec8bf3e826029fe56e572b589207f3ee42921934"

URI_x86_64_v2_rust-flate2+zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2+zlib-rs-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2+zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-flate2+zlib-rs-devel.sha256sum] = "adc3f9ac668d23138193b9571c6a45e66dd1a79b3e12138981f1f456062c1b47"

URI_x86_64_v2_rust-flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flate2-devel-1.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flate2-devel}"
SRC_URI[x86_64_v2_rust-flate2-devel.sha256sum] = "a10322a9ec863c361e222feec769643b194462a10214f215fc9995538fe60267"

URI_aarch64_rust-flate2+any_c_zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+any_c_zlib-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+any_c_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+any_c_zlib-devel}"
SRC_URI[aarch64_rust-flate2+any_c_zlib-devel.sha256sum] = "075192704aaca90343c726aa10d6f8bb42a06d6cf5eeb2f4bc014c480807b14e"

URI_aarch64_rust-flate2+any_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+any_impl-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+any_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+any_impl-devel}"
SRC_URI[aarch64_rust-flate2+any_impl-devel.sha256sum] = "155a1ee2a95329896d8a6354e978a952f60c5bf1a08ff9c3ef75e8d769d61c66"

URI_aarch64_rust-flate2+any_zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+any_zlib-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+any_zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+any_zlib-devel}"
SRC_URI[aarch64_rust-flate2+any_zlib-devel.sha256sum] = "0d707ca3b384b4b5d6b0c0bee6a6bf1270958a21ea3f55522efb2ca7af4fab7a"

URI_aarch64_rust-flate2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+default-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+default-devel}"
SRC_URI[aarch64_rust-flate2+default-devel.sha256sum] = "ae51c4d27d28d487f15a0b8f391b1534b58896cf6891d141b2328d4a47c3e4dc"

URI_aarch64_rust-flate2+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+document-features-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+document-features-devel}"
SRC_URI[aarch64_rust-flate2+document-features-devel.sha256sum] = "daf518be752924876043ac0fcff714558c36c699d846483d9acadc6d22879f49"

URI_aarch64_rust-flate2+libz-ng-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+libz-ng-sys-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+libz-ng-sys-devel}"
SRC_URI[aarch64_rust-flate2+libz-ng-sys-devel.sha256sum] = "4ca6cff0a1c6df3996180da5ce294efc771be2d6dac554310de2083baf850193"

URI_aarch64_rust-flate2+libz-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+libz-sys-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+libz-sys-devel}"
SRC_URI[aarch64_rust-flate2+libz-sys-devel.sha256sum] = "902e7465f08443d180b677fb46b60a5958aca0636a36e2786ace67b582103ae5"

URI_aarch64_rust-flate2+miniz-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+miniz-sys-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+miniz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+miniz-sys-devel}"
SRC_URI[aarch64_rust-flate2+miniz-sys-devel.sha256sum] = "4f4076f131bc09d841d7458da9950c91ddb2e37b358403d7bef8f934416a0e6a"

URI_aarch64_rust-flate2+miniz_oxide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+miniz_oxide-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+miniz_oxide-devel}"
SRC_URI[aarch64_rust-flate2+miniz_oxide-devel.sha256sum] = "2535978c3823fc4646ea3f763167918498ef98af59beae45870d9c79f31657b5"

URI_aarch64_rust-flate2+rust_backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+rust_backend-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+rust_backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+rust_backend-devel}"
SRC_URI[aarch64_rust-flate2+rust_backend-devel.sha256sum] = "ea9a57361cb9578678cc22a46467baf3b4bddc1263bdba3fd75d0f15b532f15b"

URI_aarch64_rust-flate2+zlib-default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-default-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+zlib-default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-default-devel}"
SRC_URI[aarch64_rust-flate2+zlib-default-devel.sha256sum] = "03e49bc1b3435a4434e50720bb937a3666f20ccca3b01176a3d68cce95a5f5b8"

URI_aarch64_rust-flate2+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-devel}"
SRC_URI[aarch64_rust-flate2+zlib-devel.sha256sum] = "12058bd3fccee6bdbbb9f7f72e351570d62206b28edfbf3d23fac7ad651bf0b2"

URI_aarch64_rust-flate2+zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-ng-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-ng-devel}"
SRC_URI[aarch64_rust-flate2+zlib-ng-devel.sha256sum] = "e6aedd2c8d8bcaba516fe747b1a53a0692f368b02c7ee5d82b605662d2a41b52"

URI_aarch64_rust-flate2+zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2+zlib-rs-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2+zlib-rs-devel}"
SRC_URI[aarch64_rust-flate2+zlib-rs-devel.sha256sum] = "165eecf9bcdc5e47946099a8ed05a3930f03908f7be0582151cbdc9e01a5a855"

URI_aarch64_rust-flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flate2-devel-1.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flate2-devel}"
SRC_URI[aarch64_rust-flate2-devel.sha256sum] = "4e25b128145126983e91d22ddb4d6ed8813f072a46c26ead06e655b05cd77f56"

RDEPENDS:rust-flate2+any_c_zlib-devel = " \
 cargo \
 rust-flate2+any_zlib-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+any_impl-devel = " \
 cargo \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+any_zlib-devel = " \
 cargo \
 rust-flate2+any_impl-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+default-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+libz-ng-sys-devel = " \
 cargo \
 rust-flate2-devel \
 rust-libz-ng-sys+default-devel \
 "
RDEPENDS:rust-flate2+libz-sys-devel = " \
 cargo \
 rust-flate2-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-flate2+miniz-sys-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+miniz_oxide-devel = " \
 cargo \
 rust-flate2-devel \
 rust-miniz_oxide+simd-devel \
 rust-miniz_oxide+with-alloc-devel \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-flate2+rust_backend-devel = " \
 cargo \
 rust-flate2+any_impl-devel \
 rust-flate2+miniz_oxide-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+zlib-default-devel = " \
 cargo \
 rust-flate2+any_c_zlib-devel \
 rust-flate2-devel \
 rust-libz-sys+default-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-flate2+zlib-devel = " \
 cargo \
 rust-flate2+any_c_zlib-devel \
 rust-flate2+libz-sys-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+zlib-ng-devel = " \
 cargo \
 rust-flate2+any_c_zlib-devel \
 rust-flate2+libz-ng-sys-devel \
 rust-flate2-devel \
 "
RDEPENDS:rust-flate2+zlib-rs-devel = " \
 cargo \
 rust-flate2+any_zlib-devel \
 rust-flate2-devel \
 rust-zlib-rs+rust-allocator-devel \
 rust-zlib-rs+std-devel \
 rust-zlib-rs-devel \
 "
RDEPENDS:rust-flate2-devel = " \
 cargo \
 rust \
 rust-crc32fast+default-devel \
 "
