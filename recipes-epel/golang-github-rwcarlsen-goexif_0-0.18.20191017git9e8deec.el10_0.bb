# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-rwcarlsen-goexif"
PV = "0"
PR = "0.18.20191017git9e8deec.el10_0"
PACKAGES = " \
 golang-github-rwcarlsen-goexif \
 golang-github-rwcarlsen-goexif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-rwcarlsen-goexif-0-0.18.20191017git9e8deec.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a12b768cb7f8f0485371a5a3f8eaedfad2db9d9d1a337972e56ae3e7f1fb93d"

URI_aarch64_golang-github-rwcarlsen-goexif = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-rwcarlsen-goexif-0-0.18.20191017git9e8deec.el10_0.aarch64.rpm;name=aarch64_golang-github-rwcarlsen-goexif;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-rwcarlsen-goexif}"
SRC_URI[aarch64_golang-github-rwcarlsen-goexif.sha256sum] = "eb2ed49727c46623576e2ab22793540bc1a3452621de6a36365e3315a95762cf"

URI_aarch64_golang-github-rwcarlsen-goexif-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-rwcarlsen-goexif-devel-0-0.18.20191017git9e8deec.el10_0.noarch.rpm;name=aarch64_golang-github-rwcarlsen-goexif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-rwcarlsen-goexif-devel}"
SRC_URI[aarch64_golang-github-rwcarlsen-goexif-devel.sha256sum] = "68b8e907310a2ccf3487f7d542d6ca127bd6d63e83320615c9f6d4e79f2ca2f0"

RDEPENDS:golang-github-rwcarlsen-goexif = " \
 glibc \
 "
RDEPENDS:golang-github-rwcarlsen-goexif-devel = " \
 go-filesystem \
 "
