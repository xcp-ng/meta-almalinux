# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snafu-derive"
PV = "0.8.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-snafu-derive+default-devel \
 rust-snafu-derive+rust_1_61-devel \
 rust-snafu-derive+unstable-provider-api-devel \
 rust-snafu-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snafu-derive-0.8.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f706d7339b4b1ce34d82b1fb885f2e67cfaf7a904b4bf58ca227fd6a3917456d"

URI_x86_64_v2_rust-snafu-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive+default-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive+default-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive+default-devel.sha256sum] = "2d52b71a78f8037356fdde392f0d7966a0e8be84cd162f0541568a8ce6bdc847"

URI_x86_64_v2_rust-snafu-derive+rust_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive+rust_1_61-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive+rust_1_61-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive+rust_1_61-devel.sha256sum] = "400355b0cfb50edde31a25e66e0e9add02e2f8c4cc61788a7b337dc9a27b5509"

URI_x86_64_v2_rust-snafu-derive+unstable-provider-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive+unstable-provider-api-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive+unstable-provider-api-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive+unstable-provider-api-devel.sha256sum] = "61a2ebe2e53dc88fb3ab59804c15f7bef8d0bba169baca718451ed74660d7417"

URI_x86_64_v2_rust-snafu-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive-devel-0.8.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive-devel.sha256sum] = "4886019d3804dc445b576dfdcb405e2dfa807c0ae7ae7d2ce57f481e29faf19e"

URI_aarch64_rust-snafu-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive+default-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive+default-devel}"
SRC_URI[aarch64_rust-snafu-derive+default-devel.sha256sum] = "c929b79703705f9f4bd38f0e4645e730b9ebf574c4c30fe8b701a0e55706de8f"

URI_aarch64_rust-snafu-derive+rust_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive+rust_1_61-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu-derive+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive+rust_1_61-devel}"
SRC_URI[aarch64_rust-snafu-derive+rust_1_61-devel.sha256sum] = "0fdae6a8b394602b77708f9d0f1950fea0b95b9a6719bf4dfeda242294cc4c13"

URI_aarch64_rust-snafu-derive+unstable-provider-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive+unstable-provider-api-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu-derive+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive+unstable-provider-api-devel}"
SRC_URI[aarch64_rust-snafu-derive+unstable-provider-api-devel.sha256sum] = "d3f3549709b0eacb1fea36eb563cfa24c609c4f2e3cdbd4efc7ba3b418c9dd4d"

URI_aarch64_rust-snafu-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive-devel-0.8.9-1.el10_2.noarch.rpm;name=aarch64_rust-snafu-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive-devel}"
SRC_URI[aarch64_rust-snafu-derive-devel.sha256sum] = "94d2da5066f73b3cb95f016a4e5c50f17bbd70e0eb847ba9e0a7e3330befa199"

RDEPENDS:rust-snafu-derive+default-devel = " \
 cargo \
 rust-snafu-derive-devel \
 "
RDEPENDS:rust-snafu-derive+rust_1_61-devel = " \
 cargo \
 rust-snafu-derive-devel \
 "
RDEPENDS:rust-snafu-derive+unstable-provider-api-devel = " \
 cargo \
 rust-snafu-derive-devel \
 "
RDEPENDS:rust-snafu-derive-devel = " \
 cargo \
 rust \
 rust-heck-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
