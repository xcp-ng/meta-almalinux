# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-nl"
PV = "2.20.19"
PR = "15.el10"
PACKAGES = " \
 hunspell-nl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-nl-2.20.19-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "531154c7ad7b0a5279039b9dfd0bf208c1aa70c50d55a2ee4947afbaad2d4a8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-nl-2.20.19-15.el10.noarch.rpm;name=x86_64_v2_hunspell-nl;unpack=0"
SRC_URI[x86_64_v2_hunspell-nl.sha256sum] = "b5c6c169fd5ad4183419ccefa1b71651dd62169efce8a693b972dc959c2e2127"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-nl-2.20.19-15.el10.noarch.rpm;name=aarch64_hunspell-nl;unpack=0"
SRC_URI[aarch64_hunspell-nl.sha256sum] = "b5c6c169fd5ad4183419ccefa1b71651dd62169efce8a693b972dc959c2e2127"

RDEPENDS:hunspell-nl = " \
 hunspell \
 "
