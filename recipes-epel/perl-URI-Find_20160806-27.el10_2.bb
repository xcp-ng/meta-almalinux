# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-URI-Find"
PV = "20160806"
PR = "27.el10_2"
PACKAGES = " \
 perl-URI-Find \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-URI-Find-20160806-27.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ae77740a5aefca8277f4d16dcdf64e0e6820c98484f5b560a3bedd66c93306e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-URI-Find-20160806-27.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-URI-Find;unpack=0"
SRC_URI[x86_64_v2_perl-URI-Find.sha256sum] = "d47c1f2b7458e9d041945f4f4044fdcef529fa7b1b636e095b9ac319fd956cce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-URI-Find-20160806-27.el10_2.noarch.rpm;name=aarch64_perl-URI-Find;unpack=0"
SRC_URI[aarch64_perl-URI-Find.sha256sum] = "a3bc46de85dd51632124491ce40b0c2a6dd042bd4bf158132fb16f0e856c8d6d"

RDEPENDS:perl-URI-Find = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-URI \
 perl-URI-Find \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
