# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtdb"
PV = "1.4.12"
PR = "102.el10"
PACKAGES = " \
 libtdb \
 libtdb-devel \
 python3-tdb \
 tdb-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtdb-1.4.12-102.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22955a21d46ea5c0362fc4f9038cc61ccb31c5b28ee250fbb092fdd633042c81"

URI_x86_64_v2_libtdb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtdb-1.4.12-102.el10.x86_64_v2.rpm;name=x86_64_v2_libtdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtdb}"
SRC_URI[x86_64_v2_libtdb.sha256sum] = "d2db2920fbaafe06d9ef30b367aba07524d459a92f78d1b4e70dafbd711cda07"

URI_x86_64_v2_libtdb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtdb-devel-1.4.12-102.el10.x86_64_v2.rpm;name=x86_64_v2_libtdb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtdb-devel}"
SRC_URI[x86_64_v2_libtdb-devel.sha256sum] = "6e2b7731be4b11dd3e6e243d5d8fe4f16e0a736074c3c7f1809f6091aad70e31"

URI_x86_64_v2_python3-tdb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-tdb-1.4.12-102.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tdb}"
SRC_URI[x86_64_v2_python3-tdb.sha256sum] = "742a0283aa85d7c18c02205fd0f9654323bdaf8d9174458b456c054dc9cb7bdc"

URI_x86_64_v2_tdb-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tdb-tools-1.4.12-102.el10.x86_64_v2.rpm;name=x86_64_v2_tdb-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tdb-tools}"
SRC_URI[x86_64_v2_tdb-tools.sha256sum] = "8a9e788341fd207033f814d7e4a88fe536476c16cb5bd46c3626f5ec652b0237"

URI_aarch64_libtdb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtdb-1.4.12-102.el10.aarch64.rpm;name=aarch64_libtdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtdb}"
SRC_URI[aarch64_libtdb.sha256sum] = "28e200bca26a5e2f77087866cf83af7e3c07806a489f00000969f3bd7b672d42"

URI_aarch64_libtdb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtdb-devel-1.4.12-102.el10.aarch64.rpm;name=aarch64_libtdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtdb-devel}"
SRC_URI[aarch64_libtdb-devel.sha256sum] = "35ec9fa04778ccfda9287ea57f85de24456b875c75cc6f46ef6392f9547544f7"

URI_aarch64_python3-tdb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-tdb-1.4.12-102.el10.aarch64.rpm;name=aarch64_python3-tdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tdb}"
SRC_URI[aarch64_python3-tdb.sha256sum] = "10bc14b477db6ff3b59187bce756faec06668432c53764d4e1db3184b138d0f4"

URI_aarch64_tdb-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tdb-tools-1.4.12-102.el10.aarch64.rpm;name=aarch64_tdb-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_tdb-tools}"
SRC_URI[aarch64_tdb-tools.sha256sum] = "976d1aa6e4c437ea551cddc918a6bd7696fc58e411977c3678306fb911ab7539"

RDEPENDS:libtdb = " \
 glibc \
 "
RDEPENDS:libtdb-devel = " \
 libtdb \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-tdb = " \
 glibc \
 libtdb \
 python3 \
 "
RDEPENDS:tdb-tools = " \
 glibc \
 libtdb \
 "
