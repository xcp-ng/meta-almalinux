# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "adobe-mappings-pdf"
PV = "20190401"
PR = "9.el10"
PACKAGES = " \
 adobe-mappings-pdf \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/adobe-mappings-pdf-20190401-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c6760450525c884de852ce3c52ef1dde23ef7aba56b9dd4af4c4ea9c77cd21cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/adobe-mappings-pdf-20190401-9.el10.noarch.rpm;name=x86_64_v2_adobe-mappings-pdf;unpack=0"
SRC_URI[x86_64_v2_adobe-mappings-pdf.sha256sum] = "6df62e10e4115584ac7e3bc135f61e3ddf4b82e5cda71c3f8033410584506996"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/adobe-mappings-pdf-20190401-9.el10.noarch.rpm;name=aarch64_adobe-mappings-pdf;unpack=0"
SRC_URI[aarch64_adobe-mappings-pdf.sha256sum] = "6df62e10e4115584ac7e3bc135f61e3ddf4b82e5cda71c3f8033410584506996"

RDEPENDS:adobe-mappings-pdf = " \
 "
