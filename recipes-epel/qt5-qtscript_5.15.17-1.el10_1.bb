# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtscript"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtscript \
 qt5-qtscript-devel \
 qt5-qtscript-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtscript-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6eeccdba0b614657fcb5d4595ba706775b7372acfb7f442a6e721a460a0da43"

URI_x86_64_v2_qt5-qtscript = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscript-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscript}"
SRC_URI[x86_64_v2_qt5-qtscript.sha256sum] = "3ad26aacf9b0cb7daca313db987faeb5ba650258bfd43baf88d2de3869678f72"

URI_x86_64_v2_qt5-qtscript-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscript-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscript-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscript-devel}"
SRC_URI[x86_64_v2_qt5-qtscript-devel.sha256sum] = "bb5e710253e65bc9a00aaa38f1896f6b564c84b3049a42374d3a6b1049bbffa5"

URI_x86_64_v2_qt5-qtscript-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtscript-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtscript-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtscript-examples}"
SRC_URI[x86_64_v2_qt5-qtscript-examples.sha256sum] = "daaa3357475dc63aaa56330c580e9fd0d5be3ccf615108094dfcf2954b450fa5"

URI_aarch64_qt5-qtscript = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscript-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscript}"
SRC_URI[aarch64_qt5-qtscript.sha256sum] = "5e429b5db7912ee04a82d3ed0d513a5189a189d4134b7d5b258cb1a3c79914e3"

URI_aarch64_qt5-qtscript-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscript-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtscript-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscript-devel}"
SRC_URI[aarch64_qt5-qtscript-devel.sha256sum] = "19b2d39853924b221e69b0c0dbb72f025b947dbdbaf5c44d43c2cc23f61d673f"

URI_aarch64_qt5-qtscript-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtscript-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtscript-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtscript-examples}"
SRC_URI[aarch64_qt5-qtscript-examples.sha256sum] = "0b5934a6923423b66e0bdd795b3f298f24252083b65df3d5d67e5e7d55f6c6c8"

RDEPENDS:qt5-qtscript:x86_64_v2 = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtscript:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtscript-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtscript \
 "
RDEPENDS:qt5-qtscript-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtscript \
 "
