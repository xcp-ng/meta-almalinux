# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yyjson"
PV = "0.12.0"
PR = "1.el10_2"
PACKAGES = " \
 yyjson \
 yyjson-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yyjson-0.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f5f465e57177f786311a2df123474671b7238c9f8d7ecf6c9afb504fb78150d"

URI_x86_64_v2_yyjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yyjson-0.12.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yyjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yyjson}"
SRC_URI[x86_64_v2_yyjson.sha256sum] = "2bc3b6b8e1a21caf5e2030e75627c75205965e37cef8ec0897d19dd4dd39df1d"

URI_x86_64_v2_yyjson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yyjson-devel-0.12.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yyjson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yyjson-devel}"
SRC_URI[x86_64_v2_yyjson-devel.sha256sum] = "dedd2c3c73ef964b0536e58da082b61ebf92ecc29cb2442b195287add28b3988"

URI_aarch64_yyjson = "${EPEL_MIRROR}/aarch64/Packages/y/yyjson-0.12.0-1.el10_2.aarch64.rpm;name=aarch64_yyjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_yyjson}"
SRC_URI[aarch64_yyjson.sha256sum] = "f6def88da8bff5728c86c002237f1574e7d1dd246d84953a94217ccb0e12cbf6"

URI_aarch64_yyjson-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yyjson-devel-0.12.0-1.el10_2.aarch64.rpm;name=aarch64_yyjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yyjson-devel}"
SRC_URI[aarch64_yyjson-devel.sha256sum] = "c4d0e993c4849aad7caf65de047149ec0438614e67e2363a11344550cbcf0e02"

RDEPENDS:yyjson = " \
 glibc \
 "
RDEPENDS:yyjson-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 yyjson \
 "
