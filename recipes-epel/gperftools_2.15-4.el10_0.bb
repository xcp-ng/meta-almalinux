# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gperftools"
PV = "2.15"
PR = "4.el10_0"
PACKAGES = " \
 gperftools \
 gperftools-devel \
 gperftools-libs \
 pprof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gperftools-2.15-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a8bdca8b7638baca964a26582b7c036dbfdc8da3cba12736d11b5a5f5dbc6ae"

URI_x86_64_v2_gperftools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gperftools-2.15-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gperftools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gperftools}"
SRC_URI[x86_64_v2_gperftools.sha256sum] = "83c7291364de4fc9726fc0a8a7fddb040356ef40c73d635634a739f1c8750ab6"

URI_x86_64_v2_gperftools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gperftools-devel-2.15-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gperftools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gperftools-devel}"
SRC_URI[x86_64_v2_gperftools-devel.sha256sum] = "99ae8178e4084482a77eb0c45a8ebfb42d97e267aa122eb6b3407e91c80e49e9"

URI_x86_64_v2_gperftools-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gperftools-libs-2.15-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gperftools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gperftools-libs}"
SRC_URI[x86_64_v2_gperftools-libs.sha256sum] = "55ddebfe8939baa87c2ec9501e31fefc913e0c87b6967496042271b7e7c2f459"

URI_x86_64_v2_pprof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pprof-2.15-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pprof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pprof}"
SRC_URI[x86_64_v2_pprof.sha256sum] = "1b91ea7bee38b1d282a7693b665771f2a67d596e5b12b975cab87601c054c1b4"

URI_aarch64_gperftools = "${EPEL_MIRROR}/aarch64/Packages/g/gperftools-2.15-4.el10_0.aarch64.rpm;name=aarch64_gperftools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gperftools}"
SRC_URI[aarch64_gperftools.sha256sum] = "089d96a4c0b7b925adf8ddf80244d68e311bdb22110c1ac06f4c7dde6138cf81"

URI_aarch64_gperftools-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gperftools-devel-2.15-4.el10_0.aarch64.rpm;name=aarch64_gperftools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gperftools-devel}"
SRC_URI[aarch64_gperftools-devel.sha256sum] = "7e416e3554e2f525dfaa1d232177104f36356eb27b89129f257676df132d4146"

URI_aarch64_gperftools-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gperftools-libs-2.15-4.el10_0.aarch64.rpm;name=aarch64_gperftools-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gperftools-libs}"
SRC_URI[aarch64_gperftools-libs.sha256sum] = "3709bc96cfe6d8aa66eb0466837814183b3dd181096112c5ef56b9165affdf80"

URI_aarch64_pprof = "${EPEL_MIRROR}/aarch64/Packages/p/pprof-2.15-4.el10_0.noarch.rpm;name=aarch64_pprof;unpack=0"
SRC_URI:append = " ${URI_aarch64_pprof}"
SRC_URI[aarch64_pprof.sha256sum] = "9fab1d8817eefb8575c58a4e68d57febabdfeebc8fca446c4eae16a08640f20b"

RDEPENDS:gperftools = " \
 gperftools-devel \
 pprof \
 "
RDEPENDS:gperftools-devel = " \
 gperftools-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gperftools-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libunwind \
 "
RDEPENDS:pprof = " \
 graphviz \
 gv \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 "
