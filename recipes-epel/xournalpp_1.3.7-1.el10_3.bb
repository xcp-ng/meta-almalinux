# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xournalpp"
PV = "1.3.7"
PR = "1.el10_3"
PACKAGES = " \
 xournalpp \
 xournalpp-plugins \
 xournalpp-ui \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xournalpp-1.3.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "508d8fa33c8c2b87667c944c2f2eb6f827c1c19ac97f45b023896cab39cf9320"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-1.3.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xournalpp;unpack=0"
SRC_URI[x86_64_v2_xournalpp.sha256sum] = "ea4dc22bc1f81b7b7685ed05af64c7a138c677bdc15694db6241788d65effd16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-plugins-1.3.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_xournalpp-plugins;unpack=0"
SRC_URI[x86_64_v2_xournalpp-plugins.sha256sum] = "e50c4be87f7dcae01dbd2279d35f8801e3c7eaaa24a0afba4e324638e9d03823"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xournalpp-ui-1.3.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_xournalpp-ui;unpack=0"
SRC_URI[x86_64_v2_xournalpp-ui.sha256sum] = "421783581f1837b3e7210352d8ace891f3d5d8b05a99239edf9ca2859d0c8b69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-1.3.7-1.el10_3.aarch64.rpm;name=aarch64_xournalpp;unpack=0"
SRC_URI[aarch64_xournalpp.sha256sum] = "4310df3331dbe096171597eae5deff361995c1207ae27657c4e1dd0540d6ac1f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-plugins-1.3.7-1.el10_3.noarch.rpm;name=aarch64_xournalpp-plugins;unpack=0"
SRC_URI[aarch64_xournalpp-plugins.sha256sum] = "82d564e3904cabb6871b40f9cf80c945fa78c81ec745592e1b4919c0250b555b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xournalpp-ui-1.3.7-1.el10_3.noarch.rpm;name=aarch64_xournalpp-ui;unpack=0"
SRC_URI[aarch64_xournalpp-ui.sha256sum] = "509530324efd13ba90508f79e78f256c1e4bbd8c0c021881eb2d775683e6315c"

RDEPENDS:xournalpp = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gperftools-libs \
 gtk3 \
 gtksourceview4 \
 hicolor-icon-theme \
 libX11 \
 libXi \
 libgcc \
 librsvg2 \
 libsndfile \
 libstdc++ \
 libxml2 \
 libzip \
 lua-libs \
 pango \
 poppler-glib \
 portaudio \
 qpdf-libs \
 xournalpp-plugins \
 xournalpp-ui \
 zlib-ng-compat \
 "
RDEPENDS:xournalpp-plugins = " \
 "
RDEPENDS:xournalpp-ui = " \
 "
