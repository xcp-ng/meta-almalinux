# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vnstat"
PV = "2.13"
PR = "1.el10_2"
PACKAGES = " \
 vnstat \
 vnstat-vnstati \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vnstat-2.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f141e05c48a09b8c100c822d84f5633079155174e2f360e9933b2e27b1e4ed65"

URI_x86_64_v2_vnstat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vnstat-2.13-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vnstat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vnstat}"
SRC_URI[x86_64_v2_vnstat.sha256sum] = "97f3ad1c67bc8d0972353d40f61b4b1499602d3467f86edf1dbeb5f55d1f15d3"

URI_x86_64_v2_vnstat-vnstati = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vnstat-vnstati-2.13-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vnstat-vnstati;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vnstat-vnstati}"
SRC_URI[x86_64_v2_vnstat-vnstati.sha256sum] = "d1ef39331a0fad12e063c52b0301b77813b3c97dbd5ff8a7653e19badfc03d58"

URI_aarch64_vnstat = "${EPEL_MIRROR}/aarch64/Packages/v/vnstat-2.13-1.el10_2.aarch64.rpm;name=aarch64_vnstat;unpack=0"
SRC_URI:append = " ${URI_aarch64_vnstat}"
SRC_URI[aarch64_vnstat.sha256sum] = "6b1837f961ccc1661472397726cf98d7cef1698eba7af0e440890be9759ae88a"

URI_aarch64_vnstat-vnstati = "${EPEL_MIRROR}/aarch64/Packages/v/vnstat-vnstati-2.13-1.el10_2.aarch64.rpm;name=aarch64_vnstat-vnstati;unpack=0"
SRC_URI:append = " ${URI_aarch64_vnstat-vnstati}"
SRC_URI[aarch64_vnstat-vnstati.sha256sum] = "356fdb6b1f4bfc6cc65e2a05308879db2b4bac003fc284f82b9c8535f1f93c70"

RDEPENDS:vnstat = " \
 bash \
 glibc \
 sqlite-libs \
 systemd \
 "
RDEPENDS:vnstat-vnstati = " \
 gd \
 glibc \
 sqlite-libs \
 "
