# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive_builder_core"
PV = "0.20.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-derive_builder_core+alloc-devel \
 rust-derive_builder_core+default-devel \
 rust-derive_builder_core+lib_has_std-devel \
 rust-derive_builder_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive_builder_core-0.20.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ccf3604f5932f60e8631b3aa4fcc8ef69e1c49edd0d0beab987fbcf3a24be0a1"

URI_x86_64_v2_rust-derive_builder_core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder_core+alloc-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder_core+alloc-devel}"
SRC_URI[x86_64_v2_rust-derive_builder_core+alloc-devel.sha256sum] = "1289864556879b579930b1ca37b299a36578b70ac0e4e9e861a440b651af132c"

URI_x86_64_v2_rust-derive_builder_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder_core+default-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder_core+default-devel}"
SRC_URI[x86_64_v2_rust-derive_builder_core+default-devel.sha256sum] = "ba7d715765b987762c240b4949ee647165abf676e1428c39f5e0335119ec5f17"

URI_x86_64_v2_rust-derive_builder_core+lib_has_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder_core+lib_has_std-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder_core+lib_has_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder_core+lib_has_std-devel}"
SRC_URI[x86_64_v2_rust-derive_builder_core+lib_has_std-devel.sha256sum] = "d0bb725951c2f14744c6d7b50a5d61426b915148ed1b59bcfa943e7051ecdbb6"

URI_x86_64_v2_rust-derive_builder_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder_core-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder_core-devel}"
SRC_URI[x86_64_v2_rust-derive_builder_core-devel.sha256sum] = "657e00a5091aa205cda45540308f4c7448cc1db739f7a6b1c6d0ff78a10e0f32"

URI_aarch64_rust-derive_builder_core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder_core+alloc-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder_core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder_core+alloc-devel}"
SRC_URI[aarch64_rust-derive_builder_core+alloc-devel.sha256sum] = "e02f20f6d9d4b9c08b158904546c024d3ccba0e954d04ad44ed26684b50f384f"

URI_aarch64_rust-derive_builder_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder_core+default-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder_core+default-devel}"
SRC_URI[aarch64_rust-derive_builder_core+default-devel.sha256sum] = "b3aeece62fea9a6c884cef53b08a43686df12e2cd6f98113884c79da5bd47de2"

URI_aarch64_rust-derive_builder_core+lib_has_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder_core+lib_has_std-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder_core+lib_has_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder_core+lib_has_std-devel}"
SRC_URI[aarch64_rust-derive_builder_core+lib_has_std-devel.sha256sum] = "f96f9ea045e6f12d4ce2b67f1c331f50d5d27210786c3900f9f9e1bddffc35a9"

URI_aarch64_rust-derive_builder_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder_core-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder_core-devel}"
SRC_URI[aarch64_rust-derive_builder_core-devel.sha256sum] = "af81c83211a28f5fca265b2bce13f0db7dde6308ea5e2f0e72cc0d4cad3c63d1"

RDEPENDS:rust-derive_builder_core+alloc-devel = " \
 cargo \
 rust-derive_builder_core-devel \
 "
RDEPENDS:rust-derive_builder_core+default-devel = " \
 cargo \
 rust-derive_builder_core-devel \
 "
RDEPENDS:rust-derive_builder_core+lib_has_std-devel = " \
 cargo \
 rust-derive_builder_core-devel \
 "
RDEPENDS:rust-derive_builder_core-devel = " \
 cargo \
 rust-darling+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
