# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-flit-core"
PV = "3.12.0"
PR = "6.el10"
PACKAGES = " \
 python3.14-flit-core \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-flit-core-3.12.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cb6fd911b27e3458cd4c7b18e88387cd2f3d1fdb8313f87dfa83973f7a226baf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-flit-core-3.12.0-6.el10.noarch.rpm;name=x86_64_v2_python3.14-flit-core;unpack=0"
SRC_URI[x86_64_v2_python3.14-flit-core.sha256sum] = "b3eb8cf1269688ea22249c59a0789abb7f27aa09cfecbf944ed8a5465a77ac10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-flit-core-3.12.0-6.el10.noarch.rpm;name=aarch64_python3.14-flit-core;unpack=0"
SRC_URI[aarch64_python3.14-flit-core.sha256sum] = "b3eb8cf1269688ea22249c59a0789abb7f27aa09cfecbf944ed8a5465a77ac10"

RDEPENDS:python3.14-flit-core = " \
 python3.14 \
 "
