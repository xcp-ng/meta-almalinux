# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-native-certs"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustls-native-certs+default-devel \
 rust-rustls-native-certs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-native-certs-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ada6e6519d3669fd88856dafc7de82d0700ace2f69cee7e609a95b8820ea47ee"

URI_x86_64_v2_rust-rustls-native-certs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-native-certs+default-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-native-certs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-native-certs+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-native-certs+default-devel.sha256sum] = "c34478910d90b24fba11fec96fbe2ee96e18aafa17c2a9e0430ba39cb21e6b59"

URI_x86_64_v2_rust-rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-native-certs-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-rustls-native-certs-devel.sha256sum] = "13ca9399912bc9ad487e06ae6cbcf2242dbce17e451d89b1c91559a42c39f49c"

URI_aarch64_rust-rustls-native-certs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-native-certs+default-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-native-certs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-native-certs+default-devel}"
SRC_URI[aarch64_rust-rustls-native-certs+default-devel.sha256sum] = "dfaeb998ffd003da4365840963bb691b654de58857305ada32d90f7c25d69693"

URI_aarch64_rust-rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-native-certs-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-native-certs-devel}"
SRC_URI[aarch64_rust-rustls-native-certs-devel.sha256sum] = "3db80a33b60c380781b85a9cc8700b54865befc3951b75ae2b26094a4ac585cc"

RDEPENDS:rust-rustls-native-certs+default-devel = " \
 cargo \
 rust-rustls-native-certs-devel \
 "
RDEPENDS:rust-rustls-native-certs-devel = " \
 cargo \
 rust \
 rust-openssl-probe+default-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 "
