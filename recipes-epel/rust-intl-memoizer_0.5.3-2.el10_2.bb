# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-intl-memoizer"
PV = "0.5.3"
PR = "2.el10_2"
PACKAGES = " \
 rust-intl-memoizer+default-devel \
 rust-intl-memoizer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-intl-memoizer-0.5.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf18d43fccd25e5640809afcc2e1b102a541dfe27b5168a1f24d9ac74932b5b5"

URI_x86_64_v2_rust-intl-memoizer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intl-memoizer+default-devel-0.5.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intl-memoizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intl-memoizer+default-devel}"
SRC_URI[x86_64_v2_rust-intl-memoizer+default-devel.sha256sum] = "f0806cdd3fadf44138bedae7f6ef7cc1e264ef639ceaf34f2a83590382689c34"

URI_x86_64_v2_rust-intl-memoizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intl-memoizer-devel-0.5.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intl-memoizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intl-memoizer-devel}"
SRC_URI[x86_64_v2_rust-intl-memoizer-devel.sha256sum] = "448171950b407036470b8bb58b4b12cea1e4279b3aa2970949ca5a65d2bebda0"

URI_aarch64_rust-intl-memoizer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intl-memoizer+default-devel-0.5.3-2.el10_2.noarch.rpm;name=aarch64_rust-intl-memoizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intl-memoizer+default-devel}"
SRC_URI[aarch64_rust-intl-memoizer+default-devel.sha256sum] = "3384a34568772a5585fb8380e7eecba7d84bc9644f9f2347e165fc7b01d56fc9"

URI_aarch64_rust-intl-memoizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intl-memoizer-devel-0.5.3-2.el10_2.noarch.rpm;name=aarch64_rust-intl-memoizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intl-memoizer-devel}"
SRC_URI[aarch64_rust-intl-memoizer-devel.sha256sum] = "5094f9f52c654dac086d190bcf99a25a956efcf9b7d4b083a8dc3c96e09684e5"

RDEPENDS:rust-intl-memoizer+default-devel = " \
 cargo \
 rust-intl-memoizer-devel \
 "
RDEPENDS:rust-intl-memoizer-devel = " \
 cargo \
 rust \
 rust-type-map+default-devel \
 rust-unic-langid+default-devel \
 "
