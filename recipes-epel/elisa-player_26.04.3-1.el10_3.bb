# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elisa-player"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 elisa-player \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/elisa-player-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1afb9adb1cae3f7450f55fc3f1ba94d265372e8ed04ee14cf48f42c74ede38b4"

URI_x86_64_v2_elisa-player = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/elisa-player-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_elisa-player;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elisa-player}"
SRC_URI[x86_64_v2_elisa-player.sha256sum] = "7482e60111bf4870f1f65dacc86b8a02f48cb8a9f9971ccdcb990dace31fa223"

URI_aarch64_elisa-player = "${EPEL_MIRROR}/aarch64/Packages/e/elisa-player-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_elisa-player;unpack=0"
SRC_URI:append = " ${URI_aarch64_elisa-player}"
SRC_URI[aarch64_elisa-player.sha256sum] = "b6a638eff974dbf766dd4bd181e5bd7811007a616d26c15d0fe87f6c6ccac1a3"

RDEPENDS:elisa-player = " \
 dbus-common \
 glibc \
 hicolor-icon-theme \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kitemviews \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
