# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kompare"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kompare \
 kompare-devel \
 kompare-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kompare-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f23831da1b54fbfb7c83d29040c9f798a9a23fa24587d85bbb08352dc27807f"

URI_x86_64_v2_kompare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare}"
SRC_URI[x86_64_v2_kompare.sha256sum] = "d77cf4cda631b2f7615fd7b3c077659e6696903f23a28f27e46ec25809422f61"

URI_x86_64_v2_kompare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare-devel}"
SRC_URI[x86_64_v2_kompare-devel.sha256sum] = "d862e08e53bdcaac1836275f6e0a5aa4dfc03a3ccdd20ddd57d2a80c884d0452"

URI_x86_64_v2_kompare-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare-libs}"
SRC_URI[x86_64_v2_kompare-libs.sha256sum] = "03781b8f84262c7a995139941c112802bfa29745298a2ada03a52b085b95bb83"

URI_aarch64_kompare = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kompare;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare}"
SRC_URI[aarch64_kompare.sha256sum] = "1fe22608f4721e5ebd11c009531444381430a1ee16a573832c62d7a2d61ceb9f"

URI_aarch64_kompare-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kompare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare-devel}"
SRC_URI[aarch64_kompare-devel.sha256sum] = "dc39b4f68d3f3243251826612aba14cc09b1b3e54e0189412abb98e2b1c7a93c"

URI_aarch64_kompare-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kompare-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare-libs}"
SRC_URI[aarch64_kompare-libs.sha256sum] = "a465abf204e63ee8c26a8a3cd20d6f9abb76ec073edd139fdcd2d2669d89d578"

RDEPENDS:kompare = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kompare-libs \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kompare-devel = " \
 kompare-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kompare-libs = " \
 glibc \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
