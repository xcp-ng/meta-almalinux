# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keysmith"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 keysmith \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/keysmith-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cd9d3f181b46c2f06d065e23a2d6d75bb0b350b42cd181fef482dfe21fbe76ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keysmith-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keysmith;unpack=0"
SRC_URI[x86_64_v2_keysmith.sha256sum] = "6b586ee066add2de44ed046ca9703432a6f39fb4e81abd845168cb3a5e569d70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/keysmith-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_keysmith;unpack=0"
SRC_URI[aarch64_keysmith.sha256sum] = "0313707529ca63f1415fde5c77e830751ed84e509bc4980f57e3ca632c8cc798"

RDEPENDS:keysmith = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-qqc2-desktop-style \
 libsodium \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
