# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cryptsetup"
PV = "2.8.6"
PR = "1.el10"
PACKAGES = " \
 cryptsetup \
 cryptsetup-devel \
 cryptsetup-libs \
 integritysetup \
 veritysetup \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cryptsetup-2.8.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a4ebc3dde42467ba0ba987c57b290b54ece2be872c52d8a4c1ebbc16404b0ca"

URI_x86_64_v2_cryptsetup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cryptsetup-2.8.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptsetup}"
SRC_URI[x86_64_v2_cryptsetup.sha256sum] = "3125c64dd73c550f4addde20a9a3010ed9f142e23836e36217448c029270ffd7"

URI_x86_64_v2_cryptsetup-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cryptsetup-devel-2.8.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptsetup-devel}"
SRC_URI[x86_64_v2_cryptsetup-devel.sha256sum] = "2004c8540ac06f2aac5d2ccdb237adf9f9c240ae6024e3139ece37c07d804e20"

URI_x86_64_v2_cryptsetup-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cryptsetup-libs-2.8.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptsetup-libs}"
SRC_URI[x86_64_v2_cryptsetup-libs.sha256sum] = "bc70dc10a864b7a154d1e37f8576bcd4daa5d9328dc7ec113bfa199be39c5499"

URI_x86_64_v2_integritysetup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/integritysetup-2.8.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_integritysetup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_integritysetup}"
SRC_URI[x86_64_v2_integritysetup.sha256sum] = "bc9450a14beabb11b4c6e44cb41f7cd8c291a8ab2576a6ae6d4cfbce8e05d4ff"

URI_x86_64_v2_veritysetup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/veritysetup-2.8.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_veritysetup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_veritysetup}"
SRC_URI[x86_64_v2_veritysetup.sha256sum] = "cf85c12c32cde6d37a7122bb7068ac9b907cbcb0c0f63e664098418e68aec6ea"

URI_aarch64_cryptsetup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cryptsetup-2.8.6-1.el10.aarch64.rpm;name=aarch64_cryptsetup;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptsetup}"
SRC_URI[aarch64_cryptsetup.sha256sum] = "d70bb128cc7591a44a9d9f35ee2a1305f82338abe280f2952f7cbf1d4dfa9a4b"

URI_aarch64_cryptsetup-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cryptsetup-devel-2.8.6-1.el10.aarch64.rpm;name=aarch64_cryptsetup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptsetup-devel}"
SRC_URI[aarch64_cryptsetup-devel.sha256sum] = "0addddbe0c9856e418ef4bf5ba7dcad22e9f6bf5db6d56828ec9ef041752ce56"

URI_aarch64_cryptsetup-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cryptsetup-libs-2.8.6-1.el10.aarch64.rpm;name=aarch64_cryptsetup-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptsetup-libs}"
SRC_URI[aarch64_cryptsetup-libs.sha256sum] = "2e93dd4144f6d2b66df708c63f82ab31c9d717b55bd6bfe88afc94be7702d73e"

URI_aarch64_integritysetup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/integritysetup-2.8.6-1.el10.aarch64.rpm;name=aarch64_integritysetup;unpack=0"
SRC_URI:append = " ${URI_aarch64_integritysetup}"
SRC_URI[aarch64_integritysetup.sha256sum] = "c34fb55b7e0e89728f496dfc9bd06f965b7fa625c691a8e532f8980530ebd270"

URI_aarch64_veritysetup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/veritysetup-2.8.6-1.el10.aarch64.rpm;name=aarch64_veritysetup;unpack=0"
SRC_URI:append = " ${URI_aarch64_veritysetup}"
SRC_URI[aarch64_veritysetup.sha256sum] = "27f96bbc518e64043d700c903d7c4a0dd6d809e655cabeeba73083ef533f3641"

RDEPENDS:cryptsetup = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libpwquality \
 libuuid \
 popt \
 "
RDEPENDS:cryptsetup-devel = " \
 cryptsetup-libs \
 device-mapper-devel \
 json-c-devel \
 libblkid-devel \
 libuuid-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:cryptsetup-libs = " \
 device-mapper-libs \
 glibc \
 json-c \
 libblkid \
 libuuid \
 openssl-libs \
 "
RDEPENDS:integritysetup = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libuuid \
 popt \
 "
RDEPENDS:veritysetup = " \
 cryptsetup-libs \
 glibc \
 popt \
 "
