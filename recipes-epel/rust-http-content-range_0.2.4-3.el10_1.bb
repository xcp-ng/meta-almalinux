# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-content-range"
PV = "0.2.4"
PR = "3.el10_1"
PACKAGES = " \
 rust-http-content-range+default-devel \
 rust-http-content-range-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-content-range-0.2.4-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64de677e87427f9376b33b73817b04ea8953a6f8fcfa1ab192502ab39a3b5a80"

URI_x86_64_v2_rust-http-content-range+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-content-range+default-devel-0.2.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-content-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-content-range+default-devel}"
SRC_URI[x86_64_v2_rust-http-content-range+default-devel.sha256sum] = "b94a84a0980e228932c2f1cc54ff88e7c39065b519b2e0b76c26b3a70f9e4074"

URI_x86_64_v2_rust-http-content-range-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-content-range-devel-0.2.4-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-content-range-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-content-range-devel}"
SRC_URI[x86_64_v2_rust-http-content-range-devel.sha256sum] = "92a8d09b766a33d440b2cc4db6b421688bcc3fb975a977ccde8b31126c12b2be"

URI_aarch64_rust-http-content-range+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-content-range+default-devel-0.2.4-3.el10_1.noarch.rpm;name=aarch64_rust-http-content-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-content-range+default-devel}"
SRC_URI[aarch64_rust-http-content-range+default-devel.sha256sum] = "30dad9067784d301e9b84463654b6386c3f44346a1d9b711888d1282820f0d6c"

URI_aarch64_rust-http-content-range-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-content-range-devel-0.2.4-3.el10_1.noarch.rpm;name=aarch64_rust-http-content-range-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-content-range-devel}"
SRC_URI[aarch64_rust-http-content-range-devel.sha256sum] = "91ced41379c4db442dd11a981826e67369150d190a1153709e8b2cead9e49b87"

RDEPENDS:rust-http-content-range+default-devel = " \
 cargo \
 rust-http-content-range-devel \
 "
RDEPENDS:rust-http-content-range-devel = " \
 cargo \
 rust \
 "
