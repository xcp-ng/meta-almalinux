# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ssh2"
PV = "1.5.0"
PR = "2.el10_2"
PACKAGES = " \
 php-pecl-ssh2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ssh2-1.5.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e8f751e2e0c790c0c7ff8265c4fee526408c27307bcd78398bff827a8608e14"

URI_x86_64_v2_php-pecl-ssh2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ssh2-1.5.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ssh2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-ssh2}"
SRC_URI[x86_64_v2_php-pecl-ssh2.sha256sum] = "6f118b49ab3b23a19705e7dfb1406440d6d13b58fa2b6a51f0952b99b26171a1"

URI_aarch64_php-pecl-ssh2 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ssh2-1.5.0-2.el10_2.aarch64.rpm;name=aarch64_php-pecl-ssh2;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-ssh2}"
SRC_URI[aarch64_php-pecl-ssh2.sha256sum] = "367af88d7e1ad0d284aa55c45433a9509ddd1c8d4f96097aa792a93969999b8b"

RDEPENDS:php-pecl-ssh2 = " \
 glibc \
 libssh2 \
 php-common \
 "
