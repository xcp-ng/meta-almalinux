# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-mime-types"
PV = "0.1.2.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-mime-types \
 ghc-mime-types-devel \
 ghc-mime-types-doc \
 ghc-mime-types-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-mime-types-0.1.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89754b8a7291d5c55e04dbac948a64096f7eb4145052e7c65e589919e78beb23"

URI_x86_64_v2_ghc-mime-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mime-types-0.1.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mime-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mime-types}"
SRC_URI[x86_64_v2_ghc-mime-types.sha256sum] = "674d24d2e510f4fc9048f00b28d42c7f79986f267a2bb5e617cad7678b169460"

URI_x86_64_v2_ghc-mime-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mime-types-devel-0.1.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mime-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mime-types-devel}"
SRC_URI[x86_64_v2_ghc-mime-types-devel.sha256sum] = "cfe1ee1b23236cf3e9f72cefbfadea4e0e7fe73345536035b2e792621f11b8d5"

URI_x86_64_v2_ghc-mime-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mime-types-doc-0.1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-mime-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mime-types-doc}"
SRC_URI[x86_64_v2_ghc-mime-types-doc.sha256sum] = "92af5e89a83a2803148a922842eeb8d9437fa6ddafb1bbddf2660bd73179f2be"

URI_x86_64_v2_ghc-mime-types-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mime-types-prof-0.1.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mime-types-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mime-types-prof}"
SRC_URI[x86_64_v2_ghc-mime-types-prof.sha256sum] = "b345e7e38c6e4bf2726c4883c7d299420a8afc361f70505ab694c27849e86519"

URI_aarch64_ghc-mime-types = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mime-types-0.1.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-mime-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mime-types}"
SRC_URI[aarch64_ghc-mime-types.sha256sum] = "d6357805e1485577698192ef0d948146d3ef75d63c3e858540e5ee963af839a0"

URI_aarch64_ghc-mime-types-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mime-types-devel-0.1.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-mime-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mime-types-devel}"
SRC_URI[aarch64_ghc-mime-types-devel.sha256sum] = "5de43838d33d28df3d69a5a457d933e75c692e2f4db88355b2bd2781918e17a0"

URI_aarch64_ghc-mime-types-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mime-types-doc-0.1.2.0-1.el10_0.noarch.rpm;name=aarch64_ghc-mime-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mime-types-doc}"
SRC_URI[aarch64_ghc-mime-types-doc.sha256sum] = "c741272ce34cf1b5b1f107f3ba8b0c619a6075594a37286a798523326d4d9876"

URI_aarch64_ghc-mime-types-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mime-types-prof-0.1.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-mime-types-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mime-types-prof}"
SRC_URI[aarch64_ghc-mime-types-prof.sha256sum] = "371db73aad7e8ec9f505c0b616fa66696ba8c0bc20bb01f3ad2240a32e3faa93"

RDEPENDS:ghc-mime-types = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-mime-types-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-mime-types \
 ghc-text-devel \
 "
RDEPENDS:ghc-mime-types-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-mime-types-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-mime-types-devel \
 ghc-text-prof \
 "
