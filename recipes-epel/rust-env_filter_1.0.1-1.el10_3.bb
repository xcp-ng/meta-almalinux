# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_filter"
PV = "1.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-env_filter+default-devel \
 rust-env_filter+regex-devel \
 rust-env_filter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_filter-1.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d25413a7e7ae9f573026beca27416a2d31276ee573f5f5890f098e8644955e60"

URI_x86_64_v2_rust-env_filter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter+default-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter+default-devel}"
SRC_URI[x86_64_v2_rust-env_filter+default-devel.sha256sum] = "4e591445dbbcc2efae93e49eb1360559c6f1b721609cf1b8df8d197552d931ea"

URI_x86_64_v2_rust-env_filter+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter+regex-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter+regex-devel}"
SRC_URI[x86_64_v2_rust-env_filter+regex-devel.sha256sum] = "826b9894acb72ebc5bdbde742004bfb79fb07290e360529780422b15b6d2364a"

URI_x86_64_v2_rust-env_filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter-devel}"
SRC_URI[x86_64_v2_rust-env_filter-devel.sha256sum] = "97385154b77ee80b47cbc553838d1082bc35fd88db6145b6ae4d3d0b790abd3d"

URI_aarch64_rust-env_filter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter+default-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-env_filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter+default-devel}"
SRC_URI[aarch64_rust-env_filter+default-devel.sha256sum] = "ed913cb9cdf7ce5dae3bebbb9e1373a3782375e71124d4d070292ed3da940c0d"

URI_aarch64_rust-env_filter+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter+regex-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-env_filter+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter+regex-devel}"
SRC_URI[aarch64_rust-env_filter+regex-devel.sha256sum] = "344a3a245bc25553b43672a8025cb0e0f757122c865047e74803038576666fa9"

URI_aarch64_rust-env_filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-env_filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter-devel}"
SRC_URI[aarch64_rust-env_filter-devel.sha256sum] = "b55ad81ba7c7007f26d086695a05f233456b01cadc90289af9eaa827cce47dad"

RDEPENDS:rust-env_filter+default-devel = " \
 cargo \
 rust-env_filter+regex-devel \
 rust-env_filter-devel \
 "
RDEPENDS:rust-env_filter+regex-devel = " \
 cargo \
 rust-env_filter-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_filter-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-log+std-devel \
 "
