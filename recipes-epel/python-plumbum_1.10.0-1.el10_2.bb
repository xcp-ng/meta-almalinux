# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-plumbum"
PV = "1.10.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-plumbum \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-plumbum-1.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a80a5a253652a40b52c670502a1158ffbb59b4ad8040653e1dab87a31d43c409"

URI_x86_64_v2_python3-plumbum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-plumbum-1.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-plumbum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-plumbum}"
SRC_URI[x86_64_v2_python3-plumbum.sha256sum] = "3d5cc60163fc3c9414087e185532b84773b3b19cd2913a96f13603f75b50c3b9"

URI_aarch64_python3-plumbum = "${EPEL_MIRROR}/aarch64/Packages/p/python3-plumbum-1.10.0-1.el10_2.noarch.rpm;name=aarch64_python3-plumbum;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-plumbum}"
SRC_URI[aarch64_python3-plumbum.sha256sum] = "a04d0388195b1565650ec6e211c72d620c6934b89db472a34a69b84049a9753d"

RDEPENDS:python3-plumbum = " \
 python3 \
 "
