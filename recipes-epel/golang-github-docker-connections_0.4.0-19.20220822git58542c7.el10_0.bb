# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-docker-connections"
PV = "0.4.0"
PR = "19.20220822git58542c7.el10_0"
PACKAGES = " \
 golang-github-docker-connections-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-docker-connections-0.4.0-19.20220822git58542c7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22bc9bd09b6e75c8df6392d341f91a7326e542b84d4ebf6d1016edf936629a77"

URI_aarch64_golang-github-docker-connections-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-docker-connections-devel-0.4.0-19.20220822git58542c7.el10_0.noarch.rpm;name=aarch64_golang-github-docker-connections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-docker-connections-devel}"
SRC_URI[aarch64_golang-github-docker-connections-devel.sha256sum] = "34f9dfc9593447850c3d903e5773e9fb5a460895651c5b92917740cceff452ae"

RDEPENDS:golang-github-docker-connections-devel = " \
 go-filesystem \
 golang-github-pkg-errors-devel \
 "
