# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-core"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-core+default-devel \
 rust-reqsign-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-core-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa41b5f7e6dd4065ee09e7c8a177afd6f5577dcf4cbae1bd926c057e5317c304"

URI_x86_64_v2_rust-reqsign-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-core+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-core+default-devel.sha256sum] = "59a50d244265d9b59abe4005def14add7e9520d323e46e3409ba7153ed2947ab"

URI_x86_64_v2_rust-reqsign-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-core-devel}"
SRC_URI[x86_64_v2_rust-reqsign-core-devel.sha256sum] = "5ae4ba7007609521d9a97147df912674d44f2a2a4ffa2c9b6f9e2cb590f6b993"

URI_aarch64_rust-reqsign-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-core+default-devel}"
SRC_URI[aarch64_rust-reqsign-core+default-devel.sha256sum] = "d28ab6730c5642d4929d60b1ffe8c483bf73ccfb2d08df47c76e39e3c1f743d6"

URI_aarch64_rust-reqsign-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-core-devel}"
SRC_URI[aarch64_rust-reqsign-core-devel.sha256sum] = "e9a124263168b11587a2fa28ff3fbc41230d46ec17fa959b3c45c9ba6d7aa6b5"

RDEPENDS:rust-reqsign-core+default-devel = " \
 cargo \
 rust-reqsign-core-devel \
 "
RDEPENDS:rust-reqsign-core-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-hex+default-devel \
 rust-hmac+default-devel \
 rust-http+default-devel \
 rust-jiff+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-sha1+default-devel \
 rust-sha2+default-devel \
 rust-sha2+oid-devel \
 "
