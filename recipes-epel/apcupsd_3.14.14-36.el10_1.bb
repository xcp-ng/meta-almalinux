# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apcupsd"
PV = "3.14.14"
PR = "36.el10_1"
PACKAGES = " \
 apcupsd \
 apcupsd-cgi \
 apcupsd-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apcupsd-3.14.14-36.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bb4eee43ff737aad79898920ce92662a363ef62735338e9ac58cf453501a8c4"

URI_aarch64_apcupsd = "${EPEL_MIRROR}/aarch64/Packages/a/apcupsd-3.14.14-36.el10_1.aarch64.rpm;name=aarch64_apcupsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_apcupsd}"
SRC_URI[aarch64_apcupsd.sha256sum] = "486a9efcb75d77f141aec22f55610d4cecc4e25632084b170190036509529ff9"

URI_aarch64_apcupsd-cgi = "${EPEL_MIRROR}/aarch64/Packages/a/apcupsd-cgi-3.14.14-36.el10_1.aarch64.rpm;name=aarch64_apcupsd-cgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_apcupsd-cgi}"
SRC_URI[aarch64_apcupsd-cgi.sha256sum] = "8161842715948eaa1772bb1e152d79278a6cda808d043b4071a6e06ffd506d04"

URI_aarch64_apcupsd-gui = "${EPEL_MIRROR}/aarch64/Packages/a/apcupsd-gui-3.14.14-36.el10_1.aarch64.rpm;name=aarch64_apcupsd-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_apcupsd-gui}"
SRC_URI[aarch64_apcupsd-gui.sha256sum] = "b4ce2717ab9f39b1e5437133e6c7814f7d33ff966e4b0787638edc0b343ba170"

RDEPENDS:apcupsd = " \
 bash \
 glibc \
 libstdc++ \
 libusb-compat-0.1 \
 s-nail \
 systemd \
 util-linux \
 "
RDEPENDS:apcupsd-cgi = " \
 apcupsd \
 gd \
 glibc \
 httpd \
 "
RDEPENDS:apcupsd-gui = " \
 GConf2 \
 apcupsd \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 libX11 \
 pango \
 "
