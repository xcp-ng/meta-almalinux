# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcalutils"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kcalutils \
 kcalutils-devel \
 kcalutils-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcalutils-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6154d1e57fc53d4fdda7121effb7c736d617795b604bdbdda2d1b056f2b9dfbc"

URI_x86_64_v2_kcalutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalutils}"
SRC_URI[x86_64_v2_kcalutils.sha256sum] = "e14f9160aa3d5c8b255f00f2b281cf5ab308969a9651aac591174b90b0790c92"

URI_x86_64_v2_kcalutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalutils-devel}"
SRC_URI[x86_64_v2_kcalutils-devel.sha256sum] = "5558e7a7d5b069a388a5552281e818493f99e44ea38129cb4ab6542acefe8267"

URI_x86_64_v2_kcalutils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalutils-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kcalutils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalutils-doc}"
SRC_URI[x86_64_v2_kcalutils-doc.sha256sum] = "91e8b3a9163f19aa6ac2c5599e4f1a20b38d1385a3c14844030d0ce154efc111"

URI_aarch64_kcalutils = "${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kcalutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalutils}"
SRC_URI[aarch64_kcalutils.sha256sum] = "7b3b64c17d9cb8657b57fc54a2fc1423df0101a218c48cc2e2945ac92dc0213e"

URI_aarch64_kcalutils-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kcalutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalutils-devel}"
SRC_URI[aarch64_kcalutils-devel.sha256sum] = "ecc8d1f05afd2651fc69dded200aad83c6515114c9325edf044fce7ae45b66d0"

URI_aarch64_kcalutils-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kcalutils-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kcalutils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalutils-doc}"
SRC_URI[aarch64_kcalutils-doc.sha256sum] = "1c7f8fa068d12a1292bfc2fdb794ad746cea4a270cc44f4a0055667a267433ee"

RDEPENDS:kcalutils = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcalutils-devel = " \
 cmake-filesystem \
 kcalutils \
 kf6-kcalendarcore-devel \
 kf6-kcoreaddons-devel \
 "
RDEPENDS:kcalutils-doc = " \
 "
