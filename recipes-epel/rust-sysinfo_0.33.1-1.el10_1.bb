# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sysinfo"
PV = "0.33.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-sysinfo+c-interface-devel \
 rust-sysinfo+component-devel \
 rust-sysinfo+debug-devel \
 rust-sysinfo+default-devel \
 rust-sysinfo+disk-devel \
 rust-sysinfo+linux-netdevs-devel \
 rust-sysinfo+linux-tmpfs-devel \
 rust-sysinfo+multithread-devel \
 rust-sysinfo+network-devel \
 rust-sysinfo+serde-devel \
 rust-sysinfo+system-devel \
 rust-sysinfo+user-devel \
 rust-sysinfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sysinfo-0.33.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb2c1654144b7d1efb522282dab64d2d32cf7dff0c38dadd331ce37ef0a29ca6"

URI_x86_64_v2_rust-sysinfo+c-interface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+c-interface-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+c-interface-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+c-interface-devel.sha256sum] = "7c3082dc81ae66b9623d3c210093911bcaa15085295d5d50dc4cbcebc29c3265"

URI_x86_64_v2_rust-sysinfo+component-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+component-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+component-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+component-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+component-devel.sha256sum] = "c862624a0e38031e70f2e2bf076db8b124d51e3390c43c66c4f31c224c517e79"

URI_x86_64_v2_rust-sysinfo+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+debug-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+debug-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+debug-devel.sha256sum] = "2d9b9f8768953ca0c5a289926e63117921fb1a93e220f90b2be6869275ae9cee"

URI_x86_64_v2_rust-sysinfo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+default-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+default-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+default-devel.sha256sum] = "438adf306e1f2047b162f754c5559a9af5f6fe57fb9dd0d28dff699b32cc78d4"

URI_x86_64_v2_rust-sysinfo+disk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+disk-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+disk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+disk-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+disk-devel.sha256sum] = "803679543e81b9eeb235c0624b0f3a5080a328541d2ada601e20b4cc8e284eee"

URI_x86_64_v2_rust-sysinfo+linux-netdevs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+linux-netdevs-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+linux-netdevs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+linux-netdevs-devel.sha256sum] = "7518f39cfb39ce66bb89ff2b13182caf359ee049ae7720fa74da20f229804045"

URI_x86_64_v2_rust-sysinfo+linux-tmpfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+linux-tmpfs-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+linux-tmpfs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+linux-tmpfs-devel.sha256sum] = "04cb25a192c318e4adef883a7f037f222df75e70f3d727f94bce3423d7d1e15f"

URI_x86_64_v2_rust-sysinfo+multithread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+multithread-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+multithread-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+multithread-devel.sha256sum] = "16f5161e7b9f721b0c321407560e5f7c73ad8502810d5ccecb77cb1647eb672d"

URI_x86_64_v2_rust-sysinfo+network-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+network-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+network-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+network-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+network-devel.sha256sum] = "1c59b54ca7e5414a86d7f36b4d7d54131500c5a4c6e9c14dde062bf505ba7e12"

URI_x86_64_v2_rust-sysinfo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+serde-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+serde-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+serde-devel.sha256sum] = "40d8c862605882ba5680817f9300ba4b7278f010bd0d921af2bbd50db484fdb7"

URI_x86_64_v2_rust-sysinfo+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+system-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+system-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+system-devel.sha256sum] = "9485b58db89855f9a473d0eb5a8f039a9536e85106aea4b58fba81a1644e20eb"

URI_x86_64_v2_rust-sysinfo+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo+user-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo+user-devel}"
SRC_URI[x86_64_v2_rust-sysinfo+user-devel.sha256sum] = "6a43c3d5612f958ccbc91a0c66364ba7c565240ee359628a84c40ae0aecf44a7"

URI_x86_64_v2_rust-sysinfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo-devel-0.33.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo-devel}"
SRC_URI[x86_64_v2_rust-sysinfo-devel.sha256sum] = "e3c5f04953b7da66095ed86c7a44d0e5c2f4919418a52c2f034c12d400969b21"

URI_aarch64_rust-sysinfo+c-interface-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+c-interface-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+c-interface-devel}"
SRC_URI[aarch64_rust-sysinfo+c-interface-devel.sha256sum] = "11aafd80314105e257cc68bc2d837a607b24817b7b2195fc2f1b6f8825413390"

URI_aarch64_rust-sysinfo+component-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+component-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+component-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+component-devel}"
SRC_URI[aarch64_rust-sysinfo+component-devel.sha256sum] = "5fbb03b96799831876c3d55c6250d503eaf5e8c59d9d51e9920a3abba1fd53fd"

URI_aarch64_rust-sysinfo+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+debug-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+debug-devel}"
SRC_URI[aarch64_rust-sysinfo+debug-devel.sha256sum] = "285dfeeb8999c5eb15c55a6ad0cf99c17613d0ad752602e3fedccae46901572e"

URI_aarch64_rust-sysinfo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+default-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+default-devel}"
SRC_URI[aarch64_rust-sysinfo+default-devel.sha256sum] = "74b8462127b4cbb320ad5223cedebc91a96f1902c1fb489d1fc26c7f5b80a33a"

URI_aarch64_rust-sysinfo+disk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+disk-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+disk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+disk-devel}"
SRC_URI[aarch64_rust-sysinfo+disk-devel.sha256sum] = "7933907aa69f12023ee214e2af5fed3823bb415e7fab8d99912a7aac733facc4"

URI_aarch64_rust-sysinfo+linux-netdevs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+linux-netdevs-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+linux-netdevs-devel}"
SRC_URI[aarch64_rust-sysinfo+linux-netdevs-devel.sha256sum] = "8ef2797a12c01f6e2518a04fc4607529b6b505195cedfc48ac6502b86fdad894"

URI_aarch64_rust-sysinfo+linux-tmpfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+linux-tmpfs-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+linux-tmpfs-devel}"
SRC_URI[aarch64_rust-sysinfo+linux-tmpfs-devel.sha256sum] = "6ebe83953c1c7378c73524afa2128df1718f21863e3a2bff059f8374971f9f5f"

URI_aarch64_rust-sysinfo+multithread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+multithread-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+multithread-devel}"
SRC_URI[aarch64_rust-sysinfo+multithread-devel.sha256sum] = "2a55567fdbe6dd8832786ea548c78d74812b5949f6811389f326b2bdff02807d"

URI_aarch64_rust-sysinfo+network-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+network-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+network-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+network-devel}"
SRC_URI[aarch64_rust-sysinfo+network-devel.sha256sum] = "781f1ce9ac3bd26a61a8c4317dbe2f24d3b5d890b0929821756d7baa4e732f57"

URI_aarch64_rust-sysinfo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+serde-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+serde-devel}"
SRC_URI[aarch64_rust-sysinfo+serde-devel.sha256sum] = "a8e39ea3df1e23cf20ec16afcb05a62a2b95ccd2e8dd0715829930929b40dbd2"

URI_aarch64_rust-sysinfo+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+system-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+system-devel}"
SRC_URI[aarch64_rust-sysinfo+system-devel.sha256sum] = "2346aac35f485a0948f6700644d18beab486d30f0febb82155cd5111f5f4f8c1"

URI_aarch64_rust-sysinfo+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo+user-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo+user-devel}"
SRC_URI[aarch64_rust-sysinfo+user-devel.sha256sum] = "60dea3be2a9d775a2a179e6213af3e77d5fa4ec1306b8599beff9f74357dbb1e"

URI_aarch64_rust-sysinfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo-devel-0.33.1-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo-devel}"
SRC_URI[aarch64_rust-sysinfo-devel.sha256sum] = "338243d8e0525b414fe559fc68c5e7192dc052b1cd7659032434de3661266377"

RDEPENDS:rust-sysinfo+c-interface-devel = " \
 cargo \
 rust-sysinfo+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+component-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+debug-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+default-devel = " \
 cargo \
 rust-sysinfo+component-devel \
 rust-sysinfo+disk-devel \
 rust-sysinfo+multithread-devel \
 rust-sysinfo+network-devel \
 rust-sysinfo+system-devel \
 rust-sysinfo+user-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+disk-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+linux-netdevs-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+linux-tmpfs-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+multithread-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+network-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+system-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo+user-devel = " \
 cargo \
 rust-sysinfo-devel \
 "
RDEPENDS:rust-sysinfo-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
