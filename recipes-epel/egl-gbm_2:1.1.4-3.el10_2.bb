# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-gbm"
PE = "2"
PV = "1.1.4"
PR = "3.el10_2"
PACKAGES = " \
 egl-gbm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/egl-gbm-1.1.4-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c119970257cc00b873dd5c4f3e8c572201e8740c0716e34d554ccfcc10436f3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-gbm-1.1.4-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-gbm;unpack=0"
SRC_URI[x86_64_v2_egl-gbm.sha256sum] = "5c81949b0fd2f84df7a342072356d6c19cafaa79abcb27ef12d6b0b85f27e974"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/egl-gbm-1.1.4-3.el10_2.aarch64.rpm;name=aarch64_egl-gbm;unpack=0"
SRC_URI[aarch64_egl-gbm.sha256sum] = "6720800e60aafe194aa1112dacfb8694e86fa37c9a97e0ed0268fd516f3fc606"

RDEPENDS:egl-gbm = " \
 glibc \
 libdrm \
 mesa-libgbm \
 "
