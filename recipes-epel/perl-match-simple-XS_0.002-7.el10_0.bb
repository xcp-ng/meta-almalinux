# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-match-simple-XS"
PV = "0.002"
PR = "7.el10_0"
PACKAGES = " \
 perl-match-simple-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-match-simple-XS-0.002-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb299bf4304db1c27356b976a78a41f0731f62b26dd603d7cb9e031497d9c58e"

URI_x86_64_v2_perl-match-simple-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-match-simple-XS-0.002-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-match-simple-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-match-simple-XS}"
SRC_URI[x86_64_v2_perl-match-simple-XS.sha256sum] = "b5aaa43fef549c5c8dd0f00c2da2967f3ae188fb05afc50ea9306cf5cc7209f0"

URI_aarch64_perl-match-simple-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-match-simple-XS-0.002-7.el10_0.aarch64.rpm;name=aarch64_perl-match-simple-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-match-simple-XS}"
SRC_URI[aarch64_perl-match-simple-XS.sha256sum] = "caa0ca390f67c21cce51445a692b32b7c8c06d59a92f1b1fa76f477d520e5265"

RDEPENDS:perl-match-simple-XS = " \
 glibc \
 perl-Carp \
 perl-libs \
 perl-mro \
 "
