# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Strict"
PV = "0.54"
PR = "2.el10_1"
PACKAGES = " \
 perl-Test-Strict \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Strict-0.54-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c899ca90aee8b93917f74363b4f35458928212dbfeea9de5637dbccae8129225"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Strict-0.54-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Strict;unpack=0"
SRC_URI[x86_64_v2_perl-Test-Strict.sha256sum] = "2b2a01760c0f21bd5f8e9ec1f3785268f1503b8db7b1451ead9a50102b4474f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Strict-0.54-2.el10_1.noarch.rpm;name=aarch64_perl-Test-Strict;unpack=0"
SRC_URI[aarch64_perl-Test-Strict.sha256sum] = "fc2029ad50642ea628ffeecba79d0068f30859fbe3bd4bb1ee2e5ada5723efa6"

RDEPENDS:perl-Test-Strict = " \
 perl-File-Find \
 perl-FindBin \
 perl-PathTools \
 perl-Test-Simple \
 perl-libs \
 "
