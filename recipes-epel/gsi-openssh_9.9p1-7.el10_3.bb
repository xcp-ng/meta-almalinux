# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsi-openssh"
PV = "9.9p1"
PR = "7.el10_3"
PACKAGES = " \
 gsi-openssh \
 gsi-openssh-clients \
 gsi-openssh-keysign \
 gsi-openssh-server \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gsi-openssh-9.9p1-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e4dca8b54dcb81def965c4ea56458dd7fd2a3d43df19bd539881ebb8d3d8dbd2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-9.9p1-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh;unpack=0"
SRC_URI[x86_64_v2_gsi-openssh.sha256sum] = "7b760cf11372d640f3a98a1daeb08e594890a13af4e77cb3fb35db332bb6fa06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-clients-9.9p1-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-clients;unpack=0"
SRC_URI[x86_64_v2_gsi-openssh-clients.sha256sum] = "f3e915626a0deedf679abfad8cc3cd9a936200c5ecf8fd82ec222394aa44e6eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-keysign-9.9p1-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-keysign;unpack=0"
SRC_URI[x86_64_v2_gsi-openssh-keysign.sha256sum] = "3357200a0be2119c47e9338fb36fd204a9aafb7dce0b8c797befca609582060d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-server-9.9p1-7.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-server;unpack=0"
SRC_URI[x86_64_v2_gsi-openssh-server.sha256sum] = "656bed5a6d387b00a16ec3c73aa1a1c6a7341422f90d733c6a55792c6b01c66e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-9.9p1-7.el10_3.aarch64.rpm;name=aarch64_gsi-openssh;unpack=0"
SRC_URI[aarch64_gsi-openssh.sha256sum] = "88fa7f669059a13d848ce88bb8effb05abc34b5a3dee1ad2c79e084a7bb41eae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-clients-9.9p1-7.el10_3.aarch64.rpm;name=aarch64_gsi-openssh-clients;unpack=0"
SRC_URI[aarch64_gsi-openssh-clients.sha256sum] = "34ea861f3a9c835b6f446b6b2f9dd3956c41407ce635df0f2f5f36296a8dd615"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-keysign-9.9p1-7.el10_3.aarch64.rpm;name=aarch64_gsi-openssh-keysign;unpack=0"
SRC_URI[aarch64_gsi-openssh-keysign.sha256sum] = "c6132e32e8ca505f205d6db5d0e276659289a811cda8996a10546ca4f3236e32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-server-9.9p1-7.el10_3.aarch64.rpm;name=aarch64_gsi-openssh-server;unpack=0"
SRC_URI[aarch64_gsi-openssh-server.sha256sum] = "c655a6b4748c2b0121513623f0b173580773a0e9e4ae1388904c2f2d272f893e"

RDEPENDS:gsi-openssh = " \
 audit-libs \
 glibc \
 libgcc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:gsi-openssh-clients = " \
 crypto-policies \
 glibc \
 globus-gssapi-gsi \
 gsi-openssh \
 libedit \
 libfido2 \
 libgcc \
 libselinux \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-keysign = " \
 glibc \
 gsi-openssh \
 libgcc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 gsi-openssh \
 libgcc \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam \
 pam-libs \
 policycoreutils-python-utils \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
