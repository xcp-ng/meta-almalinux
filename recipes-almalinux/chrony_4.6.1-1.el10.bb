# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chrony"
PV = "4.6.1"
PR = "1.el10"
PACKAGES = " \
 chrony \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/chrony-4.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30ec5487ec03629100e567c70704b222d81db4906088b270bc7137291e5575b2"

URI_x86_64_v2_chrony = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/chrony-4.6.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_chrony;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chrony}"
SRC_URI[x86_64_v2_chrony.sha256sum] = "ecb3b70ac4c550fac5a4285f761a2daaf0f3401d3ac3010f372832f96d5b8399"

URI_aarch64_chrony = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/chrony-4.6.1-1.el10.aarch64.rpm;name=aarch64_chrony;unpack=0"
SRC_URI:append = " ${URI_aarch64_chrony}"
SRC_URI[aarch64_chrony.sha256sum] = "3e84428d67fe7ae5843d873f607f55ba657e14eb7d9e862ee9c8725fa4d93875"

RDEPENDS:chrony = " \
 bash \
 glibc \
 gnutls \
 libcap \
 libedit \
 libseccomp \
 shadow-utils \
 systemd \
 tzdata \
 "
