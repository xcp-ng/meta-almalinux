# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pypolicyd-spf"
PV = "3.1.0"
PR = "6.el10_0"
PACKAGES = " \
 pypolicyd-spf \
 pypolicyd-spf-milter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pypolicyd-spf-3.1.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54d3867365f9fdf2bf7431a7e5689eebf1295cb123ccd6a62664302447a846d4"

URI_x86_64_v2_pypolicyd-spf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pypolicyd-spf-3.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pypolicyd-spf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pypolicyd-spf}"
SRC_URI[x86_64_v2_pypolicyd-spf.sha256sum] = "d43d5f8b80a08d35289b3c2e694eb2217bf06d82705c5340c0cfe9d052569368"

URI_x86_64_v2_pypolicyd-spf-milter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pypolicyd-spf-milter-3.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pypolicyd-spf-milter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pypolicyd-spf-milter}"
SRC_URI[x86_64_v2_pypolicyd-spf-milter.sha256sum] = "907eaaf94169ea1c300a8544b57b236f8bf19670715646597eaa30143b29bc9f"

URI_aarch64_pypolicyd-spf = "${EPEL_MIRROR}/aarch64/Packages/p/pypolicyd-spf-3.1.0-6.el10_0.noarch.rpm;name=aarch64_pypolicyd-spf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pypolicyd-spf}"
SRC_URI[aarch64_pypolicyd-spf.sha256sum] = "60864f1d218e27c35d10c0dc54dc72e62c977422cf35209ed48acc646e4cab2b"

URI_aarch64_pypolicyd-spf-milter = "${EPEL_MIRROR}/aarch64/Packages/p/pypolicyd-spf-milter-3.1.0-6.el10_0.noarch.rpm;name=aarch64_pypolicyd-spf-milter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pypolicyd-spf-milter}"
SRC_URI[aarch64_pypolicyd-spf-milter.sha256sum] = "588c52d22590a60057e97967034c019a82b237c49e8705c393a0ffc30cae97f1"

RDEPENDS:pypolicyd-spf = " \
 bash \
 postfix \
 python3 \
 python3-authres \
 python3-pyspf \
 shadow-utils \
 "
RDEPENDS:pypolicyd-spf-milter = " \
 pypolicyd-spf \
 python3 \
 python3-pymilter \
 "
