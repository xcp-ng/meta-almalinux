# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kbookmarks"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kbookmarks \
 kf6-kbookmarks-devel \
 kf6-kbookmarks-doc \
 kf6-kbookmarks-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kbookmarks-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c65d52d41e3a65e93f99d3942bf630f2c398d90a4f97b0ee8aeadd3dd0217dcc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks;unpack=0"
SRC_URI[x86_64_v2_kf6-kbookmarks.sha256sum] = "e9970b7046d199ae083a5851fac67c7a081560c44dbbfbe619f5b15b6b1afded"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kbookmarks-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kbookmarks-devel.sha256sum] = "a90de268fc94f9a19fbdc47144813d83f90fbd43073613303800aa9e20446cbc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kbookmarks-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kbookmarks-doc.sha256sum] = "aba4bc7bff8597952e240068aa4590c75805794fd424e8a4fb90dce46a330226"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kbookmarks-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kbookmarks-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kbookmarks-html.sha256sum] = "9692a8a7b9d6bad9e3fe025424e511d962c5d81d4c99ed30f5dd9eb3bdf0d630"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kbookmarks;unpack=0"
SRC_URI[aarch64_kf6-kbookmarks.sha256sum] = "39d256bbaa61801b96d8bd62299217ee408570a850567684de68b0617a25d8ab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kbookmarks-devel;unpack=0"
SRC_URI[aarch64_kf6-kbookmarks-devel.sha256sum] = "8a1552e0881a6b466dfee69919fe181459ff15303a6dfea6473e9ac9ba35b697"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kbookmarks-doc;unpack=0"
SRC_URI[aarch64_kf6-kbookmarks-doc.sha256sum] = "114fd9a34b7c92bad231ed9e7e86da8d52390d8335fbf971087f5a457e225892"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kbookmarks-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kbookmarks-html;unpack=0"
SRC_URI[aarch64_kf6-kbookmarks-html.sha256sum] = "20baf602f1ccae346fd1ebbc4e806b258034ba2b66f3bd657f19e6ca91cd6d28"

RDEPENDS:kf6-kbookmarks = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kbookmarks-devel = " \
 cmake-filesystem \
 kf6-kbookmarks \
 kf6-kwidgetsaddons-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kbookmarks-doc = " \
 "
RDEPENDS:kf6-kbookmarks-html = " \
 "
