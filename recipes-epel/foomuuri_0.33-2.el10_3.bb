# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "foomuuri"
PV = "0.33"
PR = "2.el10_3"
PACKAGES = " \
 foomuuri \
 foomuuri-firewalld \
 prometheus-foomuuri-exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/foomuuri-0.33-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22a68080547af6a64e6d17947f9aa2c654365677b0d64e50aedf943de963742d"

URI_x86_64_v2_foomuuri = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri-0.33-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri}"
SRC_URI[x86_64_v2_foomuuri.sha256sum] = "6ec7b7c27bab40559eacf61787eca0a408aba16e6b4756aed2e594bf76adec3b"

URI_x86_64_v2_foomuuri-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/foomuuri-firewalld-0.33-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_foomuuri-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_foomuuri-firewalld}"
SRC_URI[x86_64_v2_foomuuri-firewalld.sha256sum] = "fb64d4a147df63406d66a5708201a3c133b78a3c05f65f4bd5ee6c5ca0b52fbe"

URI_x86_64_v2_prometheus-foomuuri-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prometheus-foomuuri-exporter-0.33-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_prometheus-foomuuri-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prometheus-foomuuri-exporter}"
SRC_URI[x86_64_v2_prometheus-foomuuri-exporter.sha256sum] = "8040a5b69c5eb124866fb58bf11db505e112dcc8fdcf1b088cea9b048825d918"

URI_aarch64_foomuuri = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri-0.33-2.el10_3.noarch.rpm;name=aarch64_foomuuri;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri}"
SRC_URI[aarch64_foomuuri.sha256sum] = "daf7e1ac48c0e1f45d0a5023798920d5c39c043b43fcbcbccf633ee8a6133a65"

URI_aarch64_foomuuri-firewalld = "${EPEL_MIRROR}/aarch64/Packages/f/foomuuri-firewalld-0.33-2.el10_3.noarch.rpm;name=aarch64_foomuuri-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_foomuuri-firewalld}"
SRC_URI[aarch64_foomuuri-firewalld.sha256sum] = "65709fe62f013538b669494e20b831872f5774866a4d9d2924470accd636265b"

URI_aarch64_prometheus-foomuuri-exporter = "${EPEL_MIRROR}/aarch64/Packages/p/prometheus-foomuuri-exporter-0.33-2.el10_3.noarch.rpm;name=aarch64_prometheus-foomuuri-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_prometheus-foomuuri-exporter}"
SRC_URI[aarch64_prometheus-foomuuri-exporter.sha256sum] = "586bb538f8b63e7340f9a6cb886d45d71c7f09f84deb8fac3d018cc4565132f5"

RDEPENDS:foomuuri = " \
 bash \
 nftables \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-systemd \
 systemd \
 "
RDEPENDS:foomuuri-firewalld = " \
 foomuuri \
 "
RDEPENDS:prometheus-foomuuri-exporter = " \
 bash \
 foomuuri \
 python3 \
 python3-prometheus_client \
 "
