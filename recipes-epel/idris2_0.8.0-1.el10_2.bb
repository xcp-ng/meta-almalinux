# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "idris2"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 idris2 \
 idris2-doc \
 idris2-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/idris2-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2208d0badeadbb8f4fde0717d6f8dd68db054b3f9fea0d37f399e20b5656dead"

URI_x86_64_v2_idris2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idris2-0.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_idris2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idris2}"
SRC_URI[x86_64_v2_idris2.sha256sum] = "d7300dcfed08fefaa6f720569c42ea0cac35703ba1b6ce6bb4898e43290e864f"

URI_x86_64_v2_idris2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idris2-doc-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_idris2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idris2-doc}"
SRC_URI[x86_64_v2_idris2-doc.sha256sum] = "e3009e2eab93fdce2977eb017d0465f2508f9e9695a70cfd4d589c580f181486"

URI_x86_64_v2_idris2-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/idris2-libs-0.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_idris2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idris2-libs}"
SRC_URI[x86_64_v2_idris2-libs.sha256sum] = "7d8fac4edce67fbb75a46d0590e8d7af4236d225d94c15b7ead0d1307ab09843"

URI_aarch64_idris2 = "${EPEL_MIRROR}/aarch64/Packages/i/idris2-0.8.0-1.el10_2.aarch64.rpm;name=aarch64_idris2;unpack=0"
SRC_URI:append = " ${URI_aarch64_idris2}"
SRC_URI[aarch64_idris2.sha256sum] = "2767a3809939422f0c070d9709987779027fee362d8d9e37fa493445e3b12cc7"

URI_aarch64_idris2-doc = "${EPEL_MIRROR}/aarch64/Packages/i/idris2-doc-0.8.0-1.el10_2.noarch.rpm;name=aarch64_idris2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_idris2-doc}"
SRC_URI[aarch64_idris2-doc.sha256sum] = "96c25bc5438cbf16be1f65834ba7c6b7bb511294ebca63eb74a2caaf771b0569"

URI_aarch64_idris2-libs = "${EPEL_MIRROR}/aarch64/Packages/i/idris2-libs-0.8.0-1.el10_2.aarch64.rpm;name=aarch64_idris2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_idris2-libs}"
SRC_URI[aarch64_idris2-libs.sha256sum] = "3ac7d272b1b728c58d911fbfdf8008b477f3a2803337f0483632815b4c17d355"

RDEPENDS:idris2 = " \
 chez-scheme \
 idris2-libs \
 "
RDEPENDS:idris2-doc = " \
 fontawesome4-fonts \
 "
RDEPENDS:idris2-libs = " \
 glibc \
 "
