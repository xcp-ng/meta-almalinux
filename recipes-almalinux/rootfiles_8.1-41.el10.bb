# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rootfiles"
PV = "8.1"
PR = "41.el10"
PACKAGES = " \
 rootfiles \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rootfiles-8.1-41.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "45235af9f4f321bf24b43ebe742bef723c606afb3186e08b38994583e958cd2c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rootfiles-8.1-41.el10.noarch.rpm;name=x86_64_v2_rootfiles;unpack=0"
SRC_URI[x86_64_v2_rootfiles.sha256sum] = "9e32372c2a140aae06343032b8f854b41a8150cf90acc29b24ee372e09f4c58e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rootfiles-8.1-41.el10.noarch.rpm;name=aarch64_rootfiles;unpack=0"
SRC_URI[aarch64_rootfiles.sha256sum] = "9e32372c2a140aae06343032b8f854b41a8150cf90acc29b24ee372e09f4c58e"

RDEPENDS:rootfiles = " \
 bash \
 "
