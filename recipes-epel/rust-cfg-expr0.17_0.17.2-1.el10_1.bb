# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg-expr0.17"
PV = "0.17.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-cfg-expr0.17+default-devel \
 rust-cfg-expr0.17+target-lexicon-devel \
 rust-cfg-expr0.17+targets-devel \
 rust-cfg-expr0.17-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg-expr0.17-0.17.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37638f356a7793162dae2c6535e2a63cc051f73282f73035efeb724db88646eb"

URI_x86_64_v2_rust-cfg-expr0.17+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr0.17+default-devel-0.17.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr0.17+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr0.17+default-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr0.17+default-devel.sha256sum] = "9bbfecf8963f41f3de8726da09d03e2286eadc0e75481f2b7d78e63d14006f55"
RPROVIDES:rust-cfg-expr0.17+default-devel:append:x86_64_v2 = " virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

URI_x86_64_v2_rust-cfg-expr0.17+target-lexicon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr0.17+target-lexicon-devel-0.17.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr0.17+target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr0.17+target-lexicon-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr0.17+target-lexicon-devel.sha256sum] = "4baaeeaf1d28caef621ecd1d0bf00d1d957aa379a13e7c4dd7f9c4f70d55c908"

URI_x86_64_v2_rust-cfg-expr0.17+targets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr0.17+targets-devel-0.17.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr0.17+targets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr0.17+targets-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr0.17+targets-devel.sha256sum] = "fca045b3cb72753b33ec51093945d31db106b99c2271c09698f77184f277247c"
RPROVIDES:rust-cfg-expr0.17+targets-devel:append:x86_64_v2 = " virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

URI_x86_64_v2_rust-cfg-expr0.17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr0.17-devel-0.17.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr0.17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr0.17-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr0.17-devel.sha256sum] = "7c67963ed53b56d0288e9e25fd829126786629a3d71678c641b271ea67104446"

URI_aarch64_rust-cfg-expr0.17+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr0.17+default-devel-0.17.2-1.el10_1.noarch.rpm;name=aarch64_rust-cfg-expr0.17+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr0.17+default-devel}"
SRC_URI[aarch64_rust-cfg-expr0.17+default-devel.sha256sum] = "0eddc12901683c86fd8a1975c13cb38acc3e28001cb1502b86d0e6346af6d484"
RPROVIDES:rust-cfg-expr0.17+default-devel:append:aarch64 = " virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

URI_aarch64_rust-cfg-expr0.17+target-lexicon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr0.17+target-lexicon-devel-0.17.2-1.el10_1.noarch.rpm;name=aarch64_rust-cfg-expr0.17+target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr0.17+target-lexicon-devel}"
SRC_URI[aarch64_rust-cfg-expr0.17+target-lexicon-devel.sha256sum] = "48b1cb97ce5045e21b1c683424dc0b7e35c5a860f46f9fbe51ed16908de48c26"

URI_aarch64_rust-cfg-expr0.17+targets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr0.17+targets-devel-0.17.2-1.el10_1.noarch.rpm;name=aarch64_rust-cfg-expr0.17+targets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr0.17+targets-devel}"
SRC_URI[aarch64_rust-cfg-expr0.17+targets-devel.sha256sum] = "b709555040a9c93c8e88b5e6e9fa18c7960e432aed4976b8c670d34a26601522"
RPROVIDES:rust-cfg-expr0.17+targets-devel:append:aarch64 = " virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

URI_aarch64_rust-cfg-expr0.17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr0.17-devel-0.17.2-1.el10_1.noarch.rpm;name=aarch64_rust-cfg-expr0.17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr0.17-devel}"
SRC_URI[aarch64_rust-cfg-expr0.17-devel.sha256sum] = "8a7188429cd3b62d307e72d636913c041ed860a094f33eaccc306d27e766e44e"

RDEPENDS:rust-cfg-expr0.17+default-devel = " \
 cargo \
 rust-cfg-expr0.17-devel \
 "
RDEPENDS:rust-cfg-expr0.17+target-lexicon-devel = " \
 cargo \
 rust-cfg-expr0.17-devel \
 rust-target-lexicon0.12+default-devel \
 "
RDEPENDS:rust-cfg-expr0.17+targets-devel = " \
 cargo \
 rust-cfg-expr0.17+target-lexicon-devel \
 rust-cfg-expr0.17-devel \
 "
RDEPENDS:rust-cfg-expr0.17-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "
