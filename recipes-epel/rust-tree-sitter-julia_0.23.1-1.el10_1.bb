# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-julia"
PV = "0.23.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-julia+default-devel \
 rust-tree-sitter-julia-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-julia-0.23.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94930dfeba04e232c05f37f6cdcb13e1d8ddf4b7f5d3426a5882fe7e4a6cd269"

URI_x86_64_v2_rust-tree-sitter-julia+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-julia+default-devel-0.23.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-julia+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-julia+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-julia+default-devel.sha256sum] = "42d797808943c7cf072b47f7722554378e0c0e423c790c5f454306f4ce5278a1"

URI_x86_64_v2_rust-tree-sitter-julia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-julia-devel-0.23.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-julia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-julia-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-julia-devel.sha256sum] = "86ec01d5341c0f8d59ba7a98a079784fcdcb0d102fc00ab964d2de073590c960"

URI_aarch64_rust-tree-sitter-julia+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-julia+default-devel-0.23.1-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-julia+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-julia+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-julia+default-devel.sha256sum] = "8e3df78c3e502a681e27cf988a8b0c47848ae37976581051d2c92cf2b5832567"

URI_aarch64_rust-tree-sitter-julia-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-julia-devel-0.23.1-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-julia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-julia-devel}"
SRC_URI[aarch64_rust-tree-sitter-julia-devel.sha256sum] = "18a8e0887dc7eb6ca5f489a9bc3bbc9eb598f89e56b52bab3c2c43a64602ac4e"

RDEPENDS:rust-tree-sitter-julia+default-devel = " \
 cargo \
 rust-tree-sitter-julia-devel \
 "
RDEPENDS:rust-tree-sitter-julia-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
