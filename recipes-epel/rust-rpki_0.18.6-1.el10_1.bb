# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpki"
PV = "0.18.6"
PR = "1.el10_1"
PACKAGES = " \
 rpki \
 rust-rpki+__windows_ci_all-devel \
 rust-rpki+arbitrary-devel \
 rust-rpki+bcder-devel \
 rust-rpki+ca-devel \
 rust-rpki+compat-devel \
 rust-rpki+crypto-devel \
 rust-rpki+default-devel \
 rust-rpki+futures-util-devel \
 rust-rpki+openssl-devel \
 rust-rpki+quick-xml-devel \
 rust-rpki+repository-devel \
 rust-rpki+ring-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-devel \
 rust-rpki+serde-support-devel \
 rust-rpki+serde_json-devel \
 rust-rpki+slurm-devel \
 rust-rpki+softkeys-devel \
 rust-rpki+tokio-devel \
 rust-rpki+untrusted-devel \
 rust-rpki+xml-devel \
 rust-rpki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rpki-0.18.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c89860053ea9e90463832f3718aec0b795a4b8f5abd97370a302be9ff092c438"

URI_x86_64_v2_rpki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-0.18.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpki}"
SRC_URI[x86_64_v2_rpki.sha256sum] = "babb4fea9ae572e5b8efecb09e48dfd38ac3af11c5b694251d47692659445838"

URI_x86_64_v2_rust-rpki+__windows_ci_all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+__windows_ci_all-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+__windows_ci_all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+__windows_ci_all-devel}"
SRC_URI[x86_64_v2_rust-rpki+__windows_ci_all-devel.sha256sum] = "dcaa28ffb4c56c3c11f50516f584cc53d0d8519ec216733842cd37ef72ea4af3"

URI_x86_64_v2_rust-rpki+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+arbitrary-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-rpki+arbitrary-devel.sha256sum] = "ebe023bc31ee131e573961d2aab95b29df309d22164fcec83e78c57d72238739"

URI_x86_64_v2_rust-rpki+bcder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+bcder-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+bcder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+bcder-devel}"
SRC_URI[x86_64_v2_rust-rpki+bcder-devel.sha256sum] = "3d78eaf7e6297b0dcb64589f5d523af15328fef9f55edadf8bd546b3c2e181db"

URI_x86_64_v2_rust-rpki+ca-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+ca-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+ca-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+ca-devel}"
SRC_URI[x86_64_v2_rust-rpki+ca-devel.sha256sum] = "4e474f1cba31bad410f7a93b9ac593771f711ab730b5c80bdab9d47da9400375"

URI_x86_64_v2_rust-rpki+compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+compat-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+compat-devel}"
SRC_URI[x86_64_v2_rust-rpki+compat-devel.sha256sum] = "851ef33e35c01f682af173b7e474c2bc3d4a65964cddb460f1feb18f51e2c05e"

URI_x86_64_v2_rust-rpki+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+crypto-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+crypto-devel}"
SRC_URI[x86_64_v2_rust-rpki+crypto-devel.sha256sum] = "20e84b68917be091f6b1fb8b5fe34ca8b4861ae05c36613ab0c260a4fbdc13c7"

URI_x86_64_v2_rust-rpki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+default-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+default-devel}"
SRC_URI[x86_64_v2_rust-rpki+default-devel.sha256sum] = "629e9eac44847847416ab64ebc18be310a1117a8321a536df4b9a6074e28d96f"

URI_x86_64_v2_rust-rpki+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+futures-util-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+futures-util-devel}"
SRC_URI[x86_64_v2_rust-rpki+futures-util-devel.sha256sum] = "8f7081f9d7ddce2ab1ff945aae22d17a9350217ba58ba97f6482c4406f901879"

URI_x86_64_v2_rust-rpki+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+openssl-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+openssl-devel}"
SRC_URI[x86_64_v2_rust-rpki+openssl-devel.sha256sum] = "7e8db86c2361493f0d4878e5bf5e7840726379ced8615c5105507057d547f531"

URI_x86_64_v2_rust-rpki+quick-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+quick-xml-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+quick-xml-devel}"
SRC_URI[x86_64_v2_rust-rpki+quick-xml-devel.sha256sum] = "4a74879e57e495af2bf76b63818dd45467baae8dd128294c588bdc8524747054"

URI_x86_64_v2_rust-rpki+repository-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+repository-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+repository-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+repository-devel}"
SRC_URI[x86_64_v2_rust-rpki+repository-devel.sha256sum] = "9d7b5e49cb2d087868f5bb308b1d5156c6c10f2827dc4499ae0e529f0a4cca58"

URI_x86_64_v2_rust-rpki+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+ring-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+ring-devel}"
SRC_URI[x86_64_v2_rust-rpki+ring-devel.sha256sum] = "469df64d5f66c1e8a288087c84bb1d5c140349b98df49833197d5a77bbf5eb1d"

URI_x86_64_v2_rust-rpki+rrdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+rrdp-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+rrdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+rrdp-devel}"
SRC_URI[x86_64_v2_rust-rpki+rrdp-devel.sha256sum] = "07351029245bf52ca5610d0408f3194842c1f8cd3597659fa035ff31afe0b7de"

URI_x86_64_v2_rust-rpki+rtr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+rtr-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+rtr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+rtr-devel}"
SRC_URI[x86_64_v2_rust-rpki+rtr-devel.sha256sum] = "35db918255358be23926c76fdfd3c1dadfe7d00fdddc92ea3e301029996c9092"

URI_x86_64_v2_rust-rpki+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde-devel.sha256sum] = "e9703d25fb33f1f449998230b0b852c6fe64f622576e9589ee286ec716598dbb"

URI_x86_64_v2_rust-rpki+serde-support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde-support-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde-support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde-support-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde-support-devel.sha256sum] = "809c7e79d7f86129cb2ea1a861bc446afdf278e1fef76e9fd1e3674ca4adad1a"

URI_x86_64_v2_rust-rpki+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde_json-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde_json-devel.sha256sum] = "2adaa2a9d7e8e1badeedeccb3e4f48de365731806d513b6ef106e438f9289437"

URI_x86_64_v2_rust-rpki+slurm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+slurm-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+slurm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+slurm-devel}"
SRC_URI[x86_64_v2_rust-rpki+slurm-devel.sha256sum] = "25431ffd45afad0d2dfad78b154d182e2431a792d7a4fc632a68707fbbb09d66"

URI_x86_64_v2_rust-rpki+softkeys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+softkeys-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+softkeys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+softkeys-devel}"
SRC_URI[x86_64_v2_rust-rpki+softkeys-devel.sha256sum] = "cb5dc0f04fe4aa0889b0f5c73f99c744b12f77d6c2ba7f5787735960a0f45ce3"

URI_x86_64_v2_rust-rpki+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+tokio-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+tokio-devel}"
SRC_URI[x86_64_v2_rust-rpki+tokio-devel.sha256sum] = "b5bb89a81b82111ff40be07b9bd2fe15efdd4c21c1766745d56374a3ffbf7b2e"

URI_x86_64_v2_rust-rpki+untrusted-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+untrusted-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+untrusted-devel}"
SRC_URI[x86_64_v2_rust-rpki+untrusted-devel.sha256sum] = "21e91630676b8bc3d299ff6adbe68dee4e0d48e2bb9c37c670e194fefdfd53d7"

URI_x86_64_v2_rust-rpki+xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+xml-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+xml-devel}"
SRC_URI[x86_64_v2_rust-rpki+xml-devel.sha256sum] = "a95e9a0d79fdb3b8103738778dd80f1851a27c16483b31f1c3ea0f4ddfdcf6cd"

URI_x86_64_v2_rust-rpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki-devel-0.18.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki-devel}"
SRC_URI[x86_64_v2_rust-rpki-devel.sha256sum] = "27cc9d1fb5d758acd442124c8f12621ec4b33d09b4262eade00a3c56604e50a2"

URI_aarch64_rpki = "${EPEL_MIRROR}/aarch64/Packages/r/rpki-0.18.6-1.el10_1.aarch64.rpm;name=aarch64_rpki;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpki}"
SRC_URI[aarch64_rpki.sha256sum] = "cd13bd9f8423511c350acbf5463d177774d033476a09f8a2d52e7f1bd9ebcb6f"

URI_aarch64_rust-rpki+__windows_ci_all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+__windows_ci_all-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+__windows_ci_all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+__windows_ci_all-devel}"
SRC_URI[aarch64_rust-rpki+__windows_ci_all-devel.sha256sum] = "afc37d3e9ce9eb1a47126951eeeecf74409fcb100f1d9403c16c2bb4f2fb8e96"

URI_aarch64_rust-rpki+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+arbitrary-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+arbitrary-devel}"
SRC_URI[aarch64_rust-rpki+arbitrary-devel.sha256sum] = "d1fceef3afd3e36baa76e751fbe910af4727c8f76f339e2a08d5ee92c49bfed4"

URI_aarch64_rust-rpki+bcder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+bcder-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+bcder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+bcder-devel}"
SRC_URI[aarch64_rust-rpki+bcder-devel.sha256sum] = "3cc782f7496a3498c8da4a338549b63f630a2c74c967c86515963eb38a076ce1"

URI_aarch64_rust-rpki+ca-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+ca-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+ca-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+ca-devel}"
SRC_URI[aarch64_rust-rpki+ca-devel.sha256sum] = "a799deeceaa6edebd17a24743c23070a1034217850a3ecd8d87f8c27e18f60df"

URI_aarch64_rust-rpki+compat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+compat-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+compat-devel}"
SRC_URI[aarch64_rust-rpki+compat-devel.sha256sum] = "d73a77db5a470ccfb3bd6000a855e92be2f18dbf530df8db7fe439dfa1f6b3f1"

URI_aarch64_rust-rpki+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+crypto-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+crypto-devel}"
SRC_URI[aarch64_rust-rpki+crypto-devel.sha256sum] = "cbe4546ec27c14a9dad7a86a3319f932c74d44c669e59140644276cf81fd6fac"

URI_aarch64_rust-rpki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+default-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+default-devel}"
SRC_URI[aarch64_rust-rpki+default-devel.sha256sum] = "5976b4959d86baa9fda5ebc3b6564997cb4d5ce61dd485b16e950cce055b6827"

URI_aarch64_rust-rpki+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+futures-util-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+futures-util-devel}"
SRC_URI[aarch64_rust-rpki+futures-util-devel.sha256sum] = "9c8712a542175ccb5329537ed271c37c57a26e9e3d5bf9589672d3a554a93afb"

URI_aarch64_rust-rpki+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+openssl-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+openssl-devel}"
SRC_URI[aarch64_rust-rpki+openssl-devel.sha256sum] = "ce3aeba59fab5cd72b6cca0b51ec047225a5f8d8be98ea5e854df174788a95b2"

URI_aarch64_rust-rpki+quick-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+quick-xml-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+quick-xml-devel}"
SRC_URI[aarch64_rust-rpki+quick-xml-devel.sha256sum] = "c0a00917a10b82d94bab7eacaeb4c6c4448d536ffc9f3c9c6c333ae75cb944ff"

URI_aarch64_rust-rpki+repository-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+repository-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+repository-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+repository-devel}"
SRC_URI[aarch64_rust-rpki+repository-devel.sha256sum] = "cdee5a7667e3243b3d7da557d7f8bd7da7034b7ea6bdc2b93a2ba2b4bdbad4f1"

URI_aarch64_rust-rpki+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+ring-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+ring-devel}"
SRC_URI[aarch64_rust-rpki+ring-devel.sha256sum] = "2e8befc84213103b05afe297ded795c546328e066a4e4aea11363c67cf27bb5b"

URI_aarch64_rust-rpki+rrdp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+rrdp-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+rrdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+rrdp-devel}"
SRC_URI[aarch64_rust-rpki+rrdp-devel.sha256sum] = "bd19b366cb038d507b9ec913f3d6e9d1638f0ef693194ccbaa74fc62463adbc1"

URI_aarch64_rust-rpki+rtr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+rtr-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+rtr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+rtr-devel}"
SRC_URI[aarch64_rust-rpki+rtr-devel.sha256sum] = "413610a5cae985611b1bbb17d7db5c2fe5179221ae4de5efe764c7719085fd49"

URI_aarch64_rust-rpki+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde-devel}"
SRC_URI[aarch64_rust-rpki+serde-devel.sha256sum] = "bacfc850bbacd120b2fc736aab48fdd8ee6cdab53141058d20b20b9842d78810"

URI_aarch64_rust-rpki+serde-support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde-support-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+serde-support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde-support-devel}"
SRC_URI[aarch64_rust-rpki+serde-support-devel.sha256sum] = "22264dc3580343afa307b2ec6cb68c99ea89bafc3f0905f18dfb48c6d490a877"

URI_aarch64_rust-rpki+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde_json-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde_json-devel}"
SRC_URI[aarch64_rust-rpki+serde_json-devel.sha256sum] = "01b950023b06030f9aa5cd03a144a30fc6f8b4b35201d2498f985095d2de1152"

URI_aarch64_rust-rpki+slurm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+slurm-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+slurm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+slurm-devel}"
SRC_URI[aarch64_rust-rpki+slurm-devel.sha256sum] = "032a20b5dd447372dda9c6bdb732832736494341d5699644ab5bdc68a56f057d"

URI_aarch64_rust-rpki+softkeys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+softkeys-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+softkeys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+softkeys-devel}"
SRC_URI[aarch64_rust-rpki+softkeys-devel.sha256sum] = "3f88d8192098ac69126735c481eb8b338fbe104c31a7cf6d579abace27a8a90f"

URI_aarch64_rust-rpki+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+tokio-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+tokio-devel}"
SRC_URI[aarch64_rust-rpki+tokio-devel.sha256sum] = "d05531d6e5847fa81b1a120f931a1747cf3207aaf63461624a87c1197adf3f36"

URI_aarch64_rust-rpki+untrusted-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+untrusted-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+untrusted-devel}"
SRC_URI[aarch64_rust-rpki+untrusted-devel.sha256sum] = "ca8c9b98e8c865ba781e7d19fc6d9ba1d6d5207795bb2cd1a74ab5a500cd86e1"

URI_aarch64_rust-rpki+xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+xml-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki+xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+xml-devel}"
SRC_URI[aarch64_rust-rpki+xml-devel.sha256sum] = "b119afb9df845f4c8abf89cab8c6c2f85522c02c76b7197b735ed944d8e43ede"

URI_aarch64_rust-rpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki-devel-0.18.6-1.el10_1.noarch.rpm;name=aarch64_rust-rpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki-devel}"
SRC_URI[aarch64_rust-rpki-devel.sha256sum] = "eda6eaba7abdae0b0c2992b08c463e831ce6e71f16c275d6c16f143c7e2d3ceb"

RDEPENDS:rpki = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-rpki+__windows_ci_all-devel = " \
 cargo \
 rust-rpki+ca-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-support-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono+arbitrary-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+bcder-devel = " \
 cargo \
 rust-bcder+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+ca-devel = " \
 cargo \
 rust-rpki+repository-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+serde-support-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+compat-devel = " \
 cargo \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+crypto-devel = " \
 cargo \
 rust-rpki+bcder-devel \
 rust-rpki+ring-devel \
 rust-rpki+untrusted-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+default-devel = " \
 cargo \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+openssl-devel = " \
 cargo \
 rust-openssl+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+quick-xml-devel = " \
 cargo \
 rust-quick-xml0.31+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+repository-devel = " \
 cargo \
 rust-rpki+bcder-devel \
 rust-rpki+crypto-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+rrdp-devel = " \
 cargo \
 rust-rpki+ring-devel \
 rust-rpki+xml-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+rtr-devel = " \
 cargo \
 rust-rpki+futures-util-devel \
 rust-rpki+tokio-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+serde-devel = " \
 cargo \
 rust-rpki-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rpki+serde-support-devel = " \
 cargo \
 rust-rpki+serde-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+serde_json-devel = " \
 cargo \
 rust-rpki-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rpki+slurm-devel = " \
 cargo \
 rust-rpki+rtr-devel \
 rust-rpki+serde-support-devel \
 rust-rpki+serde_json-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+softkeys-devel = " \
 cargo \
 rust-rpki+openssl-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+tokio-devel = " \
 cargo \
 rust-rpki-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-rpki+untrusted-devel = " \
 cargo \
 rust-rpki-devel \
 rust-untrusted+default-devel \
 "
RDEPENDS:rust-rpki+xml-devel = " \
 cargo \
 rust-rpki+quick-xml-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-chrono+default-devel \
 rust-chrono+serde-devel \
 rust-log+default-devel \
 rust-uuid+default-devel \
 "
