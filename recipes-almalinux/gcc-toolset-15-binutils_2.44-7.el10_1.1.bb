# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-15-binutils"
PV = "2.44"
PR = "7.el10_1.1"
PACKAGES = " \
 gcc-toolset-15-binutils \
 gcc-toolset-15-binutils-devel \
 gcc-toolset-15-binutils-gold \
 gcc-toolset-15-binutils-gprofng \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-15-binutils-2.44-7.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54696e3e045d7c5ff14763267df56c52d1dc6ac1ae72d2fd30309300f12a8769"

URI_x86_64_v2_gcc-toolset-15-binutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-binutils-2.44-7.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-binutils}"
SRC_URI[x86_64_v2_gcc-toolset-15-binutils.sha256sum] = "3abc24e621f18650ea5de6112ca113a06a214ebbb60d163a639b8e11e458500a"
RPROVIDES:gcc-toolset-15-binutils:x86_64_v2 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_x86_64_v2_gcc-toolset-15-binutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-binutils-devel-2.44-7.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-binutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-binutils-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-binutils-devel.sha256sum] = "767b32b090cf48d557de2b758c451f20a18eb57a1968a1726921c77788018aab"

URI_x86_64_v2_gcc-toolset-15-binutils-gold = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-binutils-gold-2.44-7.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-binutils-gold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-binutils-gold}"
SRC_URI[x86_64_v2_gcc-toolset-15-binutils-gold.sha256sum] = "d1d6a4affb32835f6df64a118fb6543c41552001fe585be52925cbc6687e3125"

URI_x86_64_v2_gcc-toolset-15-binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-binutils-gprofng-2.44-7.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-binutils-gprofng}"
SRC_URI[x86_64_v2_gcc-toolset-15-binutils-gprofng.sha256sum] = "dbcc71bef2ede8280cab420a54e93a1d5c42c35c27c38664f0c97ca9a02d7a9e"

URI_aarch64_gcc-toolset-15-binutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-binutils-2.44-7.el10_1.1.aarch64.rpm;name=aarch64_gcc-toolset-15-binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-binutils}"
SRC_URI[aarch64_gcc-toolset-15-binutils.sha256sum] = "7dfa98580a02b324c3da1d72570e2e9f2ec889eb748039f2c213edbbc271a8dd"
RPROVIDES:gcc-toolset-15-binutils:aarch64 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_aarch64_gcc-toolset-15-binutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-binutils-devel-2.44-7.el10_1.1.aarch64.rpm;name=aarch64_gcc-toolset-15-binutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-binutils-devel}"
SRC_URI[aarch64_gcc-toolset-15-binutils-devel.sha256sum] = "90a9feaa82c7b6e6f68eddda8142e8683b45bfb99fddd971186bf04f06b0a6a1"

URI_aarch64_gcc-toolset-15-binutils-gold = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-binutils-gold-2.44-7.el10_1.1.aarch64.rpm;name=aarch64_gcc-toolset-15-binutils-gold;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-binutils-gold}"
SRC_URI[aarch64_gcc-toolset-15-binutils-gold.sha256sum] = "485d959b6db1f1be7349a106642306ae0435d61a563aade20c05fd077fc21bfc"

URI_aarch64_gcc-toolset-15-binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-binutils-gprofng-2.44-7.el10_1.1.aarch64.rpm;name=aarch64_gcc-toolset-15-binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-binutils-gprofng}"
SRC_URI[aarch64_gcc-toolset-15-binutils-gprofng.sha256sum] = "fe3ef175bde25138372a7f7434038f38989cab0de5101c601440e85b3d960e68"

RDEPENDS:gcc-toolset-15-binutils = " \
 alternatives \
 bash \
 elfutils-debuginfod-client \
 gcc-toolset-15-runtime \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-binutils-devel = " \
 bash \
 gcc-toolset-15-binutils \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
RDEPENDS:gcc-toolset-15-binutils-gold = " \
 bash \
 gcc-toolset-15-binutils \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-binutils-gprofng = " \
 bash \
 gcc-toolset-15-binutils \
 glibc \
 libgcc \
 libstdc++ \
 virtual//usr/bin/env \
 virtual/libsframe.so.1___64bit_ \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libsframe.so.1___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libsframe.so.1___64bit_"
