# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-validator_derive"
PV = "0.20.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-validator_derive+default-devel \
 rust-validator_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-validator_derive-0.20.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "615ed81d02f455b753076004efc34ad6cabcac250ec889d8f77c933469a16a83"

URI_x86_64_v2_rust-validator_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator_derive+default-devel-0.20.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator_derive+default-devel}"
SRC_URI[x86_64_v2_rust-validator_derive+default-devel.sha256sum] = "b39d94e7a5df8ba614b783a280fcc52e1dd31cfa99675d35ce16b16c661840b9"

URI_x86_64_v2_rust-validator_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-validator_derive-devel-0.20.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-validator_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-validator_derive-devel}"
SRC_URI[x86_64_v2_rust-validator_derive-devel.sha256sum] = "965e7678efc0fce817764a12f4fd8f57653c9e53360c1d7f3f5414f753ad5cd2"

URI_aarch64_rust-validator_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator_derive+default-devel-0.20.0-2.el10_3.noarch.rpm;name=aarch64_rust-validator_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator_derive+default-devel}"
SRC_URI[aarch64_rust-validator_derive+default-devel.sha256sum] = "a06a316c5034d85668575ea0f6c9acdac7eb3529172a2bbf75fbe26f0a8def7d"

URI_aarch64_rust-validator_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-validator_derive-devel-0.20.0-2.el10_3.noarch.rpm;name=aarch64_rust-validator_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-validator_derive-devel}"
SRC_URI[aarch64_rust-validator_derive-devel.sha256sum] = "581b51a1ea8aef527ef3fa9ce8d26f60bdf8cdf394514e3a64115e9ff0c9399e"

RDEPENDS:rust-validator_derive+default-devel = " \
 cargo \
 rust-validator_derive-devel \
 "
RDEPENDS:rust-validator_derive-devel = " \
 cargo \
 rust \
 rust-darling+default-devel \
 rust-darling+suggestions-devel \
 rust-once_cell+default-devel \
 rust-proc-macro-error2+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
