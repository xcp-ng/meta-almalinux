# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-libidn2"
PV = "2.3.8"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 mingw32-libidn2 \
 mingw32-libidn2-static \
 mingw64-libidn2 \
 mingw64-libidn2-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/mingw-libidn2-2.3.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c003f7293e62f1d4e0df71885e0002ebbf79747e4c0aab9ba3da8ec8e729bcf"

URI_x86_64_v2_mingw32-libidn2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libidn2-2.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libidn2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libidn2}"
SRC_URI[x86_64_v2_mingw32-libidn2.sha256sum] = "b8ea81ab9df4e24324b99c5b5c19c75ed695949e1cd3e2c04f46e8f9a021f93a"

URI_x86_64_v2_mingw32-libidn2-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libidn2-static-2.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libidn2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libidn2-static}"
SRC_URI[x86_64_v2_mingw32-libidn2-static.sha256sum] = "a03af094a70196815d52acb7c640425ff20babac679bbea07c0d28966b2ae3c3"

URI_x86_64_v2_mingw64-libidn2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libidn2-2.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libidn2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libidn2}"
SRC_URI[x86_64_v2_mingw64-libidn2.sha256sum] = "422c92b90742057d714c373dcfb1523b10d3f985c9576832298487bd12e92858"

URI_x86_64_v2_mingw64-libidn2-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libidn2-static-2.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libidn2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libidn2-static}"
SRC_URI[x86_64_v2_mingw64-libidn2-static.sha256sum] = "a476c20c27f8e527ab54896d904c527c97055fd6c25e05549f65307fdcc31eae"

RDEPENDS:mingw32-libidn2 = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 pkgconf-pkg-config \
 "
RDEPENDS:mingw32-libidn2-static = " \
 mingw32-libidn2 \
 "
RDEPENDS:mingw64-libidn2 = " \
 mingw64-crt \
 mingw64-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:mingw64-libidn2-static = " \
 mingw64-libidn2 \
 "
