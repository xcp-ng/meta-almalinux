# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bzip2-sys"
PV = "0.1.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-bzip2-sys+__disabled-devel \
 rust-bzip2-sys+default-devel \
 rust-bzip2-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bzip2-sys-0.1.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b38cef1bbb97ace0174694d4fc0ca88b5a130f23ccd2afc9eadfcacdbf6a9254"

URI_x86_64_v2_rust-bzip2-sys+__disabled-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-sys+__disabled-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-sys+__disabled-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-sys+__disabled-devel}"
SRC_URI[x86_64_v2_rust-bzip2-sys+__disabled-devel.sha256sum] = "76c9f9b24f8bf4ced3b59efcb02860c07f388d665554e4709910678361bce11f"

URI_x86_64_v2_rust-bzip2-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-sys+default-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-sys+default-devel}"
SRC_URI[x86_64_v2_rust-bzip2-sys+default-devel.sha256sum] = "29536afaa9af7717aacca1d23da47e3a239fb8b044e9e98f5d98cf2999e0b7ce"

URI_x86_64_v2_rust-bzip2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bzip2-sys-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bzip2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bzip2-sys-devel}"
SRC_URI[x86_64_v2_rust-bzip2-sys-devel.sha256sum] = "d5c5c704b1aba12eb9be2b881bd4f363276ec26040084c034555da1f5b0aa542"

URI_aarch64_rust-bzip2-sys+__disabled-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-sys+__disabled-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-bzip2-sys+__disabled-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-sys+__disabled-devel}"
SRC_URI[aarch64_rust-bzip2-sys+__disabled-devel.sha256sum] = "c3579fe22e913db6e5a2714c16823886e925ccfa909ede181a3bf03c52183673"

URI_aarch64_rust-bzip2-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-sys+default-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-bzip2-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-sys+default-devel}"
SRC_URI[aarch64_rust-bzip2-sys+default-devel.sha256sum] = "6df11eb96ee8f8052eb4945a982cd1694e449c6fb72c527a8a117b2d3beb1acd"

URI_aarch64_rust-bzip2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bzip2-sys-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-bzip2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bzip2-sys-devel}"
SRC_URI[aarch64_rust-bzip2-sys-devel.sha256sum] = "107ecf7d69e902a90a054795950e04a044bdb597b37426c64ee349bd72dc4aaa"

RDEPENDS:rust-bzip2-sys+__disabled-devel = " \
 cargo \
 rust-bzip2-sys-devel \
 "
RDEPENDS:rust-bzip2-sys+default-devel = " \
 cargo \
 rust-bzip2-sys-devel \
 "
RDEPENDS:rust-bzip2-sys-devel = " \
 bzip2-devel \
 cargo \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 "
