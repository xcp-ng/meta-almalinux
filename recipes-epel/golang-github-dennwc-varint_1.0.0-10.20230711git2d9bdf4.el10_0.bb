# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-dennwc-varint"
PV = "1.0.0"
PR = "10.20230711git2d9bdf4.el10_0"
PACKAGES = " \
 golang-github-dennwc-varint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-dennwc-varint-1.0.0-10.20230711git2d9bdf4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ce5a027f9c259e0649142bde8193fccf5c564b09cca768432631ab7da277a5d"

URI_aarch64_golang-github-dennwc-varint-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-dennwc-varint-devel-1.0.0-10.20230711git2d9bdf4.el10_0.noarch.rpm;name=aarch64_golang-github-dennwc-varint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-dennwc-varint-devel}"
SRC_URI[aarch64_golang-github-dennwc-varint-devel.sha256sum] = "0866c6e8f9af217874086d9c4f6e77d5290a068c1087489761e345475d8d8a56"

RDEPENDS:golang-github-dennwc-varint-devel = " \
 go-filesystem \
 "
