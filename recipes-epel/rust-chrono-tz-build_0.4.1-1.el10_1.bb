# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono-tz-build"
PV = "0.4.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-chrono-tz-build+case-insensitive-devel \
 rust-chrono-tz-build+default-devel \
 rust-chrono-tz-build+filter-by-regex-devel \
 rust-chrono-tz-build+phf_shared-devel \
 rust-chrono-tz-build+regex-devel \
 rust-chrono-tz-build+uncased-devel \
 rust-chrono-tz-build-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-tz-build-0.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53e364bf73a033ee0a8a2cf3c09c39a5ae3da2884726c17dc9177db7c8930378"

URI_x86_64_v2_rust-chrono-tz-build+case-insensitive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+case-insensitive-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+case-insensitive-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+case-insensitive-devel.sha256sum] = "9f15de3a2d3d005e416492ae3c0b3dd49fea6f09f7cfb1c821306ac62b885eab"

URI_x86_64_v2_rust-chrono-tz-build+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+default-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+default-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+default-devel.sha256sum] = "29cde3842406c515ac69d07b5f440c8fcff441cbf59a985396d94967686eaaba"

URI_x86_64_v2_rust-chrono-tz-build+filter-by-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+filter-by-regex-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+filter-by-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+filter-by-regex-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+filter-by-regex-devel.sha256sum] = "df2b1140d8dc8106d803ca87390a4aa5dcb06ac04c4dd056c1bc628fe1cbd2ac"

URI_x86_64_v2_rust-chrono-tz-build+phf_shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+phf_shared-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+phf_shared-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+phf_shared-devel.sha256sum] = "a47b79f41beba3dfb331bb054f3c595303d95ca6ce1384c12c62d912f0c55c2a"

URI_x86_64_v2_rust-chrono-tz-build+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+regex-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+regex-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+regex-devel.sha256sum] = "32ab3267ca745fe8d26ffc7db724fb8aa58d3f689406757fe342ff4c911fdf29"

URI_x86_64_v2_rust-chrono-tz-build+uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build+uncased-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build+uncased-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build+uncased-devel.sha256sum] = "03140696bf8628fd145e45f523ad0b748c567299b8be8057bfcd3a81dbc0da3b"

URI_x86_64_v2_rust-chrono-tz-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-build-devel-0.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-build-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-build-devel.sha256sum] = "220b3c78e3e4946102419455449728ddfcf0320ebcb00b6b6d14bf2c1900fe84"

URI_aarch64_rust-chrono-tz-build+case-insensitive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+case-insensitive-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz-build+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+case-insensitive-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+case-insensitive-devel.sha256sum] = "a4ea9f49c9ebe33297c5b99513be4d512849860fbfe0fe653ec55d6baf75d9c6"

URI_aarch64_rust-chrono-tz-build+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+default-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+default-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+default-devel.sha256sum] = "3d32aee934b4199063a4282a0073979957b49d25306e980006f7cd95676ab277"

URI_aarch64_rust-chrono-tz-build+filter-by-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+filter-by-regex-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz-build+filter-by-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+filter-by-regex-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+filter-by-regex-devel.sha256sum] = "27f129509c965105892c55a63a7e6527af47f0e0bb9a349feda6f1101350b59f"

URI_aarch64_rust-chrono-tz-build+phf_shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+phf_shared-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz-build+phf_shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+phf_shared-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+phf_shared-devel.sha256sum] = "3ade974e8ed7ab58fa14bb0f835cd23fc8f3636df0d6b831856bb230e2494d0f"

URI_aarch64_rust-chrono-tz-build+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+regex-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz-build+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+regex-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+regex-devel.sha256sum] = "8ee084fb90a0382ff7ffcaacddef7934f80530edf1260ecb9b8ad0f64ea02cfd"

URI_aarch64_rust-chrono-tz-build+uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build+uncased-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz-build+uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build+uncased-devel}"
SRC_URI[aarch64_rust-chrono-tz-build+uncased-devel.sha256sum] = "d058925bf5bb8098237d4d36564541a409220289d7e0cb275b586a06d6d02492"

URI_aarch64_rust-chrono-tz-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-build-devel-0.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-build-devel}"
SRC_URI[aarch64_rust-chrono-tz-build-devel.sha256sum] = "c84a5d64f00db9bf14a40602fd2782506c727e9de66b3696299b4d55b1d1608e"

RDEPENDS:rust-chrono-tz-build+case-insensitive-devel = " \
 cargo \
 rust-chrono-tz-build+uncased-devel \
 rust-chrono-tz-build-devel \
 rust-phf_shared+uncased-devel \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-chrono-tz-build+default-devel = " \
 cargo \
 rust-chrono-tz-build-devel \
 "
RDEPENDS:rust-chrono-tz-build+filter-by-regex-devel = " \
 cargo \
 rust-chrono-tz-build+regex-devel \
 rust-chrono-tz-build-devel \
 "
RDEPENDS:rust-chrono-tz-build+phf_shared-devel = " \
 cargo \
 rust-chrono-tz-build-devel \
 rust-phf_shared-devel \
 "
RDEPENDS:rust-chrono-tz-build+regex-devel = " \
 cargo \
 rust-chrono-tz-build-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-chrono-tz-build+uncased-devel = " \
 cargo \
 rust-chrono-tz-build-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-chrono-tz-build-devel = " \
 cargo \
 rust \
 rust-parse-zoneinfo+default-devel \
 rust-phf_codegen-devel \
 "
