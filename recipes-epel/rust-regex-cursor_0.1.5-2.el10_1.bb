# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-cursor"
PV = "0.1.5"
PR = "2.el10_1"
PACKAGES = " \
 rust-regex-cursor+default-devel \
 rust-regex-cursor+perf-inline-devel \
 rust-regex-cursor+ropey-devel \
 rust-regex-cursor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-cursor-0.1.5-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6efff0363dc8494fbe32c0f8a0d7d4f22dc420d3c4e7c8f01238831280ee8061"

URI_x86_64_v2_rust-regex-cursor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-cursor+default-devel-0.1.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-cursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-cursor+default-devel}"
SRC_URI[x86_64_v2_rust-regex-cursor+default-devel.sha256sum] = "54d08b463f032fc10be8234707af9cdf6f843f493ae3db0a11f97333fc2151e2"

URI_x86_64_v2_rust-regex-cursor+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-cursor+perf-inline-devel-0.1.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-cursor+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-cursor+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-regex-cursor+perf-inline-devel.sha256sum] = "7fee33ce0fa6bc64df7388ddf12f6ca2a3752f639e1ab2ad18e821157398616f"

URI_x86_64_v2_rust-regex-cursor+ropey-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-cursor+ropey-devel-0.1.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-cursor+ropey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-cursor+ropey-devel}"
SRC_URI[x86_64_v2_rust-regex-cursor+ropey-devel.sha256sum] = "5f26942a6132ca3d41d3d2b9f87facfdb049991ec0a37d1529ebe186a4e8b37b"

URI_x86_64_v2_rust-regex-cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-cursor-devel-0.1.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-cursor-devel}"
SRC_URI[x86_64_v2_rust-regex-cursor-devel.sha256sum] = "72523c8cc57ef997d2e80cceb6a45e326a9dd84e3f39b97fc0c5c04c3d87cb32"

URI_aarch64_rust-regex-cursor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-cursor+default-devel-0.1.5-2.el10_1.noarch.rpm;name=aarch64_rust-regex-cursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-cursor+default-devel}"
SRC_URI[aarch64_rust-regex-cursor+default-devel.sha256sum] = "e4561667b4dc3091ae23b733a6ed40d5a44df2fe8d5d7326e880700d085f0320"

URI_aarch64_rust-regex-cursor+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-cursor+perf-inline-devel-0.1.5-2.el10_1.noarch.rpm;name=aarch64_rust-regex-cursor+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-cursor+perf-inline-devel}"
SRC_URI[aarch64_rust-regex-cursor+perf-inline-devel.sha256sum] = "29825041693951d77c23ecfd4168ec108331b52804984016d40d2e9f86967c46"

URI_aarch64_rust-regex-cursor+ropey-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-cursor+ropey-devel-0.1.5-2.el10_1.noarch.rpm;name=aarch64_rust-regex-cursor+ropey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-cursor+ropey-devel}"
SRC_URI[aarch64_rust-regex-cursor+ropey-devel.sha256sum] = "aeb246d955773dc56fd77f073276f9abae06d7dc48eddf4e5192011683f49e27"

URI_aarch64_rust-regex-cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-cursor-devel-0.1.5-2.el10_1.noarch.rpm;name=aarch64_rust-regex-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-cursor-devel}"
SRC_URI[aarch64_rust-regex-cursor-devel.sha256sum] = "5eadde42b1a6807e052fde23c8dc8975d5d87a719d2a946a34886d8a7b2aa41d"

RDEPENDS:rust-regex-cursor+default-devel = " \
 cargo \
 rust-regex-cursor+perf-inline-devel \
 rust-regex-cursor+ropey-devel \
 rust-regex-cursor-devel \
 "
RDEPENDS:rust-regex-cursor+perf-inline-devel = " \
 cargo \
 rust-regex-cursor-devel \
 "
RDEPENDS:rust-regex-cursor+ropey-devel = " \
 cargo \
 rust-regex-cursor-devel \
 rust-ropey-devel \
 "
RDEPENDS:rust-regex-cursor-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-regex-automata+default-devel \
 rust-regex-syntax+default-devel \
 "
