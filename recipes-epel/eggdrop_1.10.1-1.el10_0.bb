# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eggdrop"
PV = "1.10.1"
PR = "1.el10_0"
PACKAGES = " \
 eggdrop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/eggdrop-1.10.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9916a330e3911a653d99ae306c2ca5612998e667ebc81c37979ec8c960ae3f1f"

URI_x86_64_v2_eggdrop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eggdrop-1.10.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eggdrop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eggdrop}"
SRC_URI[x86_64_v2_eggdrop.sha256sum] = "b0dff8f0e09975c70310497f84c0b7e74b56824fd9c18bc9b15a101b59ef017f"

URI_aarch64_eggdrop = "${EPEL_MIRROR}/aarch64/Packages/e/eggdrop-1.10.1-1.el10_0.aarch64.rpm;name=aarch64_eggdrop;unpack=0"
SRC_URI:append = " ${URI_aarch64_eggdrop}"
SRC_URI[aarch64_eggdrop.sha256sum] = "03ec99dbce0ca4b25e16503eee4def99d54f027fe218ac58e61f4dc196650c6f"

RDEPENDS:eggdrop = " \
 bash \
 glibc \
 openssl-libs \
 python3-libs \
 tcl \
 zlib-ng-compat \
 "
