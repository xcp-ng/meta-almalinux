# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-astroid"
PV = "3.3.8"
PR = "1.el10_0"
PACKAGES = " \
 python3-astroid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-astroid-3.3.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f158dd754ce9f0c864b3619c1b89ad565e3753730d01f36c5657f32ce3edf9e"

URI_x86_64_v2_python3-astroid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-astroid-3.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-astroid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-astroid}"
SRC_URI[x86_64_v2_python3-astroid.sha256sum] = "14b7ba3f8d43c6471b7f634b2807d1b00ed7aea6698b80e0b7ad29af6563f4e3"

URI_aarch64_python3-astroid = "${EPEL_MIRROR}/aarch64/Packages/p/python3-astroid-3.3.8-1.el10_0.noarch.rpm;name=aarch64_python3-astroid;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-astroid}"
SRC_URI[aarch64_python3-astroid.sha256sum] = "0a6ef916057e85075f9c098c4a58e2ded80814a58c478af0c1f54f6e7efaa99a"

RDEPENDS:python3-astroid = " \
 python3 \
 "
