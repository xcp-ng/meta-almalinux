# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rit-meera-new-fonts"
PV = "1.5.2"
PR = "6.el10"
PACKAGES = " \
 rit-meera-new-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rit-meera-new-fonts-1.5.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a932e7d356a09db1868164597bcdfd529ec1211d04731c596d89e194eb725106"

URI_x86_64_v2_rit-meera-new-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rit-meera-new-fonts-1.5.2-6.el10.noarch.rpm;name=x86_64_v2_rit-meera-new-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rit-meera-new-fonts}"
SRC_URI[x86_64_v2_rit-meera-new-fonts.sha256sum] = "2e8db368b2b6712932c40c69687e74683838de54d04dfc08fd728d4674bf0a34"

URI_aarch64_rit-meera-new-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rit-meera-new-fonts-1.5.2-6.el10.noarch.rpm;name=aarch64_rit-meera-new-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_rit-meera-new-fonts}"
SRC_URI[aarch64_rit-meera-new-fonts.sha256sum] = "2e8db368b2b6712932c40c69687e74683838de54d04dfc08fd728d4674bf0a34"

RDEPENDS:rit-meera-new-fonts = " \
 fonts-filesystem \
 "
