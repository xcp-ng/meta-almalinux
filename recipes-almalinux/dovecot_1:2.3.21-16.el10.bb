# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dovecot"
PE = "1"
PV = "2.3.21"
PR = "16.el10"
PACKAGES = " \
 dovecot \
 dovecot-devel \
 dovecot-mysql \
 dovecot-pgsql \
 dovecot-pigeonhole \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dovecot-2.3.21-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd90972662bb363f798daceac39160a4f4dc9a3b5324ccc6eb43ee7bdb4feb22"

URI_x86_64_v2_dovecot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-2.3.21-16.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot}"
SRC_URI[x86_64_v2_dovecot.sha256sum] = "c73370da437ffc7638800dfa3b4d61bad342ce0a9b4339db63235a2352c8270c"

URI_x86_64_v2_dovecot-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dovecot-devel-2.3.21-16.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-devel}"
SRC_URI[x86_64_v2_dovecot-devel.sha256sum] = "aa75df8e601756a7088cd4a0eed5ea963acd8b01af547828e63022bf393c8d33"

URI_x86_64_v2_dovecot-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-mysql-2.3.21-16.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-mysql}"
SRC_URI[x86_64_v2_dovecot-mysql.sha256sum] = "07d496a8714be88ea36a0cf9a5f2440d415f6aa15bd9b5fe9d3a0ec153ef0f35"

URI_x86_64_v2_dovecot-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pgsql-2.3.21-16.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-pgsql}"
SRC_URI[x86_64_v2_dovecot-pgsql.sha256sum] = "f5cfb609f6ffb93ced77c666c3b9181f9f9d2fea155a52dda1b87143ef9f4841"

URI_x86_64_v2_dovecot-pigeonhole = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pigeonhole-2.3.21-16.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-pigeonhole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-pigeonhole}"
SRC_URI[x86_64_v2_dovecot-pigeonhole.sha256sum] = "9ef18635790a0fca84bf1b0a4cb9f3c4f8082121c782166737f54030d52b9a9e"

URI_aarch64_dovecot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-2.3.21-16.el10.aarch64.rpm;name=aarch64_dovecot;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot}"
SRC_URI[aarch64_dovecot.sha256sum] = "b883ae9e46aecd1a1cca54f2da3fc29f8d8efb93b81548e7be8772bba396165b"

URI_aarch64_dovecot-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dovecot-devel-2.3.21-16.el10.aarch64.rpm;name=aarch64_dovecot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-devel}"
SRC_URI[aarch64_dovecot-devel.sha256sum] = "e508063e8f887520a166b87ae4c7831465fb3872f105398fdf169c36c3f47e43"

URI_aarch64_dovecot-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-mysql-2.3.21-16.el10.aarch64.rpm;name=aarch64_dovecot-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-mysql}"
SRC_URI[aarch64_dovecot-mysql.sha256sum] = "adb9266d669a3dd6c5d2e1c58afb208520bb4f6ec9ae947cb352670d1bcecabe"

URI_aarch64_dovecot-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pgsql-2.3.21-16.el10.aarch64.rpm;name=aarch64_dovecot-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-pgsql}"
SRC_URI[aarch64_dovecot-pgsql.sha256sum] = "1798488cccf415d6cd346239cb14496551880f0fe4043d0728c492131c2c10d3"

URI_aarch64_dovecot-pigeonhole = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pigeonhole-2.3.21-16.el10.aarch64.rpm;name=aarch64_dovecot-pigeonhole;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-pigeonhole}"
SRC_URI[aarch64_dovecot-pigeonhole.sha256sum] = "aae035d3dd0c627dd49d3c7ad3ce0edda92267fba6b2b308ac2161d493d099ce"

RDEPENDS:dovecot = " \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libcap \
 libcom_err \
 libicu \
 libxcrypt \
 libzstd \
 lz4-libs \
 openldap \
 openssl \
 openssl-libs \
 pam-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:dovecot-devel = " \
 dovecot \
 "
RDEPENDS:dovecot-mysql = " \
 dovecot \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:dovecot-pgsql = " \
 dovecot \
 glibc \
 libpq \
 "
RDEPENDS:dovecot-pigeonhole = " \
 dovecot \
 glibc \
 "
