# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtatsu"
PV = "1.0.3"
PR = "1.el10_0"
PACKAGES = " \
 libtatsu \
 libtatsu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libtatsu-1.0.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "232bedbacb47b91b6823644a2a3ab24dac88f7a598f7b36d7f63f22b53ef7b9f"

URI_x86_64_v2_libtatsu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtatsu-1.0.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtatsu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtatsu}"
SRC_URI[x86_64_v2_libtatsu.sha256sum] = "6c3f17142ceef7ee13054a8b670c00a6f33205169b7241cd4f7fa925891ee0bb"

URI_x86_64_v2_libtatsu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtatsu-devel-1.0.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtatsu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtatsu-devel}"
SRC_URI[x86_64_v2_libtatsu-devel.sha256sum] = "e1d3358734a8a64a8aa35d4407c1a57abd4ace9821974054416c7accb6b6a07b"

URI_aarch64_libtatsu = "${EPEL_MIRROR}/aarch64/Packages/l/libtatsu-1.0.3-1.el10_0.aarch64.rpm;name=aarch64_libtatsu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtatsu}"
SRC_URI[aarch64_libtatsu.sha256sum] = "b25560d69106b75a6a3be712a2982fee366b0aef8b18f57d3df3bc8b657179a4"

URI_aarch64_libtatsu-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libtatsu-devel-1.0.3-1.el10_0.aarch64.rpm;name=aarch64_libtatsu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtatsu-devel}"
SRC_URI[aarch64_libtatsu-devel.sha256sum] = "f23bc5467591ffbfb3dfd5c1386b860fadfd81124ea02a1ce9587a3112e2dd9e"

RDEPENDS:libtatsu = " \
 glibc \
 libplist \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libtatsu-devel = " \
 libplist-devel \
 libtatsu \
 pkgconf-pkg-config \
 "
