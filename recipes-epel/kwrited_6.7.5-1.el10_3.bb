# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwrited"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kwrited \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kwrited-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e65c8358f4a1b8da46c6c54de1f5d5740d865369a9ed045815f0df00bc6dcb8c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwrited-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwrited;unpack=0"
SRC_URI[x86_64_v2_kwrited.sha256sum] = "6b14c043041db345d7b6419ace1a4c9454d05cdc2ddbace00a92c00c44d29eae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwrited-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kwrited;unpack=0"
SRC_URI[aarch64_kwrited.sha256sum] = "c7804195f90f7972b853c6e3be682a7100705230cc3c8113798a684758437d61"

RDEPENDS:kwrited = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-knotifications \
 kf6-kpty \
 libstdc++ \
 qt6-qtbase \
 "
