# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-toml-parser"
PV = "1.3.2.0"
PR = "5.el10_0"
PACKAGES = " \
 ghc-toml-parser \
 ghc-toml-parser-devel \
 ghc-toml-parser-doc \
 ghc-toml-parser-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-toml-parser-1.3.2.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42100b3bcb24907239a63d00ad13fe0eaa0eeac9684ae11b8faee9c32ae7583c"

URI_x86_64_v2_ghc-toml-parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-toml-parser-1.3.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-toml-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-toml-parser}"
SRC_URI[x86_64_v2_ghc-toml-parser.sha256sum] = "6155ad2ce1790d58b11c513f20db29889b3bb1a3e11fe8c5e9ea56b2054d7762"

URI_x86_64_v2_ghc-toml-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-toml-parser-devel-1.3.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-toml-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-toml-parser-devel}"
SRC_URI[x86_64_v2_ghc-toml-parser-devel.sha256sum] = "f4917ef4733981a0150b12932f265705e0c1f4c9cc99710929e9296101222705"

URI_x86_64_v2_ghc-toml-parser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-toml-parser-doc-1.3.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-toml-parser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-toml-parser-doc}"
SRC_URI[x86_64_v2_ghc-toml-parser-doc.sha256sum] = "f00066e67e28b1a5f074ee32424bb26dd57ee7c149d2cceb7f42bce4905dc7fd"

URI_x86_64_v2_ghc-toml-parser-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-toml-parser-prof-1.3.2.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-toml-parser-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-toml-parser-prof}"
SRC_URI[x86_64_v2_ghc-toml-parser-prof.sha256sum] = "6749068013d09a699e97ec2306b4e5ebad8faad20c14a8497b4becfa5e98e6bf"

URI_aarch64_ghc-toml-parser = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-toml-parser-1.3.2.0-5.el10_0.aarch64.rpm;name=aarch64_ghc-toml-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-toml-parser}"
SRC_URI[aarch64_ghc-toml-parser.sha256sum] = "037fbc9aa02f8d674d2a4e3d7cf41afcbb6ff4d456d4cc4d02a2f36a839ef5e9"

URI_aarch64_ghc-toml-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-toml-parser-devel-1.3.2.0-5.el10_0.aarch64.rpm;name=aarch64_ghc-toml-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-toml-parser-devel}"
SRC_URI[aarch64_ghc-toml-parser-devel.sha256sum] = "59461987e1ff618cacaf27d80cffe2186dacb66d14c1728b35779d3465646558"

URI_aarch64_ghc-toml-parser-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-toml-parser-doc-1.3.2.0-5.el10_0.noarch.rpm;name=aarch64_ghc-toml-parser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-toml-parser-doc}"
SRC_URI[aarch64_ghc-toml-parser-doc.sha256sum] = "5164443d7e59ca92053b148d506bc5f09647c77f9cc1eb024fe1bd0bb856c72a"

URI_aarch64_ghc-toml-parser-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-toml-parser-prof-1.3.2.0-5.el10_0.aarch64.rpm;name=aarch64_ghc-toml-parser-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-toml-parser-prof}"
SRC_URI[aarch64_ghc-toml-parser-prof.sha256sum] = "cd3a46b5e3b7670897db7c1d3bd6f5fdfe2f4d344290bf1f3c568c07c7dad6d9"

RDEPENDS:ghc-toml-parser = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-toml-parser-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-prettyprinter-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-toml-parser \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-toml-parser-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-toml-parser-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-prettyprinter-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-toml-parser-devel \
 ghc-transformers-prof \
 "
