# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "killbots"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 killbots \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/killbots-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2c0b4d3021b6144f9463d6dc7e710994e3e832db9d17351ad6ded0f1f93444a"

URI_x86_64_v2_killbots = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/killbots-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_killbots;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_killbots}"
SRC_URI[x86_64_v2_killbots.sha256sum] = "d16ccde616b4fa08d47a107aac3bce8071ee6040d7632fa0494ef57ae8235f12"

URI_aarch64_killbots = "${EPEL_MIRROR}/aarch64/Packages/k/killbots-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_killbots;unpack=0"
SRC_URI:append = " ${URI_aarch64_killbots}"
SRC_URI[aarch64_killbots.sha256sum] = "10f7746782a2dd5201e4e4fcda7f18dcbdda395675028024982be070c2df8b93"

RDEPENDS:killbots = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
