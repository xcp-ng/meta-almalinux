# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mozilla-PublicSuffix"
PV = "1.0.7"
PR = "1.el10_0"
PACKAGES = " \
 perl-Mozilla-PublicSuffix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mozilla-PublicSuffix-1.0.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffd5b0b7cc70cdbed2101b3a16e5415107d045e71def496230b0fc72c815457c"

URI_x86_64_v2_perl-Mozilla-PublicSuffix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mozilla-PublicSuffix-1.0.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mozilla-PublicSuffix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mozilla-PublicSuffix}"
SRC_URI[x86_64_v2_perl-Mozilla-PublicSuffix.sha256sum] = "bc4e4d1523e82303e98e1eeb68671777ce153e89cd7d7565624574b0df7ace59"

URI_aarch64_perl-Mozilla-PublicSuffix = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mozilla-PublicSuffix-1.0.7-1.el10_0.noarch.rpm;name=aarch64_perl-Mozilla-PublicSuffix;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mozilla-PublicSuffix}"
SRC_URI[aarch64_perl-Mozilla-PublicSuffix.sha256sum] = "d4ebe08017134ab5377c5c7913969802536187ed42c6509c4f5e882c6f9fb08f"

RDEPENDS:perl-Mozilla-PublicSuffix = " \
 perl-Exporter \
 perl-URI \
 perl-libs \
 perl-open \
 publicsuffix-list \
 "
