# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-LibBuilder"
PV = "0.09"
PR = "3.el10_3"
PACKAGES = " \
 perl-ExtUtils-LibBuilder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-LibBuilder-0.09-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbaf5a427fb33ceba6b7d58fc12e89e074cc110a1f2c245dcc1e8968849efb7f"

URI_x86_64_v2_perl-ExtUtils-LibBuilder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-LibBuilder-0.09-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-LibBuilder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-LibBuilder}"
SRC_URI[x86_64_v2_perl-ExtUtils-LibBuilder.sha256sum] = "9ea803934e5c2633add28537a204eab6b480b1e5d0365236b84e6cfd51a675c7"

URI_aarch64_perl-ExtUtils-LibBuilder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-LibBuilder-0.09-3.el10_3.noarch.rpm;name=aarch64_perl-ExtUtils-LibBuilder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-LibBuilder}"
SRC_URI[aarch64_perl-ExtUtils-LibBuilder.sha256sum] = "8456449f5795f802fb0f00ff4215065feccec49c2b94a108afd8abaadee1d787"

RDEPENDS:perl-ExtUtils-LibBuilder = " \
 perl-ExtUtils-CBuilder \
 perl-File-Temp \
 perl-PathTools \
 perl-base \
 perl-libs \
 "
