# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kldap"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kldap \
 kldap-devel \
 kldap-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kldap-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c500e986a2e9f612460b23641c4566a7f4af9dc8bb797fa8348ecc972b0dba42"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap;unpack=0"
SRC_URI[x86_64_v2_kldap.sha256sum] = "e25ef5156a5f2fa22100219fdbbae9e1db4f47f5cc2ea5769e3a23d37531adbc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kldap-devel;unpack=0"
SRC_URI[x86_64_v2_kldap-devel.sha256sum] = "9106ffdc907d253d1a7341707a53c12d2232348b02f5615ec4ba99e6211a2e31"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kldap-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kldap-doc;unpack=0"
SRC_URI[x86_64_v2_kldap-doc.sha256sum] = "68cc8c1bef4c75b288855aef55080c95cd4a178665a4b339c093bc9705bf8195"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kldap-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kldap;unpack=0"
SRC_URI[aarch64_kldap.sha256sum] = "9cc4863e13d0a89e7ed2bb83b4e197cb67aecf66ffce2a9b3916352bf922d437"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kldap-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kldap-devel;unpack=0"
SRC_URI[aarch64_kldap-devel.sha256sum] = "eba24cba980495c2d1326217ef5b33c29832886591e4cda470599b02a352385e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kldap-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kldap-doc;unpack=0"
SRC_URI[aarch64_kldap-doc.sha256sum] = "f3d897936e36281038de4f874cb720dac68f7ee647d32a3556b2d550c1aeb338"

RDEPENDS:kldap = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 openldap \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kldap-devel = " \
 cmake-filesystem \
 cyrus-sasl-devel \
 kldap \
 openldap-devel \
 "
RDEPENDS:kldap-doc = " \
 "
