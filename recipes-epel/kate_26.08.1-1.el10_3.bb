# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kate"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kate \
 kate-libs \
 kate-plugins \
 kwrite \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kate-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4cf78f7d303efc7731f4aa25a74f12c19bf0ab11f2f7f165dd9d77ce5c50e63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate;unpack=0"
SRC_URI[x86_64_v2_kate.sha256sum] = "c788b71e46117c885ccaf911f8f1a28bc11e9b7ecd3664a1d37544298bf32449"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-libs;unpack=0"
SRC_URI[x86_64_v2_kate-libs.sha256sum] = "776913797c5e763ccdb3092c66b7f3a9ca6b8f5956701e92c011e814da5fa085"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-plugins-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-plugins;unpack=0"
SRC_URI[x86_64_v2_kate-plugins.sha256sum] = "7cc4df3d1aa261d3fe9ab8fb09187c53b4fb3dbf12848ae4083b0c5896767bc2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwrite-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwrite;unpack=0"
SRC_URI[x86_64_v2_kwrite.sha256sum] = "659194f3e5f6a78fbcd247282544aa1c2cbb81045572f1c24e456beb24edf0fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kate-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kate;unpack=0"
SRC_URI[aarch64_kate.sha256sum] = "1222b32917f202dae62ac5255bd6970f1337bca7c95593ff3c93d9e52d71c789"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kate-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kate-libs;unpack=0"
SRC_URI[aarch64_kate-libs.sha256sum] = "594269ebf98a192115fc31828923d7ab57eb66108ab3a261628e06eff31a52d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kate-plugins-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kate-plugins;unpack=0"
SRC_URI[aarch64_kate-plugins.sha256sum] = "60170852bf7fc1bd9f996122643a8090802d41deb0645cb1a660a39e3425e52b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwrite-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kwrite;unpack=0"
SRC_URI[aarch64_kwrite.sha256sum] = "842cf3201a4bf68632e0f18aa8608a35288634573e28ff9177898c4d575b2a35"

RDEPENDS:kate = " \
 glibc \
 kate-libs \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kate-libs = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kate-plugins = " \
 bash \
 glibc \
 kate \
 kate-libs \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-kparts \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
RDEPENDS:kwrite = " \
 glibc \
 kate-libs \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
