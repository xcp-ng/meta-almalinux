# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llhttp"
PV = "9.1.3"
PR = "10.el10"
PACKAGES = " \
 llhttp \
 llhttp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/llhttp-9.1.3-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "582e6ac425cf66ddbec3749199bb2b26e673cf5e92a33be6748d3a3d1855dd2b"

URI_x86_64_v2_llhttp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llhttp-9.1.3-10.el10.x86_64_v2.rpm;name=x86_64_v2_llhttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llhttp}"
SRC_URI[x86_64_v2_llhttp.sha256sum] = "4008fc78a3c7bdf2fa3161263a65a40ce4c38cca14cf9da93a66087ea7a4ddf9"

URI_x86_64_v2_llhttp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/llhttp-devel-9.1.3-10.el10.x86_64_v2.rpm;name=x86_64_v2_llhttp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llhttp-devel}"
SRC_URI[x86_64_v2_llhttp-devel.sha256sum] = "54492f8c4ede7dcc009ab62b202b060b979ced3731a37796b05e70296719d1e4"

URI_aarch64_llhttp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llhttp-9.1.3-10.el10.aarch64.rpm;name=aarch64_llhttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_llhttp}"
SRC_URI[aarch64_llhttp.sha256sum] = "89a79fc3b766a5fd94b16a71fa6ae93ba2e655c5627a451a3301552fe72141a8"

URI_aarch64_llhttp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/llhttp-devel-9.1.3-10.el10.aarch64.rpm;name=aarch64_llhttp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llhttp-devel}"
SRC_URI[aarch64_llhttp-devel.sha256sum] = "e9bf03fff17eeb56091ff0e00d4749dd27e32bdb66e54965ac1faa8a5aedc02e"

RDEPENDS:llhttp = " \
 glibc \
 "
RDEPENDS:llhttp-devel = " \
 cmake-filesystem \
 llhttp \
 pkgconf-pkg-config \
 "
