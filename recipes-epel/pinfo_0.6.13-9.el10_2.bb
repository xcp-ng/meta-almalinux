# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pinfo"
PV = "0.6.13"
PR = "9.el10_2"
PACKAGES = " \
 pinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pinfo-0.6.13-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "454e86d1f4f58390348b620add2962052b12aa5d1ff9c1fdba8f7e4b52430348"

URI_x86_64_v2_pinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pinfo-0.6.13-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pinfo}"
SRC_URI[x86_64_v2_pinfo.sha256sum] = "6273ef6f65c6e1963eea424c649a1c6be917bbb6b366dd1e2e0059df2714da49"

URI_aarch64_pinfo = "${EPEL_MIRROR}/aarch64/Packages/p/pinfo-0.6.13-9.el10_2.aarch64.rpm;name=aarch64_pinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_pinfo}"
SRC_URI[aarch64_pinfo.sha256sum] = "603149e4bf83079af19d9f967b67b9e0734eb5435434f0c3fc3071ff224e687b"

RDEPENDS:pinfo = " \
 glibc \
 ncurses-libs \
 xdg-utils \
 "
