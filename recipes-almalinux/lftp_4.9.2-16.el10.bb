# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lftp"
PV = "4.9.2"
PR = "16.el10"
PACKAGES = " \
 lftp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lftp-4.9.2-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "386ea45ec3d41050e1f8cde7ae9211d727521b58dafba6dcb5de33b66ef684e8"

URI_x86_64_v2_lftp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lftp-4.9.2-16.el10.x86_64_v2.rpm;name=x86_64_v2_lftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lftp}"
SRC_URI[x86_64_v2_lftp.sha256sum] = "bbd56c85ef2c5051e15f4c448d02aa981c12c3b67c280200717e11fed0fd2daa"

URI_aarch64_lftp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lftp-4.9.2-16.el10.aarch64.rpm;name=aarch64_lftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_lftp}"
SRC_URI[aarch64_lftp.sha256sum] = "f41cccd509648b3b275cca4438a23bb46428631e6b479c1846566537f0cdefbd"

RDEPENDS:lftp = " \
 bash \
 glibc \
 gnutls \
 libgcc \
 libidn2 \
 libstdc++ \
 ncurses-libs \
 readline \
 zlib-ng-compat \
 "
