# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duo_unix"
PV = "2.2.3"
PR = "1.el10_1"
PACKAGES = " \
 duo_unix \
 duo_unix-devel \
 duo_unix-doc \
 duo_unix-selinux \
 pam_duo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/duo_unix-2.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61a7434673ed0a6820fb604b3aaabebb76811747e4c063db0ec6239c6ad48983"

URI_x86_64_v2_duo_unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-2.2.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duo_unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix}"
SRC_URI[x86_64_v2_duo_unix.sha256sum] = "2254561a64508dac61f7f531c8f2d9be2eb3f168bb4014a22f5b58326f42f847"

URI_x86_64_v2_duo_unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-devel-2.2.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duo_unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix-devel}"
SRC_URI[x86_64_v2_duo_unix-devel.sha256sum] = "0b1b2eadde33f0ca84a554cbbd2e78b9b2978c34c3438485506ab84fcf4100b5"

URI_x86_64_v2_duo_unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-doc-2.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_duo_unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix-doc}"
SRC_URI[x86_64_v2_duo_unix-doc.sha256sum] = "9c5af003fa8becd596f85447bfa1360a362f6caf592e3cfb44f43e5c0b017502"

URI_x86_64_v2_duo_unix-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duo_unix-selinux-2.2.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duo_unix-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duo_unix-selinux}"
SRC_URI[x86_64_v2_duo_unix-selinux.sha256sum] = "bc22358c92e97588dca9a408c418adf7a424ee7743d323c78b56684a088092b8"

URI_x86_64_v2_pam_duo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_duo-2.2.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_duo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_duo}"
SRC_URI[x86_64_v2_pam_duo.sha256sum] = "77282aa2057b7b29aef97dc89cce988c8586d3ada198f3e6092f11b224b34d48"

URI_aarch64_duo_unix = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-2.2.3-1.el10_1.aarch64.rpm;name=aarch64_duo_unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix}"
SRC_URI[aarch64_duo_unix.sha256sum] = "4e82eaddce87b5725ff2f257c00723d8521044af32ce71bab17fda0dffbc4059"

URI_aarch64_duo_unix-devel = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-devel-2.2.3-1.el10_1.aarch64.rpm;name=aarch64_duo_unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix-devel}"
SRC_URI[aarch64_duo_unix-devel.sha256sum] = "501d91652c63d5c365db81aa26c7c23accc81c93ec0728ac0860b1f3c410b1f9"

URI_aarch64_duo_unix-doc = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-doc-2.2.3-1.el10_1.noarch.rpm;name=aarch64_duo_unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix-doc}"
SRC_URI[aarch64_duo_unix-doc.sha256sum] = "da7b39fd9afab424b87a6f11d2f1126bbae1946b650a641de11451b66a250656"

URI_aarch64_duo_unix-selinux = "${EPEL_MIRROR}/aarch64/Packages/d/duo_unix-selinux-2.2.3-1.el10_1.aarch64.rpm;name=aarch64_duo_unix-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_duo_unix-selinux}"
SRC_URI[aarch64_duo_unix-selinux.sha256sum] = "cce8c8417603f30c0ea4320a5cd8a3fa8003a714bafe123f0096055404e93540"

URI_aarch64_pam_duo = "${EPEL_MIRROR}/aarch64/Packages/p/pam_duo-2.2.3-1.el10_1.aarch64.rpm;name=aarch64_pam_duo;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_duo}"
SRC_URI[aarch64_pam_duo.sha256sum] = "7ed8311f41b3b1022c2bf7c3d9f156d07ff666d6f6f5a5b8830de859d76bd372"

RDEPENDS:duo_unix = " \
 bash \
 glibc \
 openssl-libs \
 "
RDEPENDS:duo_unix-devel = " \
 duo_unix \
 openssl-devel \
 pam_duo \
 pkgconf-pkg-config \
 "
RDEPENDS:duo_unix-doc = " \
 "
RDEPENDS:duo_unix-selinux = " \
 bash \
 libselinux-utils \
 pam_duo \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:pam_duo = " \
 duo_unix-selinux \
 glibc \
 openssl-libs \
 pam \
 pam-libs \
 "
