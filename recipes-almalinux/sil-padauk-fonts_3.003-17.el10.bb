# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sil-padauk-fonts"
PV = "3.003"
PR = "17.el10"
PACKAGES = " \
 sil-padauk-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sil-padauk-fonts-3.003-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "530e8c18d787824beb569f0ebea0188485064312d95f2111defce2d7dd38cef3"

URI_x86_64_v2_sil-padauk-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sil-padauk-fonts-3.003-17.el10.noarch.rpm;name=x86_64_v2_sil-padauk-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sil-padauk-fonts}"
SRC_URI[x86_64_v2_sil-padauk-fonts.sha256sum] = "9bd28600a29d68871ec21976d41e3e9c0fe5fd9ba237579a12d50d4d74e23936"

URI_aarch64_sil-padauk-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sil-padauk-fonts-3.003-17.el10.noarch.rpm;name=aarch64_sil-padauk-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_sil-padauk-fonts}"
SRC_URI[aarch64_sil-padauk-fonts.sha256sum] = "9bd28600a29d68871ec21976d41e3e9c0fe5fd9ba237579a12d50d4d74e23936"

RDEPENDS:sil-padauk-fonts = " \
 fonts-filesystem \
 "
