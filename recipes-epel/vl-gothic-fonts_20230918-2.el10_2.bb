# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vl-gothic-fonts"
PV = "20230918"
PR = "2.el10_2"
PACKAGES = " \
 vl-gothic-fonts \
 vl-gothic-fonts-all \
 vl-pgothic-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vl-gothic-fonts-20230918-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99690f703d7999712816fc84f413ce4d6579e28bb590e856800b4381db6b2d06"

URI_x86_64_v2_vl-gothic-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vl-gothic-fonts-20230918-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vl-gothic-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vl-gothic-fonts}"
SRC_URI[x86_64_v2_vl-gothic-fonts.sha256sum] = "49b76a195d182c6be7fe0828b5626c7dbc608a15bda38fc9b93a854ed03c3c29"

URI_x86_64_v2_vl-gothic-fonts-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vl-gothic-fonts-all-20230918-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vl-gothic-fonts-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vl-gothic-fonts-all}"
SRC_URI[x86_64_v2_vl-gothic-fonts-all.sha256sum] = "11b2769cf0467e8557fa7beed71f5a24072c93ae6fd37b23e3969f8fbd96b69d"

URI_x86_64_v2_vl-pgothic-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vl-pgothic-fonts-20230918-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vl-pgothic-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vl-pgothic-fonts}"
SRC_URI[x86_64_v2_vl-pgothic-fonts.sha256sum] = "2d223bb3a36fec3d2ed3996dc70826c67b8f46ffcd55c2428d1f2eabbcf5c44d"

URI_aarch64_vl-gothic-fonts = "${EPEL_MIRROR}/aarch64/Packages/v/vl-gothic-fonts-20230918-2.el10_2.noarch.rpm;name=aarch64_vl-gothic-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_vl-gothic-fonts}"
SRC_URI[aarch64_vl-gothic-fonts.sha256sum] = "39799f188521de5ae6b3134cd076e3e672478f71ec0d182c57a398d85afb9181"

URI_aarch64_vl-gothic-fonts-all = "${EPEL_MIRROR}/aarch64/Packages/v/vl-gothic-fonts-all-20230918-2.el10_2.noarch.rpm;name=aarch64_vl-gothic-fonts-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_vl-gothic-fonts-all}"
SRC_URI[aarch64_vl-gothic-fonts-all.sha256sum] = "01de0fd78922f45e9bfb40cfe96da38b97bc92921ee3d096f3d73d8746a2cb2d"

URI_aarch64_vl-pgothic-fonts = "${EPEL_MIRROR}/aarch64/Packages/v/vl-pgothic-fonts-20230918-2.el10_2.noarch.rpm;name=aarch64_vl-pgothic-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_vl-pgothic-fonts}"
SRC_URI[aarch64_vl-pgothic-fonts.sha256sum] = "1139cb3eee04076b289d0bf56b42e426e3c0920f67184b6a84886d10c31d0d62"

RDEPENDS:vl-gothic-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:vl-gothic-fonts-all = " \
 vl-gothic-fonts \
 vl-pgothic-fonts \
 "
RDEPENDS:vl-pgothic-fonts = " \
 fonts-filesystem \
 "
