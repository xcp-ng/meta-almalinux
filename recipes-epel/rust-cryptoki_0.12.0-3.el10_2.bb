# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cryptoki"
PV = "0.12.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-cryptoki+default-devel \
 rust-cryptoki+generate-bindings-devel \
 rust-cryptoki+serde-devel \
 rust-cryptoki-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cryptoki-0.12.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f7d0f4258faa0f03c17a445465ba4ac5c90bf642a57dcd13b95853ac979d70bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki+default-devel-0.12.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cryptoki+default-devel.sha256sum] = "3bcb00dd5e23807ff88516734d328f0506f9d1c91f8a615e95f86dbc50bb2319"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki+generate-bindings-devel-0.12.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki+generate-bindings-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cryptoki+generate-bindings-devel.sha256sum] = "b977de0a9eb0f90ed6bfffb6d3a77259d17db2f6304fc3c9b1a193c5bd9a0d29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki+serde-devel-0.12.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cryptoki+serde-devel.sha256sum] = "259a0500015d5425405466e2f41d838e7dcc98ffd6f7df9edb1929f3712a65d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cryptoki-devel-0.12.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cryptoki-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cryptoki-devel.sha256sum] = "e574877a0b0bbe16ce9448d8b9a0b2c46406637669540056dea5470dc36d5994"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki+default-devel-0.12.0-3.el10_2.noarch.rpm;name=aarch64_rust-cryptoki+default-devel;unpack=0"
SRC_URI[aarch64_rust-cryptoki+default-devel.sha256sum] = "195c9cbcb5683939428f000909e643cee43622b0af814c41f24b92eab266afa7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki+generate-bindings-devel-0.12.0-3.el10_2.noarch.rpm;name=aarch64_rust-cryptoki+generate-bindings-devel;unpack=0"
SRC_URI[aarch64_rust-cryptoki+generate-bindings-devel.sha256sum] = "2ffa87026c3147b29a74c3dc527ee4030ea21d88684d047d12720fa8388d5a2a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki+serde-devel-0.12.0-3.el10_2.noarch.rpm;name=aarch64_rust-cryptoki+serde-devel;unpack=0"
SRC_URI[aarch64_rust-cryptoki+serde-devel.sha256sum] = "c70ed9d8409f7392341235f917eca1061e80b70bf8905a86ce7731b1fe63190b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cryptoki-devel-0.12.0-3.el10_2.noarch.rpm;name=aarch64_rust-cryptoki-devel;unpack=0"
SRC_URI[aarch64_rust-cryptoki-devel.sha256sum] = "7f20d38db257e4ca586f84141a761055f4a88b4117f44d7f38cd1eabd0b8130a"

RDEPENDS:rust-cryptoki+default-devel = " \
 cargo \
 rust-cryptoki-devel \
 "
RDEPENDS:rust-cryptoki+generate-bindings-devel = " \
 cargo \
 rust-cryptoki-devel \
 rust-cryptoki-sys+generate-bindings-devel \
 "
RDEPENDS:rust-cryptoki+serde-devel = " \
 cargo \
 rust-cryptoki-devel \
 rust-secrecy+serde-devel \
 "
RDEPENDS:rust-cryptoki-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cryptoki-sys+default-devel \
 rust-libloading+default-devel \
 rust-log+default-devel \
 rust-secrecy+default-devel \
 "
