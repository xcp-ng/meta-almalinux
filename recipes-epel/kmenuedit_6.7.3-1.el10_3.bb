# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmenuedit"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kmenuedit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmenuedit-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad54fd62247cedcb8a5167fd3cf477925e79cd201f3f3f7dadb551a9c9d1d038"

URI_x86_64_v2_kmenuedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmenuedit-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmenuedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmenuedit}"
SRC_URI[x86_64_v2_kmenuedit.sha256sum] = "4418ce3d39192249b676bcc2da1bd88e190f7c09ffd4b09eecd7b933604061bf"

URI_aarch64_kmenuedit = "${EPEL_MIRROR}/aarch64/Packages/k/kmenuedit-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kmenuedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmenuedit}"
SRC_URI[aarch64_kmenuedit.sha256sum] = "7aec4b62c30752ad06d9ddaceed69241be388517f7534c962cf3e9c9d7cfa54a"

RDEPENDS:kmenuedit = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
