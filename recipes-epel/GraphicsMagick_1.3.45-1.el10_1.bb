# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "GraphicsMagick"
PV = "1.3.45"
PR = "1.el10_1"
PACKAGES = " \
 GraphicsMagick \
 GraphicsMagick-c++ \
 GraphicsMagick-c++-devel \
 GraphicsMagick-devel \
 GraphicsMagick-doc \
 GraphicsMagick-perl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/GraphicsMagick-1.3.45-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee3daee027eca3ec0a4cee8f45c768d5719f7c91607df4441404558c4aa06df5"

URI_x86_64_v2_GraphicsMagick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GraphicsMagick-1.3.45-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GraphicsMagick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GraphicsMagick}"
SRC_URI[x86_64_v2_GraphicsMagick.sha256sum] = "7707c17743152216f5e89b006c2b3dd2dfc8e9a5331fe409cde462e44776039d"

URI_x86_64_v2_GraphicsMagick-c++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GraphicsMagick-c++-1.3.45-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GraphicsMagick-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GraphicsMagick-c++}"
SRC_URI[x86_64_v2_GraphicsMagick-c++.sha256sum] = "84c2338f02c91260a6c2fdde4d03e52d050e8899203461922a0ac621a7951c6f"

URI_x86_64_v2_GraphicsMagick-c++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GraphicsMagick-c++-devel-1.3.45-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GraphicsMagick-c++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GraphicsMagick-c++-devel}"
SRC_URI[x86_64_v2_GraphicsMagick-c++-devel.sha256sum] = "98d82a4cf2fb2ae4d69b24317feb10dbfd1e59f5511bcf1a485714cd26af8373"

URI_x86_64_v2_GraphicsMagick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GraphicsMagick-devel-1.3.45-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GraphicsMagick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GraphicsMagick-devel}"
SRC_URI[x86_64_v2_GraphicsMagick-devel.sha256sum] = "db69f2ecc83ba0396a679bb0d9cf6ec10693caf25ee8b712d20d18ef590add5e"

URI_x86_64_v2_GraphicsMagick-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GraphicsMagick-doc-1.3.45-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_GraphicsMagick-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GraphicsMagick-doc}"
SRC_URI[x86_64_v2_GraphicsMagick-doc.sha256sum] = "87ddfb2b48ae4195863a1a58380ecbacf5f91f37cba17e739bad2ea7722b7b2f"

URI_x86_64_v2_GraphicsMagick-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GraphicsMagick-perl-1.3.45-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GraphicsMagick-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GraphicsMagick-perl}"
SRC_URI[x86_64_v2_GraphicsMagick-perl.sha256sum] = "233a3e45fe25c71148e3aa148720cc1fc65f64f6c50a7706b9ff7a62497c3cd5"

URI_aarch64_GraphicsMagick = "${EPEL_MIRROR}/aarch64/Packages/g/GraphicsMagick-1.3.45-1.el10_1.aarch64.rpm;name=aarch64_GraphicsMagick;unpack=0"
SRC_URI:append = " ${URI_aarch64_GraphicsMagick}"
SRC_URI[aarch64_GraphicsMagick.sha256sum] = "12d9d9636e03349ffa8ad3e3603609ce8787cd8b803c32ea5c07e86a91567e72"

URI_aarch64_GraphicsMagick-c++ = "${EPEL_MIRROR}/aarch64/Packages/g/GraphicsMagick-c++-1.3.45-1.el10_1.aarch64.rpm;name=aarch64_GraphicsMagick-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_GraphicsMagick-c++}"
SRC_URI[aarch64_GraphicsMagick-c++.sha256sum] = "a5d7d70275a7dd8e58459f6a6009423eb53f07866dee676a68c3f88de1b63138"

URI_aarch64_GraphicsMagick-c++-devel = "${EPEL_MIRROR}/aarch64/Packages/g/GraphicsMagick-c++-devel-1.3.45-1.el10_1.aarch64.rpm;name=aarch64_GraphicsMagick-c++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_GraphicsMagick-c++-devel}"
SRC_URI[aarch64_GraphicsMagick-c++-devel.sha256sum] = "91dd0a9ffa7b527d3e1cc6d30ef6aca67c740b0213beac703bef17384df77285"

URI_aarch64_GraphicsMagick-devel = "${EPEL_MIRROR}/aarch64/Packages/g/GraphicsMagick-devel-1.3.45-1.el10_1.aarch64.rpm;name=aarch64_GraphicsMagick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_GraphicsMagick-devel}"
SRC_URI[aarch64_GraphicsMagick-devel.sha256sum] = "672ef37db67ad8d5d22c59da30437ed7896ce26539b2fff3d4361f4609fdd66f"

URI_aarch64_GraphicsMagick-doc = "${EPEL_MIRROR}/aarch64/Packages/g/GraphicsMagick-doc-1.3.45-1.el10_1.noarch.rpm;name=aarch64_GraphicsMagick-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_GraphicsMagick-doc}"
SRC_URI[aarch64_GraphicsMagick-doc.sha256sum] = "d90bbd2259d3028de45ee8ec0b9f3459c69eeb98ce52e3c5a1b3d77133d008c7"

URI_aarch64_GraphicsMagick-perl = "${EPEL_MIRROR}/aarch64/Packages/g/GraphicsMagick-perl-1.3.45-1.el10_1.aarch64.rpm;name=aarch64_GraphicsMagick-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_GraphicsMagick-perl}"
SRC_URI[aarch64_GraphicsMagick-perl.sha256sum] = "95056d060f0bc4ef50bc5f693223a6075822a6a19a937e02a80bf074ceb39556"

RDEPENDS:GraphicsMagick = " \
 bzip2-libs \
 freetype \
 glibc \
 jasper-libs \
 jbigkit-libs \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libgcc \
 libgomp \
 libheif \
 libjpeg-turbo \
 libjxl \
 libpng \
 libtiff \
 libtool-ltdl \
 libwebp \
 libwmf-lite \
 libxml2 \
 libzstd \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:GraphicsMagick-c++ = " \
 GraphicsMagick \
 bzip2-libs \
 freetype \
 glibc \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libgcc \
 libgomp \
 libstdc++ \
 libtool-ltdl \
 zlib-ng-compat \
 "
RDEPENDS:GraphicsMagick-c++-devel = " \
 GraphicsMagick-c++ \
 GraphicsMagick-devel \
 bash \
 pkgconf-pkg-config \
 "
RDEPENDS:GraphicsMagick-devel = " \
 GraphicsMagick \
 GraphicsMagick-devel \
 bash \
 pkgconf-pkg-config \
 "
RDEPENDS:GraphicsMagick-doc = " \
 "
RDEPENDS:GraphicsMagick-perl = " \
 GraphicsMagick \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
