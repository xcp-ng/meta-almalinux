# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cyclonedx-bom"
PV = "0.8.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-cyclonedx-bom+default-devel \
 rust-cyclonedx-bom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cyclonedx-bom-0.8.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40e5c14428c6838bde968813389d394f2125277943d1039426d40d06e25c6b23"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-cyclonedx-bom-devel: (crate(xml-rs/default) >= 0.8.16 with crate(xml-rs/default) < 0.9.0~)

URI_x86_64_v2_rust-cyclonedx-bom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cyclonedx-bom+default-devel-0.8.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cyclonedx-bom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cyclonedx-bom+default-devel}"
SRC_URI[x86_64_v2_rust-cyclonedx-bom+default-devel.sha256sum] = "a9a0aff77851c0dd96fa772a46dff1ff4044ee5c6128b669c893bbf991437b4f"

URI_x86_64_v2_rust-cyclonedx-bom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cyclonedx-bom-devel-0.8.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cyclonedx-bom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cyclonedx-bom-devel}"
SRC_URI[x86_64_v2_rust-cyclonedx-bom-devel.sha256sum] = "de0cf7cf725ce5f9e22ca029adcafa2ab79cb96e45d54381987310940c308ed9"

URI_aarch64_rust-cyclonedx-bom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cyclonedx-bom+default-devel-0.8.0-2.el10_2.noarch.rpm;name=aarch64_rust-cyclonedx-bom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cyclonedx-bom+default-devel}"
SRC_URI[aarch64_rust-cyclonedx-bom+default-devel.sha256sum] = "e314ab61135c445b139434db25251e873915fb9d84b1274eb1186c328aba008e"

URI_aarch64_rust-cyclonedx-bom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cyclonedx-bom-devel-0.8.0-2.el10_2.noarch.rpm;name=aarch64_rust-cyclonedx-bom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cyclonedx-bom-devel}"
SRC_URI[aarch64_rust-cyclonedx-bom-devel.sha256sum] = "d6f4a215471475bc68789d0b880d9260be174259ec5cd6be9d30cb47fd52351e"

RDEPENDS:rust-cyclonedx-bom+default-devel = " \
 cargo \
 rust-cyclonedx-bom-devel \
 "
RDEPENDS:rust-cyclonedx-bom-devel:x86_64_v2 = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-cyclonedx-bom-macros+default-devel \
 rust-fluent-uri+default-devel \
 rust-indexmap+default-devel \
 rust-once_cell+default-devel \
 rust-ordered-float-devel \
 rust-purl-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-spdx+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
"
RDEPENDS:rust-cyclonedx-bom-devel:aarch64 = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-cyclonedx-bom-macros+default-devel \
 rust-fluent-uri+default-devel \
 rust-indexmap+default-devel \
 rust-once_cell+default-devel \
 rust-ordered-float-devel \
 rust-purl-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-spdx+default-devel \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 rust-xml-rs+default-devel \
"
