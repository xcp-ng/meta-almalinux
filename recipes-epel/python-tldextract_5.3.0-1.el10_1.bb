# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tldextract"
PV = "5.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-tldextract \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tldextract-5.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c32be6cbc8d630aa34c6e830f3390a639392b7e5636e3542f90078a92c8a55"

URI_x86_64_v2_python3-tldextract = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tldextract-5.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tldextract;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tldextract}"
SRC_URI[x86_64_v2_python3-tldextract.sha256sum] = "513f04901b4cb2b3be3a9e6bbfe4f3e3cc1488f40e2b0fb055ce9f824adef928"

URI_aarch64_python3-tldextract = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tldextract-5.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-tldextract;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tldextract}"
SRC_URI[aarch64_python3-tldextract.sha256sum] = "0dc3e93956ec6d8de850f3859e5461dbfd0c472cc8fc1fb96cb35783b4c1287a"

RDEPENDS:python3-tldextract = " \
 python3 \
 python3-filelock \
 python3-idna \
 python3-requests \
 python3-requests-file \
 "
