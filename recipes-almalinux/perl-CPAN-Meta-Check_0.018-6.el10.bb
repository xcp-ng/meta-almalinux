# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Meta-Check"
PV = "0.018"
PR = "6.el10"
PACKAGES = " \
 perl-CPAN-Meta-Check \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-CPAN-Meta-Check-0.018-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8abd12d22b3f5b249a430cd805f910fe875899b3210c1a6e1e9233bb68c28b19"

URI_x86_64_v2_perl-CPAN-Meta-Check = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-CPAN-Meta-Check-0.018-6.el10.noarch.rpm;name=x86_64_v2_perl-CPAN-Meta-Check;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-Meta-Check}"
SRC_URI[x86_64_v2_perl-CPAN-Meta-Check.sha256sum] = "237e2ff71265658655835edb3cd56c36688517da1d12add750e0d97d78ff2910"

URI_aarch64_perl-CPAN-Meta-Check = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-CPAN-Meta-Check-0.018-6.el10.noarch.rpm;name=aarch64_perl-CPAN-Meta-Check;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-Meta-Check}"
SRC_URI[aarch64_perl-CPAN-Meta-Check.sha256sum] = "237e2ff71265658655835edb3cd56c36688517da1d12add750e0d97d78ff2910"

RDEPENDS:perl-CPAN-Meta-Check = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Exporter \
 perl-Module-Metadata \
 perl-base \
 perl-libs \
 "
