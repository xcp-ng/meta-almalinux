# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-url"
PV = "2.5.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-url+default-devel \
 rust-url+expose_internals-devel \
 rust-url+serde-devel \
 rust-url+std-devel \
 rust-url-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-url-2.5.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9eb177d81c48e1e577abd778eb574217a598a828769b0a1603cf0f978c494d66"

URI_x86_64_v2_rust-url+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+default-devel-2.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+default-devel}"
SRC_URI[x86_64_v2_rust-url+default-devel.sha256sum] = "c3eef5f6628b90aa50a554391881c286f340e80b560e2760777d827f071cbd64"

URI_x86_64_v2_rust-url+expose_internals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+expose_internals-devel-2.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+expose_internals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+expose_internals-devel}"
SRC_URI[x86_64_v2_rust-url+expose_internals-devel.sha256sum] = "eaf1968b60e3147f7ce9d7411dd708e564f755fbf3f7724ef80756bba7514d00"

URI_x86_64_v2_rust-url+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+serde-devel-2.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+serde-devel}"
SRC_URI[x86_64_v2_rust-url+serde-devel.sha256sum] = "b294d2f36b80814c852e38b36dc2b8f2a7d9c60faf3891ed709ee8d86a488d3b"

URI_x86_64_v2_rust-url+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+std-devel-2.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+std-devel}"
SRC_URI[x86_64_v2_rust-url+std-devel.sha256sum] = "9c0995c1b0218b2d2b006ec885c7af21b0fd97640fd821b7fafa7de9963bb456"

URI_x86_64_v2_rust-url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url-devel-2.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url-devel}"
SRC_URI[x86_64_v2_rust-url-devel.sha256sum] = "7add99cc1d585e4faa67f0cb8846dfaf5b6b58884b1763f857be7b8f8743f010"

URI_aarch64_rust-url+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+default-devel-2.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+default-devel}"
SRC_URI[aarch64_rust-url+default-devel.sha256sum] = "3e0e78da05fca760a89e993f5245061f57721b5430449b03a1d5547057f1cf17"

URI_aarch64_rust-url+expose_internals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+expose_internals-devel-2.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-url+expose_internals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+expose_internals-devel}"
SRC_URI[aarch64_rust-url+expose_internals-devel.sha256sum] = "ce219388184e0aafb0a16ebff84d330ae02182caa98c85f41e38dec6757f13aa"

URI_aarch64_rust-url+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+serde-devel-2.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+serde-devel}"
SRC_URI[aarch64_rust-url+serde-devel.sha256sum] = "28cf1186d53bcbc3f3ad40d4381c98ac7efc9882c458766e1c0ceb17b74ca572"

URI_aarch64_rust-url+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+std-devel-2.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-url+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+std-devel}"
SRC_URI[aarch64_rust-url+std-devel.sha256sum] = "6622111f529565a84eb83bfb6dc9dfd4adc0be7e1fab87b2230ddb81c3ae0858"

URI_aarch64_rust-url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url-devel-2.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url-devel}"
SRC_URI[aarch64_rust-url-devel.sha256sum] = "84d704c2eee064fd1fbf502f54ce868fa6797b2a126940b09061e834a56cf709"

RDEPENDS:rust-url+default-devel = " \
 cargo \
 rust-url+std-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url+expose_internals-devel = " \
 cargo \
 rust-url-devel \
 "
RDEPENDS:rust-url+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_derive-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url+std-devel = " \
 cargo \
 rust-form_urlencoded+std-devel \
 rust-idna+std-devel \
 rust-percent-encoding+std-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url-devel = " \
 cargo \
 rust \
 rust-form_urlencoded+alloc-devel \
 rust-form_urlencoded-devel \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna-devel \
 rust-percent-encoding+alloc-devel \
 rust-percent-encoding-devel \
 "
