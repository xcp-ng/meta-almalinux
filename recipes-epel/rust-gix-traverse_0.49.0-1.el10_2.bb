# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-traverse"
PV = "0.49.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-traverse+default-devel \
 rust-gix-traverse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-traverse-0.49.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c11b7be82d3e6a00ef4b23bdcceb0e376b4108f3729ef3237d311cf4d75bd7d4"

URI_x86_64_v2_rust-gix-traverse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse+default-devel-0.49.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse+default-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse+default-devel.sha256sum] = "33ba6dd7f355c4b0ccf1d7e4b22489acae45f062abdaef6f6e03d4c922c5f669"

URI_x86_64_v2_rust-gix-traverse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse-devel-0.49.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse-devel.sha256sum] = "2543b60a3fa3bc215c103ca23d84073062cbc7af21e80754d1edf21904bfa551"

URI_aarch64_rust-gix-traverse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse+default-devel-0.49.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-traverse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse+default-devel}"
SRC_URI[aarch64_rust-gix-traverse+default-devel.sha256sum] = "0cdde3eb189076284b91ec16d59c158be65a9f810f65fd9ee1d7913b438c63c2"

URI_aarch64_rust-gix-traverse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse-devel-0.49.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-traverse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse-devel}"
SRC_URI[aarch64_rust-gix-traverse-devel.sha256sum] = "578fd340636e439fbad730d9bef4dbdea0d07528f0bb4af5b614481a8fc31880"

RDEPENDS:rust-gix-traverse+default-devel = " \
 cargo \
 rust-gix-traverse-devel \
 "
RDEPENDS:rust-gix-traverse-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
