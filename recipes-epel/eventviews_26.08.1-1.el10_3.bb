# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eventviews"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 eventviews \
 eventviews-devel \
 eventviews-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/eventviews-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6ca642945de017b3828f8013eb85d2fe2dc570b21f17bb5b9e2ef4c4584606ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews;unpack=0"
SRC_URI[x86_64_v2_eventviews.sha256sum] = "42cd67d95ec6a57ec59ec3cc5f1a8f31c938c9f330c7cee63b69fdf6fd0c3d3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eventviews-devel;unpack=0"
SRC_URI[x86_64_v2_eventviews-devel.sha256sum] = "b5a396ebe9fc2543d7a1280326db93ee039e7b9d479abfee2e2c99577640830b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eventviews-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_eventviews-doc;unpack=0"
SRC_URI[x86_64_v2_eventviews-doc.sha256sum] = "c477bdb46bfe65ba483125c5bbc028310d66c64db1739c77c13ae27016bb72f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eventviews-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_eventviews;unpack=0"
SRC_URI[aarch64_eventviews.sha256sum] = "b965886b2bbf33299cdbfe786a2821d3d2e0ef69ea6e34de23d8216197104f61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eventviews-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_eventviews-devel;unpack=0"
SRC_URI[aarch64_eventviews-devel.sha256sum] = "12eba8ffe06dd81b232b35ea7f1a0ad9c37306e3782a0cd010bd381800845c57"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eventviews-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_eventviews-doc;unpack=0"
SRC_URI[aarch64_eventviews-doc.sha256sum] = "786ff9a52ddce8d15bde67ac9f5b2facfa0d7b634b6df01efe3bec282bd52fab"

RDEPENDS:eventviews = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kcalutils \
 kdiagram \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:eventviews-devel = " \
 akonadi-calendar-devel \
 akonadi-server-devel \
 calendarsupport-devel \
 cmake-filesystem \
 eventviews \
 kcalutils-devel \
 kf6-kcalendarcore-devel \
 "
RDEPENDS:eventviews-doc = " \
 "
