# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MIME-Lite-HTML"
PV = "1.24"
PR = "39.el10_0"
PACKAGES = " \
 perl-MIME-Lite-HTML \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MIME-Lite-HTML-1.24-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ef94b43cc08b7c2df1ea7c2f565dec1855da4a63cf99d30839f2f41fea5220f"

URI_x86_64_v2_perl-MIME-Lite-HTML = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MIME-Lite-HTML-1.24-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MIME-Lite-HTML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MIME-Lite-HTML}"
SRC_URI[x86_64_v2_perl-MIME-Lite-HTML.sha256sum] = "87fbd968cf17b26d004455ba6df4d2e0b081a74ff1ae376ce76e4088a5139efb"

URI_aarch64_perl-MIME-Lite-HTML = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MIME-Lite-HTML-1.24-39.el10_0.noarch.rpm;name=aarch64_perl-MIME-Lite-HTML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MIME-Lite-HTML}"
SRC_URI[aarch64_perl-MIME-Lite-HTML.sha256sum] = "1f808dfceda79db64b993b3590be2a911dda7fc7ffa6adb3d9f41f193a51a276"

RDEPENDS:perl-MIME-Lite-HTML = " \
 perl-Exporter \
 perl-HTML-Parser \
 perl-MIME-Lite \
 perl-URI \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
