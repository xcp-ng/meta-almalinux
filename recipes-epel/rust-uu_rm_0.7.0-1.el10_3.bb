# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_rm"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_rm+default-devel \
 rust-uu_rm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_rm-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ad2e6dcf72a2d6b6bce7b7d511a62b4608e7f1d310c24a63a615e506645db08"

URI_x86_64_v2_rust-uu_rm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_rm+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_rm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_rm+default-devel}"
SRC_URI[x86_64_v2_rust-uu_rm+default-devel.sha256sum] = "07d17c97f274293c73244b5fba81045e99032aae3849fbabfa5cea5552fd8768"

URI_x86_64_v2_rust-uu_rm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_rm-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_rm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_rm-devel}"
SRC_URI[x86_64_v2_rust-uu_rm-devel.sha256sum] = "d9b130c6e762169cd98768f8956469a6ce615afe69e8c90df298ede4dafa61da"

URI_aarch64_rust-uu_rm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_rm+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_rm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_rm+default-devel}"
SRC_URI[aarch64_rust-uu_rm+default-devel.sha256sum] = "20b00a8422fb4d1b423e8f08291ac1376b159a27844ae8d4a231d9a88d113f6a"

URI_aarch64_rust-uu_rm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_rm-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_rm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_rm-devel}"
SRC_URI[aarch64_rust-uu_rm-devel.sha256sum] = "d719a6df6cbebd733f5af2ea457c239932ee16a1f84d563f925096f528a65972"

RDEPENDS:rust-uu_rm+default-devel = " \
 cargo \
 rust-uu_rm-devel \
 "
RDEPENDS:rust-uu_rm-devel = " \
 bash \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-indicatif+default-devel \
 rust-libc+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 rust-uucore+parser-devel \
 rust-uucore+safe-traversal-devel \
 "
