# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-net"
PV = "0.26.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-hickory-net+default-devel \
 rust-hickory-net+mdns-devel \
 rust-hickory-net+serde-devel \
 rust-hickory-net+socket2-devel \
 rust-hickory-net+tokio-devel \
 rust-hickory-net+webpki-roots-devel \
 rust-hickory-net-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-net-0.26.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0421b173b26906c376f457968d3bc91eb35423a76186e1b7beb207336dcc17a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+default-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-net+default-devel.sha256sum] = "09f848de20a38f00c02bdc72cae41e8ca525c4e3218ca4ecbf6649cdd3b6cc0f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+mdns-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+mdns-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-net+mdns-devel.sha256sum] = "17c0bb5a501b8537b824bac38e628b5d7f973219f5764291eb1515ecfa524019"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+serde-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-net+serde-devel.sha256sum] = "dfb3e2788ff3e96a1a9b1a24bfbe3817d51e7af355d541335ddeca971729e75f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+socket2-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+socket2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-net+socket2-devel.sha256sum] = "2d96d267a52f050cae55bbf4bd649a145d3409888e54beeb9f2f20eb298d22cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+tokio-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-net+tokio-devel.sha256sum] = "3dad65dcf672a3592ecfdee130310881c9d7695777ec81f27b63ced2c4b15f26"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net+webpki-roots-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net+webpki-roots-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-net+webpki-roots-devel.sha256sum] = "a53e8590985fcba043ba1fe77740ecfc6627bb7bd2a43a70e8a4d9ea83919714"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-net-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-net-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-net-devel.sha256sum] = "232aaf1c40718e0753365d40b3d44964f8cc4a3f5e405813809d285c69e4f87d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+default-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+default-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-net+default-devel.sha256sum] = "fc126441055aca3fbd9c772e9ecbee13561f77356ecb2911f79390f57098b68c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+mdns-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+mdns-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-net+mdns-devel.sha256sum] = "c9f8d7f36ca55d74953cd0b163fe4f597e39d2e90c447517696dcba18bbeeaad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+serde-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+serde-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-net+serde-devel.sha256sum] = "2453e123d18831faa4c2a339c9f27bb21360fa71559a6ba00098057cba6ea7ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+socket2-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+socket2-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-net+socket2-devel.sha256sum] = "b93a9aab333ff1f256ac863987ba550a407d2edddb91e40cb50803beae20f251"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+tokio-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-net+tokio-devel.sha256sum] = "c3260ba2444e4c5f1ceb0aee7d45715c35a72203bbca698c7ae9a6286e7eb036"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net+webpki-roots-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net+webpki-roots-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-net+webpki-roots-devel.sha256sum] = "a0c025bfa3c8ff6f7e8c9fd0f2c364919b15a88aa30ab5df2b34bb502d572172"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-net-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-net-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-net-devel.sha256sum] = "3886663f1782b5c1d480baa5541cdcaa2b70f6cf6783036be780d9f2dff1f50e"

RDEPENDS:rust-hickory-net+default-devel = " \
 cargo \
 rust-hickory-net+tokio-devel \
 rust-hickory-net-devel \
 "
RDEPENDS:rust-hickory-net+mdns-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 "
RDEPENDS:rust-hickory-net+serde-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-hickory-net+socket2-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-socket2+default-devel \
 "
RDEPENDS:rust-hickory-net+tokio-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-hickory-net+webpki-roots-devel = " \
 cargo \
 rust-hickory-net-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-hickory-net-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-cfg-if+default-devel \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna-devel \
 rust-ipnet-devel \
 rust-rand+alloc-devel \
 rust-rand+std_rng-devel \
 rust-rand-devel \
 rust-thiserror-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 rust-tracing-devel \
 rust-url-devel \
 "
