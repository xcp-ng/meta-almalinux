# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgoldrunner"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kgoldrunner \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgoldrunner-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd60ef6504a02beeda121ad78733b178519c09c72e8216eb74447c84c1935eb6"

URI_x86_64_v2_kgoldrunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgoldrunner-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgoldrunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgoldrunner}"
SRC_URI[x86_64_v2_kgoldrunner.sha256sum] = "cc32c973c070550d905b74a50dd2ca5ebaf041415878e117fc70e21d27ea98fe"

URI_aarch64_kgoldrunner = "${EPEL_MIRROR}/aarch64/Packages/k/kgoldrunner-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kgoldrunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgoldrunner}"
SRC_URI[aarch64_kgoldrunner.sha256sum] = "79a85414dd639dd2ccabeabdc3f9a1e16865d280190c0c1d535b82fae5a1c7d1"

RDEPENDS:kgoldrunner = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
