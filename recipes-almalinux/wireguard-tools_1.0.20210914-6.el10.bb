# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wireguard-tools"
PV = "1.0.20210914"
PR = "6.el10"
PACKAGES = " \
 wireguard-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wireguard-tools-1.0.20210914-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4c059d3ea50d74a028d0bb1eb870cfb587bfbfbb0bfd5674c46cfd85138ea4c"

URI_x86_64_v2_wireguard-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireguard-tools-1.0.20210914-6.el10.x86_64_v2.rpm;name=x86_64_v2_wireguard-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireguard-tools}"
SRC_URI[x86_64_v2_wireguard-tools.sha256sum] = "2d229ee5d959d34c4a2e4dbd6a8db15825ec017e39871863b75daaddc4351c89"

URI_aarch64_wireguard-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireguard-tools-1.0.20210914-6.el10.aarch64.rpm;name=aarch64_wireguard-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireguard-tools}"
SRC_URI[aarch64_wireguard-tools.sha256sum] = "b00a27f5a64c77186e3eaeef8e39493f3b5d0a4cacb85b6bdeac535315896bad"

RDEPENDS:wireguard-tools = " \
 bash \
 glibc \
 systemd \
 systemd-resolved \
 "
