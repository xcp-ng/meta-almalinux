# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-shs"
PV = "0.20090828"
PR = "31.el10"
PACKAGES = " \
 hunspell-shs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-shs-0.20090828-31.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "54386a0f076083ec8b594d822959fc28581e47ec9f5aa0e313b7ec88930f62be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-shs-0.20090828-31.el10.noarch.rpm;name=x86_64_v2_hunspell-shs;unpack=0"
SRC_URI[x86_64_v2_hunspell-shs.sha256sum] = "b5a5fca8c45a324ea01d5bc561eae29e7d52c616a05ea94577b9b441889a30ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-shs-0.20090828-31.el10.noarch.rpm;name=aarch64_hunspell-shs;unpack=0"
SRC_URI[aarch64_hunspell-shs.sha256sum] = "b5a5fca8c45a324ea01d5bc561eae29e7d52c616a05ea94577b9b441889a30ee"

RDEPENDS:hunspell-shs = " \
 hunspell \
 "
