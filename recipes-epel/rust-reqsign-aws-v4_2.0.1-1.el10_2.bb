# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-aws-v4"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-aws-v4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-aws-v4-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d154956f3b74b979990862720a3fb17c0fed381a07a3bd84f051f5bbfb3e52c2"

URI_x86_64_v2_rust-reqsign-aws-v4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aws-v4+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aws-v4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aws-v4+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aws-v4+default-devel.sha256sum] = "abc0864c7a4db0002944d6060515c8db83930850caf0c43c8d7e56d239ed8dd6"

URI_x86_64_v2_rust-reqsign-aws-v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aws-v4-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aws-v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aws-v4-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aws-v4-devel.sha256sum] = "4e163ba03b0f9f90d41da552ff6939a18bac69a05d7d785643bfd9aea8e627af"

URI_aarch64_rust-reqsign-aws-v4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aws-v4+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-aws-v4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aws-v4+default-devel}"
SRC_URI[aarch64_rust-reqsign-aws-v4+default-devel.sha256sum] = "9b1c55d61e5282cb8d40789b26f5bdd8e53cb9f09d874fa14b1618330803330d"

URI_aarch64_rust-reqsign-aws-v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aws-v4-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-aws-v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aws-v4-devel}"
SRC_URI[aarch64_rust-reqsign-aws-v4-devel.sha256sum] = "ce6983af870e37c61075773e8e3882bf7531e6abac532fc76e340f0364bd7cb6"

RDEPENDS:rust-reqsign-aws-v4+default-devel = " \
 cargo \
 rust-reqsign-aws-v4-devel \
 "
RDEPENDS:rust-reqsign-aws-v4-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-quick-xml+default-devel \
 rust-quick-xml+serialize-devel \
 rust-reqsign-core+default-devel \
 rust-rust-ini+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-sha1+default-devel \
 "
