# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "x509viewer"
PV = "0.1.0"
PR = "18.el10_0"
PACKAGES = " \
 x509viewer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/x509viewer-0.1.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16d6608110c76584ebde82422df1b085fca52da84f428e184fa3d311863f7b68"

URI_x86_64_v2_x509viewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/x509viewer-0.1.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_x509viewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_x509viewer}"
SRC_URI[x86_64_v2_x509viewer.sha256sum] = "44958e668d4396c05490453b43577c6031a4de507b91309f9d18118617f994a8"

URI_aarch64_x509viewer = "${EPEL_MIRROR}/aarch64/Packages/x/x509viewer-0.1.0-18.el10_0.noarch.rpm;name=aarch64_x509viewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_x509viewer}"
SRC_URI[aarch64_x509viewer.sha256sum] = "adf37a77af95f0535b44f22b56bf26bcfa9e03f427b888805dc9bd82985d2e70"

RDEPENDS:x509viewer = " \
 openssl \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-interpreter \
 perl-libs \
 "
