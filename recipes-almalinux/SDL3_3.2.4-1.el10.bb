# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SDL3"
PV = "3.2.4"
PR = "1.el10"
PACKAGES = " \
 SDL3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/SDL3-3.2.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f625a75ac88a1da4164ebd98cc4c0d85fe16e6728a25eb8c9eadbe7c2072142"

URI_x86_64_v2_SDL3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/SDL3-3.2.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_SDL3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL3}"
SRC_URI[x86_64_v2_SDL3.sha256sum] = "3553c4b8bf6d7627c0885cfcb4efa668c54544d41695866e24579f2f4b7994ff"

URI_aarch64_SDL3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/SDL3-3.2.4-1.el10.aarch64.rpm;name=aarch64_SDL3;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL3}"
SRC_URI[aarch64_SDL3.sha256sum] = "5943232f1ab6930ce55483d85b02bc406d72a3fe6f8e5e41e8b9acecf3b24001"

RDEPENDS:SDL3 = " \
 glibc \
 libdecor \
 "
