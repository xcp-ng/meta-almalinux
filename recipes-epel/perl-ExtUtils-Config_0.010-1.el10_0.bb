# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Config"
PV = "0.010"
PR = "1.el10_0"
PACKAGES = " \
 perl-ExtUtils-Config \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-Config-0.010-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4945666ff216b2ef8715e2d22f29e6a4e0c2904f3beb6d753a0b8e2f1f47013"

URI_x86_64_v2_perl-ExtUtils-Config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-Config-0.010-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-Config}"
SRC_URI[x86_64_v2_perl-ExtUtils-Config.sha256sum] = "c70349a93668d0c5e85cda6911193f9789ae27fffb36ea8902ea4cf8703058c3"

URI_aarch64_perl-ExtUtils-Config = "${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-Config-0.010-1.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-Config;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-Config}"
SRC_URI[aarch64_perl-ExtUtils-Config.sha256sum] = "3d2bd55d3f344bd8831b52ff2d749996f50f2300c2f7ae9634edb1d48dd02d7e"

RDEPENDS:perl-ExtUtils-Config = " \
 perl-Data-Dumper \
 perl-ExtUtils-MakeMaker \
 perl-libs \
 "
