# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "file"
PV = "5.45"
PR = "7.el10"
PACKAGES = " \
 file \
 file-devel \
 file-libs \
 python3-file-magic \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/file-5.45-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "121672e865a8e772d321a37433169104c42de4b3f3494f6631631d3afab59adf"

URI_x86_64_v2_file = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/file-5.45-7.el10.x86_64_v2.rpm;name=x86_64_v2_file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_file}"
SRC_URI[x86_64_v2_file.sha256sum] = "c00e7f4b04b233284704d655338192df3a7a994807504eb6369907ca36972ae9"

URI_x86_64_v2_file-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/file-devel-5.45-7.el10.x86_64_v2.rpm;name=x86_64_v2_file-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_file-devel}"
SRC_URI[x86_64_v2_file-devel.sha256sum] = "8935d8cc834d5deb3bb33d813b2d0fa7dd7441f083a674f21b7f3ce43d22ece5"

URI_x86_64_v2_file-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/file-libs-5.45-7.el10.x86_64_v2.rpm;name=x86_64_v2_file-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_file-libs}"
SRC_URI[x86_64_v2_file-libs.sha256sum] = "a64d0e67bbb7e9153e27fdd0dad3977a16d1a9ea8bd15395fed018d18f63be42"

URI_x86_64_v2_python3-file-magic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-file-magic-5.45-7.el10.noarch.rpm;name=x86_64_v2_python3-file-magic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-file-magic}"
SRC_URI[x86_64_v2_python3-file-magic.sha256sum] = "24ab3ec5362d1767fe0156f009c9f503eb6a5a86e73c1e2b0672d6451cf259fd"

URI_aarch64_file = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/file-5.45-7.el10.aarch64.rpm;name=aarch64_file;unpack=0"
SRC_URI:append = " ${URI_aarch64_file}"
SRC_URI[aarch64_file.sha256sum] = "688425619d92dcdb3103b7870aa92c99d3c7d42a5ff5acbcf2ba072a6bca0962"

URI_aarch64_file-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/file-devel-5.45-7.el10.aarch64.rpm;name=aarch64_file-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_file-devel}"
SRC_URI[aarch64_file-devel.sha256sum] = "cad2f68c00972e557ffd87cddd3478d2be5f615fe584bc8cd66f72c2bfae8213"

URI_aarch64_file-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/file-libs-5.45-7.el10.aarch64.rpm;name=aarch64_file-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_file-libs}"
SRC_URI[aarch64_file-libs.sha256sum] = "63661daa610a584b0027cc6dc35d3a87572e0075547047f8b635255bc9e3453a"

URI_aarch64_python3-file-magic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-file-magic-5.45-7.el10.noarch.rpm;name=aarch64_python3-file-magic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-file-magic}"
SRC_URI[aarch64_python3-file-magic.sha256sum] = "24ab3ec5362d1767fe0156f009c9f503eb6a5a86e73c1e2b0672d6451cf259fd"

RDEPENDS:file = " \
 file-libs \
 glibc \
 "
RDEPENDS:file-devel = " \
 file-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:file-libs = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:python3-file-magic = " \
 file-libs \
 python3 \
 "
