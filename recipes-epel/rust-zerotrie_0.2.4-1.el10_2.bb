# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerotrie"
PV = "0.2.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-zerotrie+alloc-devel \
 rust-zerotrie+databake-devel \
 rust-zerotrie+default-devel \
 rust-zerotrie+dense-devel \
 rust-zerotrie+litemap-devel \
 rust-zerotrie+serde-devel \
 rust-zerotrie+yoke-devel \
 rust-zerotrie+zerofrom-devel \
 rust-zerotrie+zerovec-devel \
 rust-zerotrie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerotrie-0.2.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfda44f9a22d262138efadaf088e804de18bc5a902b25138514abd5d8fb51acb"

URI_x86_64_v2_rust-zerotrie+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+alloc-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+alloc-devel.sha256sum] = "a1a5ae49fae30cfd0d346a6c675dd15411724a5227e57357454abf9438130fab"

URI_x86_64_v2_rust-zerotrie+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+databake-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+databake-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+databake-devel.sha256sum] = "9df30543815da44113ef4851ebfae23bc7929d8cbc5cf74c911012b05d776dfb"

URI_x86_64_v2_rust-zerotrie+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+default-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+default-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+default-devel.sha256sum] = "500737cd7b0f6ec6e28d58e4b0a9965df0b38625c774076732e13c7bfcc8cf1f"

URI_x86_64_v2_rust-zerotrie+dense-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+dense-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+dense-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+dense-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+dense-devel.sha256sum] = "fc33f10e022866d0a56db9778322b160aba95c4f40ffe88e961f90dd334760fe"

URI_x86_64_v2_rust-zerotrie+litemap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+litemap-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+litemap-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+litemap-devel.sha256sum] = "2648758797957f6454252e54f7e70a237ff4db1636d063ae3ca4dc14b0a6c1cf"

URI_x86_64_v2_rust-zerotrie+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+serde-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+serde-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+serde-devel.sha256sum] = "5fb24622820f908b798e9f77f8ca22d354dffcb1ec152166484ed55f9cbe473c"

URI_x86_64_v2_rust-zerotrie+yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+yoke-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+yoke-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+yoke-devel.sha256sum] = "d38bba723a61f10d2f83aadc11f0c993ce6a5a9479c97eac43a113b247ef55f3"

URI_x86_64_v2_rust-zerotrie+zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+zerofrom-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+zerofrom-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+zerofrom-devel.sha256sum] = "3c81ca33db696acb295825a68e2dc8d0fae71fe0a62078c35090633d696af7e1"

URI_x86_64_v2_rust-zerotrie+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie+zerovec-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie+zerovec-devel}"
SRC_URI[x86_64_v2_rust-zerotrie+zerovec-devel.sha256sum] = "58c7563b8aabda89615465cd57b0b625a8a283891c6de7e583850c66a891a3c2"

URI_x86_64_v2_rust-zerotrie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerotrie-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerotrie-devel}"
SRC_URI[x86_64_v2_rust-zerotrie-devel.sha256sum] = "d3837e38acf7908e4d2783c401024226e2c52247205b2cc08db4fd3921666f26"

URI_aarch64_rust-zerotrie+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+alloc-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+alloc-devel}"
SRC_URI[aarch64_rust-zerotrie+alloc-devel.sha256sum] = "1c6545bc357253cc2d153e09e0ce680c1dba7a243ad4ca05f5477320dd335984"

URI_aarch64_rust-zerotrie+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+databake-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+databake-devel}"
SRC_URI[aarch64_rust-zerotrie+databake-devel.sha256sum] = "39341f37b8c6b4514d645fa3fbe04f3be5b22ada530537116ba6e6ca5026e414"

URI_aarch64_rust-zerotrie+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+default-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+default-devel}"
SRC_URI[aarch64_rust-zerotrie+default-devel.sha256sum] = "476767fedd58756fb539027321129512141e17f2d6ab7358679d6440869700de"

URI_aarch64_rust-zerotrie+dense-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+dense-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie+dense-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+dense-devel}"
SRC_URI[aarch64_rust-zerotrie+dense-devel.sha256sum] = "6d1aa34b0e7ed7690d53c65a6817fe70ba9f118192140455a25b25b0f08fb003"

URI_aarch64_rust-zerotrie+litemap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+litemap-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie+litemap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+litemap-devel}"
SRC_URI[aarch64_rust-zerotrie+litemap-devel.sha256sum] = "e8d3c4bc9787cf90a2d5a1d89bfc17871f4b2ec34344e1c8839d6e82264d7f1a"

URI_aarch64_rust-zerotrie+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+serde-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+serde-devel}"
SRC_URI[aarch64_rust-zerotrie+serde-devel.sha256sum] = "855e850551cf3b1e8a985a659b11880b26435d3949f02af218d17fd07f258e05"

URI_aarch64_rust-zerotrie+yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+yoke-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie+yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+yoke-devel}"
SRC_URI[aarch64_rust-zerotrie+yoke-devel.sha256sum] = "ede242edd3e32204358e153af6b2384a40c0e9a89eb3e2e3b89c18b9c49b8bd8"

URI_aarch64_rust-zerotrie+zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+zerofrom-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+zerofrom-devel}"
SRC_URI[aarch64_rust-zerotrie+zerofrom-devel.sha256sum] = "56e74be62a57bb0ce7d9a6f48858bd6c4a67e1847fd8d22e9a3a30190ae513f4"

URI_aarch64_rust-zerotrie+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie+zerovec-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie+zerovec-devel}"
SRC_URI[aarch64_rust-zerotrie+zerovec-devel.sha256sum] = "6e90989c2c911b5e3ed0bcdfd08b9f377409ff3ff81880afa8b75281f0e20489"

URI_aarch64_rust-zerotrie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerotrie-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerotrie-devel}"
SRC_URI[aarch64_rust-zerotrie-devel.sha256sum] = "6f1bc3c542860f510f8a8e1675d6f689cd9268abbbe983fbdafdcff6c0e3874f"

RDEPENDS:rust-zerotrie+alloc-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-zerotrie-devel \
 rust-zerovec+databake-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+default-devel = " \
 cargo \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+dense-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+litemap-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+serde-devel = " \
 cargo \
 rust-litemap+alloc-devel \
 rust-litemap+serde-devel \
 rust-litemap-devel \
 rust-serde_core-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 rust-zerovec+serde-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie+yoke-devel = " \
 cargo \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+zerofrom-devel = " \
 cargo \
 rust-zerofrom-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-zerotrie+zerovec-devel = " \
 cargo \
 rust-zerotrie-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-zerotrie-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 "
