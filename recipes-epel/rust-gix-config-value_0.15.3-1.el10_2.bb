# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-config-value"
PV = "0.15.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-config-value+default-devel \
 rust-gix-config-value+document-features-devel \
 rust-gix-config-value+serde-devel \
 rust-gix-config-value-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-config-value-0.15.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4218c08a07f9db4f3d1421ab491e5ac3efa302030b2bdf70fe1fdcea33a1db8a"

URI_x86_64_v2_rust-gix-config-value+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+default-devel-0.15.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+default-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+default-devel.sha256sum] = "bf88f753fdc0734d08d68af5640dcdf6cbbe58d499a194a325d5cae4a63d3438"

URI_x86_64_v2_rust-gix-config-value+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+document-features-devel-0.15.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+document-features-devel.sha256sum] = "f683385b7c841cc81f54c0e2c0c7f9a346c7835f18c84d0a68a4e4a0892bc9be"

URI_x86_64_v2_rust-gix-config-value+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+serde-devel-0.15.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+serde-devel.sha256sum] = "0ba054e9ff851425ed4e845e39646022b68dbaaf0c9d1555289011b77647d0bd"

URI_x86_64_v2_rust-gix-config-value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value-devel-0.15.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value-devel.sha256sum] = "03bfd4eb599a4496ecc5d044098747e65f4a6a74259abdcad6562ed6b3e8eba7"

URI_aarch64_rust-gix-config-value+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+default-devel-0.15.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-config-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+default-devel}"
SRC_URI[aarch64_rust-gix-config-value+default-devel.sha256sum] = "403b84bf8d35ab3e7e005bd7778bb893cc67facb70959468f37ae3ef4464413b"

URI_aarch64_rust-gix-config-value+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+document-features-devel-0.15.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-config-value+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+document-features-devel}"
SRC_URI[aarch64_rust-gix-config-value+document-features-devel.sha256sum] = "e56325c6765e3196ac86fcfd246f5b8182652bee02860317980dc19f5c22075b"

URI_aarch64_rust-gix-config-value+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+serde-devel-0.15.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-config-value+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+serde-devel}"
SRC_URI[aarch64_rust-gix-config-value+serde-devel.sha256sum] = "bd3ff00115d75f875c62d5f54ade20d4ed496e4920ca079e21947c79b4ef9a91"

URI_aarch64_rust-gix-config-value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value-devel-0.15.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value-devel}"
SRC_URI[aarch64_rust-gix-config-value-devel.sha256sum] = "0e4a0e529cf153909a3c261af6ec790647e5a92bd4ddad46e7a2f9dbe98d145d"

RDEPENDS:rust-gix-config-value+default-devel = " \
 cargo \
 rust-gix-config-value-devel \
 "
RDEPENDS:rust-gix-config-value+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-config-value-devel \
 "
RDEPENDS:rust-gix-config-value+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-config-value-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-config-value-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-path+default-devel \
 rust-libc+default-devel \
 rust-thiserror+default-devel \
 "
