# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mailparse"
PV = "3.1.9"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-mailparse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mailparse-3.1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc217156f369b77f6a906559564882147f74acbe4f204ba494f123e86b65048f"

URI_x86_64_v2_php-pecl-mailparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mailparse-3.1.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mailparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mailparse}"
SRC_URI[x86_64_v2_php-pecl-mailparse.sha256sum] = "339e70c4b961b98cd039cb4afd46a9cf5e007a1b386f01d6c4d32ddf621bafce"

URI_aarch64_php-pecl-mailparse = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mailparse-3.1.9-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-mailparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mailparse}"
SRC_URI[aarch64_php-pecl-mailparse.sha256sum] = "2bec7d9ebf69d31cf367cb96055729e253381a6eece3a47457f71666b949ec10"

RDEPENDS:php-pecl-mailparse = " \
 glibc \
 php-common \
 php-mbstring \
 "
