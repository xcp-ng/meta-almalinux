# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-html"
PV = "0.23.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-html+default-devel \
 rust-tree-sitter-html-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-html-0.23.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9884ab434433b36b849811507c85bbdeed9369c702c41a79ed5406bb21c56ea1"

URI_x86_64_v2_rust-tree-sitter-html+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-html+default-devel-0.23.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-html+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-html+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-html+default-devel.sha256sum] = "255bea1bce914f80c2b0bfcbf585e179607262e5f54333c0f6d0bc8a76b7efc1"

URI_x86_64_v2_rust-tree-sitter-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-html-devel-0.23.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-html-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-html-devel.sha256sum] = "e0a5201722d8ac8041c518640442cdce440fc9b5933c61044135011f3710139c"

URI_aarch64_rust-tree-sitter-html+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-html+default-devel-0.23.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-html+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-html+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-html+default-devel.sha256sum] = "320d6de134709226e937be615cc1af4bffbe87016f6b3e8b776dbb8aabdd6a15"

URI_aarch64_rust-tree-sitter-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-html-devel-0.23.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-html-devel}"
SRC_URI[aarch64_rust-tree-sitter-html-devel.sha256sum] = "cf156b193b35c031314ef3ad513dc0ba969602f7f410d99e70e1844ca1d14557"

RDEPENDS:rust-tree-sitter-html+default-devel = " \
 cargo \
 rust-tree-sitter-html-devel \
 "
RDEPENDS:rust-tree-sitter-html-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
