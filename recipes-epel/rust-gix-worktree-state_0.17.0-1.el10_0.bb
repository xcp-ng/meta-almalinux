# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree-state"
PV = "0.17.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-worktree-state+default-devel \
 rust-gix-worktree-state-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-state-0.17.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42516e11f046ec2ae156e5f6f04b120ead758aad256597c23c861904997dc00c"

URI_x86_64_v2_rust-gix-worktree-state+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state+default-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state+default-devel.sha256sum] = "1f2d25010b35e9a3eb9a7b1d5f09e47613e428ac69db40a3d88eaae323bbe380"

URI_x86_64_v2_rust-gix-worktree-state-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state-devel-0.17.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state-devel.sha256sum] = "d814d82d30040242148c3fd780437e620621d1edcef0280acad4c26eeb55c5de"

URI_aarch64_rust-gix-worktree-state+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state+default-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-worktree-state+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state+default-devel}"
SRC_URI[aarch64_rust-gix-worktree-state+default-devel.sha256sum] = "47df36ac7e7cd97a27fd9a962cd7c5a2350c38a68cf631ea328a93689bcd439b"

URI_aarch64_rust-gix-worktree-state-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state-devel-0.17.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-worktree-state-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state-devel}"
SRC_URI[aarch64_rust-gix-worktree-state-devel.sha256sum] = "16745acc07c8fb4b675b93499af14ad283db8fe37abdb35c2f4df42b390cc789"

RDEPENDS:rust-gix-worktree-state+default-devel = " \
 cargo \
 rust-gix-worktree-state-devel \
 "
RDEPENDS:rust-gix-worktree-state-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-io-close+default-devel \
 rust-thiserror+default-devel \
 "
