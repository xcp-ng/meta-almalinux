# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-kajiki"
PV = "0.9.2"
PR = "8.el10_0"
PACKAGES = " \
 python3-kajiki \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-kajiki-0.9.2-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "226987dc06d50cec34c4f41b073ff51de42cd84e5441cd672c140ebb41745147"

URI_x86_64_v2_python3-kajiki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kajiki-0.9.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kajiki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kajiki}"
SRC_URI[x86_64_v2_python3-kajiki.sha256sum] = "1cc389ca2e2d8ed69b8faaa5b66fea947043b35a459d7dd6cd1ac06ac84fe093"

URI_aarch64_python3-kajiki = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kajiki-0.9.2-8.el10_0.noarch.rpm;name=aarch64_python3-kajiki;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kajiki}"
SRC_URI[aarch64_python3-kajiki.sha256sum] = "691f0794e8b2f4b867b3d3aa5b483c327af0ba0b3abee060b3778736f4907600"

RDEPENDS:python3-kajiki = " \
 python3 \
 python3-babel \
 python3-linetable \
 python3-pytz \
 "
