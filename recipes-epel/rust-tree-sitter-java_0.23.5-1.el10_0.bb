# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-java"
PV = "0.23.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-java+default-devel \
 rust-tree-sitter-java-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-java-0.23.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e954e4f3464201955b82b8b7da485dfec6bcb1e4e60b355aaa747f692432a4b"

URI_x86_64_v2_rust-tree-sitter-java+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-java+default-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-java+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-java+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-java+default-devel.sha256sum] = "474d1fd3cf14540ddea2524f13a947333965cee726a991260552de764d16b924"

URI_x86_64_v2_rust-tree-sitter-java-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-java-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-java-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-java-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-java-devel.sha256sum] = "69e2cfc59aff7892fac1dae472c6a2769629903f126356f886700ec98046dbad"

URI_aarch64_rust-tree-sitter-java+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-java+default-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-java+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-java+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-java+default-devel.sha256sum] = "24fc10397e7259a84f0dd931733659d107859c3fe201c358edb1d89910b3cce8"

URI_aarch64_rust-tree-sitter-java-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-java-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-java-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-java-devel}"
SRC_URI[aarch64_rust-tree-sitter-java-devel.sha256sum] = "779eba6b5b05617d538c687bbc5d66ed3a983d84cbf97f695bac253c1c087790"

RDEPENDS:rust-tree-sitter-java+default-devel = " \
 cargo \
 rust-tree-sitter-java-devel \
 "
RDEPENDS:rust-tree-sitter-java-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
