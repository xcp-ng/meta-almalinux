# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-ilist"
PV = "0.4.0.1"
PR = "13.el10_0"
PACKAGES = " \
 ghc-ilist \
 ghc-ilist-devel \
 ghc-ilist-doc \
 ghc-ilist-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-ilist-0.4.0.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7375ca3bf84511c1ed45585e2be388512f66b7e8e60174596eb823abb5a672d3"

URI_x86_64_v2_ghc-ilist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ilist-0.4.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ilist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ilist}"
SRC_URI[x86_64_v2_ghc-ilist.sha256sum] = "528ce325ee8d057a675342f410b82f4accc710e3161bbefd43a361552850d03f"

URI_x86_64_v2_ghc-ilist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ilist-devel-0.4.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ilist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ilist-devel}"
SRC_URI[x86_64_v2_ghc-ilist-devel.sha256sum] = "46de1671b38b6b3836f78be496d3b02a84745c41db2447280acfd06543188f5f"

URI_x86_64_v2_ghc-ilist-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ilist-doc-0.4.0.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ilist-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ilist-doc}"
SRC_URI[x86_64_v2_ghc-ilist-doc.sha256sum] = "8b206958587e9c31f61c65be4acd81baf0bb991ce1552a43e71f41fe0f56a33e"

URI_x86_64_v2_ghc-ilist-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ilist-prof-0.4.0.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ilist-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ilist-prof}"
SRC_URI[x86_64_v2_ghc-ilist-prof.sha256sum] = "5415924bdf2092d682c44c6f800a1de2da5f0da14f182e201b84d7749b7c678f"

URI_aarch64_ghc-ilist = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ilist-0.4.0.1-13.el10_0.aarch64.rpm;name=aarch64_ghc-ilist;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ilist}"
SRC_URI[aarch64_ghc-ilist.sha256sum] = "16958384faa80ed1ad872713a73a82daed732a635acb585116d846b7889a67c3"

URI_aarch64_ghc-ilist-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ilist-devel-0.4.0.1-13.el10_0.aarch64.rpm;name=aarch64_ghc-ilist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ilist-devel}"
SRC_URI[aarch64_ghc-ilist-devel.sha256sum] = "38b262465f7a9a4e8d45e126bb278042df564d84eceaaabaa1c926841c811f2e"

URI_aarch64_ghc-ilist-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ilist-doc-0.4.0.1-13.el10_0.noarch.rpm;name=aarch64_ghc-ilist-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ilist-doc}"
SRC_URI[aarch64_ghc-ilist-doc.sha256sum] = "cea87effc45181a6e0f37a41c9c0ea26f208bc37579b5611eab69fe73d62ee5a"

URI_aarch64_ghc-ilist-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ilist-prof-0.4.0.1-13.el10_0.aarch64.rpm;name=aarch64_ghc-ilist-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ilist-prof}"
SRC_URI[aarch64_ghc-ilist-prof.sha256sum] = "9f24882676fc859dec2adf5a9c771dcfe6d5778647382a9f87cd90d5e5e35664"

RDEPENDS:ghc-ilist = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ilist-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-ilist \
 "
RDEPENDS:ghc-ilist-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ilist-prof = " \
 ghc-base-prof \
 ghc-ilist-devel \
 "
