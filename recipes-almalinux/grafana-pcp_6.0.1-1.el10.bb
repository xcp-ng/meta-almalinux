# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana-pcp"
PV = "6.0.1"
PR = "1.el10"
PACKAGES = " \
 grafana-pcp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-pcp-6.0.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc5fe017f6eca8821cd41b4104415235a5b93c56104248ac073e3c47bb779a67"

URI_x86_64_v2_grafana-pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-pcp-6.0.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_grafana-pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana-pcp}"
SRC_URI[x86_64_v2_grafana-pcp.sha256sum] = "14715d7da1ac1bd45c7e27074c8aa6baaa532ee5a8684ebd85ae51362d462235"

URI_aarch64_grafana-pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-pcp-6.0.1-1.el10.aarch64.rpm;name=aarch64_grafana-pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana-pcp}"
SRC_URI[aarch64_grafana-pcp.sha256sum] = "671f36139a0d91d370c46e4e40cd4781997e77b28381e2537667229906938cc7"

RDEPENDS:grafana-pcp = " \
 bash \
 glibc \
 grafana \
 systemd \
 "
