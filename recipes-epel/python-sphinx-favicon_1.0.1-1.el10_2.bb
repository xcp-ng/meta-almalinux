# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-favicon"
PV = "1.0.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-sphinx-favicon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-favicon-1.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28012ed1313c14c0de6592a3bb7fd2e8e91690d94b0f1fcaed0e607326315df3"

URI_x86_64_v2_python3-sphinx-favicon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-favicon-1.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-favicon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-favicon}"
SRC_URI[x86_64_v2_python3-sphinx-favicon.sha256sum] = "6981d38756f6fdd1de6aa2adf7e49e0b712cefb141816c57bb66e45b6cfe53da"

URI_aarch64_python3-sphinx-favicon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-favicon-1.0.1-1.el10_2.noarch.rpm;name=aarch64_python3-sphinx-favicon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-favicon}"
SRC_URI[aarch64_python3-sphinx-favicon.sha256sum] = "5c7f24ea224c0f36bc66a591e20596c052b2cb0eb9ff0e1fc1fcd0053ccd5551"

RDEPENDS:python3-sphinx-favicon = " \
 python3 \
 python3-sphinx \
 "
