# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stats_alloc"
PV = "0.1.10"
PR = "5.el10_1"
PACKAGES = " \
 rust-stats_alloc+default-devel \
 rust-stats_alloc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stats_alloc-0.1.10-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0c341e6aec9ebb94f00671e939326e84d68900add4064c9b9d68a6de7d7f164"

URI_x86_64_v2_rust-stats_alloc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stats_alloc+default-devel-0.1.10-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stats_alloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stats_alloc+default-devel}"
SRC_URI[x86_64_v2_rust-stats_alloc+default-devel.sha256sum] = "e8244495d860f8e7cc3d8c9bb599910d8449f6a10ce9accf0668278598cf00bd"

URI_x86_64_v2_rust-stats_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stats_alloc-devel-0.1.10-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stats_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stats_alloc-devel}"
SRC_URI[x86_64_v2_rust-stats_alloc-devel.sha256sum] = "7dd0fa48e5ab8355e73fcfb7e50148d2887f43d775757c7d68d673359c2d945d"

URI_aarch64_rust-stats_alloc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stats_alloc+default-devel-0.1.10-5.el10_1.noarch.rpm;name=aarch64_rust-stats_alloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stats_alloc+default-devel}"
SRC_URI[aarch64_rust-stats_alloc+default-devel.sha256sum] = "f5a7d04e5ab4ff4930ba0b37cf141755ff69a4189420d059971e06a255276ce8"

URI_aarch64_rust-stats_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stats_alloc-devel-0.1.10-5.el10_1.noarch.rpm;name=aarch64_rust-stats_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stats_alloc-devel}"
SRC_URI[aarch64_rust-stats_alloc-devel.sha256sum] = "8214a8a2bb80c883fe1ba369263401e611c210768344ad87e6e35610717e2452"

RDEPENDS:rust-stats_alloc+default-devel = " \
 cargo \
 rust-stats_alloc-devel \
 "
RDEPENDS:rust-stats_alloc-devel = " \
 cargo \
 "
