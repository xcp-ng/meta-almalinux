# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-zookeeper-zk"
PV = "1.0.2"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-zookeeper-zk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-zookeeper-zk-1.0.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9448f8f6133c39df064cfa896f32a88fd6ec731ccde9e22c52b7026e77893dce"

URI_x86_64_v2_golang-github-zookeeper-zk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-zookeeper-zk-devel-1.0.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-zookeeper-zk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-zookeeper-zk-devel}"
SRC_URI[x86_64_v2_golang-github-zookeeper-zk-devel.sha256sum] = "957b8159067aa574bb32c06325e419e3e376bde76cb88690dc0cfd8f3779c737"

URI_aarch64_golang-github-zookeeper-zk-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-zookeeper-zk-devel-1.0.2-10.el10_0.noarch.rpm;name=aarch64_golang-github-zookeeper-zk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-zookeeper-zk-devel}"
SRC_URI[aarch64_golang-github-zookeeper-zk-devel.sha256sum] = "e51ac43a5d082888ca3a01cb93d0df00dcd1e2cdeca902e3c3a5855da7284e72"

RDEPENDS:golang-github-zookeeper-zk-devel = " \
 go-filesystem \
 "
