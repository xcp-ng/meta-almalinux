# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-warlock"
PV = "2.1.0"
PR = "7.el10_2"
PACKAGES = " \
 python3-warlock \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-warlock-2.1.0-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7640982df32b266b62a6ece520dcb0ef616fb572848764375eb8cd1d952acc3"

URI_x86_64_v2_python3-warlock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-warlock-2.1.0-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-warlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-warlock}"
SRC_URI[x86_64_v2_python3-warlock.sha256sum] = "da579b5ed9a50c87b91d3e23daeab53cd15330a0590403c3cf56dcfd287837f5"

URI_aarch64_python3-warlock = "${EPEL_MIRROR}/aarch64/Packages/p/python3-warlock-2.1.0-7.el10_2.noarch.rpm;name=aarch64_python3-warlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-warlock}"
SRC_URI[aarch64_python3-warlock.sha256sum] = "984c1ca222236771b865774b0cf9c8a49de8a68c9dd7865af1184751a6f03c93"

RDEPENDS:python3-warlock = " \
 python3 \
 python3-jsonpatch \
 python3-jsonschema \
 "
