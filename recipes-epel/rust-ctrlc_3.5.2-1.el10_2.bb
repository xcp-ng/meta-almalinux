# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctrlc"
PV = "3.5.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-ctrlc+default-devel \
 rust-ctrlc+termination-devel \
 rust-ctrlc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ctrlc-3.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f58220af95af0fd0a2b4be49a53bdd2cb1f2aa407a34d5f04d74515cd6521dc"

URI_x86_64_v2_rust-ctrlc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctrlc+default-devel-3.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctrlc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctrlc+default-devel}"
SRC_URI[x86_64_v2_rust-ctrlc+default-devel.sha256sum] = "bef24419d165e254a5805fc8fd66a55d7e835b84e17802d93d6a26eb723299e6"

URI_x86_64_v2_rust-ctrlc+termination-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctrlc+termination-devel-3.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctrlc+termination-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctrlc+termination-devel}"
SRC_URI[x86_64_v2_rust-ctrlc+termination-devel.sha256sum] = "2baa9339e6e622a61d6d42027a24571c546373f90ec2dffd9bec0a03b1261e44"

URI_x86_64_v2_rust-ctrlc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctrlc-devel-3.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctrlc-devel}"
SRC_URI[x86_64_v2_rust-ctrlc-devel.sha256sum] = "6a924abe5c224214c19795abe3ac7093183b6b3962ad202b7cfef2c5f469636c"

URI_aarch64_rust-ctrlc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctrlc+default-devel-3.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ctrlc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctrlc+default-devel}"
SRC_URI[aarch64_rust-ctrlc+default-devel.sha256sum] = "5c6a429b2cfbda3202c58f2f035f4bfc4356c2b057fd602c4d892a72f644889e"

URI_aarch64_rust-ctrlc+termination-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctrlc+termination-devel-3.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ctrlc+termination-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctrlc+termination-devel}"
SRC_URI[aarch64_rust-ctrlc+termination-devel.sha256sum] = "ba82fbdbc49123bcfac12dd41bb9714efbef7453977dea08e0ab5a77b1cf6e99"

URI_aarch64_rust-ctrlc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctrlc-devel-3.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctrlc-devel}"
SRC_URI[aarch64_rust-ctrlc-devel.sha256sum] = "e409a233f2219e3987aeee83d9928fe42acdc5f14cb7de2c8c85ba1ce2229921"

RDEPENDS:rust-ctrlc+default-devel = " \
 cargo \
 rust-ctrlc-devel \
 "
RDEPENDS:rust-ctrlc+termination-devel = " \
 cargo \
 rust-ctrlc-devel \
 "
RDEPENDS:rust-ctrlc-devel = " \
 cargo \
 rust \
 rust-nix+signal-devel \
 rust-nix-devel \
 "
