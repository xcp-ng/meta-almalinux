# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 akonadi-calendar \
 akonadi-calendar-devel \
 akonadi-calendar-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbac88464cc2fa8de23a2fae784d5f6fab20b1dcecfdaae970a7f5c7f02e59a3"

URI_x86_64_v2_akonadi-calendar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar}"
SRC_URI[x86_64_v2_akonadi-calendar.sha256sum] = "8f7739e2be85f5d5a2de3fab34e223ffeaf4c71a813cf197de26d00e0b8f2e5a"

URI_x86_64_v2_akonadi-calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-devel}"
SRC_URI[x86_64_v2_akonadi-calendar-devel.sha256sum] = "3e515fc360dd0ffa761ee58ab048d37883e4e2fba10006244ff60a2af585d157"

URI_x86_64_v2_akonadi-calendar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-calendar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-doc}"
SRC_URI[x86_64_v2_akonadi-calendar-doc.sha256sum] = "1e45db9f74c5ff2c44e56191e415e7f5ef04af049e9835b615364ed5c5072ae1"

URI_aarch64_akonadi-calendar = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-calendar;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar}"
SRC_URI[aarch64_akonadi-calendar.sha256sum] = "30b6bb1b7780f9b0f0d63b7772ea83903bce0d15dd83d3e10991a9966f3bbd6f"

URI_aarch64_akonadi-calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-devel}"
SRC_URI[aarch64_akonadi-calendar-devel.sha256sum] = "5e00b06bb9b7c1c3c4baa06b27b924c5f0be77f79c7a034d4bb70f0060d97a71"

URI_aarch64_akonadi-calendar-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_akonadi-calendar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-doc}"
SRC_URI[aarch64_akonadi-calendar-doc.sha256sum] = "a5e7d26a3bdc923563dc4e476b13a2dba81af9276b1e586a8ee351e9a944dbdb"

RDEPENDS:akonadi-calendar = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgmepp \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libkleo \
 libstdc++ \
 messagelib \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-calendar-devel = " \
 akonadi-calendar \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kidentitymanagement-devel \
 "
RDEPENDS:akonadi-calendar-doc = " \
 "
