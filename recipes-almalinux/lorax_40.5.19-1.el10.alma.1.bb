# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax"
PV = "40.5.19"
PR = "1.el10.alma.1"
PACKAGES = " \
 lorax \
 lorax-docs \
 lorax-lmc-novirt \
 lorax-lmc-virt \
 lorax-templates-generic \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-40.5.19-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d1e5e428c6616b4879b11bfcb558cea9ac78ecb970d697079413732640bd6167"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-40.5.19-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax;unpack=0"
SRC_URI[x86_64_v2_lorax.sha256sum] = "1eddc228b344809d7fcebc75103b58260b4c3bdb3f7b9c916ed7650d3cef1c10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-docs-40.5.19-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-docs;unpack=0"
SRC_URI[x86_64_v2_lorax-docs.sha256sum] = "54e6499deee4d597d0214a54f19e732c481c39db7cd9f1ccfd25a758c9e09d25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-novirt-40.5.19-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-novirt;unpack=0"
SRC_URI[x86_64_v2_lorax-lmc-novirt.sha256sum] = "6ae1b7211e8ec36c5eab1d1c0d5eaa26f570df9d1d6b968908e071ea6bb42d0a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-virt-40.5.19-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-virt;unpack=0"
SRC_URI[x86_64_v2_lorax-lmc-virt.sha256sum] = "678812b410ad37bf13d38b39e9003b0c9db6e79523a054018ae364f2c498a9be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-generic-40.5.19-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-templates-generic;unpack=0"
SRC_URI[x86_64_v2_lorax-templates-generic.sha256sum] = "5bdd02508aa09c67c86697fdf877d3e626c9ade8b497e96ecd8f64b3f888a113"
RPROVIDES:lorax-templates-generic:append:x86_64_v2 = " virtual/lorax-templates"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-40.5.19-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax;unpack=0"
SRC_URI[aarch64_lorax.sha256sum] = "8af198947b064b5983ca036aeaed915dd6b2e2a2a56fc26b601554924354f55d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-docs-40.5.19-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-docs;unpack=0"
SRC_URI[aarch64_lorax-docs.sha256sum] = "4547fcb7fb1729aab6ff74a641e9cbf39d8d1f0ff76e07ff8011c0f8b4e7dbf6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-novirt-40.5.19-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-lmc-novirt;unpack=0"
SRC_URI[aarch64_lorax-lmc-novirt.sha256sum] = "2eb7192e1eb6deee48c285e4116cf69b5784572efd86de503010a5018d4b1e72"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-virt-40.5.19-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-lmc-virt;unpack=0"
SRC_URI[aarch64_lorax-lmc-virt.sha256sum] = "6958047ad99851dd6f28fa109fce9f08b8ecb1cc3948f3e39032a948db810cc8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-generic-40.5.19-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-templates-generic;unpack=0"
SRC_URI[aarch64_lorax-templates-generic.sha256sum] = "f66d70758cd7ccac172f3a65245f4ec606cb84820628deb5b15c94f8280bd528"
RPROVIDES:lorax-templates-generic:append:aarch64 = " virtual/lorax-templates"

RDEPENDS:lorax:x86_64_v2 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 grub2-pc \
 grub2-tools \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax:aarch64 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax-docs = " \
 lorax \
 "
RDEPENDS:lorax-lmc-novirt = " \
 almalinux-logos \
 anaconda-core \
 anaconda-install-env-deps \
 anaconda-tui \
 lorax \
 python3-psutil \
 tar \
 "
RDEPENDS:lorax-lmc-virt:x86_64_v2 = " \
 edk2-ovmf \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-lmc-virt:aarch64 = " \
 edk2-aarch64 \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-templates-generic = " \
 lorax \
 "
