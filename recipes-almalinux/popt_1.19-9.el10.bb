# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "popt"
PV = "1.19"
PR = "9.el10"
PACKAGES = " \
 popt \
 popt-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/popt-1.19-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "40750bde25d53e659ef16658e16748dc41e2a2ab6cebb51ddf3fb1fcf64f1a26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/popt-1.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_popt;unpack=0"
SRC_URI[x86_64_v2_popt.sha256sum] = "21153301316310fb729f75337bb82472ee65dfd524926e585ef45843b533f440"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/popt-devel-1.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_popt-devel;unpack=0"
SRC_URI[x86_64_v2_popt-devel.sha256sum] = "04c1f8d0fa2103931d1aee3afe5b006add59ba896fa426460952edbc89307849"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/popt-1.19-9.el10.aarch64.rpm;name=aarch64_popt;unpack=0"
SRC_URI[aarch64_popt.sha256sum] = "11413b4f3739941b1755fad4e9c1989deaaaff0809397905065c2128d93923b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/popt-devel-1.19-9.el10.aarch64.rpm;name=aarch64_popt-devel;unpack=0"
SRC_URI[aarch64_popt-devel.sha256sum] = "44c2bf615ed1a5c90fdadf0783a8d3222c7e2fdc6a89c2b285c19adf68149dff"

RDEPENDS:popt = " \
 glibc \
 "
RDEPENDS:popt-devel = " \
 pkgconf-pkg-config \
 popt \
 "
