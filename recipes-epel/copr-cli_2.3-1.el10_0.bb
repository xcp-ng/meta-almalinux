# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "copr-cli"
PV = "2.3"
PR = "1.el10_0"
PACKAGES = " \
 copr-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/copr-cli-2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e64fc9e67935e6523e9dc8c58c8c240c0ca8f2bfc3fe63a7cd64d59281fe7b3"

URI_x86_64_v2_copr-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/copr-cli-2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_copr-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_copr-cli}"
SRC_URI[x86_64_v2_copr-cli.sha256sum] = "5f55f9011050355f291a0b252d0d65027ca4151b06e424e21074193067cbf77d"

URI_aarch64_copr-cli = "${EPEL_MIRROR}/aarch64/Packages/c/copr-cli-2.3-1.el10_0.noarch.rpm;name=aarch64_copr-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_copr-cli}"
SRC_URI[aarch64_copr-cli.sha256sum] = "ce86c22dc547f0066140dfad8c66b3ec400dc8e11c0b530ecc866bcb06e37e65"

RDEPENDS:copr-cli = " \
 python3 \
 python3-copr \
 python3-humanize \
 python3-jinja2 \
 python3-koji \
 python3-setuptools \
 wget \
 "
