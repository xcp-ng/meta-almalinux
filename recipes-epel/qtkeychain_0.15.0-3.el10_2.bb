# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qtkeychain"
PV = "0.15.0"
PR = "3.el10_2"
PACKAGES = " \
 qtkeychain-qt5 \
 qtkeychain-qt5-devel \
 qtkeychain-qt6 \
 qtkeychain-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qtkeychain-0.15.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6872b3465b8a4408a3bfe826d5c2220fa83267e4cdd3d820c14933d61891f5c7"

URI_x86_64_v2_qtkeychain-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt5-0.15.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt5}"
SRC_URI[x86_64_v2_qtkeychain-qt5.sha256sum] = "de4db70c86ac2923ac341458167878bc2f0f604b7c0af051e008572d7c32ca9e"

URI_x86_64_v2_qtkeychain-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt5-devel-0.15.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt5-devel}"
SRC_URI[x86_64_v2_qtkeychain-qt5-devel.sha256sum] = "f1c522b051ead0b9e9cd2b3f5999a2cfe2ddee2006abb47e0951ada628ee34ec"

URI_x86_64_v2_qtkeychain-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt6-0.15.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt6}"
SRC_URI[x86_64_v2_qtkeychain-qt6.sha256sum] = "927ca39c6ea48d38cca32bf874768a52a2484e5ea29ebb4cb1f22737dc6aa629"

URI_x86_64_v2_qtkeychain-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt6-devel-0.15.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt6-devel}"
SRC_URI[x86_64_v2_qtkeychain-qt6-devel.sha256sum] = "9d5d13b5f3857989d8c0fe7d5b5e816c711066758956a5c510a5d725de5fb424"

URI_aarch64_qtkeychain-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt5-0.15.0-3.el10_2.aarch64.rpm;name=aarch64_qtkeychain-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt5}"
SRC_URI[aarch64_qtkeychain-qt5.sha256sum] = "d4cebfa4e77ce5957550c11b6eaaf7e870d1d23e903095fd148bf564a96b2694"

URI_aarch64_qtkeychain-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt5-devel-0.15.0-3.el10_2.aarch64.rpm;name=aarch64_qtkeychain-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt5-devel}"
SRC_URI[aarch64_qtkeychain-qt5-devel.sha256sum] = "e53334405a122d86c3e0e9e3ea7b859d1a83ae0ffad097fc1ce9fd57b40701d3"

URI_aarch64_qtkeychain-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt6-0.15.0-3.el10_2.aarch64.rpm;name=aarch64_qtkeychain-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt6}"
SRC_URI[aarch64_qtkeychain-qt6.sha256sum] = "338c743f803c8eeaa24e8c9975a9f60fadd221776c0ca6656fdbfada4ca0294c"

URI_aarch64_qtkeychain-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt6-devel-0.15.0-3.el10_2.aarch64.rpm;name=aarch64_qtkeychain-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt6-devel}"
SRC_URI[aarch64_qtkeychain-qt6-devel.sha256sum] = "fd17eb7f8ca1bc481de9ad35b3b3f555f12e4db2b3733b45be09468bb2fa8b4a"

RDEPENDS:qtkeychain-qt5 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qtkeychain-qt5-devel = " \
 cmake-filesystem \
 libsecret-devel \
 qt5-qtbase-devel \
 qtkeychain-qt5 \
 "
RDEPENDS:qtkeychain-qt6 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qtkeychain-qt6-devel = " \
 cmake-filesystem \
 libsecret-devel \
 qt6-qtbase-devel \
 qtkeychain-qt6 \
 "
