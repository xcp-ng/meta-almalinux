# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "AMF"
PE = "1"
PV = "1.5.2"
PR = "1.el10_1"
PACKAGES = " \
 AMF-devel \
 AMF-docs \
 AMF-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/AMF-1.5.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f69c5252709aef02d3c5ccb38e40e18bbdcee3e7b033742f48411f4a29b2a956"

URI_x86_64_v2_AMF-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-devel-1.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-devel}"
SRC_URI[x86_64_v2_AMF-devel.sha256sum] = "1da7cfbc5b6aeac47fe57ea004d459358076d843e8334c0fe53209e0a12bc547"

URI_x86_64_v2_AMF-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-docs-1.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-docs}"
SRC_URI[x86_64_v2_AMF-docs.sha256sum] = "b8d8c714ef34298d03e5778651ee54839434bede74b0a90f41a0f39fb812c3c2"

URI_x86_64_v2_AMF-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-samples-1.5.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-samples}"
SRC_URI[x86_64_v2_AMF-samples.sha256sum] = "b7a3391436370136a551996df39ffe412727d89fee5f0f48eff2148ea6d2c0fb"

URI_aarch64_AMF-devel = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-devel-1.5.2-1.el10_1.noarch.rpm;name=aarch64_AMF-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-devel}"
SRC_URI[aarch64_AMF-devel.sha256sum] = "92bbb607c5e67ceda24298e106cf75a193b758f5c197040d4114cd917f6565bc"

URI_aarch64_AMF-docs = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-docs-1.5.2-1.el10_1.noarch.rpm;name=aarch64_AMF-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-docs}"
SRC_URI[aarch64_AMF-docs.sha256sum] = "ca0874a5d3905b27a0c7ae49ee61206a1639c550a50b757a373af8ae441217d9"

URI_aarch64_AMF-samples = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-samples-1.5.2-1.el10_1.noarch.rpm;name=aarch64_AMF-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-samples}"
SRC_URI[aarch64_AMF-samples.sha256sum] = "de2aee8629b32b97d588c54c9aab154fb3fe3956b88371931b4bbc51f6e954e2"

RDEPENDS:AMF-devel = " \
 "
RDEPENDS:AMF-docs = " \
 "
RDEPENDS:AMF-samples = " \
 "
