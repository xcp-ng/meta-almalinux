# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-barbicanclient"
PV = "7.3.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-barbicanclient \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-barbicanclient-7.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cb072b71229c245e7b897f4f8dd62f628e39862696897a627e6df4a58155a92b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-barbicanclient-7.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-barbicanclient;unpack=0"
SRC_URI[x86_64_v2_python3-barbicanclient.sha256sum] = "a226cd6663e17b68a9fa41f2904654939647a8fe85b6e38d4a60899bb36582c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-barbicanclient-7.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-barbicanclient;unpack=0"
SRC_URI[aarch64_python3-barbicanclient.sha256sum] = "e3e87e5d0ace83d3f23f66bc6031c8deb6a2c8aabb267ceafe3761dc8c2c5a29"

RDEPENDS:python3-barbicanclient = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-requests \
 "
