# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xxhash-rust"
PV = "0.8.18"
PR = "1.el10_2"
PACKAGES = " \
 rust-xxhash-rust+const_xxh3-devel \
 rust-xxhash-rust+const_xxh32-devel \
 rust-xxhash-rust+const_xxh64-devel \
 rust-xxhash-rust+default-devel \
 rust-xxhash-rust+std-devel \
 rust-xxhash-rust+xxh3-devel \
 rust-xxhash-rust+xxh32-devel \
 rust-xxhash-rust+xxh64-devel \
 rust-xxhash-rust-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xxhash-rust-0.8.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b82313114acfe61782e1b34f2184c94bd62c1c7801507518fc40d2b75f120d3"

URI_x86_64_v2_rust-xxhash-rust+const_xxh3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+const_xxh3-devel-0.8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+const_xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+const_xxh3-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+const_xxh3-devel.sha256sum] = "d6424cee101317c5aa0e21e9604b594c051cd033410a75de5eaaa9e2865e257b"

URI_x86_64_v2_rust-xxhash-rust+const_xxh32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+const_xxh32-devel-0.8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+const_xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+const_xxh32-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+const_xxh32-devel.sha256sum] = "506fb628d9ab6402b9528bee9aec68be230d4f0498c713a4e00d171f171d5ba2"

URI_x86_64_v2_rust-xxhash-rust+const_xxh64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+const_xxh64-devel-0.8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+const_xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+const_xxh64-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+const_xxh64-devel.sha256sum] = "bbe97531ac9d0b195147920afcf8fc617e8172ba941a8d2fefd4c32c80bdedc0"

URI_x86_64_v2_rust-xxhash-rust+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+default-devel-0.8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+default-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+default-devel.sha256sum] = "48272e98267fecb5ad4488057dff8acbc84638efd0f8c494dfc3f1cc7e0bd5eb"

URI_x86_64_v2_rust-xxhash-rust+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+std-devel-0.8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+std-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+std-devel.sha256sum] = "c268df6b2dd3af00944a49a447e993b8215d39502cc30b1ef824cadecc743c0e"

URI_x86_64_v2_rust-xxhash-rust+xxh3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+xxh3-devel-0.8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+xxh3-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+xxh3-devel.sha256sum] = "fb7536ac06799a70b763f2e0d417b87a320be9e024e1cb4328987cdf39ec856a"

URI_x86_64_v2_rust-xxhash-rust+xxh32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+xxh32-devel-0.8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+xxh32-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+xxh32-devel.sha256sum] = "50af2846efd1ab194d00569d3bd91ee773a482d54bba61915e413bce140064b5"

URI_x86_64_v2_rust-xxhash-rust+xxh64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust+xxh64-devel-0.8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust+xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust+xxh64-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust+xxh64-devel.sha256sum] = "fb64bd6bec02eda5153beeaa878d4105ff2428c05bbed7584a7dafa446581ad6"

URI_x86_64_v2_rust-xxhash-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xxhash-rust-devel-0.8.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xxhash-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xxhash-rust-devel}"
SRC_URI[x86_64_v2_rust-xxhash-rust-devel.sha256sum] = "0345a9af2d84921a3ba19fbe50f86295d680b9250726fcef2152b8cdb79945eb"

URI_aarch64_rust-xxhash-rust+const_xxh3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+const_xxh3-devel-0.8.18-1.el10_2.noarch.rpm;name=aarch64_rust-xxhash-rust+const_xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+const_xxh3-devel}"
SRC_URI[aarch64_rust-xxhash-rust+const_xxh3-devel.sha256sum] = "b5e2ba793d16cdd708f6319fdc80a1cf0d5fa3bc9f0a4da6f0dc7637ca2f918f"

URI_aarch64_rust-xxhash-rust+const_xxh32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+const_xxh32-devel-0.8.18-1.el10_2.noarch.rpm;name=aarch64_rust-xxhash-rust+const_xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+const_xxh32-devel}"
SRC_URI[aarch64_rust-xxhash-rust+const_xxh32-devel.sha256sum] = "7844b4f47b65fedb19a24b0c78f04b12b05eccbce69fc5a6ba38ae4be8b60f59"

URI_aarch64_rust-xxhash-rust+const_xxh64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+const_xxh64-devel-0.8.18-1.el10_2.noarch.rpm;name=aarch64_rust-xxhash-rust+const_xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+const_xxh64-devel}"
SRC_URI[aarch64_rust-xxhash-rust+const_xxh64-devel.sha256sum] = "d27b350a6493f48f7ab45c2ceb87b26e05af961afd99248f907c281e2bc76ddd"

URI_aarch64_rust-xxhash-rust+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+default-devel-0.8.18-1.el10_2.noarch.rpm;name=aarch64_rust-xxhash-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+default-devel}"
SRC_URI[aarch64_rust-xxhash-rust+default-devel.sha256sum] = "0d8fd0863e59a7be9fb7d7fc654721beee8c4aab2e20b157ad6d33fdd2327963"

URI_aarch64_rust-xxhash-rust+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+std-devel-0.8.18-1.el10_2.noarch.rpm;name=aarch64_rust-xxhash-rust+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+std-devel}"
SRC_URI[aarch64_rust-xxhash-rust+std-devel.sha256sum] = "bd22059a024e1d15af72320ff5080fa469225855474b6d73a4a17ea744be366f"

URI_aarch64_rust-xxhash-rust+xxh3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+xxh3-devel-0.8.18-1.el10_2.noarch.rpm;name=aarch64_rust-xxhash-rust+xxh3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+xxh3-devel}"
SRC_URI[aarch64_rust-xxhash-rust+xxh3-devel.sha256sum] = "e3ad22a96e61b757bb3744d64a7e23f55f02e15de84f6e2a062a9c932d4dccfc"

URI_aarch64_rust-xxhash-rust+xxh32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+xxh32-devel-0.8.18-1.el10_2.noarch.rpm;name=aarch64_rust-xxhash-rust+xxh32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+xxh32-devel}"
SRC_URI[aarch64_rust-xxhash-rust+xxh32-devel.sha256sum] = "592d69f54217ef0b39b1651c6f254c0eb5d53711865723a75e21c48bed70000a"

URI_aarch64_rust-xxhash-rust+xxh64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust+xxh64-devel-0.8.18-1.el10_2.noarch.rpm;name=aarch64_rust-xxhash-rust+xxh64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust+xxh64-devel}"
SRC_URI[aarch64_rust-xxhash-rust+xxh64-devel.sha256sum] = "f3f8bf943089845c96603e6faf454c392f9911e8c6a3ec3e2dde2aa585d93ad1"

URI_aarch64_rust-xxhash-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xxhash-rust-devel-0.8.18-1.el10_2.noarch.rpm;name=aarch64_rust-xxhash-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xxhash-rust-devel}"
SRC_URI[aarch64_rust-xxhash-rust-devel.sha256sum] = "214ea7e2ab98a3c8cedd2db7da57539367215eab4bd1afd01b6e0f7149fa3e54"

RDEPENDS:rust-xxhash-rust+const_xxh3-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+const_xxh32-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+const_xxh64-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+default-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+std-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+xxh3-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+xxh32-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust+xxh64-devel = " \
 cargo \
 rust-xxhash-rust-devel \
 "
RDEPENDS:rust-xxhash-rust-devel = " \
 cargo \
 "
