# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "device-mapper-multipath"
PV = "0.9.9"
PR = "19.el10"
PACKAGES = " \
 device-mapper-multipath \
 device-mapper-multipath-devel \
 device-mapper-multipath-libs \
 kpartx \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/device-mapper-multipath-0.9.9-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fdea36a1199d759bc6636f3727c51d837480ed909c192c97f29168bf8538afe"

URI_x86_64_v2_device-mapper-multipath = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-0.9.9-19.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath}"
SRC_URI[x86_64_v2_device-mapper-multipath.sha256sum] = "fa8112215ff53d23b9cdbe52d6f4694c028de9bb9181a3c67bbdd0e81b81f2f0"

URI_x86_64_v2_device-mapper-multipath-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-multipath-devel-0.9.9-19.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath-devel}"
SRC_URI[x86_64_v2_device-mapper-multipath-devel.sha256sum] = "ae65c5d77fa4e7c1cb3ba1f4c8039316afb2f9bda8f23697a0be91e928471182"

URI_x86_64_v2_device-mapper-multipath-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-libs-0.9.9-19.el10.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath-libs}"
SRC_URI[x86_64_v2_device-mapper-multipath-libs.sha256sum] = "8df0fbb9324986519d90ae38713fd52919bad252f58f3b9d9591ad4ae6621598"

URI_x86_64_v2_kpartx = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpartx-0.9.9-19.el10.x86_64_v2.rpm;name=x86_64_v2_kpartx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpartx}"
SRC_URI[x86_64_v2_kpartx.sha256sum] = "feb137d0c5963c91ecfa1841415d2a314f536b0d1e71d710e4c8269797cd3ca5"

URI_aarch64_device-mapper-multipath = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-0.9.9-19.el10.aarch64.rpm;name=aarch64_device-mapper-multipath;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath}"
SRC_URI[aarch64_device-mapper-multipath.sha256sum] = "c3b181ab9ec384d8d8a59fae49897972f993085956f0e653a62c5b0d7422453b"

URI_aarch64_device-mapper-multipath-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-multipath-devel-0.9.9-19.el10.aarch64.rpm;name=aarch64_device-mapper-multipath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath-devel}"
SRC_URI[aarch64_device-mapper-multipath-devel.sha256sum] = "a74105ee131295d159f9b091118efbeb5400fa92aedfd194fc835988678582d0"

URI_aarch64_device-mapper-multipath-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-libs-0.9.9-19.el10.aarch64.rpm;name=aarch64_device-mapper-multipath-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath-libs}"
SRC_URI[aarch64_device-mapper-multipath-libs.sha256sum] = "7ee4c59cb722432f2784fab56128eb68e22ff341448fa275bc3fd65761a57c45"

URI_aarch64_kpartx = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpartx-0.9.9-19.el10.aarch64.rpm;name=aarch64_kpartx;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpartx}"
SRC_URI[aarch64_kpartx.sha256sum] = "7c6c58813da07378f309a810fd4556b6fd4e363ae490a98cd5b4393f167ad537"

RDEPENDS:device-mapper-multipath = " \
 bash \
 device-mapper \
 device-mapper-libs \
 device-mapper-multipath-libs \
 glibc \
 kpartx \
 libgcc \
 libmount \
 readline \
 systemd \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:device-mapper-multipath-devel = " \
 device-mapper-multipath \
 device-mapper-multipath-libs \
 "
RDEPENDS:device-mapper-multipath-libs = " \
 device-mapper-libs \
 glibc \
 libaio \
 libgcc \
 libmount \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:kpartx = " \
 bash \
 device-mapper-libs \
 glibc \
 "
