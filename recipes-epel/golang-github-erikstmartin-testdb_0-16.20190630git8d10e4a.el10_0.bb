# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-erikstmartin-testdb"
PV = "0"
PR = "16.20190630git8d10e4a.el10_0"
PACKAGES = " \
 golang-github-erikstmartin-testdb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-erikstmartin-testdb-0-16.20190630git8d10e4a.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3948a0e7ca1e52920ce545d08dcaad621ef09e2114c62d27444d0a5bf33d1e6"

URI_aarch64_golang-github-erikstmartin-testdb-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-erikstmartin-testdb-devel-0-16.20190630git8d10e4a.el10_0.noarch.rpm;name=aarch64_golang-github-erikstmartin-testdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-erikstmartin-testdb-devel}"
SRC_URI[aarch64_golang-github-erikstmartin-testdb-devel.sha256sum] = "57083aaac41653f71ca30e485f586f421ba2db1c3f894408adaf3209b47e0898"

RDEPENDS:golang-github-erikstmartin-testdb-devel = " \
 go-filesystem \
 "
