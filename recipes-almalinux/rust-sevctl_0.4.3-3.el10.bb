# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sevctl"
PV = "0.4.3"
PR = "3.el10"
PACKAGES:x86_64_v2 = " \
 sevctl \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-sevctl-0.4.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "28c990c2644efbf85d91b0eb1bf39b2dda1b64586478a4fee127e98c0fe1b437"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sevctl-0.4.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_sevctl;unpack=0"
SRC_URI[x86_64_v2_sevctl.sha256sum] = "d644d4c1b453d750fc90acedab221621c104541275c2dfd3f9296ce9c2aff067"

RDEPENDS:sevctl = " \
 glibc \
 libgcc \
 openssl-libs \
 "
