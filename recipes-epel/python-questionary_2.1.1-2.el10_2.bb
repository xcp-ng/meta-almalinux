# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-questionary"
PV = "2.1.1"
PR = "2.el10_2"
PACKAGES = " \
 python3-questionary \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-questionary-2.1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "09efb8237e0a0bb25c216037f04188b1f875b7c469d3335f767c92a99fcc5cd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-questionary-2.1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-questionary;unpack=0"
SRC_URI[x86_64_v2_python3-questionary.sha256sum] = "cba5abe622418e8a9e1aaa4e8c6bd3f5b66cd34c470d67f1f88929d7566b84b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-questionary-2.1.1-2.el10_2.noarch.rpm;name=aarch64_python3-questionary;unpack=0"
SRC_URI[aarch64_python3-questionary.sha256sum] = "9e81ac0934b229c47a78da705c0fcb75d9c5933994db0de592ca0e05819ad3fa"

RDEPENDS:python3-questionary = " \
 python3 \
 python3-prompt-toolkit \
 "
