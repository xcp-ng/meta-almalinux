# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl-sys"
PV = "0.9.117"
PR = "1.el10_3"
PACKAGES = " \
 rust-openssl-sys+bindgen-devel \
 rust-openssl-sys+default-devel \
 rust-openssl-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-sys-0.9.117-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7678cdea6ad89b5653a76e34a956bffb0944b86e8e935cf6dc4d0e7ed8cd9f24"

URI_x86_64_v2_rust-openssl-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys+bindgen-devel-0.9.117-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys+bindgen-devel.sha256sum] = "29e0266dfcfa08bbb275ad799e2536e56f6d314c511031dc58d8a58649901937"

URI_x86_64_v2_rust-openssl-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys+default-devel-0.9.117-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys+default-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys+default-devel.sha256sum] = "52cc0cf8cd8814bbf65390e176e090e21da45c818b0ea872260b2d04a26594a4"

URI_x86_64_v2_rust-openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys-devel-0.9.117-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys-devel.sha256sum] = "5bfcff015f6482589ebe8bd2bc5dad533045c893678ccc799fce2722c060af09"

URI_aarch64_rust-openssl-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys+bindgen-devel-0.9.117-1.el10_3.noarch.rpm;name=aarch64_rust-openssl-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys+bindgen-devel}"
SRC_URI[aarch64_rust-openssl-sys+bindgen-devel.sha256sum] = "1496852723cc60da1f302065666158ecfad3fdf6f3d3e040611cfa54fab9feba"

URI_aarch64_rust-openssl-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys+default-devel-0.9.117-1.el10_3.noarch.rpm;name=aarch64_rust-openssl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys+default-devel}"
SRC_URI[aarch64_rust-openssl-sys+default-devel.sha256sum] = "7724093d9a2149ffe92fc9dcf81d47ee7713b056ff3188129b0ba5af72b39e35"

URI_aarch64_rust-openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys-devel-0.9.117-1.el10_3.noarch.rpm;name=aarch64_rust-openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys-devel}"
SRC_URI[aarch64_rust-openssl-sys-devel.sha256sum] = "ea33b9dd8cd5890dccd90ca6007ed00bf0db1186b760f15cae6c4def3974b0df"

RDEPENDS:rust-openssl-sys+bindgen-devel = " \
 cargo \
 rust-bindgen+default-devel \
 rust-bindgen+experimental-devel \
 rust-openssl-sys-devel \
 "
RDEPENDS:rust-openssl-sys+default-devel = " \
 cargo \
 rust-openssl-sys-devel \
 "
RDEPENDS:rust-openssl-sys-devel = " \
 cargo \
 openssl-devel \
 rust \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
