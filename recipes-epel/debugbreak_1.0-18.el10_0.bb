# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debugbreak"
PV = "1.0"
PR = "18.el10_0"
PACKAGES = " \
 debugbreak-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debugbreak-1.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bffe06ffa795edd18d4a76c4a535e77dfb5fa6e4911ad4ae3a1f1a81d40e203c"

URI_x86_64_v2_debugbreak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debugbreak-devel-1.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_debugbreak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debugbreak-devel}"
SRC_URI[x86_64_v2_debugbreak-devel.sha256sum] = "6038e2d03453524524e713ab2f52bd4b62bb45d7dba392233fc161f9dde6c6dc"

URI_aarch64_debugbreak-devel = "${EPEL_MIRROR}/aarch64/Packages/d/debugbreak-devel-1.0-18.el10_0.noarch.rpm;name=aarch64_debugbreak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_debugbreak-devel}"
SRC_URI[aarch64_debugbreak-devel.sha256sum] = "68e9630f72809e32dce3d3440cbbdebb9e7ce51e6715cc6a3020d52cbf160de8"

RDEPENDS:debugbreak-devel = " \
 "
