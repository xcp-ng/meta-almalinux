# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arpwatch"
PE = "14"
PV = "3.9"
PR = "10.el10_3"
PACKAGES = " \
 arpwatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arpwatch-3.9-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdb3e36e901a5ab11f6dd036836efc7102b002083c3c921a8d30753557b2ff10"

URI_x86_64_v2_arpwatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arpwatch-3.9-10.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arpwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arpwatch}"
SRC_URI[x86_64_v2_arpwatch.sha256sum] = "d48868b316ff694345f3b78f6f39fa46fc47283513067b2e81c6fa2be245ac0f"

URI_aarch64_arpwatch = "${EPEL_MIRROR}/aarch64/Packages/a/arpwatch-3.9-10.el10_3.aarch64.rpm;name=aarch64_arpwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_arpwatch}"
SRC_URI[aarch64_arpwatch.sha256sum] = "84e6ba47684d501c3e5f37be614076a5647d07e83ed2557800ed9dd95f7e2bb3"

RDEPENDS:arpwatch = " \
 bash \
 glibc \
 libpcap \
 python3 \
 shadow-utils \
 virtual//usr/sbin/sendmail \
 "
