# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-files"
PV = "36"
PR = "1.el10"
PACKAGES = " \
 cockpit-files \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-files-36-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "579e16aa729bbe03bc56eba400bf6e09d6a8918ec24798fd7221512aaf7deced"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-files-36-1.el10.noarch.rpm;name=x86_64_v2_cockpit-files;unpack=0"
SRC_URI[x86_64_v2_cockpit-files.sha256sum] = "5115f3af4a7d22c9f52940a8e1fa196184a713eb58c322baff330d578d7b0b35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-files-36-1.el10.noarch.rpm;name=aarch64_cockpit-files;unpack=0"
SRC_URI[aarch64_cockpit-files.sha256sum] = "5115f3af4a7d22c9f52940a8e1fa196184a713eb58c322baff330d578d7b0b35"

RDEPENDS:cockpit-files = " \
 cockpit-bridge \
 "
