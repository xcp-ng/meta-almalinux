# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdecoration"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kdecoration \
 kdecoration-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdecoration-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "433f059270b580acfd20d8b407f183a09c9b7b80821a31ecfd406271b38cd268"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration;unpack=0"
SRC_URI[x86_64_v2_kdecoration.sha256sum] = "2b93b92bb61e1a39b82c9f32f3710f4bb072b03b145eec14db65600d583c609b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration-devel;unpack=0"
SRC_URI[x86_64_v2_kdecoration-devel.sha256sum] = "c65c403096c65ac8bddd00d0e86a8a432c1ae1047faad1c0ea75609328563108"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kdecoration;unpack=0"
SRC_URI[aarch64_kdecoration.sha256sum] = "3e1d7b2c90d13d9a6ad566b4ae5850e8c023f6bc70a99b32aa36ea26cd1203d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kdecoration-devel;unpack=0"
SRC_URI[aarch64_kdecoration-devel.sha256sum] = "8e6f4ef161b4127931b757d8a49eabc7a3752cf5e4dd50ceef66338d52d9cb9f"

RDEPENDS:kdecoration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdecoration-devel = " \
 cmake-filesystem \
 kdecoration \
 "
