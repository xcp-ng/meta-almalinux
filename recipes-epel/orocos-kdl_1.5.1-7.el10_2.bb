# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "orocos-kdl"
PV = "1.5.1"
PR = "7.el10_2"
PACKAGES = " \
 orocos-kdl \
 orocos-kdl-devel \
 orocos-kdl-doc \
 python3-pykdl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/orocos-kdl-1.5.1-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63af00b9f2ed0e42a42d9c4e8ad48517f6b03a1eac2136aa05b2b8d359527094"

URI_x86_64_v2_orocos-kdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/orocos-kdl-1.5.1-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_orocos-kdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_orocos-kdl}"
SRC_URI[x86_64_v2_orocos-kdl.sha256sum] = "c707416c98ae2310bb030b2badff1f828ab9590d4738265b159c9d615a91eefc"

URI_x86_64_v2_orocos-kdl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/orocos-kdl-devel-1.5.1-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_orocos-kdl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_orocos-kdl-devel}"
SRC_URI[x86_64_v2_orocos-kdl-devel.sha256sum] = "0ea8b787c309f97a933da7f9bf2ab1c05db8727b290862f9147bbe71099fe37e"

URI_x86_64_v2_orocos-kdl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/orocos-kdl-doc-1.5.1-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_orocos-kdl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_orocos-kdl-doc}"
SRC_URI[x86_64_v2_orocos-kdl-doc.sha256sum] = "8673ac8f400b7c959eb3efdf31768d948edc096c77d830b09647c01320a23556"

URI_x86_64_v2_python3-pykdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pykdl-1.5.1-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pykdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pykdl}"
SRC_URI[x86_64_v2_python3-pykdl.sha256sum] = "459cc7809216c8d234bd13113290b907dd56266cdc8dd2b45db8b86f8288d2f0"

URI_aarch64_orocos-kdl = "${EPEL_MIRROR}/aarch64/Packages/o/orocos-kdl-1.5.1-7.el10_2.aarch64.rpm;name=aarch64_orocos-kdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_orocos-kdl}"
SRC_URI[aarch64_orocos-kdl.sha256sum] = "2b4c8806c2f87548c25c50553f8e02782f9e612f5334ede1b8291a3b075db438"

URI_aarch64_orocos-kdl-devel = "${EPEL_MIRROR}/aarch64/Packages/o/orocos-kdl-devel-1.5.1-7.el10_2.aarch64.rpm;name=aarch64_orocos-kdl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_orocos-kdl-devel}"
SRC_URI[aarch64_orocos-kdl-devel.sha256sum] = "fe95807bf37bc4e64067fa13518d809d80c14aeedcbc0d6ed608c8ed4b292f69"

URI_aarch64_orocos-kdl-doc = "${EPEL_MIRROR}/aarch64/Packages/o/orocos-kdl-doc-1.5.1-7.el10_2.noarch.rpm;name=aarch64_orocos-kdl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_orocos-kdl-doc}"
SRC_URI[aarch64_orocos-kdl-doc.sha256sum] = "9f03f1237557905aa6f32b7741de3bdebc83107c43f4d29a4d5e14aeec4f9c40"

URI_aarch64_python3-pykdl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pykdl-1.5.1-7.el10_2.aarch64.rpm;name=aarch64_python3-pykdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pykdl}"
SRC_URI[aarch64_python3-pykdl.sha256sum] = "33d526aaca82b7dc63d3204b8bed43638cb71d1838401fc9ec8829c194c884ec"

RDEPENDS:orocos-kdl = " \
 eigen3-devel \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:orocos-kdl-devel = " \
 orocos-kdl \
 pkgconf-pkg-config \
 "
RDEPENDS:orocos-kdl-doc = " \
 "
RDEPENDS:python3-pykdl = " \
 glibc \
 libgcc \
 libstdc++ \
 orocos-kdl \
 python3 \
 "
