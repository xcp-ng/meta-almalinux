# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql-jdbc"
PV = "42.7.1"
PR = "7.el10"
PACKAGES = " \
 postgresql-jdbc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql-jdbc-42.7.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f2b124dc0169db44951df39c5a40b64c0203f7db0f6714493e65b2d3fa01c72"

URI_x86_64_v2_postgresql-jdbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-jdbc-42.7.1-7.el10.noarch.rpm;name=x86_64_v2_postgresql-jdbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-jdbc}"
SRC_URI[x86_64_v2_postgresql-jdbc.sha256sum] = "529f6484409367259cfdc6f802be0e2beb368e89c6ab7e9966c3e6d38b5000b6"

URI_aarch64_postgresql-jdbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-jdbc-42.7.1-7.el10.noarch.rpm;name=aarch64_postgresql-jdbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-jdbc}"
SRC_URI[aarch64_postgresql-jdbc.sha256sum] = "529f6484409367259cfdc6f802be0e2beb368e89c6ab7e9966c3e6d38b5000b6"

RDEPENDS:postgresql-jdbc = " \
 javapackages-filesystem \
 ongres-scram-client \
 "
