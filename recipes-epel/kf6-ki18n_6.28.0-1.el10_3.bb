# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ki18n"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ki18n \
 kf6-ki18n-devel \
 kf6-ki18n-doc \
 kf6-ki18n-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ki18n-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b650c7729f834a955a8273f62ba8f6c839f61a545100d52f7154b36157c4df61"

URI_x86_64_v2_kf6-ki18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n}"
SRC_URI[x86_64_v2_kf6-ki18n.sha256sum] = "d916ce6d88e84cd6147247ccf4915889f4e57caa151bd08092eafa96617d8ff4"

URI_x86_64_v2_kf6-ki18n-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-devel}"
SRC_URI[x86_64_v2_kf6-ki18n-devel.sha256sum] = "b404ac5cc513c708f5143cee44bf31e1adb2a3e8afa673d218c6019e07eed16d"

URI_x86_64_v2_kf6-ki18n-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ki18n-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-doc}"
SRC_URI[x86_64_v2_kf6-ki18n-doc.sha256sum] = "2fc76302d0fb9e47c48be9fb91fa865e832be992fd62c06c83dc9e5e9d715021"

URI_x86_64_v2_kf6-ki18n-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ki18n-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-html}"
SRC_URI[x86_64_v2_kf6-ki18n-html.sha256sum] = "f9d3f11b2bc5d093502be1ab8325ea3b9861a65431512f563e6f6a557c8c0ee0"

URI_aarch64_kf6-ki18n = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ki18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n}"
SRC_URI[aarch64_kf6-ki18n.sha256sum] = "17dc629cdc47280dd2e8055244140cd0639d972c51b7a9f21c914740c8567a83"

URI_aarch64_kf6-ki18n-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ki18n-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-devel}"
SRC_URI[aarch64_kf6-ki18n-devel.sha256sum] = "ad944b35f5fe981f7a603f1283e4b6547165fb59ab6eb597a836be752322c283"

URI_aarch64_kf6-ki18n-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ki18n-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-doc}"
SRC_URI[aarch64_kf6-ki18n-doc.sha256sum] = "06c9b75c50425f716d66fb7c5aa6aff5e5cc81b72ddda764aac1a430f01aa47e"

URI_aarch64_kf6-ki18n-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ki18n-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-html}"
SRC_URI[aarch64_kf6-ki18n-html.sha256sum] = "320ff1555640d269a589b59845b6166fc8e30053d48234508d03eef7942bd65d"

RDEPENDS:kf6-ki18n = " \
 glibc \
 iso-codes \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ki18n-devel = " \
 cmake-filesystem \
 gettext \
 kf6-ki18n \
 python3 \
 "
RDEPENDS:kf6-ki18n-doc = " \
 "
RDEPENDS:kf6-ki18n-html = " \
 "
