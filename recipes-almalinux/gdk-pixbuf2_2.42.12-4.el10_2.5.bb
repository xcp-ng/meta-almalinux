# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdk-pixbuf2"
PV = "2.42.12"
PR = "4.el10_2.5"
PACKAGES = " \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 gdk-pixbuf2-modules \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdk-pixbuf2-2.42.12-4.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ebc145f932d7fc6a9dfe31bfee7c7887b9f6431039b8ba004322756b47eb3b2"

URI_x86_64_v2_gdk-pixbuf2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-2.42.12-4.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2}"
SRC_URI[x86_64_v2_gdk-pixbuf2.sha256sum] = "f655018f75604e387b6120e0860892c54325460d3db46e3de0023275ec122cc6"

URI_x86_64_v2_gdk-pixbuf2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-devel-2.42.12-4.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2-devel}"
SRC_URI[x86_64_v2_gdk-pixbuf2-devel.sha256sum] = "a1bf0321a8580c443644ed6a67368305a1f206b113fc90a44cead4479d5cc81a"

URI_x86_64_v2_gdk-pixbuf2-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-modules-2.42.12-4.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2-modules}"
SRC_URI[x86_64_v2_gdk-pixbuf2-modules.sha256sum] = "94027679f070a2e650981b38205752e7d999ae64ae5b7c241f2a7e2dc5f50ea8"

URI_aarch64_gdk-pixbuf2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-2.42.12-4.el10_2.5.aarch64.rpm;name=aarch64_gdk-pixbuf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2}"
SRC_URI[aarch64_gdk-pixbuf2.sha256sum] = "5a876679b0f43e0966e7226ed5f21ba1f4cbea5342f9d73f5c826c15d0e51330"

URI_aarch64_gdk-pixbuf2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-devel-2.42.12-4.el10_2.5.aarch64.rpm;name=aarch64_gdk-pixbuf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2-devel}"
SRC_URI[aarch64_gdk-pixbuf2-devel.sha256sum] = "b9a71fe0c897fadd69514b1210562b904a916e031d37149a9440013284f9d9ff"

URI_aarch64_gdk-pixbuf2-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-modules-2.42.12-4.el10_2.5.aarch64.rpm;name=aarch64_gdk-pixbuf2-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2-modules}"
SRC_URI[aarch64_gdk-pixbuf2-modules.sha256sum] = "06e125167675d351940ba3746a864c5caea6150cbeeba7d6f4ab6fa8b36fe515"

RDEPENDS:gdk-pixbuf2 = " \
 bash \
 glib2 \
 glibc \
 libjpeg-turbo \
 libpng \
 shared-mime-info \
 "
RDEPENDS:gdk-pixbuf2-devel = " \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 libjpeg-turbo-devel \
 libpng-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 shared-mime-info \
 "
RDEPENDS:gdk-pixbuf2-modules = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libtiff \
 "
