# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colorama"
PV = "0.4.6"
PR = "13.el10"
PACKAGES = " \
 python3-colorama \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-colorama-0.4.6-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4c48e329332ca26942e844e0764e14db2a032c80723733cb7f5a318445447c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-colorama-0.4.6-13.el10.noarch.rpm;name=x86_64_v2_python3-colorama;unpack=0"
SRC_URI[x86_64_v2_python3-colorama.sha256sum] = "a447179b8e31a4eae687eeb5faa6ed52430c823d14f2e7b1a8120be1b1bca783"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-colorama-0.4.6-13.el10.noarch.rpm;name=aarch64_python3-colorama;unpack=0"
SRC_URI[aarch64_python3-colorama.sha256sum] = "a447179b8e31a4eae687eeb5faa6ed52430c823d14f2e7b1a8120be1b1bca783"

RDEPENDS:python3-colorama = " \
 python3 \
 "
