# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-network-info"
PV = "0.2.1"
PR = "9.el10_0"
PACKAGES = " \
 ghc-network-info \
 ghc-network-info-devel \
 ghc-network-info-doc \
 ghc-network-info-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-network-info-0.2.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3544c4aa5a2643e9aa1f173c838fb23aacfb008c9e6bfe20a6263397416b9df"

URI_x86_64_v2_ghc-network-info = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-info-0.2.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-info}"
SRC_URI[x86_64_v2_ghc-network-info.sha256sum] = "09fcc447d04702464b3b7d6bb2f613c1affd9e1c4bb3a46da3890e06c42ea85d"

URI_x86_64_v2_ghc-network-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-info-devel-0.2.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-info-devel}"
SRC_URI[x86_64_v2_ghc-network-info-devel.sha256sum] = "3dea8475310b811dfaeec484ae831682dbc90477526e04da69c6bde0902487b4"

URI_x86_64_v2_ghc-network-info-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-info-doc-0.2.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-network-info-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-info-doc}"
SRC_URI[x86_64_v2_ghc-network-info-doc.sha256sum] = "c48e5132bf9ac96b59fe3f4f1a60e1af74c07906cad7c4a6aab9e00ee9e6fc92"

URI_x86_64_v2_ghc-network-info-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-info-prof-0.2.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-info-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-info-prof}"
SRC_URI[x86_64_v2_ghc-network-info-prof.sha256sum] = "0ea16daed3d715bb819bf14446cfc498a99a27a2cd9b1f0b252b930ec9c7a636"

URI_aarch64_ghc-network-info = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-info-0.2.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-network-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-info}"
SRC_URI[aarch64_ghc-network-info.sha256sum] = "e006b211585fa95596baba2444d9527451596d670ac3086a48b8642075e44be2"

URI_aarch64_ghc-network-info-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-info-devel-0.2.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-network-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-info-devel}"
SRC_URI[aarch64_ghc-network-info-devel.sha256sum] = "936781566e3bd5d2a571cb82fe3abe1bbd1ec1705ac05c4e3ffa9de401fdb424"

URI_aarch64_ghc-network-info-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-info-doc-0.2.1-9.el10_0.noarch.rpm;name=aarch64_ghc-network-info-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-info-doc}"
SRC_URI[aarch64_ghc-network-info-doc.sha256sum] = "9f34e4077eef428a3b6326a80c307f005228449e3379c9674e21e0c4466eff55"

URI_aarch64_ghc-network-info-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-info-prof-0.2.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-network-info-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-info-prof}"
SRC_URI[aarch64_ghc-network-info-prof.sha256sum] = "c410a6583284589f622e693e191f9112bad5c92e1e8280934c636ffac69c041c"

RDEPENDS:ghc-network-info = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-network-info-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-network-info \
 "
RDEPENDS:ghc-network-info-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-network-info-prof = " \
 ghc-base-prof \
 ghc-network-info-devel \
 "
