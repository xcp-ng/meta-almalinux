# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap"
PV = "4.5.51"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+debug-devel \
 rust-clap+default-devel \
 rust-clap+deprecated-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+string-devel \
 rust-clap+suggestions-devel \
 rust-clap+unicode-devel \
 rust-clap+unstable-doc-devel \
 rust-clap+unstable-ext-devel \
 rust-clap+unstable-markdown-devel \
 rust-clap+unstable-styles-devel \
 rust-clap+unstable-v5-devel \
 rust-clap+usage-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap-4.5.51-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaeb6c59e86d3b60f8eeb42b96c979365f482d1d481e921f65b880c7aeadb265"

URI_x86_64_v2_rust-clap+cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+cargo-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+cargo-devel}"
SRC_URI[x86_64_v2_rust-clap+cargo-devel.sha256sum] = "e1936e87d94cceb799e0ba820e139bd427b822915c27820d9a5721aee0453944"

URI_x86_64_v2_rust-clap+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+color-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+color-devel}"
SRC_URI[x86_64_v2_rust-clap+color-devel.sha256sum] = "834d2b5cc342508fb5006ba32d1ad6ef32be9c1d9febab8167df9c17ebe855ec"

URI_x86_64_v2_rust-clap+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+debug-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+debug-devel}"
SRC_URI[x86_64_v2_rust-clap+debug-devel.sha256sum] = "ed676d1fdf846d434c4b97d820bdb51bb3cb5cfc21d65752a5889592b7dcca89"

URI_x86_64_v2_rust-clap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+default-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+default-devel}"
SRC_URI[x86_64_v2_rust-clap+default-devel.sha256sum] = "6058c783a15435a7079359edffcc638129e50be60e119e401af5c8f3e0570d1a"

URI_x86_64_v2_rust-clap+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+deprecated-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap+deprecated-devel.sha256sum] = "c3b1fb4bab842ad3e1634c9969786557e1e881d55b22032afcd6c7b49761aa3a"

URI_x86_64_v2_rust-clap+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+derive-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+derive-devel}"
SRC_URI[x86_64_v2_rust-clap+derive-devel.sha256sum] = "92db9e1ac219fbe68942d26a08a53fd2192739c35c94c4e34c159c6d151532ec"

URI_x86_64_v2_rust-clap+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+env-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+env-devel}"
SRC_URI[x86_64_v2_rust-clap+env-devel.sha256sum] = "54319404be44b7a2fa06cad08f76d0e510ce7b7a3107fec4c2950e386c218ef7"

URI_x86_64_v2_rust-clap+error-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+error-context-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+error-context-devel}"
SRC_URI[x86_64_v2_rust-clap+error-context-devel.sha256sum] = "3b482e4a60102c13d92c0add8d240cf87f95c3b4688ddbff3d8599e1d5888e36"

URI_x86_64_v2_rust-clap+help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+help-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+help-devel}"
SRC_URI[x86_64_v2_rust-clap+help-devel.sha256sum] = "8615444b7381ebf192cc937ef1d51a31186847a9bf169fd7705d7c6e58fb7ef1"

URI_x86_64_v2_rust-clap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+std-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+std-devel}"
SRC_URI[x86_64_v2_rust-clap+std-devel.sha256sum] = "1818ef289a18794688e3fda24469fad1652032b015ffdc41b6e1e16434038f0d"

URI_x86_64_v2_rust-clap+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+string-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+string-devel}"
SRC_URI[x86_64_v2_rust-clap+string-devel.sha256sum] = "1344b75bee9ab665270fa0f76e2d1e41225991c1001fe513b2ee97a38902a9f7"

URI_x86_64_v2_rust-clap+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+suggestions-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+suggestions-devel}"
SRC_URI[x86_64_v2_rust-clap+suggestions-devel.sha256sum] = "ae76a349a2ff54507ed1ec36d9ab80f51907fcbcf8c43c8d70b982abcda9bdfb"

URI_x86_64_v2_rust-clap+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unicode-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unicode-devel}"
SRC_URI[x86_64_v2_rust-clap+unicode-devel.sha256sum] = "5b271874c4da7fa6179d4dc35a1c34e3e01a09ba570c4b43b4fd4aa8cb5bb8b3"

URI_x86_64_v2_rust-clap+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-doc-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-doc-devel.sha256sum] = "ef0de0f4e4edbc57cc0d4345ae66051311e5f3a9f055fb249c2ef31b21d83a78"

URI_x86_64_v2_rust-clap+unstable-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-ext-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-ext-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-ext-devel.sha256sum] = "2c0de875a01e7d9f11e93e8410752bfc85a3da615500aa0c484458f17a371771"

URI_x86_64_v2_rust-clap+unstable-markdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-markdown-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-markdown-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-markdown-devel.sha256sum] = "788a86fba46d897a5eef79c82e7770d715d817ede3b24878b188ade21fe08bf2"

URI_x86_64_v2_rust-clap+unstable-styles-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-styles-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-styles-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-styles-devel.sha256sum] = "6d98d00fec9bbcd4c66d394d173c1b2f1ea0e82234bdd2596237718c9b4917fd"

URI_x86_64_v2_rust-clap+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+unstable-v5-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap+unstable-v5-devel.sha256sum] = "1880501cd44dec520e05fd8077dc5767ff4cc68febdc1d56794a8428661fe9a6"

URI_x86_64_v2_rust-clap+usage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+usage-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+usage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+usage-devel}"
SRC_URI[x86_64_v2_rust-clap+usage-devel.sha256sum] = "c71fbc617d85c63ab175b9a5bef95ad9e4512f2d5d512df5b98c137630f8d47b"

URI_x86_64_v2_rust-clap+wrap_help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap+wrap_help-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap+wrap_help-devel}"
SRC_URI[x86_64_v2_rust-clap+wrap_help-devel.sha256sum] = "526830688bef03080dfbe072cc55bd3e23e2955576b75177037148fe4cb5d577"

URI_x86_64_v2_rust-clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap-devel}"
SRC_URI[x86_64_v2_rust-clap-devel.sha256sum] = "a202044ddba99ea6694518cd08970280959e23fb14cedd9bf80be4d137055fe3"

URI_aarch64_rust-clap+cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+cargo-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+cargo-devel}"
SRC_URI[aarch64_rust-clap+cargo-devel.sha256sum] = "7debf7c37e71275223103e0ffa251f4daff22a4d1ba5ee1bb4c4b029bbb3b396"

URI_aarch64_rust-clap+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+color-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+color-devel}"
SRC_URI[aarch64_rust-clap+color-devel.sha256sum] = "91d814286f4834b20275be7faab231096b8ef8bd2176bcb4d51f9796e3c1f354"

URI_aarch64_rust-clap+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+debug-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+debug-devel}"
SRC_URI[aarch64_rust-clap+debug-devel.sha256sum] = "2b20b692788f496999aad7367d3fcf39c67d136e3c491aeeaff7c7d6d6c9eac7"

URI_aarch64_rust-clap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+default-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+default-devel}"
SRC_URI[aarch64_rust-clap+default-devel.sha256sum] = "de2882cf574a5791f576f8a0a8d5dfa15776c675d18a5d140416821eeff1c04d"

URI_aarch64_rust-clap+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+deprecated-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+deprecated-devel}"
SRC_URI[aarch64_rust-clap+deprecated-devel.sha256sum] = "b97d370ad09392201f8214a71b515b7bf00aa7c06b3b1a8a4b857eecda00fe81"

URI_aarch64_rust-clap+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+derive-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+derive-devel}"
SRC_URI[aarch64_rust-clap+derive-devel.sha256sum] = "b27822d310a1f435a1a74451fa7949728e3654b027678a1306ec1eba5314a396"

URI_aarch64_rust-clap+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+env-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+env-devel}"
SRC_URI[aarch64_rust-clap+env-devel.sha256sum] = "35536ba0e496f7ff8b64c73b9b0e562e86d9dddf8e3ccfd169bf21d978adafe9"

URI_aarch64_rust-clap+error-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+error-context-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+error-context-devel}"
SRC_URI[aarch64_rust-clap+error-context-devel.sha256sum] = "794199b1a52eb9ff3642416492b707073523b759134b9fee9306a6fb9c2d75c5"

URI_aarch64_rust-clap+help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+help-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+help-devel}"
SRC_URI[aarch64_rust-clap+help-devel.sha256sum] = "537bded6111b1cebb00d79b452ab2232c485f5468759f872346a2c004febf856"

URI_aarch64_rust-clap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+std-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+std-devel}"
SRC_URI[aarch64_rust-clap+std-devel.sha256sum] = "ca204d051a04b234bd6f37de92b3dd72f2d220ffb2a3ae7aa029218db870a2da"

URI_aarch64_rust-clap+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+string-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+string-devel}"
SRC_URI[aarch64_rust-clap+string-devel.sha256sum] = "024d68d1a307588e07a2989962a29a220a855f52703e661bfaef30f2c3361add"

URI_aarch64_rust-clap+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+suggestions-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+suggestions-devel}"
SRC_URI[aarch64_rust-clap+suggestions-devel.sha256sum] = "da63e4ebd03f5f473bd4b88d1fdd9b454957dad5820870f38592c134f2c1c563"

URI_aarch64_rust-clap+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unicode-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unicode-devel}"
SRC_URI[aarch64_rust-clap+unicode-devel.sha256sum] = "c8b98b096f3f491a3fb31482ff2ae98cece87e43f6468a8ded284a18b03de1e1"

URI_aarch64_rust-clap+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-doc-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap+unstable-doc-devel.sha256sum] = "1c1c2e0458b1b19f8f35799f8a964268464b1ef6d7a1f4cd4b441f9fba450146"

URI_aarch64_rust-clap+unstable-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-ext-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-ext-devel}"
SRC_URI[aarch64_rust-clap+unstable-ext-devel.sha256sum] = "87eb5856ad61809d21540e022a0e3e88f74c65ce5ba45d214f49fca2c0efa0eb"

URI_aarch64_rust-clap+unstable-markdown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-markdown-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+unstable-markdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-markdown-devel}"
SRC_URI[aarch64_rust-clap+unstable-markdown-devel.sha256sum] = "28179281477ec248aa638bbbd59a2080ac30e33acf6d024bc7fa2b0f26acfc84"

URI_aarch64_rust-clap+unstable-styles-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-styles-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-styles-devel}"
SRC_URI[aarch64_rust-clap+unstable-styles-devel.sha256sum] = "667630db524968e27f8e468210941443346fba4803aeb22237b39ebf693e3a9b"

URI_aarch64_rust-clap+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+unstable-v5-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap+unstable-v5-devel.sha256sum] = "ad04622324f4fe17d56d53e49380cd1f854aee7b1fa34a307a5f9eca0195619d"

URI_aarch64_rust-clap+usage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+usage-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+usage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+usage-devel}"
SRC_URI[aarch64_rust-clap+usage-devel.sha256sum] = "cc33f636cf8c69ed454afc951ada73ae9ac182f072f0cfcc49fc63ecaca558e1"

URI_aarch64_rust-clap+wrap_help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap+wrap_help-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap+wrap_help-devel}"
SRC_URI[aarch64_rust-clap+wrap_help-devel.sha256sum] = "aef70a042c25b554e2dc5192bed6e81335602ed7fab63b4da33c64894c286262"

URI_aarch64_rust-clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap-devel}"
SRC_URI[aarch64_rust-clap-devel.sha256sum] = "75f52c10116c97573f20019bc4775ae832eaedd6d67a577f207a7bcecf352124"

RDEPENDS:rust-clap+cargo-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+cargo-devel \
 "
RDEPENDS:rust-clap+color-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+color-devel \
 "
RDEPENDS:rust-clap+debug-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+debug-devel \
 rust-clap_derive+debug-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+default-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+suggestions-devel \
 rust-clap+usage-devel \
 rust-clap-devel \
 "
RDEPENDS:rust-clap+deprecated-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+deprecated-devel \
 "
RDEPENDS:rust-clap+derive-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 "
RDEPENDS:rust-clap+env-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+env-devel \
 "
RDEPENDS:rust-clap+error-context-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+error-context-devel \
 "
RDEPENDS:rust-clap+help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+help-devel \
 "
RDEPENDS:rust-clap+std-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+std-devel \
 "
RDEPENDS:rust-clap+string-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+string-devel \
 "
RDEPENDS:rust-clap+suggestions-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+suggestions-devel \
 "
RDEPENDS:rust-clap+unicode-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unicode-devel \
 "
RDEPENDS:rust-clap+unstable-doc-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-doc-devel \
 "
RDEPENDS:rust-clap+unstable-ext-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-ext-devel \
 "
RDEPENDS:rust-clap+unstable-markdown-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-markdown-devel \
 "
RDEPENDS:rust-clap+unstable-styles-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+unstable-styles-devel \
 "
RDEPENDS:rust-clap+unstable-v5-devel = " \
 cargo \
 rust-clap+deprecated-devel \
 rust-clap-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_derive+default-devel \
 rust-clap_derive+unstable-v5-devel \
 "
RDEPENDS:rust-clap+usage-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+usage-devel \
 "
RDEPENDS:rust-clap+wrap_help-devel = " \
 cargo \
 rust-clap-devel \
 rust-clap_builder+wrap_help-devel \
 "
RDEPENDS:rust-clap-devel = " \
 cargo \
 rust \
 rust-clap_builder-devel \
 "
