# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-lua"
PV = "0.2.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree-sitter-lua+default-devel \
 rust-tree-sitter-lua-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-lua-0.2.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "425a96ff56a72397fd27f4fa8a76c4a0d957991342d31f9322e31ced9621723b"

URI_x86_64_v2_rust-tree-sitter-lua+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-lua+default-devel-0.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-lua+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-lua+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-lua+default-devel.sha256sum] = "b56b2154db6c845e628a41e7e106c22777623c602b8443b5def8cfd9f3dc03b9"

URI_x86_64_v2_rust-tree-sitter-lua-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-lua-devel-0.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-lua-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-lua-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-lua-devel.sha256sum] = "ff6d4806426b62533ebeb6f768363e83aca88f44e1651bea6481936f7f2af958"

URI_aarch64_rust-tree-sitter-lua+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-lua+default-devel-0.2.0-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-lua+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-lua+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-lua+default-devel.sha256sum] = "3d222793463845497e6fdc969fe6927fe4f736c5c0fe4c5cfd8456099c097cf5"

URI_aarch64_rust-tree-sitter-lua-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-lua-devel-0.2.0-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-lua-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-lua-devel}"
SRC_URI[aarch64_rust-tree-sitter-lua-devel.sha256sum] = "90bfde3399f435927dc40ba87a46aadfded8e9e90790eaffc2876bfb851e69c2"

RDEPENDS:rust-tree-sitter-lua+default-devel = " \
 cargo \
 rust-tree-sitter-lua-devel \
 "
RDEPENDS:rust-tree-sitter-lua-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
