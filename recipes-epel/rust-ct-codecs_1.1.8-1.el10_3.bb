# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ct-codecs"
PV = "1.1.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-ct-codecs+default-devel \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ct-codecs-1.1.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ae4636a1674cd3c27f031f180cfd4e639050de83d2dcd4e710ad3279027b72f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+default-devel-1.1.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ct-codecs+default-devel.sha256sum] = "99874297fc17c1984ded4b544080821a1c07b318062cce9191f96715a378552e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+std-devel-1.1.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ct-codecs+std-devel.sha256sum] = "15084ef899bc22806aea4d4cbb61c936b5641702327aeec104adb5f57ad1faa3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs-devel-1.1.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ct-codecs-devel.sha256sum] = "0e7e1c962fced72d0b9909bfd4275a1e23e064ec2297436b7711af85c7285569"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+default-devel-1.1.8-1.el10_3.noarch.rpm;name=aarch64_rust-ct-codecs+default-devel;unpack=0"
SRC_URI[aarch64_rust-ct-codecs+default-devel.sha256sum] = "ba813183d2539f6f021b861898aea41e576ccb0a34f76c01dc435739b639fded"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+std-devel-1.1.8-1.el10_3.noarch.rpm;name=aarch64_rust-ct-codecs+std-devel;unpack=0"
SRC_URI[aarch64_rust-ct-codecs+std-devel.sha256sum] = "295bd1fa988688ec31645d637c428e27f7e68bc6c906ac9500b3098e2f3a48b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs-devel-1.1.8-1.el10_3.noarch.rpm;name=aarch64_rust-ct-codecs-devel;unpack=0"
SRC_URI[aarch64_rust-ct-codecs-devel.sha256sum] = "31b39aab95cfc67043b8cf5bf8c5f98db41980fdfd20e9128a3a064fff35cf1e"

RDEPENDS:rust-ct-codecs+default-devel = " \
 cargo \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs+std-devel = " \
 cargo \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs-devel = " \
 cargo \
 "
