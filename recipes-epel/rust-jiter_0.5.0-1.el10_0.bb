# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiter"
PV = "0.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-jiter+default-devel \
 rust-jiter+python-devel \
 rust-jiter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jiter-0.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcbd62db3fbdf2ef83d137acb0878c7edb4a1dd9c0086e448136ff25fed80997"

URI_x86_64_v2_rust-jiter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiter+default-devel-0.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiter+default-devel}"
SRC_URI[x86_64_v2_rust-jiter+default-devel.sha256sum] = "374e8aa08f1bd3bd730f363177dfd78f84af4a6c9205d517a3dbc354074ee2a4"

URI_x86_64_v2_rust-jiter+python-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiter+python-devel-0.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiter+python-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiter+python-devel}"
SRC_URI[x86_64_v2_rust-jiter+python-devel.sha256sum] = "10d66b3e7cf619f9c6130c592aae47bcc6e83e52886bbd5be91447a4fb334d66"

URI_x86_64_v2_rust-jiter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiter-devel-0.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiter-devel}"
SRC_URI[x86_64_v2_rust-jiter-devel.sha256sum] = "a3fa225c8816d94d33389387b28018425ca5272ae9a124f1faba5418e431b5e0"

URI_aarch64_rust-jiter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiter+default-devel-0.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-jiter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiter+default-devel}"
SRC_URI[aarch64_rust-jiter+default-devel.sha256sum] = "4fe6f4a9b8308e47bd6b636a5028b841a4ef6287bb5246739c86a795a61a1b70"

URI_aarch64_rust-jiter+python-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiter+python-devel-0.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-jiter+python-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiter+python-devel}"
SRC_URI[aarch64_rust-jiter+python-devel.sha256sum] = "79eb51c382ccbf4811f39523f4749c245b0a758bcf35afde1768a85d26bca850"

URI_aarch64_rust-jiter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiter-devel-0.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-jiter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiter-devel}"
SRC_URI[aarch64_rust-jiter-devel.sha256sum] = "ee0cd9d1a3243ae851b7fa937df289c23447fdc6f25bffd2ac99ab9e3220fc24"

RDEPENDS:rust-jiter+default-devel = " \
 cargo \
 rust-jiter-devel \
 "
RDEPENDS:rust-jiter+python-devel = " \
 cargo \
 rust-jiter-devel \
 rust-pyo3-build-config0.22+default-devel \
 rust-pyo3_0.22+default-devel \
 "
RDEPENDS:rust-jiter-devel = " \
 cargo \
 python3 \
 rust-ahash+default-devel \
 rust-bitvec+default-devel \
 rust-lexical-parse-float+default-devel \
 rust-lexical-parse-float+format-devel \
 rust-num-bigint+default-devel \
 rust-num-traits+default-devel \
 rust-smallvec+default-devel \
 "
