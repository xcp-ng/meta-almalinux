# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-xlzd-gotp"
PV = "0.1.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-xlzd-gotp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-xlzd-gotp-0.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cba357e1473f8bfc93607153231b7c12ba6d18586b84aa054bcf66f0b97a5c1d"

URI_x86_64_v2_golang-github-xlzd-gotp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-xlzd-gotp-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-xlzd-gotp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-xlzd-gotp-devel}"
SRC_URI[x86_64_v2_golang-github-xlzd-gotp-devel.sha256sum] = "7b5d19fe94d244f64ba218c8b4c39b5f201fa7091b275dc9b87f831b5cb2e3c9"

URI_aarch64_golang-github-xlzd-gotp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-xlzd-gotp-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-xlzd-gotp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-xlzd-gotp-devel}"
SRC_URI[aarch64_golang-github-xlzd-gotp-devel.sha256sum] = "41401e821c094659297606f684ccc9275507d3eef6ded34cc65f2a8206ddf8ca"

RDEPENDS:golang-github-xlzd-gotp-devel = " \
 go-filesystem \
 "
