# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Pod-Coverage"
PV = "0.23"
PR = "36.el10"
PACKAGES = " \
 perl-Pod-Coverage \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Pod-Coverage-0.23-36.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d89a3677a5d9949b8f4fbfe3218dd12040afe73fda8c4d8e527721a6a002544d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Pod-Coverage-0.23-36.el10.noarch.rpm;name=x86_64_v2_perl-Pod-Coverage;unpack=0"
SRC_URI[x86_64_v2_perl-Pod-Coverage.sha256sum] = "1312fdeb24edcca2fccb24fe10a331181efef854465993afad4d17a395216de4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Pod-Coverage-0.23-36.el10.noarch.rpm;name=aarch64_perl-Pod-Coverage;unpack=0"
SRC_URI[aarch64_perl-Pod-Coverage.sha256sum] = "1312fdeb24edcca2fccb24fe10a331181efef854465993afad4d17a395216de4"

RDEPENDS:perl-Pod-Coverage = " \
 perl-B \
 perl-Devel-Symdump \
 perl-Pod-Coverage \
 perl-Pod-Parser \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
