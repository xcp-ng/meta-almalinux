# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-const-str-proc-macro"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-const-str-proc-macro+default-devel \
 rust-const-str-proc-macro+heck-devel \
 rust-const-str-proc-macro+http-devel \
 rust-const-str-proc-macro+regex-devel \
 rust-const-str-proc-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-const-str-proc-macro-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e822b887f012f6889068e8ad0072df9bc379cf24718748cf59838d9f9a2605b9"

URI_x86_64_v2_rust-const-str-proc-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str-proc-macro+default-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str-proc-macro+default-devel}"
SRC_URI[x86_64_v2_rust-const-str-proc-macro+default-devel.sha256sum] = "23b5a7588e6d9661872d352ea8c711dbd9643626c688631dbb09d19ba4f8d4ae"

URI_x86_64_v2_rust-const-str-proc-macro+heck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str-proc-macro+heck-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str-proc-macro+heck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str-proc-macro+heck-devel}"
SRC_URI[x86_64_v2_rust-const-str-proc-macro+heck-devel.sha256sum] = "d44bde4ca45e840a5b054541942606e10fc3a209b00310e9ead66fceae937487"

URI_x86_64_v2_rust-const-str-proc-macro+http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str-proc-macro+http-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str-proc-macro+http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str-proc-macro+http-devel}"
SRC_URI[x86_64_v2_rust-const-str-proc-macro+http-devel.sha256sum] = "feae0b3a2e313f131ad9535c961dcc4f792cb132d40d6561872e6bb6a5a99095"

URI_x86_64_v2_rust-const-str-proc-macro+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str-proc-macro+regex-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str-proc-macro+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str-proc-macro+regex-devel}"
SRC_URI[x86_64_v2_rust-const-str-proc-macro+regex-devel.sha256sum] = "7b179cbf3c0d7ec876a15629841250ecf0b34cec21a4e8b6da14138c189651d3"

URI_x86_64_v2_rust-const-str-proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str-proc-macro-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str-proc-macro-devel}"
SRC_URI[x86_64_v2_rust-const-str-proc-macro-devel.sha256sum] = "02cd209091412c26550e2e8c67b64911ba4cc65f53ba1a42c9b7cfdab9a67e04"

URI_aarch64_rust-const-str-proc-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str-proc-macro+default-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str-proc-macro+default-devel}"
SRC_URI[aarch64_rust-const-str-proc-macro+default-devel.sha256sum] = "7f2ae8eb6a96a5e784246959741e585ece7b88d81e486f5c04e35cea21810dcd"

URI_aarch64_rust-const-str-proc-macro+heck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str-proc-macro+heck-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str-proc-macro+heck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str-proc-macro+heck-devel}"
SRC_URI[aarch64_rust-const-str-proc-macro+heck-devel.sha256sum] = "dcb550ee00e9c0d3f9a0e0ce0cd8cc0ff6f5392b57f1334a7e278713cc839d67"

URI_aarch64_rust-const-str-proc-macro+http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str-proc-macro+http-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str-proc-macro+http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str-proc-macro+http-devel}"
SRC_URI[aarch64_rust-const-str-proc-macro+http-devel.sha256sum] = "2981e5b08a7458b283224aaeb4f7993c617977a156397b78040196cda8c783f8"

URI_aarch64_rust-const-str-proc-macro+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str-proc-macro+regex-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str-proc-macro+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str-proc-macro+regex-devel}"
SRC_URI[aarch64_rust-const-str-proc-macro+regex-devel.sha256sum] = "4885f347325e050b1d2bce31174acb0e2448f7e3336b1a7fb5bf47bf5697b368"

URI_aarch64_rust-const-str-proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str-proc-macro-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str-proc-macro-devel}"
SRC_URI[aarch64_rust-const-str-proc-macro-devel.sha256sum] = "b8a7ad1552418778f6d82d1a20e6624b6473d809d1f935826b97b3237f183566"

RDEPENDS:rust-const-str-proc-macro+default-devel = " \
 cargo \
 rust-const-str-proc-macro-devel \
 "
RDEPENDS:rust-const-str-proc-macro+heck-devel = " \
 cargo \
 rust-const-str-proc-macro-devel \
 rust-heck+default-devel \
 "
RDEPENDS:rust-const-str-proc-macro+http-devel = " \
 cargo \
 rust-const-str-proc-macro-devel \
 rust-http+default-devel \
 "
RDEPENDS:rust-const-str-proc-macro+regex-devel = " \
 cargo \
 rust-const-str-proc-macro-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-const-str-proc-macro-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 "
