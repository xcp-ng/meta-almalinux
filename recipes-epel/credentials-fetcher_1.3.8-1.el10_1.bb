# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "credentials-fetcher"
PV = "1.3.8"
PR = "1.el10_1"
PACKAGES = " \
 credentials-fetcher \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/credentials-fetcher-1.3.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bdf7d2d16284adb671a63e9d8b6391e8de29414695fedab49d2d8a608b18a9a"

URI_x86_64_v2_credentials-fetcher = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/credentials-fetcher-1.3.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_credentials-fetcher;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_credentials-fetcher}"
SRC_URI[x86_64_v2_credentials-fetcher.sha256sum] = "94f0cd31ba4376162326487432b4aaccae66508dc9e88370833a2dfd5b0e5117"

URI_aarch64_credentials-fetcher = "${EPEL_MIRROR}/aarch64/Packages/c/credentials-fetcher-1.3.8-1.el10_1.aarch64.rpm;name=aarch64_credentials-fetcher;unpack=0"
SRC_URI:append = " ${URI_aarch64_credentials-fetcher}"
SRC_URI[aarch64_credentials-fetcher.sha256sum] = "c3d05b770c7867a55b1f2d30ea07d283a55e4a7d058fd1522a6bce1afc4a3a8a"

RDEPENDS:credentials-fetcher = " \
 abseil-cpp \
 awscli2 \
 bind-utils \
 c-ares \
 dotnet-runtime-8.0 \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 jsoncpp \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libkadm5 \
 libstdc++ \
 openldap \
 openldap-clients \
 openssl-libs \
 protobuf \
 re2 \
 systemd-libs \
 zlib-ng-compat \
 "
