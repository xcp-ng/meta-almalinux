# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytemuck_derive"
PV = "1.12.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-bytemuck_derive+default-devel \
 rust-bytemuck_derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-bytemuck_derive-1.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "68610de026e9ccd55c5bc4c4ccdc4f94e7a6b6082663a14c02bb780960f8b6bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive+default-devel-1.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bytemuck_derive+default-devel.sha256sum] = "0fb839e710da52a3b1213aaa255895181a80dfc5afd676b7c08b6ed72fef6d79"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive-devel-1.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bytemuck_derive-devel.sha256sum] = "7cfd85736007b3d7e4a988d090ff521dc5afa5fe459c2b86d7e84a98f39fa307"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive+default-devel-1.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-bytemuck_derive+default-devel.sha256sum] = "de85294bf4139d95f9e5e017d7d249875aa59ea86e6cc492de45f1f5a27ca689"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive-devel-1.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck_derive-devel;unpack=0"
SRC_URI[aarch64_rust-bytemuck_derive-devel.sha256sum] = "2a93fb42cd4fc2e3ffe0061fcba460c60f0744817f3b38774a695f51417dc4e2"

RDEPENDS:rust-bytemuck_derive+default-devel = " \
 cargo \
 rust-bytemuck_derive-devel \
 "
RDEPENDS:rust-bytemuck_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
