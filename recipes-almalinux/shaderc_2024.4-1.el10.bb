# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shaderc"
PV = "2024.4"
PR = "1.el10"
PACKAGES = " \
 glslc \
 libshaderc \
 libshaderc-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/shaderc-2024.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e3bb401eb009da787414c3a05617a4e3510f742bdcab63da4fc39a031870515"

URI_x86_64_v2_glslc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glslc-2024.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslc}"
SRC_URI[x86_64_v2_glslc.sha256sum] = "0e0e197b3f3ef8319656d775c7a41b7541f7b9a1d555117bf2e93bbc056e9c83"

URI_x86_64_v2_libshaderc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libshaderc-2024.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_libshaderc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshaderc}"
SRC_URI[x86_64_v2_libshaderc.sha256sum] = "dceef61161c558a457ecbae41319bc34c78826ea1703f5372fdea3c34a46c3fa"

URI_x86_64_v2_libshaderc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libshaderc-devel-2024.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_libshaderc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshaderc-devel}"
SRC_URI[x86_64_v2_libshaderc-devel.sha256sum] = "7c4e3b0ceea38f10e7d28f67a971f0345c8e8dc29083d2d86534c8ac29949b16"

URI_aarch64_glslc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glslc-2024.4-1.el10.aarch64.rpm;name=aarch64_glslc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslc}"
SRC_URI[aarch64_glslc.sha256sum] = "cc1cc8389c8cedf79df0228782b05d7b22400200aaf79ebc14a024fd71538443"

URI_aarch64_libshaderc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libshaderc-2024.4-1.el10.aarch64.rpm;name=aarch64_libshaderc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshaderc}"
SRC_URI[aarch64_libshaderc.sha256sum] = "cbd3dcf4d4ba39b275fb0adce6c32658c9f4c70a6fe1217e8547efe2ba62b424"

URI_aarch64_libshaderc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libshaderc-devel-2024.4-1.el10.aarch64.rpm;name=aarch64_libshaderc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshaderc-devel}"
SRC_URI[aarch64_libshaderc-devel.sha256sum] = "427343cc6542ad80a655eabc7e4ee19c7eded936ab339346e3839f962193ff06"

RDEPENDS:glslc = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:libshaderc = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:libshaderc-devel = " \
 libshaderc \
 pkgconf-pkg-config \
 "
