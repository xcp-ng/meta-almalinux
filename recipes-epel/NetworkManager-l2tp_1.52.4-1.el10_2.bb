# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-l2tp"
PV = "1.52.4"
PR = "1.el10_2"
PACKAGES = " \
 NetworkManager-l2tp \
 NetworkManager-l2tp-gnome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-l2tp-1.52.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4f99c0cb5c99e25938dc53ef8b3f2fe0bb8be0de95b7415fb5cd69f9c213b7c"

URI_x86_64_v2_NetworkManager-l2tp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-1.52.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-l2tp}"
SRC_URI[x86_64_v2_NetworkManager-l2tp.sha256sum] = "9e9c59f813f6f852f3ea634823ac46d53a876e5b1ba22c5abc05f77387952a6f"

URI_x86_64_v2_NetworkManager-l2tp-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-gnome-1.52.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-l2tp-gnome}"
SRC_URI[x86_64_v2_NetworkManager-l2tp-gnome.sha256sum] = "c36ad6e0cd6e70e7818e3cc5e2f388bd3bb5ae2259407396291541861c6b23b4"

URI_aarch64_NetworkManager-l2tp = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-1.52.4-1.el10_2.aarch64.rpm;name=aarch64_NetworkManager-l2tp;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-l2tp}"
SRC_URI[aarch64_NetworkManager-l2tp.sha256sum] = "9958823c2d3ffe2a0ba51d8f561e0e7305afdfac3b6106004dd17e8495ebd052"

URI_aarch64_NetworkManager-l2tp-gnome = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-gnome-1.52.4-1.el10_2.aarch64.rpm;name=aarch64_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-l2tp-gnome}"
SRC_URI[aarch64_NetworkManager-l2tp-gnome.sha256sum] = "778b8d8c92756c69e96b05f98d3ba7a217e6f5c11df5fb084b99abb9ef53aba3"

RDEPENDS:NetworkManager-l2tp = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 nspr \
 nss \
 openssl-libs \
 ppp \
 xl2tpd \
 "
RDEPENDS:NetworkManager-l2tp-gnome = " \
 NetworkManager-l2tp \
 NetworkManager-libnm \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 openssl-libs \
 pango \
 vulkan-loader \
 "
