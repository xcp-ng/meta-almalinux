# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Encode-HanExtra"
PV = "0.23"
PR = "44.el10_0"
PACKAGES = " \
 perl-Encode-HanExtra \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Encode-HanExtra-0.23-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9d719ff63eb5199b4ac6654a59baad3a0500bbb8bfe80319ea5d753c73e1d7df"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Encode-HanExtra-0.23-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Encode-HanExtra;unpack=0"
SRC_URI[x86_64_v2_perl-Encode-HanExtra.sha256sum] = "efc12cff64fd62fd70b85f49e4e3eac7dc962463e6625ce8844085d052b48627"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Encode-HanExtra-0.23-44.el10_0.aarch64.rpm;name=aarch64_perl-Encode-HanExtra;unpack=0"
SRC_URI[aarch64_perl-Encode-HanExtra.sha256sum] = "8347a9d075b2bdb4732056b9a054d16b0a5b16971e7df0bcecf0ad0162052c51"

RDEPENDS:perl-Encode-HanExtra = " \
 glibc \
 perl-Encode \
 perl-base \
 perl-libs \
 perl-vars \
 "
