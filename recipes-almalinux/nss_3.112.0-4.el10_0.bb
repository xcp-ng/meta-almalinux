# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nss"
PV = "3.112.0"
PR = "4.el10_0"
PACKAGES = " \
 nspr \
 nspr-devel \
 nss \
 nss-devel \
 nss-softokn \
 nss-softokn-devel \
 nss-softokn-freebl \
 nss-softokn-freebl-devel \
 nss-sysinit \
 nss-tools \
 nss-util \
 nss-util-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nss-3.112.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "baafcec849eca88a230d441e8e29e2661dc6586b07ababd347fc94c4d0487985"

URI_x86_64_v2_nspr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nspr-4.36.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nspr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nspr}"
SRC_URI[x86_64_v2_nspr.sha256sum] = "31d26b19c9201d94e11bd57be069cb178fa6a46e249f8e5491bcfb341fbf22f6"

URI_x86_64_v2_nspr-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nspr-devel-4.36.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nspr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nspr-devel}"
SRC_URI[x86_64_v2_nspr-devel.sha256sum] = "4012c3949fa1b9614b0f2936ec0fabf61c865989437d52dee8b97d298ddfedba"

URI_x86_64_v2_nss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss}"
SRC_URI[x86_64_v2_nss.sha256sum] = "62d780173e10f008fc0ee873855708f07203c8513711a8a124709c76d31bf73d"

URI_x86_64_v2_nss-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-devel-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-devel}"
SRC_URI[x86_64_v2_nss-devel.sha256sum] = "235f434f4887b13fd59f7b472c55ae5d0e6f67122c735943d355aaeb2afc50f2"

URI_x86_64_v2_nss-softokn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn}"
SRC_URI[x86_64_v2_nss-softokn.sha256sum] = "b022f2d189cc0b60c8f8656cd571a7c09b889881237317c15acac3e4fc5482ff"

URI_x86_64_v2_nss-softokn-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-devel-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn-devel}"
SRC_URI[x86_64_v2_nss-softokn-devel.sha256sum] = "e315aa49dcfd1d296c097e3b0f0d5270c0eb45df5bad558ee223bffa86602177"

URI_x86_64_v2_nss-softokn-freebl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-freebl-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn-freebl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn-freebl}"
SRC_URI[x86_64_v2_nss-softokn-freebl.sha256sum] = "3d3e39c21f471c750221209923c807d8821385eafaa1370f0dcfa570d642aa49"

URI_x86_64_v2_nss-softokn-freebl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-freebl-devel-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn-freebl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn-freebl-devel}"
SRC_URI[x86_64_v2_nss-softokn-freebl-devel.sha256sum] = "caf6dce01f0647dca366efdbf543b10da8965a165d34ba0391ae27b944166de2"

URI_x86_64_v2_nss-sysinit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-sysinit-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-sysinit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-sysinit}"
SRC_URI[x86_64_v2_nss-sysinit.sha256sum] = "ccc4b86a31d3dc6283dcc9d269141d7d52f5df175eb74c3737a6c6e5e160c287"

URI_x86_64_v2_nss-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-tools-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-tools}"
SRC_URI[x86_64_v2_nss-tools.sha256sum] = "673b322ef75fe6e31e3251bc8e39d29d6d8104883993a5c7c900e4d4d2640b3a"

URI_x86_64_v2_nss-util = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-util-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-util}"
SRC_URI[x86_64_v2_nss-util.sha256sum] = "99113324e25db29b48ee4ae68695e7f55a6042213e1a8b8341686d322296d5f8"

URI_x86_64_v2_nss-util-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-util-devel-3.112.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-util-devel}"
SRC_URI[x86_64_v2_nss-util-devel.sha256sum] = "5f58e3de3f241a837f4cad238ccfe9472783389eb71460b568479a957f943bb2"

URI_aarch64_nspr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nspr-4.36.0-4.el10_0.aarch64.rpm;name=aarch64_nspr;unpack=0"
SRC_URI:append = " ${URI_aarch64_nspr}"
SRC_URI[aarch64_nspr.sha256sum] = "5130d7ee59f89df9e7b8a45ae55bdba68edd65d8ca7dfcaa07720dddbe4e9c97"

URI_aarch64_nspr-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nspr-devel-4.36.0-4.el10_0.aarch64.rpm;name=aarch64_nspr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nspr-devel}"
SRC_URI[aarch64_nspr-devel.sha256sum] = "d240f62be19e34fc916b76f7923784f33c8578196daed3264a17c84867d83f38"

URI_aarch64_nss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss}"
SRC_URI[aarch64_nss.sha256sum] = "036c7a2345d3812a5d254a5ff6e1ac25b0d282f76d44fbc4b0ac9fa97e10df12"

URI_aarch64_nss-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-devel-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-devel}"
SRC_URI[aarch64_nss-devel.sha256sum] = "a32caf7a64fdc0d5a340d6bd0a98e77240a7b355e4ca514c1e069894aabd7dd1"

URI_aarch64_nss-softokn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss-softokn;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn}"
SRC_URI[aarch64_nss-softokn.sha256sum] = "cb2ebdbca401f15aa36c958a869cf9ce85f1d8f9cb8f20f14e33d93057c8864d"

URI_aarch64_nss-softokn-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-devel-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss-softokn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn-devel}"
SRC_URI[aarch64_nss-softokn-devel.sha256sum] = "0803ae50fe8fd9055c2db3c31be5e28f1d6be39ba1b15d4a04b3df334e2ae555"

URI_aarch64_nss-softokn-freebl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-freebl-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss-softokn-freebl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn-freebl}"
SRC_URI[aarch64_nss-softokn-freebl.sha256sum] = "f04547c15056934046b0865e7462a22afc220a179fc5b5bbbafddee2011ffdfa"

URI_aarch64_nss-softokn-freebl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-freebl-devel-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss-softokn-freebl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn-freebl-devel}"
SRC_URI[aarch64_nss-softokn-freebl-devel.sha256sum] = "284bb957545f0dcd70e2e5918430a7566771d523197c05fe4009ab8e52672532"

URI_aarch64_nss-sysinit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-sysinit-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss-sysinit;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-sysinit}"
SRC_URI[aarch64_nss-sysinit.sha256sum] = "b93c7ec8821bfd93c2b5defc44134116634774f58c5b41c45364b94dbded3305"

URI_aarch64_nss-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-tools-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-tools}"
SRC_URI[aarch64_nss-tools.sha256sum] = "6f35efa7c27fcdd7c1354d8daec105eb1165ea4adddf8a228f9f0d83f3bd9933"

URI_aarch64_nss-util = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-util-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-util}"
SRC_URI[aarch64_nss-util.sha256sum] = "46a1740a8faed7d694232ed04b7145860493e03952bc53d91db174ff43656bcf"

URI_aarch64_nss-util-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-util-devel-3.112.0-4.el10_0.aarch64.rpm;name=aarch64_nss-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-util-devel}"
SRC_URI[aarch64_nss-util-devel.sha256sum] = "42c8130062e33ae7f18206be730b1f45dcda82ba45a81e28b1c5a0cd8e722644"

RDEPENDS:nspr = " \
 glibc \
 "
RDEPENDS:nspr-devel = " \
 bash \
 nspr \
 pkgconf-pkg-config \
 "
RDEPENDS:nss = " \
 bash \
 crypto-policies \
 glibc \
 nspr \
 nss-softokn \
 nss-sysinit \
 nss-util \
 p11-kit-trust \
 "
RDEPENDS:nss-devel = " \
 bash \
 nspr-devel \
 nss \
 nss-softokn-devel \
 nss-util-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nss-softokn = " \
 glibc \
 nspr \
 nss-softokn-freebl \
 nss-util \
 sqlite-libs \
 "
RDEPENDS:nss-softokn-devel = " \
 bash \
 nspr-devel \
 nss-softokn \
 nss-softokn-freebl-devel \
 nss-util-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nss-softokn-freebl = " \
 bash \
 glibc \
 nspr \
 nss-util \
 "
RDEPENDS:nss-softokn-freebl-devel = " \
 nss-softokn-freebl \
 "
RDEPENDS:nss-sysinit = " \
 bash \
 glibc \
 nspr \
 nss \
 nss-util \
 sed \
 virtual/coreutils \
 "
RDEPENDS:nss-tools = " \
 glibc \
 nspr \
 nss \
 nss-util \
 zlib-ng-compat \
 "
RDEPENDS:nss-util = " \
 glibc \
 nspr \
 "
RDEPENDS:nss-util-devel = " \
 bash \
 nspr-devel \
 nss-util \
 pkgconf-pkg-config \
 "
