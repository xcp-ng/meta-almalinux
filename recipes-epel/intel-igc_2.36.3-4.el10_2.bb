# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-igc"
PV = "2.36.3"
PR = "4.el10_2"
PACKAGES:x86_64_v2 = " \
 intel-igc \
 intel-igc-devel \
 intel-igc-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-igc-2.36.3-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4260a4e5deaaf1559f39054aca598ce7f3104c1fa01cf2ad1ef5b9e205f5406"

URI_x86_64_v2_intel-igc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-igc-2.36.3-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-igc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-igc}"
SRC_URI[x86_64_v2_intel-igc.sha256sum] = "7158d1ccf71026343d37d48cd696ee7b541efb82ad51fd04261f9d03ca242245"

URI_x86_64_v2_intel-igc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-igc-devel-2.36.3-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-igc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-igc-devel}"
SRC_URI[x86_64_v2_intel-igc-devel.sha256sum] = "33101b7aebe175a3aa775238d314736bdf616f927713d647c4fe8a0f01083bb0"

URI_x86_64_v2_intel-igc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-igc-libs-2.36.3-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-igc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-igc-libs}"
SRC_URI[x86_64_v2_intel-igc-libs.sha256sum] = "978c3955254ccb2ef07646a4ef04d0b767c8659990fba157943917681ab7e5de"

RDEPENDS:intel-igc = " \
 glibc \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-igc-devel = " \
 intel-igc-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:intel-igc-libs = " \
 glibc \
 intel-igc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
