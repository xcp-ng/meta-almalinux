# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-proxy-utils"
PV = "7.4"
PR = "1.el10_1"
PACKAGES = " \
 globus-proxy-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-proxy-utils-7.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3f537d2a0c74c7f90c54d7fb52e83ff25826483c397ecdce6c4abdc40781719"

URI_x86_64_v2_globus-proxy-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-proxy-utils-7.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-proxy-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-proxy-utils}"
SRC_URI[x86_64_v2_globus-proxy-utils.sha256sum] = "d82dd7db334ff6a2ac1eb3282074826f4dbe63b5831c159dd546b6749384757f"

URI_aarch64_globus-proxy-utils = "${EPEL_MIRROR}/aarch64/Packages/g/globus-proxy-utils-7.4-1.el10_1.aarch64.rpm;name=aarch64_globus-proxy-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-proxy-utils}"
SRC_URI[aarch64_globus-proxy-utils.sha256sum] = "3776f23f2c3c0331245b8bb98df84742ff0419aeabeb0b89ef355e4b0f78e0ea"

RDEPENDS:globus-proxy-utils = " \
 glibc \
 globus-common \
 globus-gsi-callback \
 globus-gsi-credential \
 globus-gsi-openssl-error \
 globus-gsi-proxy-core \
 globus-gsi-sysconfig \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-openssl-module \
 openssl-libs \
 "
