# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta_derive"
PV = "0.3.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-ptr_meta_derive+default-devel \
 rust-ptr_meta_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta_derive-0.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6b2846524b15909b451b2ea28c6c7c63a66b751cca02b252e7f2af51199ab3a"

URI_x86_64_v2_rust-ptr_meta_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive+default-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive+default-devel.sha256sum] = "480ecd20f55cb613764cd91b54f45f79517a31dcde7034ed668e0e4815b8e9db"

URI_x86_64_v2_rust-ptr_meta_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive-devel.sha256sum] = "8d8336b62e55d0abd10e5f7da02a9780bf60bb00a14737d5f21f9d11b09fffec"

URI_aarch64_rust-ptr_meta_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive+default-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-ptr_meta_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive+default-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive+default-devel.sha256sum] = "deba5e9c410c956662cdaa52f367b40a9f854b2460a8289cfd8d9ec2dffd7994"

URI_aarch64_rust-ptr_meta_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive-devel.sha256sum] = "71e341297d9dbe4a996969f8a9c516a46176ce213b2cf37691607eb3a37da41a"

RDEPENDS:rust-ptr_meta_derive+default-devel = " \
 cargo \
 rust-ptr_meta_derive-devel \
 "
RDEPENDS:rust-ptr_meta_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
