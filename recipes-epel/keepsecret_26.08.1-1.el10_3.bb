# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keepsecret"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 keepsecret \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/keepsecret-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2dd06ac7cb36b35b3196dfb3a82de8b5d4f54871d00c0e307c12d4f86c49dd40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keepsecret-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keepsecret;unpack=0"
SRC_URI[x86_64_v2_keepsecret.sha256sum] = "de8fc800fce58b57c2845c792e4dd3698b8ba69733c33429b11a37eae465a758"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/keepsecret-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_keepsecret;unpack=0"
SRC_URI[aarch64_keepsecret.sha256sum] = "39c30b7d5b707923e36b5daa3b1b406ac78a23d258196a5e72e86f39492636d8"

RDEPENDS:keepsecret = " \
 glib2 \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 libsecret \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
