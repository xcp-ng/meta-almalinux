# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus_names"
PV = "4.3.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-zbus_names+default-devel \
 rust-zbus_names-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zbus_names-4.3.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b0efa5bfd230d8f4906d1b37598803578e5b480463ae6baa1355c659cacf855"

URI_x86_64_v2_rust-zbus_names+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_names+default-devel-4.3.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_names+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_names+default-devel}"
SRC_URI[x86_64_v2_rust-zbus_names+default-devel.sha256sum] = "501de580c127b4aebb1f42d27ef7cde03cd92ee9f2dfa266278cd6d867e2a3a5"

URI_x86_64_v2_rust-zbus_names-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_names-devel-4.3.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_names-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_names-devel}"
SRC_URI[x86_64_v2_rust-zbus_names-devel.sha256sum] = "a324302c8a76535e1a690d5878fa4fbc194b7fb1ebd5fac8d9453a082595259f"

URI_aarch64_rust-zbus_names+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_names+default-devel-4.3.4-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_names+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_names+default-devel}"
SRC_URI[aarch64_rust-zbus_names+default-devel.sha256sum] = "5559605cf71bb6e2d2257d17fb27e8374251302b4228eed1667ea6694f777a17"

URI_aarch64_rust-zbus_names-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_names-devel-4.3.4-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_names-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_names-devel}"
SRC_URI[aarch64_rust-zbus_names-devel.sha256sum] = "3086ef3e2ceac190a13a8ebdf00664520836dadf84e57127139905e6fbb40069"

RDEPENDS:rust-zbus_names+default-devel = " \
 cargo \
 rust-zbus_names-devel \
 "
RDEPENDS:rust-zbus_names-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-winnow+default-devel \
 rust-zvariant+default-devel \
 rust-zvariant+enumflags2-devel \
 "
