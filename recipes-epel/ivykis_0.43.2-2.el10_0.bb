# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ivykis"
PV = "0.43.2"
PR = "2.el10_0"
PACKAGES = " \
 ivykis \
 ivykis-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ivykis-0.43.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1682f54640555282b76ffc45e8abd24884097b8b9656ab0d0f16268851672fdf"

URI_x86_64_v2_ivykis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ivykis-0.43.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ivykis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ivykis}"
SRC_URI[x86_64_v2_ivykis.sha256sum] = "10d448c4e74bd8a24ed3bdbf1b20855e971a2e9548cdd030de6b35fba5585bb7"

URI_x86_64_v2_ivykis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ivykis-devel-0.43.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ivykis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ivykis-devel}"
SRC_URI[x86_64_v2_ivykis-devel.sha256sum] = "0ecec80a1fa437e97a765410e18d85d2a053baa13f0445c479daae85f82dc1ac"

URI_aarch64_ivykis = "${EPEL_MIRROR}/aarch64/Packages/i/ivykis-0.43.2-2.el10_0.aarch64.rpm;name=aarch64_ivykis;unpack=0"
SRC_URI:append = " ${URI_aarch64_ivykis}"
SRC_URI[aarch64_ivykis.sha256sum] = "3408ba6d9f09ec91492c99419ba5068588588a1febbfc9690b17b147d1d772bb"

URI_aarch64_ivykis-devel = "${EPEL_MIRROR}/aarch64/Packages/i/ivykis-devel-0.43.2-2.el10_0.aarch64.rpm;name=aarch64_ivykis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ivykis-devel}"
SRC_URI[aarch64_ivykis-devel.sha256sum] = "21c8a64f92a585f0563dbbd33424de4af48c44d23bed4d86c67c86b11cbb3c69"

RDEPENDS:ivykis = " \
 glibc \
 "
RDEPENDS:ivykis-devel = " \
 ivykis \
 pkgconf-pkg-config \
 "
