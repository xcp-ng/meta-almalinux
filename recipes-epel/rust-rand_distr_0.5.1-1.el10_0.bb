# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_distr"
PV = "0.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand_distr+alloc-devel \
 rust-rand_distr+default-devel \
 rust-rand_distr+serde-devel \
 rust-rand_distr+std-devel \
 rust-rand_distr+std_math-devel \
 rust-rand_distr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_distr-0.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "330bba6b31830a734c93bc3c58140104169e58f09c13bd43c6cb0bcf6466e8f1"

URI_x86_64_v2_rust-rand_distr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+alloc-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+alloc-devel.sha256sum] = "cf64fa2906b0c096eb55b78f26ac1f72f6982d9361f65f314228ea96619c8ddb"

URI_x86_64_v2_rust-rand_distr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+default-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+default-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+default-devel.sha256sum] = "78c1698168a1d676074268adbbaaf0f1298aad430b8931aa2ab104a720225831"

URI_x86_64_v2_rust-rand_distr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+serde-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+serde-devel.sha256sum] = "12b4c6b89c7fff308b85c0ed831ef31be3183980bb583ded9bd7cf83f0db688a"

URI_x86_64_v2_rust-rand_distr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+std-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+std-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+std-devel.sha256sum] = "8ced7323b12f5b163322174e9fde10f7b3478750547bc8eff1b4632676537ba9"

URI_x86_64_v2_rust-rand_distr+std_math-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+std_math-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+std_math-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+std_math-devel.sha256sum] = "fd9543b3d9532b2e0a5b75a5a5107144b9e275b39f62c4d8816bbe0a0ef46952"

URI_x86_64_v2_rust-rand_distr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr-devel}"
SRC_URI[x86_64_v2_rust-rand_distr-devel.sha256sum] = "60d9f917a21e084c28235fa23edf324adbdf872d3030726378d7747685984abd"

URI_aarch64_rust-rand_distr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+alloc-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+alloc-devel}"
SRC_URI[aarch64_rust-rand_distr+alloc-devel.sha256sum] = "af5f4be054915a80b011a288ddaf28825f6d6ad1ce3ed41b4befd77d51556567"

URI_aarch64_rust-rand_distr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+default-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+default-devel}"
SRC_URI[aarch64_rust-rand_distr+default-devel.sha256sum] = "4d3d1b20f3c01e953b2df1126ead21e7e549564fff60198978264b72a6807a73"

URI_aarch64_rust-rand_distr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+serde-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+serde-devel}"
SRC_URI[aarch64_rust-rand_distr+serde-devel.sha256sum] = "ee6944bba11dea1e2a19e0537dd9960d8869b18fd4869b709c0411065063e93b"

URI_aarch64_rust-rand_distr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+std-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+std-devel}"
SRC_URI[aarch64_rust-rand_distr+std-devel.sha256sum] = "e69068d9a2f494eea5e87a0c0c8926bea8a82f1a518f6ef7253d6dbe1be1725c"

URI_aarch64_rust-rand_distr+std_math-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+std_math-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+std_math-devel}"
SRC_URI[aarch64_rust-rand_distr+std_math-devel.sha256sum] = "b692a39a8deffbcb63f7de4a04dfe74bb876bf10303ed45bf1a8406ee6c09b28"

URI_aarch64_rust-rand_distr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr-devel}"
SRC_URI[aarch64_rust-rand_distr-devel.sha256sum] = "8101f0baad2a6962f14841c114e840d665442e1f3c1684c605a48de62c437657"

RDEPENDS:rust-rand_distr+alloc-devel = " \
 cargo \
 rust-rand+alloc-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr+default-devel = " \
 cargo \
 rust-rand_distr+std-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr+serde-devel = " \
 cargo \
 rust-rand+serde-devel \
 rust-rand_distr-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_with+default-devel \
 "
RDEPENDS:rust-rand_distr+std-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand_distr+alloc-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr+std_math-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr-devel = " \
 cargo \
 rust \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 rust-rand-devel \
 "
