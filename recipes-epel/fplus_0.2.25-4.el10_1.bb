# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fplus"
PV = "0.2.25"
PR = "4.el10_1"
PACKAGES = " \
 fplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fplus-0.2.25-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a1bb822c7f3e92d01012c6cb39df5ff8a85938817a8752e437a990c28bd0da4"

URI_x86_64_v2_fplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fplus-devel-0.2.25-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fplus-devel}"
SRC_URI[x86_64_v2_fplus-devel.sha256sum] = "1991ab6cf74582ebbd24fb02e95167f77309a11185c5dc672d8dbcb9ea6288eb"

URI_aarch64_fplus-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fplus-devel-0.2.25-4.el10_1.aarch64.rpm;name=aarch64_fplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fplus-devel}"
SRC_URI[aarch64_fplus-devel.sha256sum] = "71b23e62fda98fa499ad57bf8974580f85fb83277b72114d3129979c776b0089"

RDEPENDS:fplus-devel = " \
 cmake-filesystem \
 "
