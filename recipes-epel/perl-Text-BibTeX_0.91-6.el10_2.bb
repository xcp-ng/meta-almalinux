# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-BibTeX"
PV = "0.91"
PR = "6.el10_2"
PACKAGES = " \
 perl-Text-BibTeX \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-BibTeX-0.91-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13d27590463fc27d54fd3a37c27eb6d83a50113b44a21c01093b502a059cac8a"

URI_x86_64_v2_perl-Text-BibTeX = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-BibTeX-0.91-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Text-BibTeX;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-BibTeX}"
SRC_URI[x86_64_v2_perl-Text-BibTeX.sha256sum] = "a1490bfee13fc9a17cb009f50dc7541624d04ae1b0a5360f31b968f7357fee49"

URI_aarch64_perl-Text-BibTeX = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-BibTeX-0.91-6.el10_2.aarch64.rpm;name=aarch64_perl-Text-BibTeX;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-BibTeX}"
SRC_URI[aarch64_perl-Text-BibTeX.sha256sum] = "2c64ecd860f78aef0ab689d3650404b3ce617a7a4e21cc5f456c0e74c943a58f"

RDEPENDS:perl-Text-BibTeX = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Tabular \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-Text-BibTeX \
 perl-Unicode-Normalize \
 perl-libs \
 perl-vars \
 "
