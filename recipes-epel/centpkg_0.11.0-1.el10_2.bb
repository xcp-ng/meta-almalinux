# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "centpkg"
PV = "0.11.0"
PR = "1.el10_2"
PACKAGES = " \
 centpkg \
 centpkg-sig \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/centpkg-0.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c4f1b9b02cacdbfe3f6693378bc2ca54acce36fa90cdf5bdc514e96193a8070"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centpkg-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_centpkg;unpack=0"
SRC_URI[x86_64_v2_centpkg.sha256sum] = "6a5b05af5922e81bd4f891bfaa8a360af265df5f37cbc7f7f218cd6cdfe80f28"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centpkg-sig-0.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_centpkg-sig;unpack=0"
SRC_URI[x86_64_v2_centpkg-sig.sha256sum] = "347b1943776dc17189066b7d167977c186fa9de74c723a0a14579277aedb7575"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/centpkg-0.11.0-1.el10_2.noarch.rpm;name=aarch64_centpkg;unpack=0"
SRC_URI[aarch64_centpkg.sha256sum] = "1d475198a448954dcea7edeb1eed80f0c6eecc25a9f76f099563e72e78642f87"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/centpkg-sig-0.11.0-1.el10_2.noarch.rpm;name=aarch64_centpkg-sig;unpack=0"
SRC_URI[aarch64_centpkg-sig.sha256sum] = "c8be7c2bd350a150cea3dad51b93b85bebee0516bea49bc0e650bad3418f8600"

RDEPENDS:centpkg = " \
 python3 \
 python3-GitPython \
 python3-cryptography \
 python3-gitlab \
 python3-pycurl \
 python3-pyyaml \
 python3-rpkg \
 "
RDEPENDS:centpkg-sig = " \
 centpkg \
 python3 \
 "
