# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Config-Any"
PV = "0.33"
PR = "1.el10_2"
PACKAGES = " \
 perl-Config-Any \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Config-Any-0.33-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d18209b4c87e380d6a186cbc2a1b1bb5558c632ebb8e823548f503cc2d2f16e"

URI_x86_64_v2_perl-Config-Any = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Config-Any-0.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Config-Any;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Config-Any}"
SRC_URI[x86_64_v2_perl-Config-Any.sha256sum] = "d2289e20c263e906885b90f3b71218f47b1ec5b04ab6b22989b49ebe83d51d13"

URI_aarch64_perl-Config-Any = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Config-Any-0.33-1.el10_2.noarch.rpm;name=aarch64_perl-Config-Any;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Config-Any}"
SRC_URI[aarch64_perl-Config-Any.sha256sum] = "379c6e81b2d8ddf79420715ec0ba62a413f566d936938055feaf3b3a31912229"

RDEPENDS:perl-Config-Any = " \
 perl-Carp \
 perl-Config-General \
 perl-Config-Tiny \
 perl-Cpanel-JSON-XS \
 perl-Module-Pluggable \
 perl-PathTools \
 perl-XML-NamespaceSupport \
 perl-XML-Simple \
 perl-YAML \
 perl-YAML-LibYAML \
 perl-base \
 perl-libs \
 "
