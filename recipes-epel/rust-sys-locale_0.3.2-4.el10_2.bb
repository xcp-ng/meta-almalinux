# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sys-locale"
PV = "0.3.2"
PR = "4.el10_2"
PACKAGES = " \
 rust-sys-locale+default-devel \
 rust-sys-locale-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sys-locale-0.3.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0515e9f9f9875c15b69289169a39b0fddc8bf3de999c6de6cd341758eac67fe4"

URI_x86_64_v2_rust-sys-locale+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sys-locale+default-devel-0.3.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sys-locale+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sys-locale+default-devel}"
SRC_URI[x86_64_v2_rust-sys-locale+default-devel.sha256sum] = "7b1302472060dc34bbba9350b9daa57c3d398a489cd86d246e3737f5fe36ba73"

URI_x86_64_v2_rust-sys-locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sys-locale-devel-0.3.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sys-locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sys-locale-devel}"
SRC_URI[x86_64_v2_rust-sys-locale-devel.sha256sum] = "8bc7eb340030e2a207c002ec27480641ea38c1fd9e2251e0ed933d43427615c7"

URI_aarch64_rust-sys-locale+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sys-locale+default-devel-0.3.2-4.el10_2.noarch.rpm;name=aarch64_rust-sys-locale+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sys-locale+default-devel}"
SRC_URI[aarch64_rust-sys-locale+default-devel.sha256sum] = "67d06fb9cde5f827b9aad2a2a0c516b3afbafb6591ad40a6ceb3720d1729e014"

URI_aarch64_rust-sys-locale-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sys-locale-devel-0.3.2-4.el10_2.noarch.rpm;name=aarch64_rust-sys-locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sys-locale-devel}"
SRC_URI[aarch64_rust-sys-locale-devel.sha256sum] = "072f174f9b6f8b15d3ff12355195e0d7fcb4b7c407e1cbf3df57b2bf0c2468b9"

RDEPENDS:rust-sys-locale+default-devel = " \
 cargo \
 rust-sys-locale-devel \
 "
RDEPENDS:rust-sys-locale-devel = " \
 cargo \
 rust \
 "
