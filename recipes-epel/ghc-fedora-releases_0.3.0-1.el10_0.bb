# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-fedora-releases"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 ghc-fedora-releases \
 ghc-fedora-releases-devel \
 ghc-fedora-releases-doc \
"
PACKAGES:aarch64 = " \
 ghc-fedora-releases \
 ghc-fedora-releases-devel \
 ghc-fedora-releases-doc \
 ghc-fedora-releases-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-fedora-releases-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df3edfee824bc0ba859cefbe3142f252bf83d60e3a4a1fc13b17301c3d5f9265"

URI_x86_64_v2_ghc-fedora-releases = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fedora-releases-0.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fedora-releases;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fedora-releases}"
SRC_URI[x86_64_v2_ghc-fedora-releases.sha256sum] = "8dedb8f6d3016860a197ae72a048ae9f8c0a3fd9b64f2feaafb31021fa5caed6"

URI_x86_64_v2_ghc-fedora-releases-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fedora-releases-devel-0.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fedora-releases-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fedora-releases-devel}"
SRC_URI[x86_64_v2_ghc-fedora-releases-devel.sha256sum] = "8f448b29adde2dbce6a8e30d48b78e7fa2973318257126dcb8f6c6f2361384d9"

URI_x86_64_v2_ghc-fedora-releases-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fedora-releases-doc-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-fedora-releases-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fedora-releases-doc}"
SRC_URI[x86_64_v2_ghc-fedora-releases-doc.sha256sum] = "f86cc269a084e0c89dff4c35371c6b48527cef95108b88d6cd57ae28797753bb"

URI_aarch64_ghc-fedora-releases = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-releases-0.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-fedora-releases;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-releases}"
SRC_URI[aarch64_ghc-fedora-releases.sha256sum] = "3a41e95c28a8a87760d19b9f6552a9619ea10de9aa137b29d1c06d07bdf630c8"

URI_aarch64_ghc-fedora-releases-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-releases-devel-0.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-fedora-releases-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-releases-devel}"
SRC_URI[aarch64_ghc-fedora-releases-devel.sha256sum] = "f6253b83a3d148916b4bd65b1afef40171f347b335a4d9bc77aefc60223bb02a"

URI_aarch64_ghc-fedora-releases-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-releases-doc-0.3.0-1.el10_0.noarch.rpm;name=aarch64_ghc-fedora-releases-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-releases-doc}"
SRC_URI[aarch64_ghc-fedora-releases-doc.sha256sum] = "4eb04fff56aaece54c26add1802a54bed51732978c2f20c0339ae87696499614"

URI_aarch64_ghc-fedora-releases-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fedora-releases-prof-0.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-fedora-releases-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fedora-releases-prof}"
SRC_URI[aarch64_ghc-fedora-releases-prof.sha256sum] = "9647d4d60a8ccdd7e950c012c0c39b15eac4cd655b41fb398eb3b6cb34606019"

RDEPENDS:ghc-fedora-releases = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-bodhi \
 ghc-byteorder \
 ghc-bytestring \
 ghc-cached-json-file \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-clock \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-extra \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-query \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xdg-basedir \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-fedora-releases-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bodhi-devel \
 ghc-cached-json-file-devel \
 ghc-compiler \
 ghc-extra-devel \
 ghc-fedora-releases \
 ghc-safe-devel \
 "
RDEPENDS:ghc-fedora-releases-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-fedora-releases-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bodhi-prof \
 ghc-cached-json-file-prof \
 ghc-extra-prof \
 ghc-fedora-releases-devel \
 ghc-safe-prof \
 "
