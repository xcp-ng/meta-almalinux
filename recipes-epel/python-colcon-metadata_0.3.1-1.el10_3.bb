# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-metadata"
PV = "0.3.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-metadata \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-metadata-0.3.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3c41004ef4cb55b9f40747d49e8223ae1a3c39f06916518f0deb0ab0de1908d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-metadata-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-metadata;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-metadata.sha256sum] = "7afa953aa8c63efc6859dc2f5842689d3c49b783879f389d9199068f3616a4a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-metadata-0.3.1-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-metadata;unpack=0"
SRC_URI[aarch64_python3-colcon-metadata.sha256sum] = "c8912a115dde33692353ddc8bf8da7b38031aea9ca8ad48267032afbbf837a2b"

RDEPENDS:python3-colcon-metadata = " \
 python3 \
 python3-colcon-core \
 python3-pyyaml \
 "
