# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-regex"
PV = "0.1.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-grep-regex+default-devel \
 rust-grep-regex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-regex-0.1.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aab97db70152ef98a87a4bdc4acb162b12c47da257709d3fd61f678cead2e12c"

URI_x86_64_v2_rust-grep-regex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-regex+default-devel-0.1.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-regex+default-devel}"
SRC_URI[x86_64_v2_rust-grep-regex+default-devel.sha256sum] = "cf0642e3b6b9a60f56962771cfb6bdcadc21848574e72566c3128bbcc34d02de"

URI_x86_64_v2_rust-grep-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-regex-devel-0.1.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-regex-devel}"
SRC_URI[x86_64_v2_rust-grep-regex-devel.sha256sum] = "032d9768dba4f25618136fb5f0c57b41abbde7d0a2c645689f49c016ffa14872"

URI_aarch64_rust-grep-regex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-regex+default-devel-0.1.14-1.el10_2.noarch.rpm;name=aarch64_rust-grep-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-regex+default-devel}"
SRC_URI[aarch64_rust-grep-regex+default-devel.sha256sum] = "63ff3aec86a9a447b895b06618b1ffce472f592d2bd532323e6bc6ff5ef2f727"

URI_aarch64_rust-grep-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-regex-devel-0.1.14-1.el10_2.noarch.rpm;name=aarch64_rust-grep-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-regex-devel}"
SRC_URI[aarch64_rust-grep-regex-devel.sha256sum] = "eb6e5b2432b91190f08f0197c5b1ec0793ad4fdcbb179d9a90e82175d9e93cf4"

RDEPENDS:rust-grep-regex+default-devel = " \
 cargo \
 rust-grep-regex-devel \
 "
RDEPENDS:rust-grep-regex-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-grep-matcher+default-devel \
 rust-log+default-devel \
 rust-regex-automata+default-devel \
 rust-regex-syntax+default-devel \
 "
