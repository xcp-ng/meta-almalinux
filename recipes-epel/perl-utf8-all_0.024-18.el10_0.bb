# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-utf8-all"
PV = "0.024"
PR = "18.el10_0"
PACKAGES = " \
 perl-utf8-all \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-utf8-all-0.024-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67a19d3f6ce4c15c524c4a3037968d317d611c24f88570b5218701fcc6fb738a"

URI_x86_64_v2_perl-utf8-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-utf8-all-0.024-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-utf8-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-utf8-all}"
SRC_URI[x86_64_v2_perl-utf8-all.sha256sum] = "0e7ebd566797ec9fc6409cc54d4d7f0c1d2bc7b1884f80f735439e824da40e23"

URI_aarch64_perl-utf8-all = "${EPEL_MIRROR}/aarch64/Packages/p/perl-utf8-all-0.024-18.el10_0.noarch.rpm;name=aarch64_perl-utf8-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-utf8-all}"
SRC_URI[aarch64_perl-utf8-all.sha256sum] = "a905a2945897fab18071c5b66f345e740e550af969cb9842f111a7b35662a65f"

RDEPENDS:perl-utf8-all = " \
 perl-Carp \
 perl-Encode \
 perl-Import-Into \
 perl-PerlIO-utf8_strict \
 perl-Symbol \
 perl-libs \
 perl-open \
 perl-parent \
 "
