# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjumpingcube"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kjumpingcube \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kjumpingcube-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ebc9c45a4e0d0e917e91087fc0ca3de053b64efcf2a97120494e2dcc303cca95"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjumpingcube-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjumpingcube;unpack=0"
SRC_URI[x86_64_v2_kjumpingcube.sha256sum] = "59f08130f35efe3b8b1671a3135427eb14f7aefcf0be907d02b4162dc242e159"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kjumpingcube-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kjumpingcube;unpack=0"
SRC_URI[aarch64_kjumpingcube.sha256sum] = "990b5488c65d02da3818d4c926f256452d021672ed1aff16bfed889c0899b2a0"

RDEPENDS:kjumpingcube = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
