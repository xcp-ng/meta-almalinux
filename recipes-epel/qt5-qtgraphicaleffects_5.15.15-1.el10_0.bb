# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtgraphicaleffects"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtgraphicaleffects \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtgraphicaleffects-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3402bd8a17c9c9a08a934a0d84a9fcdb1bcc74dd317d16cc2a992603f00b0e9"

URI_x86_64_v2_qt5-qtgraphicaleffects = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgraphicaleffects-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgraphicaleffects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgraphicaleffects}"
SRC_URI[x86_64_v2_qt5-qtgraphicaleffects.sha256sum] = "b1c3421eeb88f1acd0864e15eeeed7b6f790f9b53573dc12e6897a8260ed374a"

URI_aarch64_qt5-qtgraphicaleffects = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgraphicaleffects-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtgraphicaleffects;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgraphicaleffects}"
SRC_URI[aarch64_qt5-qtgraphicaleffects.sha256sum] = "261cbda69508289b1f8735b1520c5a728f89f458e65e38bce04db9dabed27d58"

RDEPENDS:qt5-qtgraphicaleffects = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
