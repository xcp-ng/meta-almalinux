# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cups-pdf"
PV = "3.0.2"
PR = "1.el10_2"
PACKAGES = " \
 cups-pdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cups-pdf-3.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f7a4ed19cd3e54a5dbfa9d469072ac339759b91faa2e1e900e455464b1f5e7b"

URI_x86_64_v2_cups-pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cups-pdf-3.0.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cups-pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-pdf}"
SRC_URI[x86_64_v2_cups-pdf.sha256sum] = "931adaed17c7595b8bd1068a32fa0de7e23f8613e697d7e8125c72268f4165be"

URI_aarch64_cups-pdf = "${EPEL_MIRROR}/aarch64/Packages/c/cups-pdf-3.0.2-1.el10_2.aarch64.rpm;name=aarch64_cups-pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-pdf}"
SRC_URI[aarch64_cups-pdf.sha256sum] = "b336641561e3ba68f68099efadded6795b09b8b8ec23dd18279ba3a0f64d64f8"

RDEPENDS:cups-pdf = " \
 bash \
 cups \
 cups-libs \
 ghostscript \
 glibc \
 procps-ng \
 "
