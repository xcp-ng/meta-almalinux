# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree"
PV = "0.42.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree+default-devel \
 rust-gix-worktree+document-features-devel \
 rust-gix-worktree+serde-devel \
 rust-gix-worktree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-0.42.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fef171b35da107d939d5f3a38067fa9f5f0ea8adda505391f92f669aef7cfc0"

URI_x86_64_v2_rust-gix-worktree+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+attributes-devel-0.42.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+attributes-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+attributes-devel.sha256sum] = "5d44860a8ea072331981b8fc44ecd009f8d5738a0ab866f1360c5b74cfcd4a25"

URI_x86_64_v2_rust-gix-worktree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+default-devel-0.42.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+default-devel.sha256sum] = "734ad189da4c26cbf0ddf36b06f3f7363e53eb8e3f0d6e7b007ef2046785b60b"

URI_x86_64_v2_rust-gix-worktree+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+document-features-devel-0.42.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+document-features-devel.sha256sum] = "bc4d163a7a8b33abd3f38b29e282351f8d5090cb60166e844d77cbb249ff402d"

URI_x86_64_v2_rust-gix-worktree+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+serde-devel-0.42.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+serde-devel.sha256sum] = "a5ed8a67b63b6c417e85894fb320a05dfce03cd9a747685d0a04432766336a07"

URI_x86_64_v2_rust-gix-worktree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-devel-0.42.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-devel.sha256sum] = "bcc0f93a4d7c6f989634904451b416a95c0c4385716b61584ff2ca11b7bfe354"

URI_aarch64_rust-gix-worktree+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+attributes-devel-0.42.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-worktree+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+attributes-devel}"
SRC_URI[aarch64_rust-gix-worktree+attributes-devel.sha256sum] = "427c1ef033754ad069ecd126d42d434a15dd4a979f9796e56462bf247a9e84ba"

URI_aarch64_rust-gix-worktree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+default-devel-0.42.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-worktree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+default-devel}"
SRC_URI[aarch64_rust-gix-worktree+default-devel.sha256sum] = "022179b8b87d3986a196117d1d30c9b23deb7b6da34e7f44234b6754860f47f2"

URI_aarch64_rust-gix-worktree+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+document-features-devel-0.42.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-worktree+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+document-features-devel}"
SRC_URI[aarch64_rust-gix-worktree+document-features-devel.sha256sum] = "6be5125ed19fa80b40db19ec4e01d9e63de6f2583c3994e56abe4978719f0047"

URI_aarch64_rust-gix-worktree+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+serde-devel-0.42.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-worktree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+serde-devel}"
SRC_URI[aarch64_rust-gix-worktree+serde-devel.sha256sum] = "12c918d4fd4898866b3abbe3de054589a5c044fabea36fd9dd092c702d36cdd2"

URI_aarch64_rust-gix-worktree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-devel-0.42.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-worktree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-devel}"
SRC_URI[aarch64_rust-gix-worktree-devel.sha256sum] = "a4e5f52f127a11eb0dcea7cd8653850328e22966ec0f7d28aa17c0fd67bfceaf"

RDEPENDS:rust-gix-worktree+attributes-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-validate+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+default-devel = " \
 cargo \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-index+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-worktree-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-worktree-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-ignore+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 "
