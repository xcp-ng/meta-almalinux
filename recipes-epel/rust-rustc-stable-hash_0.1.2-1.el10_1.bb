# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-stable-hash"
PV = "0.1.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustc-stable-hash+default-devel \
 rust-rustc-stable-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-stable-hash-0.1.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08af406a737523d6e2e433876b6cff498e6c0899c3e8f5416f922730e8b03a85"

URI_x86_64_v2_rust-rustc-stable-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-stable-hash+default-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-stable-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-stable-hash+default-devel}"
SRC_URI[x86_64_v2_rust-rustc-stable-hash+default-devel.sha256sum] = "936b63fd57bf49c402412e9be30f8a20c129a043dbd7bc48e0a9b976753486de"

URI_x86_64_v2_rust-rustc-stable-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-stable-hash-devel-0.1.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-stable-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-stable-hash-devel}"
SRC_URI[x86_64_v2_rust-rustc-stable-hash-devel.sha256sum] = "d7199765c701c70fe60ac0c58d22e06a7820368d8e4e7c482cf8f0114d1b7488"

URI_aarch64_rust-rustc-stable-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-stable-hash+default-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-rustc-stable-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-stable-hash+default-devel}"
SRC_URI[aarch64_rust-rustc-stable-hash+default-devel.sha256sum] = "9a8ea5e4ad6b49154ff8ca691563109d6e84f869a8d037a3b6663d2e5f8707e1"

URI_aarch64_rust-rustc-stable-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-stable-hash-devel-0.1.2-1.el10_1.noarch.rpm;name=aarch64_rust-rustc-stable-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-stable-hash-devel}"
SRC_URI[aarch64_rust-rustc-stable-hash-devel.sha256sum] = "9a05636a6554b1f86179792d74823767cba65f9ed4707708cdfb68c6fde7887d"

RDEPENDS:rust-rustc-stable-hash+default-devel = " \
 cargo \
 rust-rustc-stable-hash-devel \
 "
RDEPENDS:rust-rustc-stable-hash-devel = " \
 cargo \
 "
