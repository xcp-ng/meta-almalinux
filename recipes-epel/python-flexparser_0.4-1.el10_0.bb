# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flexparser"
PV = "0.4"
PR = "1.el10_0"
PACKAGES = " \
 python3-flexparser \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-flexparser-0.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "14ce5563c064a2c37417272d0f5cf51e0888042e9ac96757afdcbc4716f36638"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flexparser-0.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flexparser;unpack=0"
SRC_URI[x86_64_v2_python3-flexparser.sha256sum] = "a741d67a739ee431e8c69734a2e12eb738c94ffdeba3d3db1e67373370f9ceaf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-flexparser-0.4-1.el10_0.noarch.rpm;name=aarch64_python3-flexparser;unpack=0"
SRC_URI[aarch64_python3-flexparser.sha256sum] = "cb5411ddccc6ce90ce8bd3bbe37dcb4a1d521223ff3161294d0fb64cb948bda1"

RDEPENDS:python3-flexparser = " \
 python3 \
 python3-typing-extensions \
 "
