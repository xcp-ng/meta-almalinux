# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtwebsockets"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtwebsockets \
 qt5-qtwebsockets-devel \
 qt5-qtwebsockets-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtwebsockets-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3d9c586d27cd236023aca6f9480cca7f8259529869ae05faaeef89ba86c29ce"

URI_x86_64_v2_qt5-qtwebsockets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets}"
SRC_URI[x86_64_v2_qt5-qtwebsockets.sha256sum] = "35cf86babe985cef6fe310024cc74c4ad2983c91b39e4d7ace6aaa5a8f366551"

URI_x86_64_v2_qt5-qtwebsockets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets-devel}"
SRC_URI[x86_64_v2_qt5-qtwebsockets-devel.sha256sum] = "4a061e074462c7e21c5455b49d06351d27886b68acc6d92a180e7b0654798db8"

URI_x86_64_v2_qt5-qtwebsockets-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwebsockets-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwebsockets-examples}"
SRC_URI[x86_64_v2_qt5-qtwebsockets-examples.sha256sum] = "250ae15ad11e34518082698ab9f74b51887f4dadd95931264f1649a10e90cb67"

URI_aarch64_qt5-qtwebsockets = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets}"
SRC_URI[aarch64_qt5-qtwebsockets.sha256sum] = "de2f40acbffe2c435e388001771f839fd7dc87e039c7976761055f9688a2899f"

URI_aarch64_qt5-qtwebsockets-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets-devel}"
SRC_URI[aarch64_qt5-qtwebsockets-devel.sha256sum] = "76d08b5a573d74e59b9e89e95c2ed916ffb2fb8e3d06f466dda7bf2b60032874"

URI_aarch64_qt5-qtwebsockets-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwebsockets-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwebsockets-examples}"
SRC_URI[aarch64_qt5-qtwebsockets-examples.sha256sum] = "403fe0e9c77906561b846d5c448978836914e0b435ba81abefdbe139e855346b"

RDEPENDS:qt5-qtwebsockets = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtwebsockets-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 "
RDEPENDS:qt5-qtwebsockets-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 "
