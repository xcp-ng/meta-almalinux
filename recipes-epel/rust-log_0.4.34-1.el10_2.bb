# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-log"
PV = "0.4.34"
PR = "1.el10_2"
PACKAGES = " \
 rust-log+alloc-devel \
 rust-log+default-devel \
 rust-log+kv-devel \
 rust-log+max_level_debug-devel \
 rust-log+max_level_error-devel \
 rust-log+max_level_info-devel \
 rust-log+max_level_off-devel \
 rust-log+max_level_trace-devel \
 rust-log+max_level_warn-devel \
 rust-log+release_max_level_debug-devel \
 rust-log+release_max_level_error-devel \
 rust-log+release_max_level_info-devel \
 rust-log+release_max_level_off-devel \
 rust-log+release_max_level_trace-devel \
 rust-log+release_max_level_warn-devel \
 rust-log+serde-devel \
 rust-log+serde_core-devel \
 rust-log+std-devel \
 rust-log-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-log-0.4.34-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "20bf733f35802f13c522706ceed4cdb30da97185c23bb69fd9f9f37f231ffd6e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+alloc-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+alloc-devel.sha256sum] = "1f2f410723d381f431e3fcfcb41f9e7c6ebe59122ed97fa05f6e1e0fba8cf4ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+default-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+default-devel.sha256sum] = "9c39aa04336bc4669ac3f8a3b6198891a7cd8ad754c1b754bcfbc3c98fe4f588"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+kv-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+kv-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+kv-devel.sha256sum] = "0a2712c9c2492142f1ce0dcbb85cdda2ccaa9dbd69c5912399f0de03e6bf5a54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_debug-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_debug-devel.sha256sum] = "62df674f88278c7dfa076bfece1406b0473e911e06ff2b8ae9ea0ad24c8e4f6a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_error-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_error-devel.sha256sum] = "86a2ca95e3cd5b99479562ca11ab4918e457ad8517f2aad2bc457b08a9bc4f49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_info-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_info-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_info-devel.sha256sum] = "8b2ef4086aa728b89aee7928bd9c132d69715c36524bb77fd4f0c51059eaf002"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_off-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_off-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_off-devel.sha256sum] = "c5a951b271c5ea91e3bf699d8c9d8ff075d84c68e3cc8d042608ebdc42719c33"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_trace-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_trace-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_trace-devel.sha256sum] = "c558cb243b430cae57f7add3e0f139bd494c562cb67ed2f0e87a0ad99ce0a273"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_warn-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_warn-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+max_level_warn-devel.sha256sum] = "eeee9bb6340f2ee5607048a4e301a9d9aeca94cde433416140b69e8aaf4f119f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_debug-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_debug-devel.sha256sum] = "c7d5367f1fb6e41ca32dac62ce7b817b73ab4bc73c372c4b24b672142fa058a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_error-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_error-devel.sha256sum] = "b66d46c863be10262bffd7d72eb18a223ea8787c23cb515c7bd602ad2496901c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_info-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_info-devel.sha256sum] = "c5eb4a5f3b2355eecacf75843f0ee1479ce48317acd1bef1b67fa1306ded990c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_off-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_off-devel.sha256sum] = "3e27c73d9c38fff9ef45c28a3f4a12c438c5199cfb9b8da5a01b38281991721d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_trace-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_trace-devel.sha256sum] = "daafd257d81021bec276dd7eab9028cb93348016877b8c680f17898b152dee12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_warn-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+release_max_level_warn-devel.sha256sum] = "69fc8a04c56c80146e03928a77b6b2c137d0d383f676dfd90a023931f3e547f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+serde-devel.sha256sum] = "4f143594f9b15cd9bcf02bcd6c63c55380081a33687f897644f7f7daf581a3f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde_core-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde_core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+serde_core-devel.sha256sum] = "33031bc4cffb225e08a3aec1704415ab55947c2da1a1806837da29ae42205fca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+std-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log+std-devel.sha256sum] = "28bd069e2055d7b92722828758868e794ebe9258847700e402b960d378191252"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log-devel-0.4.34-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-log-devel.sha256sum] = "f99146ea834e9af13658dc55a0bdfdf71458516c98048b383c539a64bd901ffe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+alloc-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-log+alloc-devel.sha256sum] = "b2b96b59c047506c5d8ec4ce0596c9cc9228e1dcf272c1fae6e335088fc311e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+default-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+default-devel;unpack=0"
SRC_URI[aarch64_rust-log+default-devel.sha256sum] = "835d3146408b0fdf1a9dbc4bd7baa934664caa84a3269355efe6ea364eba2f49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+kv-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+kv-devel;unpack=0"
SRC_URI[aarch64_rust-log+kv-devel.sha256sum] = "7ed2416f61c0812eb7709ff742fcc31f68a7f43c67af92416367a6a059ade2aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_debug-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_debug-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_debug-devel.sha256sum] = "307eb453fe9e253909ee0c3e06ebce46c1edf0686199daffabb9e555cfe813a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_error-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_error-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_error-devel.sha256sum] = "eae7c52d2e661ee6534a360c77da21615c8064b6d00df4a3c3120bc2762f85fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_info-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_info-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_info-devel.sha256sum] = "1e33df66ac2e28c07033c8af1e52e46fe010ab4f5e082391c6d84bbd0aa8acf9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_off-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_off-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_off-devel.sha256sum] = "48ed5b35cd0eabe061f191a207ed6bbdd5a510ea7222c7abab9b829965a07fb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_trace-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_trace-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_trace-devel.sha256sum] = "169e0de6fb2c4f4e65dc8f254038a1c1c8e028255a353c0572727d44c30ecd5c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_warn-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_warn-devel;unpack=0"
SRC_URI[aarch64_rust-log+max_level_warn-devel.sha256sum] = "bdaa98a83810c51e6b9799d29c494d48b0d0c4c43563eb53e881cf91ae79e55f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_debug-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_debug-devel.sha256sum] = "8060a4d0a45ec5d36fd8aedd84616274990d45cad60fba1f16df70fce975618a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_error-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_error-devel.sha256sum] = "fd1ef2de06d04c0920639ca22f38cfb41ac0ea190bef183d830f3da602381dfe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_info-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_info-devel.sha256sum] = "dccc7b6299d25537ec8435b6906c757d586d186b7b6f25664680b00f0a8741e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_off-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_off-devel.sha256sum] = "dd859e1ea3056e8758b30d4fb0acfa1423150d63cd8fbda022a28191484e19d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_trace-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_trace-devel.sha256sum] = "9871dce78d6ff07c158f100c700bb95b2aca9d6b27657574a8a6778b4ab1b370"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_warn-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI[aarch64_rust-log+release_max_level_warn-devel.sha256sum] = "04f7001a3539b554602d5be7ad61f5622b2ac04ccf7f8416781697f97624b5bd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+serde-devel;unpack=0"
SRC_URI[aarch64_rust-log+serde-devel.sha256sum] = "c88067bb75a8eec0755090d33ad363b0367bc8acdc64bf235a4551950f980a0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde_core-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+serde_core-devel;unpack=0"
SRC_URI[aarch64_rust-log+serde_core-devel.sha256sum] = "aab3acab7764288d2837525db99ce606d0fbba9a2f96113d0249dabd94797402"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log+std-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log+std-devel;unpack=0"
SRC_URI[aarch64_rust-log+std-devel.sha256sum] = "774d3cd8bac6f313d774fdeeb8b7911e741a68df5b3baea666c7eaa5ce13ffd0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-log-devel-0.4.34-1.el10_2.noarch.rpm;name=aarch64_rust-log-devel;unpack=0"
SRC_URI[aarch64_rust-log-devel.sha256sum] = "b158f2bfc41c5a0998dcad99d79ded7bace7a83ba6254920a51b78e5175b4898"

RDEPENDS:rust-log+alloc-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+default-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+kv-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde-devel = " \
 cargo \
 rust-log+serde_core-devel \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde_core-devel = " \
 cargo \
 rust-log-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-log+std-devel = " \
 cargo \
 rust-log+alloc-devel \
 rust-log-devel \
 "
RDEPENDS:rust-log-devel = " \
 cargo \
 rust \
 "
