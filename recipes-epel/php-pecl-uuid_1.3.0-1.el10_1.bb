# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-uuid"
PV = "1.3.0"
PR = "1.el10_1"
PACKAGES = " \
 php-pecl-uuid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-uuid-1.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "407df3b79605bef4af3f610c2a230d59f8a809e14e563fb2deeadc786857d72f"

URI_x86_64_v2_php-pecl-uuid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-uuid-1.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-uuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-uuid}"
SRC_URI[x86_64_v2_php-pecl-uuid.sha256sum] = "a1bd09ff9f63ac64ef642c50cc8b3522917800283ee5d704a2d65799f894c413"

URI_aarch64_php-pecl-uuid = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-uuid-1.3.0-1.el10_1.aarch64.rpm;name=aarch64_php-pecl-uuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-uuid}"
SRC_URI[aarch64_php-pecl-uuid.sha256sum] = "89aaef053a4ceb165f4079b207ad09fd59602e22445b93609de25155fb0557d9"

RDEPENDS:php-pecl-uuid = " \
 glibc \
 libuuid \
 php-common \
 "
