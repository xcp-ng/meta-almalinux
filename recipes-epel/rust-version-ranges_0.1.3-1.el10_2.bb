# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-version-ranges"
PV = "0.1.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-version-ranges+default-devel \
 rust-version-ranges+proptest-devel \
 rust-version-ranges+semver-devel \
 rust-version-ranges+serde-devel \
 rust-version-ranges-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-version-ranges-0.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a36eb43e5e387647baef74e9d62743bf87e910e0134b8427f5d637ba0097f2e"

URI_x86_64_v2_rust-version-ranges+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+default-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+default-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+default-devel.sha256sum] = "9ec9984c015092e9ba48e36ec735d7df5045fcbdff039d4473e2a9d8100c6088"

URI_x86_64_v2_rust-version-ranges+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+proptest-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+proptest-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+proptest-devel.sha256sum] = "3583194ea48caa065245010aab98f18335024d119271ba59a9064bd5fde641b5"

URI_x86_64_v2_rust-version-ranges+semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+semver-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+semver-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+semver-devel.sha256sum] = "d2b659a65a601f32f41f2b6f8713ce47bde3287586a6ec1663e8f1a04b131658"

URI_x86_64_v2_rust-version-ranges+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+serde-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+serde-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+serde-devel.sha256sum] = "3c1941cd747db7536ddff2c8ca0afbdd49d07fe501b7441bc1fa28c849a2f566"

URI_x86_64_v2_rust-version-ranges-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges-devel}"
SRC_URI[x86_64_v2_rust-version-ranges-devel.sha256sum] = "927cce97ae11b9bf483b006c3339f907a33aafa0fd322ab7328a960bbaf05cde"

URI_aarch64_rust-version-ranges+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+default-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+default-devel}"
SRC_URI[aarch64_rust-version-ranges+default-devel.sha256sum] = "fbff93dcc5a09262eb804feb235b0b14a95c2a2ca11006c3816bbd7b15e01350"

URI_aarch64_rust-version-ranges+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+proptest-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+proptest-devel}"
SRC_URI[aarch64_rust-version-ranges+proptest-devel.sha256sum] = "c35318f85c9c4884db4654650143b7df40d250f5f142ce2ffece6dea04440da1"

URI_aarch64_rust-version-ranges+semver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+semver-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-version-ranges+semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+semver-devel}"
SRC_URI[aarch64_rust-version-ranges+semver-devel.sha256sum] = "b30134ad65731ddf7933643257f3edc976676b7d488675d192918ec6e44176a9"

URI_aarch64_rust-version-ranges+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+serde-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+serde-devel}"
SRC_URI[aarch64_rust-version-ranges+serde-devel.sha256sum] = "60fed84d7a563a187bccb44f9baaf120c1847fae9ae4b5d23138ded0d1092166"

URI_aarch64_rust-version-ranges-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges-devel}"
SRC_URI[aarch64_rust-version-ranges-devel.sha256sum] = "b53e2bc54d461a5842c4a964f34d1aee9b71ead9017c1d0e6076e5e111573f59"

RDEPENDS:rust-version-ranges+default-devel = " \
 cargo \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+proptest-devel = " \
 cargo \
 rust-proptest+default-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+semver-devel = " \
 cargo \
 rust-semver+default-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-smallvec+serde-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
