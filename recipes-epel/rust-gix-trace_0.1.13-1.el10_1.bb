# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-trace"
PV = "0.1.13"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-trace+default-devel \
 rust-gix-trace+document-features-devel \
 rust-gix-trace+tracing-detail-devel \
 rust-gix-trace+tracing-devel \
 rust-gix-trace-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-trace-0.1.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3685823f531452442d46d18025b14c908ccbbd104425c68fb0c511aec25ff4f"

URI_x86_64_v2_rust-gix-trace+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+default-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+default-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+default-devel.sha256sum] = "a3f28278fc9c80611331867e9b2d2e21aba3f33f77ec3e7f18dcab2a687ab010"

URI_x86_64_v2_rust-gix-trace+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+document-features-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+document-features-devel.sha256sum] = "84f4acb3b7f2b13efcfffa19a63a3a66126b7d609c9946a5f324dd4745d0f3b6"

URI_x86_64_v2_rust-gix-trace+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+tracing-detail-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+tracing-detail-devel.sha256sum] = "835ec91d4c2b3fd0cde1c6ddb51898adddfbcda952001b483c336b9308d32f5e"

URI_x86_64_v2_rust-gix-trace+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+tracing-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+tracing-devel.sha256sum] = "4608106d30f783d1930cf2eb17969fd7520201fa8183ad99de9503148dd93514"

URI_x86_64_v2_rust-gix-trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace-devel-0.1.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace-devel}"
SRC_URI[x86_64_v2_rust-gix-trace-devel.sha256sum] = "0c9cc7c011302b2a48eafc2e3bc599a09c2c113c09d1c05998b5348c0a7b1b5b"

URI_aarch64_rust-gix-trace+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+default-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-gix-trace+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+default-devel}"
SRC_URI[aarch64_rust-gix-trace+default-devel.sha256sum] = "a97ffd1db6177dd278e5f7414390f1ed3875f00083094120ce3d8b59197dc023"

URI_aarch64_rust-gix-trace+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+document-features-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-gix-trace+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+document-features-devel}"
SRC_URI[aarch64_rust-gix-trace+document-features-devel.sha256sum] = "b02957a91f8d808439da259e15fe3e1a15ff61ac2ec5975d00c70cb6aaad86f8"

URI_aarch64_rust-gix-trace+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+tracing-detail-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-gix-trace+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix-trace+tracing-detail-devel.sha256sum] = "4ac775b57f93363621e752365c15a05ec855eaa433dc48f889173edb19076c64"

URI_aarch64_rust-gix-trace+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+tracing-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-gix-trace+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+tracing-devel}"
SRC_URI[aarch64_rust-gix-trace+tracing-devel.sha256sum] = "e3fdd29c5509862260b6313290f447891b856be0845bda88d8f5b9f43d40515f"

URI_aarch64_rust-gix-trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace-devel-0.1.13-1.el10_1.noarch.rpm;name=aarch64_rust-gix-trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace-devel}"
SRC_URI[aarch64_rust-gix-trace-devel.sha256sum] = "ff111cc34c0974a86459e04f576ec7f54757d8500b997f9ee1ecc8926d02442f"

RDEPENDS:rust-gix-trace+default-devel = " \
 cargo \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+tracing-detail-devel = " \
 cargo \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+tracing-devel = " \
 cargo \
 rust-gix-trace-devel \
 rust-tracing-core+default-devel \
 "
RDEPENDS:rust-gix-trace-devel = " \
 cargo \
 rust \
 "
