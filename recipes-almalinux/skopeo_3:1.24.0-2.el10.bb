# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skopeo"
PE = "3"
PV = "1.24.0"
PR = "2.el10"
PACKAGES = " \
 skopeo \
 skopeo-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/skopeo-1.24.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8307738c615642ab4a202ad9d0c414605397429c2824521e32b14931cc89e711"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-1.24.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_skopeo;unpack=0"
SRC_URI[x86_64_v2_skopeo.sha256sum] = "17a0bf4c7aa2fe5a0114a3dc4e3e156b48e320b0630771a3f5e6e30493c954ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-tests-1.24.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_skopeo-tests;unpack=0"
SRC_URI[x86_64_v2_skopeo-tests.sha256sum] = "b7db908a14c17dba96095cade6c5691cf4fd24a5f7043edad5ebecd1f2273f52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-1.24.0-2.el10.aarch64.rpm;name=aarch64_skopeo;unpack=0"
SRC_URI[aarch64_skopeo.sha256sum] = "7cea2d8314c0c0cbc75941db1cf2ac79c2affa11f7815234efd8716cc336215f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-tests-1.24.0-2.el10.aarch64.rpm;name=aarch64_skopeo-tests;unpack=0"
SRC_URI[aarch64_skopeo-tests.sha256sum] = "faaffd2c78a3f61bf882647e98e4ae38c1fdbf76620ed6eab85ce57436134846"

RDEPENDS:skopeo = " \
 containers-common \
 glibc \
 gpgme \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:skopeo-tests = " \
 bash \
 crun \
 gnupg2 \
 golang \
 httpd-tools \
 jq \
 openssl \
 podman \
 skopeo \
 squashfs-tools \
 virtual//usr/bin/env \
 "
