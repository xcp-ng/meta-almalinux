# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kqtquickcharts"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kqtquickcharts \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kqtquickcharts-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4bad33e84386983bf1d08bec4dfb0cddb8b725ea4486ff224d5bd51117e6bcef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kqtquickcharts-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kqtquickcharts;unpack=0"
SRC_URI[x86_64_v2_kqtquickcharts.sha256sum] = "29847e6ab7be63db0cc916948dc24d01a26e5edefc34e32fe934d671f62e1828"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kqtquickcharts-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kqtquickcharts;unpack=0"
SRC_URI[aarch64_kqtquickcharts.sha256sum] = "e3de889b3ae4620970296ad3aca3076c3ae8ef3231f94ed4e5069727f38d4a0b"

RDEPENDS:kqtquickcharts = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
