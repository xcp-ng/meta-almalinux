# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-url"
PV = "0.29.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-url+default-devel \
 rust-gix-url+document-features-devel \
 rust-gix-url+serde-devel \
 rust-gix-url-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-url-0.29.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f6cbae9f17d57f9597b656a4f06e538e61b4485f44616943ea738b31e29a3cd"

URI_x86_64_v2_rust-gix-url+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+default-devel-0.29.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+default-devel}"
SRC_URI[x86_64_v2_rust-gix-url+default-devel.sha256sum] = "6653c37c3f26c4575666a1171c43ae4ac132051a50b1fd16a886ff16530a333a"

URI_x86_64_v2_rust-gix-url+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+document-features-devel-0.29.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-url+document-features-devel.sha256sum] = "bc6de97452690199b167fa2f82a4ffec5d233d2e3956e7fca19abf6dab903497"

URI_x86_64_v2_rust-gix-url+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url+serde-devel-0.29.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-url+serde-devel.sha256sum] = "073fa524681fcd0ebdf55f93ce54be5ad42e1e4f35f158bb1824a8aee80ec3eb"

URI_x86_64_v2_rust-gix-url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-url-devel-0.29.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-url-devel}"
SRC_URI[x86_64_v2_rust-gix-url-devel.sha256sum] = "5b340de872ba16283d3ae40b3c1c9d77747dd884839250da6b61663e8c3bac35"

URI_aarch64_rust-gix-url+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+default-devel-0.29.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+default-devel}"
SRC_URI[aarch64_rust-gix-url+default-devel.sha256sum] = "4a61c0c531cfdb88d705d551fae7dc5b97f8410edfef88ae4978daed8feb7a0f"

URI_aarch64_rust-gix-url+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+document-features-devel-0.29.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-url+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+document-features-devel}"
SRC_URI[aarch64_rust-gix-url+document-features-devel.sha256sum] = "9136c7f9fa860290fd99a3d7575da44265de673fe90ffd6339bf988b1538e582"

URI_aarch64_rust-gix-url+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url+serde-devel-0.29.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url+serde-devel}"
SRC_URI[aarch64_rust-gix-url+serde-devel.sha256sum] = "4596127dc843113a6629962c000c6a9cf8d08fc5047c096438baa4eb637564cf"

URI_aarch64_rust-gix-url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-url-devel-0.29.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-url-devel}"
SRC_URI[aarch64_rust-gix-url-devel.sha256sum] = "0fdc02e362a7f76af5d96991b46a5a5c96f9db4b468b5c2c05a656505863436f"

RDEPENDS:rust-gix-url+default-devel = " \
 cargo \
 rust-gix-url-devel \
 "
RDEPENDS:rust-gix-url+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-url-devel \
 "
RDEPENDS:rust-gix-url+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-url-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-url-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-path+default-devel \
 rust-percent-encoding+default-devel \
 rust-thiserror+default-devel \
 rust-url+default-devel \
 "
