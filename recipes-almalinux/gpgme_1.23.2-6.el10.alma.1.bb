# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpgme"
PV = "1.23.2"
PR = "6.el10.alma.1"
PACKAGES = " \
 gpgme \
 gpgme-devel \
 gpgmepp \
 gpgmepp-devel \
 python3-gpg \
 qgpgme-common-devel \
 qgpgme-qt6 \
 qgpgme-qt6-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gpgme-1.23.2-6.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e93d1c6a7bfcc12a2a91d59dceb15cfa9305d8e9f16f7dbc01d7f90cf0f4ada"

URI_x86_64_v2_gpgme = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gpgme-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gpgme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgme}"
SRC_URI[x86_64_v2_gpgme.sha256sum] = "d76f49b03971411cffd4c42baa5af3ea7e1d55da675fbcfb2e483eeff886336d"

URI_x86_64_v2_gpgme-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gpgme-devel-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gpgme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgme-devel}"
SRC_URI[x86_64_v2_gpgme-devel.sha256sum] = "d2befd24f0b77d134e7dee8941c8b58286adec7370ea049561ac6164e9537fb1"

URI_x86_64_v2_gpgmepp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gpgmepp-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gpgmepp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgmepp}"
SRC_URI[x86_64_v2_gpgmepp.sha256sum] = "3545284869b3f2cac47785c1b589067256fb5515238676378eb87ab4bfe0f26b"

URI_x86_64_v2_gpgmepp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gpgmepp-devel-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gpgmepp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgmepp-devel}"
SRC_URI[x86_64_v2_gpgmepp-devel.sha256sum] = "8fedcc09c9f2b414637969372ba1f05247bfe2da3e7605433009861ae197599a"

URI_x86_64_v2_python3-gpg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-gpg-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-gpg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gpg}"
SRC_URI[x86_64_v2_python3-gpg.sha256sum] = "2e5c4afa35ea573972349ebfd306275ad7d08103c9995e95ffaa730daabe6ad9"

URI_x86_64_v2_qgpgme-common-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qgpgme-common-devel-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qgpgme-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qgpgme-common-devel}"
SRC_URI[x86_64_v2_qgpgme-common-devel.sha256sum] = "d243062645af95c6d47f787b326d4c8036c33251b318994d7e0b5fd3efb716a8"

URI_x86_64_v2_qgpgme-qt6 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qgpgme-qt6-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qgpgme-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qgpgme-qt6}"
SRC_URI[x86_64_v2_qgpgme-qt6.sha256sum] = "2db8b3772055e3d5e15151b6b31f8074cefa5daa06ca58e9a6e8d96a22fc424e"

URI_x86_64_v2_qgpgme-qt6-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qgpgme-qt6-devel-1.23.2-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qgpgme-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qgpgme-qt6-devel}"
SRC_URI[x86_64_v2_qgpgme-qt6-devel.sha256sum] = "710cce68af3aebb088af502b9af8223b4669c129fd6f5cb9cc744530c4b716f4"

URI_aarch64_gpgme = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gpgme-1.23.2-6.el10.alma.1.aarch64.rpm;name=aarch64_gpgme;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgme}"
SRC_URI[aarch64_gpgme.sha256sum] = "74c55c153c0ab2aac64de3facbe213733c554fff183c107824c554b946213e98"

URI_aarch64_gpgme-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gpgme-devel-1.23.2-6.el10.alma.1.aarch64.rpm;name=aarch64_gpgme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgme-devel}"
SRC_URI[aarch64_gpgme-devel.sha256sum] = "32f325d37a866a1b8c96a4c57c6ff7921b34c01a87aa8a80f7588e3383743fd3"

URI_aarch64_gpgmepp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gpgmepp-1.23.2-6.el10.alma.1.aarch64.rpm;name=aarch64_gpgmepp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgmepp}"
SRC_URI[aarch64_gpgmepp.sha256sum] = "baea46848b049273cf7e84c120ed7640f05469f44e7eda66bd2b19e76d054b55"

URI_aarch64_gpgmepp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gpgmepp-devel-1.23.2-6.el10.alma.1.aarch64.rpm;name=aarch64_gpgmepp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgmepp-devel}"
SRC_URI[aarch64_gpgmepp-devel.sha256sum] = "cc35e4714f12c7b1ddcd8ae9b3eb45009ca22fa6321c45d4e2789796137b1942"

URI_aarch64_python3-gpg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-gpg-1.23.2-6.el10.alma.1.aarch64.rpm;name=aarch64_python3-gpg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gpg}"
SRC_URI[aarch64_python3-gpg.sha256sum] = "97e17d5f32f8a8944cef0fd2c16967272a78a23c63304e7459adaa414e8571b1"

URI_aarch64_qgpgme-common-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qgpgme-common-devel-1.23.2-6.el10.alma.1.aarch64.rpm;name=aarch64_qgpgme-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qgpgme-common-devel}"
SRC_URI[aarch64_qgpgme-common-devel.sha256sum] = "9a3a738c30e83a9d84d2a118c7fc60b9a909b061d302a01f9689afaae489f1dd"

URI_aarch64_qgpgme-qt6 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qgpgme-qt6-1.23.2-6.el10.alma.1.aarch64.rpm;name=aarch64_qgpgme-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qgpgme-qt6}"
SRC_URI[aarch64_qgpgme-qt6.sha256sum] = "403c77843a02cecdcb5e940d381482b6bcaf4948dc6c12093e0958e505d5d117"

URI_aarch64_qgpgme-qt6-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qgpgme-qt6-devel-1.23.2-6.el10.alma.1.aarch64.rpm;name=aarch64_qgpgme-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qgpgme-qt6-devel}"
SRC_URI[aarch64_qgpgme-qt6-devel.sha256sum] = "173b9c6ee8cccf45a6ab66011bea7e089b530e6a2b36db03f9c84f90d9f215dd"

RDEPENDS:gpgme = " \
 glibc \
 gnupg2 \
 libassuan \
 libgpg-error \
 "
RDEPENDS:gpgme-devel = " \
 bash \
 glib2-devel \
 glibc \
 gpgme \
 libassuan \
 libassuan-devel \
 libgpg-error \
 libgpg-error-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gpgmepp = " \
 glibc \
 gpgme \
 libassuan \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gpgmepp-devel = " \
 cmake-filesystem \
 gpgme-devel \
 gpgmepp \
 "
RDEPENDS:python3-gpg = " \
 glibc \
 gpgme \
 python3 \
 "
RDEPENDS:qgpgme-common-devel = " \
 gpgmepp-devel \
 "
RDEPENDS:qgpgme-qt6 = " \
 glibc \
 gpgme \
 gpgmepp \
 libassuan \
 libgcc \
 libgpg-error \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qgpgme-qt6-devel = " \
 cmake-filesystem \
 qgpgme-common-devel \
 qgpgme-qt6 \
 "
