# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ytree"
PV = "2.13"
PR = "1.el10_2"
PACKAGES = " \
 ytree \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/y/ytree-2.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91d9e524b1055da73ec65c9eea76dfc9d92b591889a8dce04b792ffcec0d4bc5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ytree-2.13-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ytree;unpack=0"
SRC_URI[x86_64_v2_ytree.sha256sum] = "c93d62a7b394150aed1a1a056680a581cc924071b423c239236c02a2261ecae8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/ytree-2.13-1.el10_2.aarch64.rpm;name=aarch64_ytree;unpack=0"
SRC_URI[aarch64_ytree.sha256sum] = "469eaddde0434ff65a76ba19c9cc49ccc435e6d316f73ed71869f6b1b891e984"

RDEPENDS:ytree = " \
 glibc \
 ncurses-libs \
 readline \
 "
