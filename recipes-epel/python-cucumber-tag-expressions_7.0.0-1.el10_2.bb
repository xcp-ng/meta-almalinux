# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cucumber-tag-expressions"
PV = "7.0.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-cucumber-tag-expressions \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cucumber-tag-expressions-7.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e007435a131b71912e0aade46db8cfcc036288630c7b57af9fef446d24870d8"

URI_x86_64_v2_python3-cucumber-tag-expressions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cucumber-tag-expressions-7.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cucumber-tag-expressions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cucumber-tag-expressions}"
SRC_URI[x86_64_v2_python3-cucumber-tag-expressions.sha256sum] = "6ea25d7da28184e7b989b64caf0bb8a8f3acc9b663c18ba809e1b05a6a36ebb3"

URI_aarch64_python3-cucumber-tag-expressions = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cucumber-tag-expressions-7.0.0-1.el10_2.noarch.rpm;name=aarch64_python3-cucumber-tag-expressions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cucumber-tag-expressions}"
SRC_URI[aarch64_python3-cucumber-tag-expressions.sha256sum] = "78847b70d4eb89708db428deb7b9662d57ba4de21124826f146067ae83065024"

RDEPENDS:python3-cucumber-tag-expressions = " \
 python3 \
 "
