# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-publicsuffix"
PV = "2.3.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-publicsuffix+anycase-devel \
 rust-publicsuffix+default-devel \
 rust-publicsuffix+hashbrown-devel \
 rust-publicsuffix+idna-devel \
 rust-publicsuffix+punycode-devel \
 rust-publicsuffix+std-devel \
 rust-publicsuffix+unicase-devel \
 rust-publicsuffix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-publicsuffix-2.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "698f1e7611c0824af730f4d95821391ac250805edf9b631397a25a1375298b45"

URI_x86_64_v2_rust-publicsuffix+anycase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+anycase-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+anycase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+anycase-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+anycase-devel.sha256sum] = "5b10188b935073a0ba0dc2ca08bccbd6940fdfb7544822f4fab62108bc63bd71"

URI_x86_64_v2_rust-publicsuffix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+default-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+default-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+default-devel.sha256sum] = "a73a1f67335101bf437840f60c7e815ac04caae5c4e21d83429f5be9e8e98b28"

URI_x86_64_v2_rust-publicsuffix+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+hashbrown-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+hashbrown-devel.sha256sum] = "ca939d6ed6b43ce167151d434e0942c414f36d024d7d22ce7ea7786777d668ac"

URI_x86_64_v2_rust-publicsuffix+idna-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+idna-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+idna-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+idna-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+idna-devel.sha256sum] = "676ff678e38a8eea29e25a90e3af1294d53a3a7a5aad2de18f7420002814ed0f"

URI_x86_64_v2_rust-publicsuffix+punycode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+punycode-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+punycode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+punycode-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+punycode-devel.sha256sum] = "419fd7ff35b6854c62227619cfc96d31e4e6d28f2f8741c8a596df2561d4a904"

URI_x86_64_v2_rust-publicsuffix+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+std-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+std-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+std-devel.sha256sum] = "242cf19b99b011d037deebfdd69e0c5c24f9412853ba82c255fbef5e70683661"

URI_x86_64_v2_rust-publicsuffix+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+unicase-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+unicase-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+unicase-devel.sha256sum] = "9c03ccfd647d46b4c325e526a595d5ec9ccfe33c70783746159e9e143c8444c1"

URI_x86_64_v2_rust-publicsuffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix-devel-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix-devel.sha256sum] = "366fae12c9f118619c77167acbee2f93b49824c3e126deef7ec387ecd7c882b4"

URI_aarch64_rust-publicsuffix+anycase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+anycase-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-publicsuffix+anycase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+anycase-devel}"
SRC_URI[aarch64_rust-publicsuffix+anycase-devel.sha256sum] = "956de7b5e456248b3cf70715a5505a1731d390ed12a8e3b217332b68490dc842"

URI_aarch64_rust-publicsuffix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+default-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-publicsuffix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+default-devel}"
SRC_URI[aarch64_rust-publicsuffix+default-devel.sha256sum] = "18f2d376cde63032d558f3aecad77b7a221360eb6d67a7c07171a80a503653c2"

URI_aarch64_rust-publicsuffix+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+hashbrown-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-publicsuffix+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+hashbrown-devel}"
SRC_URI[aarch64_rust-publicsuffix+hashbrown-devel.sha256sum] = "8b14a3a67657dc2d206263759b7fcbc2fc0810dc36714c15807f59c31de509bf"

URI_aarch64_rust-publicsuffix+idna-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+idna-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-publicsuffix+idna-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+idna-devel}"
SRC_URI[aarch64_rust-publicsuffix+idna-devel.sha256sum] = "a1e7767f59cea4feb66fbb59f59346b1cab49cf3e1573d430e3a6d7858a73a23"

URI_aarch64_rust-publicsuffix+punycode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+punycode-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-publicsuffix+punycode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+punycode-devel}"
SRC_URI[aarch64_rust-publicsuffix+punycode-devel.sha256sum] = "44d53e21dbc436cd875934284dee68f29961efdfdcc2634690f448b6dcbd337c"

URI_aarch64_rust-publicsuffix+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+std-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-publicsuffix+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+std-devel}"
SRC_URI[aarch64_rust-publicsuffix+std-devel.sha256sum] = "e440b32b4cfac7530b0c73e2f4bbf4e495294e5b375a2a74afda4820942d75a7"

URI_aarch64_rust-publicsuffix+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+unicase-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-publicsuffix+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+unicase-devel}"
SRC_URI[aarch64_rust-publicsuffix+unicase-devel.sha256sum] = "5b62b50f3a85ac66da54383c2314d2a07757799638751ea0324e279811d16afd"

URI_aarch64_rust-publicsuffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix-devel-2.3.0-1.el10_1.noarch.rpm;name=aarch64_rust-publicsuffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix-devel}"
SRC_URI[aarch64_rust-publicsuffix-devel.sha256sum] = "014d76b5fdb7f5e3255a0f6be4c5c9112adb9d37657d25ed47054f056e3d4ecf"

RDEPENDS:rust-publicsuffix+anycase-devel = " \
 cargo \
 rust-publicsuffix+unicase-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+default-devel = " \
 cargo \
 rust-publicsuffix+punycode-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+hashbrown-devel = " \
 cargo \
 rust-hashbrown+default-devel \
 rust-hashbrown+inline-more-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+idna-devel = " \
 cargo \
 rust-idna+default-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+punycode-devel = " \
 cargo \
 rust-publicsuffix+idna-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+std-devel = " \
 cargo \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+unicase-devel = " \
 cargo \
 rust-publicsuffix-devel \
 rust-unicase-devel \
 "
RDEPENDS:rust-publicsuffix-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
