# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_cmd"
PV = "2.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-assert_cmd+color-auto-devel \
 rust-assert_cmd+color-devel \
 rust-assert_cmd+default-devel \
 rust-assert_cmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_cmd-2.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d4c91585a8baa5e7a16e5f845040cbe062c9d536fc240e287a67f5eba1ef0b9"

URI_x86_64_v2_rust-assert_cmd+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+color-auto-devel-2.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+color-auto-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+color-auto-devel.sha256sum] = "792d935a3393d215f7787583288ca54e075469d05a1a22f1401bbd9a99b1d25b"

URI_x86_64_v2_rust-assert_cmd+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+color-devel-2.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+color-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+color-devel.sha256sum] = "a04a8cb53f7e3c38005cc5a71087a819907a8e5c880057bdb92f7ffedc9d307b"

URI_x86_64_v2_rust-assert_cmd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+default-devel-2.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+default-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+default-devel.sha256sum] = "ac2e1f5e7c21188d550761a45bd0dc8f1e73c1f98f70f636c3a5c95cd0073f8c"

URI_x86_64_v2_rust-assert_cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd-devel-2.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd-devel.sha256sum] = "fdb07383cc3b922fba6269c95612049eed0a8edd2f1cab48a9b845cc3bc06673"

URI_aarch64_rust-assert_cmd+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+color-auto-devel-2.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-assert_cmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+color-auto-devel}"
SRC_URI[aarch64_rust-assert_cmd+color-auto-devel.sha256sum] = "8d26e85803fe0c38a7483010eb3abe171c07dc88079d754357f123a91ec46fb8"

URI_aarch64_rust-assert_cmd+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+color-devel-2.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-assert_cmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+color-devel}"
SRC_URI[aarch64_rust-assert_cmd+color-devel.sha256sum] = "796cc52ea474c016ba52070b8ac1087e3e42c4ee86faa9bdc6896ed72e845fa7"

URI_aarch64_rust-assert_cmd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+default-devel-2.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-assert_cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+default-devel}"
SRC_URI[aarch64_rust-assert_cmd+default-devel.sha256sum] = "26ef25e8bdfdb8043614eb26d3788820c2a87fb4fca717afea22d8643a50dc0c"

URI_aarch64_rust-assert_cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd-devel-2.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-assert_cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd-devel}"
SRC_URI[aarch64_rust-assert_cmd-devel.sha256sum] = "7908c08cca5a91d5696474c2991564e84d54d7ae346fd98d57ed5077e8276362"

RDEPENDS:rust-assert_cmd+color-auto-devel = " \
 cargo \
 rust-assert_cmd+color-devel \
 rust-assert_cmd-devel \
 "
RDEPENDS:rust-assert_cmd+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-assert_cmd-devel \
 rust-predicates+color-devel \
 "
RDEPENDS:rust-assert_cmd+default-devel = " \
 cargo \
 rust-assert_cmd-devel \
 "
RDEPENDS:rust-assert_cmd-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-bstr+default-devel \
 rust-libc+default-devel \
 rust-predicates+diff-devel \
 rust-predicates-core+default-devel \
 rust-predicates-devel \
 rust-predicates-tree+default-devel \
 rust-wait-timeout+default-devel \
 "
