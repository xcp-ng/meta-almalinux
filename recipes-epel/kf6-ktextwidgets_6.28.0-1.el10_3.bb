# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktextwidgets"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ktextwidgets \
 kf6-ktextwidgets-devel \
 kf6-ktextwidgets-doc \
 kf6-ktextwidgets-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktextwidgets-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cf19ff6f6705865bc21a1b63c0fd5ce4837a3d4f19f5945a88c6349aca7d1bb"

URI_x86_64_v2_kf6-ktextwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktextwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets}"
SRC_URI[x86_64_v2_kf6-ktextwidgets.sha256sum] = "0a249f42b1fe59feab4cd3b380135f39b6d78bfc0e0e650e4a3533ff0c12a6d2"

URI_x86_64_v2_kf6-ktextwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktextwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets-devel}"
SRC_URI[x86_64_v2_kf6-ktextwidgets-devel.sha256sum] = "89a6965cd17459442ba2d03721fa6953a4d45787733f0ba702b91659a2ddd036"

URI_x86_64_v2_kf6-ktextwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktextwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets-doc}"
SRC_URI[x86_64_v2_kf6-ktextwidgets-doc.sha256sum] = "1a4fb4ac59953db30beeeb268e55327ec2dae94edea0dcf635e0d3b055555320"

URI_x86_64_v2_kf6-ktextwidgets-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktextwidgets-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktextwidgets-html}"
SRC_URI[x86_64_v2_kf6-ktextwidgets-html.sha256sum] = "9c6bb5cc9472085a736b40678e2505ede42b7d2cb1c31d83fbbd8a94a267a074"

URI_aarch64_kf6-ktextwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktextwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets}"
SRC_URI[aarch64_kf6-ktextwidgets.sha256sum] = "b2655c50a37cb90af3849622edb41bea085916c1a1811e3523c80bff5d5723e8"

URI_aarch64_kf6-ktextwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktextwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets-devel}"
SRC_URI[aarch64_kf6-ktextwidgets-devel.sha256sum] = "0e4e3a3481edf1042ef9b77434ae7ea7593abe38bd22e621abfa087892846794"

URI_aarch64_kf6-ktextwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktextwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets-doc}"
SRC_URI[aarch64_kf6-ktextwidgets-doc.sha256sum] = "bb570854001b0eab235f2e3f85f03b5c7dba893e0e77fb1a9a3bd091d9ce0b7b"

URI_aarch64_kf6-ktextwidgets-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktextwidgets-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktextwidgets-html}"
SRC_URI[aarch64_kf6-ktextwidgets-html.sha256sum] = "f1141ca93a2d218bbe2afdeb4ff8b535060cb22a7c8b32fd413b7842008bbc61"

RDEPENDS:kf6-ktextwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
RDEPENDS:kf6-ktextwidgets-devel = " \
 cmake-filesystem \
 glibc \
 kf6-ki18n-devel \
 kf6-ktextwidgets \
 kf6-sonnet-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-ktextwidgets-doc = " \
 "
RDEPENDS:kf6-ktextwidgets-html = " \
 "
