# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Filter"
PE = "2"
PV = "1.64"
PR = "512.el10"
PACKAGES = " \
 perl-Filter \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Filter-1.64-512.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ac9529411ae68946f6e217e1d9d442c6621aa5f4cb1f740bc13247560a35aa6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Filter-1.64-512.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Filter;unpack=0"
SRC_URI[x86_64_v2_perl-Filter.sha256sum] = "00f923cefe98f515a9a26cb9d55b11c33c081c2247d6d0102dfefe719fc8e764"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Filter-1.64-512.el10.aarch64.rpm;name=aarch64_perl-Filter;unpack=0"
SRC_URI[aarch64_perl-Filter.sha256sum] = "73d8913854f208ae5d2ca93a7eb987373b453388e3353aae0858aa380a8938d1"

RDEPENDS:perl-Filter = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Filter \
 perl-libs \
 "
