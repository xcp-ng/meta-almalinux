# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms"
PV = "2.1.3"
PR = "1.el10_1"
PACKAGES = " \
 voms \
 voms-clients-cpp \
 voms-devel \
 voms-doc \
 voms-server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/voms-2.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00b14bfb5e18c679b265010538ebec416fee91e36eebff4df3a473675ffedeea"

URI_x86_64_v2_voms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-2.1.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms}"
SRC_URI[x86_64_v2_voms.sha256sum] = "d5ee429ea703c94596d466f3f2e188feb8f8903e97ff5aee1ecb7fa6290b07bc"

URI_x86_64_v2_voms-clients-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-clients-cpp-2.1.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-clients-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-clients-cpp}"
SRC_URI[x86_64_v2_voms-clients-cpp.sha256sum] = "13525f2162acf281480d8af1db4dec59b79530c40cd63bc5630e04c9fcd9fb45"
RPROVIDES:voms-clients-cpp:append:x86_64_v2 = " virtual/voms-clients"

URI_x86_64_v2_voms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-devel-2.1.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-devel}"
SRC_URI[x86_64_v2_voms-devel.sha256sum] = "a53b8d1d3f269508caa05562970b4f1fc9fcd3998af43db459457336ca1eecf7"

URI_x86_64_v2_voms-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-doc-2.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_voms-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-doc}"
SRC_URI[x86_64_v2_voms-doc.sha256sum] = "9e37b7004857ebbaa8590a1e52cf5ae618fac9d8989513a306989dc278074094"

URI_x86_64_v2_voms-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-server-2.1.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-server}"
SRC_URI[x86_64_v2_voms-server.sha256sum] = "b9114036d62c417fdcb5c0805cb93de40d546b44fd58905e049eb6eb5f9cec64"

URI_aarch64_voms = "${EPEL_MIRROR}/aarch64/Packages/v/voms-2.1.3-1.el10_1.aarch64.rpm;name=aarch64_voms;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms}"
SRC_URI[aarch64_voms.sha256sum] = "02da9091a5fc4a3f149ab310f6be67cfd9c72f72e25c3951e708bbd00f13dac6"

URI_aarch64_voms-clients-cpp = "${EPEL_MIRROR}/aarch64/Packages/v/voms-clients-cpp-2.1.3-1.el10_1.aarch64.rpm;name=aarch64_voms-clients-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-clients-cpp}"
SRC_URI[aarch64_voms-clients-cpp.sha256sum] = "0b9923cdbcb4c604af9d3d556b20906cb10c0ece65fb1ddc6788cec39bdab4fa"
RPROVIDES:voms-clients-cpp:append:aarch64 = " virtual/voms-clients"

URI_aarch64_voms-devel = "${EPEL_MIRROR}/aarch64/Packages/v/voms-devel-2.1.3-1.el10_1.aarch64.rpm;name=aarch64_voms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-devel}"
SRC_URI[aarch64_voms-devel.sha256sum] = "db95aa3107ca9d9b5a1a40c0f8ce76584affeee1f1755e96d3eeeb1267039b7f"

URI_aarch64_voms-doc = "${EPEL_MIRROR}/aarch64/Packages/v/voms-doc-2.1.3-1.el10_1.noarch.rpm;name=aarch64_voms-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-doc}"
SRC_URI[aarch64_voms-doc.sha256sum] = "454fc1f8a1605e47ea8f676eb93b2857e9747198ab2b67428268f072ff4e2d7d"

URI_aarch64_voms-server = "${EPEL_MIRROR}/aarch64/Packages/v/voms-server-2.1.3-1.el10_1.aarch64.rpm;name=aarch64_voms-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-server}"
SRC_URI[aarch64_voms-server.sha256sum] = "be02ffa53b863fa66fece01ce071728e9b410d2994ef3b8cab58c3b9c1f3cd3a"

RDEPENDS:voms = " \
 bash \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:voms-clients-cpp = " \
 alternatives \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 voms \
 "
RDEPENDS:voms-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 voms \
 "
RDEPENDS:voms-doc = " \
 "
RDEPENDS:voms-server = " \
 bash \
 expat \
 glibc \
 gsoap \
 libgcc \
 libstdc++ \
 openssl-libs \
 shadow-utils \
 systemd \
 voms \
 "
