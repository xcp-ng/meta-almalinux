# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "OpenTimelineIO"
PV = "0.17.0"
PR = "5.el10_2"
PACKAGES = " \
 OpenTimelineIO \
 OpenTimelineIO-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/OpenTimelineIO-0.17.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a4b214258a5c78a21e758cb2007730843fbe8da957a858db248b85a9f2d3954"

URI_x86_64_v2_OpenTimelineIO = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/OpenTimelineIO-0.17.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_OpenTimelineIO;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_OpenTimelineIO}"
SRC_URI[x86_64_v2_OpenTimelineIO.sha256sum] = "8e895cf96e44e219f6ff444d460c5d2e0ea3937bd7755cebe07baaf46907d50d"

URI_x86_64_v2_OpenTimelineIO-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/OpenTimelineIO-devel-0.17.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_OpenTimelineIO-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_OpenTimelineIO-devel}"
SRC_URI[x86_64_v2_OpenTimelineIO-devel.sha256sum] = "d6fbb2012c1c3fbf79ad48a6c344be26850b12ca48a5dd3682d7366e33a77f6e"

URI_aarch64_OpenTimelineIO = "${EPEL_MIRROR}/aarch64/Packages/o/OpenTimelineIO-0.17.0-5.el10_2.aarch64.rpm;name=aarch64_OpenTimelineIO;unpack=0"
SRC_URI:append = " ${URI_aarch64_OpenTimelineIO}"
SRC_URI[aarch64_OpenTimelineIO.sha256sum] = "0c9070d200d296b692b1e6322afa546f1c0378a3bc7b8c0d7b0e33efd7a5cf0a"

URI_aarch64_OpenTimelineIO-devel = "${EPEL_MIRROR}/aarch64/Packages/o/OpenTimelineIO-devel-0.17.0-5.el10_2.aarch64.rpm;name=aarch64_OpenTimelineIO-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_OpenTimelineIO-devel}"
SRC_URI[aarch64_OpenTimelineIO-devel.sha256sum] = "e03ad49a6bb065de89740c9835016fc772bdc07d14bd40794386e243c958bc4f"

RDEPENDS:OpenTimelineIO = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:OpenTimelineIO-devel = " \
 OpenTimelineIO \
 cmake-filesystem \
 imath-devel \
 "
