# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fluent-bit"
PV = "3.2.8"
PR = "2.el10_0"
PACKAGES = " \
 fluent-bit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fluent-bit-3.2.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d41b79a6b6d09075e5594f32fd6a633b7223bafa830590e10f64945f73e46603"

URI_x86_64_v2_fluent-bit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fluent-bit-3.2.8-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fluent-bit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fluent-bit}"
SRC_URI[x86_64_v2_fluent-bit.sha256sum] = "cab60b7a6355d6ff526bd50c9425e22081d052db0669bc486a6ed7da0a57ba01"

URI_aarch64_fluent-bit = "${EPEL_MIRROR}/aarch64/Packages/f/fluent-bit-3.2.8-2.el10_0.aarch64.rpm;name=aarch64_fluent-bit;unpack=0"
SRC_URI:append = " ${URI_aarch64_fluent-bit}"
SRC_URI[aarch64_fluent-bit.sha256sum] = "aed21140b8286311b8b8bc2ce3549bee84b6713ed39d022368d4206867b4fc74"

RDEPENDS:fluent-bit = " \
 bash \
 cyrus-sasl-lib \
 glibc \
 libgcc \
 libyaml \
 libzstd \
 openssl-libs \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
