# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-editables"
PV = "0.5"
PR = "7.el10_0"
PACKAGES = " \
 python3-editables \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-editables-0.5-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d9f54df5621c4043aa11e82d0f27f6f879272966a2157f1f95d882da2e3b4c2"

URI_x86_64_v2_python3-editables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-editables-0.5-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-editables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-editables}"
SRC_URI[x86_64_v2_python3-editables.sha256sum] = "0d2d4f4552a554a5778a50635401e3fd6e4b5b32b5ff61429bcf93d53a1b3558"

URI_aarch64_python3-editables = "${EPEL_MIRROR}/aarch64/Packages/p/python3-editables-0.5-7.el10_0.noarch.rpm;name=aarch64_python3-editables;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-editables}"
SRC_URI[aarch64_python3-editables.sha256sum] = "dacd56a67e492ba3084bf7d5fbd60c1311d0d23acdb4154a9c5b4db2a7117a43"

RDEPENDS:python3-editables = " \
 python3 \
 "
