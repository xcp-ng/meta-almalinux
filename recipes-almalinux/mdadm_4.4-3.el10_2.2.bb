# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mdadm"
PV = "4.4"
PR = "3.el10_2.2"
PACKAGES = " \
 mdadm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mdadm-4.4-3.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "845c308d4fa04d103ad44734d1967d8c28b5d85311b2f557609365b956af0618"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mdadm-4.4-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_mdadm;unpack=0"
SRC_URI[x86_64_v2_mdadm.sha256sum] = "4b515e286200f1f54c1f7de693ca5b5e52f353d479c778f50988a027830de1cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mdadm-4.4-3.el10_2.2.aarch64.rpm;name=aarch64_mdadm;unpack=0"
SRC_URI[aarch64_mdadm.sha256sum] = "b977160f5c01ee513d08b82f69e204faccf94462c876c3f85133f5ad6ffb5663"

RDEPENDS:mdadm = " \
 bash \
 glibc \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
