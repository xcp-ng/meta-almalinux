# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix"
PV = "0.73.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix+async-network-client-async-std-devel \
 rust-gix+async-network-client-devel \
 rust-gix+async-std-devel \
 rust-gix+attributes-devel \
 rust-gix+basic-devel \
 rust-gix+blame-devel \
 rust-gix+blob-diff-devel \
 rust-gix+blocking-http-transport-curl-devel \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix+blocking-http-transport-reqwest-native-tls-devel \
 rust-gix+blocking-http-transport-reqwest-rust-tls-devel \
 rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel \
 rust-gix+blocking-network-client-devel \
 rust-gix+cache-efficiency-debug-devel \
 rust-gix+comfort-devel \
 rust-gix+command-devel \
 rust-gix+credentials-devel \
 rust-gix+default-devel \
 rust-gix+dirwalk-devel \
 rust-gix+document-features-devel \
 rust-gix+excludes-devel \
 rust-gix+extras-devel \
 rust-gix+gix-archive-devel \
 rust-gix+gix-status-devel \
 rust-gix+gix-worktree-stream-devel \
 rust-gix+hp-tempfile-registry-devel \
 rust-gix+index-devel \
 rust-gix+interrupt-devel \
 rust-gix+mailmap-devel \
 rust-gix+max-control-devel \
 rust-gix+max-performance-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix+merge-devel \
 rust-gix+need-more-recent-msrv-devel \
 rust-gix+pack-cache-lru-dynamic-devel \
 rust-gix+pack-cache-lru-static-devel \
 rust-gix+parallel-devel \
 rust-gix+prodash-devel \
 rust-gix+progress-tree-devel \
 rust-gix+regex-devel \
 rust-gix+revision-devel \
 rust-gix+revparse-regex-devel \
 rust-gix+serde-devel \
 rust-gix+status-devel \
 rust-gix+tracing-detail-devel \
 rust-gix+tracing-devel \
 rust-gix+tree-editor-devel \
 rust-gix+verbose-object-parsing-errors-devel \
 rust-gix+worktree-archive-devel \
 rust-gix+worktree-mutation-devel \
 rust-gix+worktree-stream-devel \
 rust-gix+zlib-ng-devel \
 rust-gix+zlib-rs-devel \
 rust-gix+zlib-stock-devel \
 rust-gix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-0.73.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d6145638c399308e262545229278eef0e80a0ce1f06865c35bb771675882b07"

URI_x86_64_v2_rust-gix+async-network-client-async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-network-client-async-std-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-network-client-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-network-client-async-std-devel}"
SRC_URI[x86_64_v2_rust-gix+async-network-client-async-std-devel.sha256sum] = "8e6c9712c02d396a1d7d0095904c6dc72c844ef00500f3d1343209cf17e553e2"

URI_x86_64_v2_rust-gix+async-network-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-network-client-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-network-client-devel}"
SRC_URI[x86_64_v2_rust-gix+async-network-client-devel.sha256sum] = "2dff6864beb956232b7659944fe504e48efa0ff15544ed19477eeb3878e95426"

URI_x86_64_v2_rust-gix+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-std-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-std-devel}"
SRC_URI[x86_64_v2_rust-gix+async-std-devel.sha256sum] = "44e2e1ffb9735a53f8e1eb8ac8c0757b76af8b72ecdd3acafccc1f6aa81efa6e"

URI_x86_64_v2_rust-gix+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+attributes-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+attributes-devel}"
SRC_URI[x86_64_v2_rust-gix+attributes-devel.sha256sum] = "0e76b0e30a38aa736e5e4e0e7005869559c6d37b27b5e1575b504cf11c4876e3"

URI_x86_64_v2_rust-gix+basic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+basic-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+basic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+basic-devel}"
SRC_URI[x86_64_v2_rust-gix+basic-devel.sha256sum] = "79e21aed5915f79129d8e1750e909d1679f4fd205d454fbf7d53bba514441e8d"

URI_x86_64_v2_rust-gix+blame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blame-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blame-devel}"
SRC_URI[x86_64_v2_rust-gix+blame-devel.sha256sum] = "4e2ab27886e4d38264c876e3aa65c35b53f21cdb25b031fce0376bf9deab5664"

URI_x86_64_v2_rust-gix+blob-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blob-diff-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blob-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blob-diff-devel}"
SRC_URI[x86_64_v2_rust-gix+blob-diff-devel.sha256sum] = "145aa5123c70662ea78e024cca39a8c197981edfbd7d5d2b7585c374bca1f3e7"

URI_x86_64_v2_rust-gix+blocking-http-transport-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-curl-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-curl-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-curl-devel.sha256sum] = "ce25a436fca7fde08e6532762b9799c4749404a11a0b8b8637ece544d3433a7c"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel.sha256sum] = "9368336cc24fb976e0855a1c298c90aee33d09925c9644092b7838ec0b7fc825"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-native-tls-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel.sha256sum] = "b39cac9129cb4eb163fc9f99af2829ad4c5709be69162781bf8eb58f4281262e"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-rust-tls-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel.sha256sum] = "792c82e00c279aa0577bc43109ba61b726997dcff0a762e5f0de49454b5f8e0a"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel.sha256sum] = "168b4f486ee283ec6683e61aa0676dc8d3ed0d560cb5ccadf3fd3d91ef17129c"

URI_x86_64_v2_rust-gix+blocking-network-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-network-client-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-network-client-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-network-client-devel.sha256sum] = "3871102a6a4c726cbe114f57559205ee146650922078d3c2acc95e2c1aaf44d4"

URI_x86_64_v2_rust-gix+cache-efficiency-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+cache-efficiency-debug-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+cache-efficiency-debug-devel}"
SRC_URI[x86_64_v2_rust-gix+cache-efficiency-debug-devel.sha256sum] = "634d49fe1b20a0bf6831b03236df55d0dadd2c3e61c0ade0db95a87ed7552db2"

URI_x86_64_v2_rust-gix+comfort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+comfort-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+comfort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+comfort-devel}"
SRC_URI[x86_64_v2_rust-gix+comfort-devel.sha256sum] = "e2a041d3f84a30cfc150fd14a4bbc761c71747e0aa26e0c0f888beb6928dbc66"

URI_x86_64_v2_rust-gix+command-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+command-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+command-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+command-devel}"
SRC_URI[x86_64_v2_rust-gix+command-devel.sha256sum] = "f8a6f2bda05349cdca2d75e32d9f3a7552bcd8db3253bfb07174664fc2391b06"

URI_x86_64_v2_rust-gix+credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+credentials-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+credentials-devel}"
SRC_URI[x86_64_v2_rust-gix+credentials-devel.sha256sum] = "93824265de5984bd49b53c6ebf12986dbed434cc577628fc122c1b0b4d775847"

URI_x86_64_v2_rust-gix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+default-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+default-devel}"
SRC_URI[x86_64_v2_rust-gix+default-devel.sha256sum] = "705dc33de70fd2a78a2943fc705ccafc56e5c244f587c53d0a4800e2d4563adf"

URI_x86_64_v2_rust-gix+dirwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+dirwalk-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+dirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+dirwalk-devel}"
SRC_URI[x86_64_v2_rust-gix+dirwalk-devel.sha256sum] = "e479b04277604ee188c5609323868a1e1ac64fa57d4dfffe1835abc109c53bd7"

URI_x86_64_v2_rust-gix+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+document-features-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix+document-features-devel.sha256sum] = "ff5b8fe62d39094c7217d327e741789d3445d3b411bcc19597975adc0ee8e0de"

URI_x86_64_v2_rust-gix+excludes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+excludes-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+excludes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+excludes-devel}"
SRC_URI[x86_64_v2_rust-gix+excludes-devel.sha256sum] = "85ebc95d3f44b9c0ca456d30ac289c6b19345b5906b63d04b78471e11df56f31"

URI_x86_64_v2_rust-gix+extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+extras-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+extras-devel}"
SRC_URI[x86_64_v2_rust-gix+extras-devel.sha256sum] = "47153aa975b3fd6ef13ac5f9d1e4356cc0b116b8593d59498eb6531494c55455"

URI_x86_64_v2_rust-gix+gix-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-archive-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-archive-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-archive-devel.sha256sum] = "24f1f0302286fc3fd0b2b0aafc0a7a2c13573eb1e8db7c5a2872c5c00d51bcf4"

URI_x86_64_v2_rust-gix+gix-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-status-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-status-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-status-devel.sha256sum] = "fa5ce175523cb7aa9d5bef70777fdea25741d8a20f37cf0302231b611a8cb2fd"

URI_x86_64_v2_rust-gix+gix-worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-worktree-stream-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-worktree-stream-devel.sha256sum] = "07feedbb4a6f22b396243ddaa23766a4a9e3a795dd2517e3e919eae526fc5554"

URI_x86_64_v2_rust-gix+hp-tempfile-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+hp-tempfile-registry-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+hp-tempfile-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+hp-tempfile-registry-devel}"
SRC_URI[x86_64_v2_rust-gix+hp-tempfile-registry-devel.sha256sum] = "4a4a456eff10040b2627dbb18948ab5be2cb4bcab3312056ad697a37b0c93d79"

URI_x86_64_v2_rust-gix+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+index-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+index-devel}"
SRC_URI[x86_64_v2_rust-gix+index-devel.sha256sum] = "c8836042b9b737b45afd936bb843bfa2187afb239a739ff96876d36957d0b474"

URI_x86_64_v2_rust-gix+interrupt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+interrupt-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+interrupt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+interrupt-devel}"
SRC_URI[x86_64_v2_rust-gix+interrupt-devel.sha256sum] = "24839bbe39ec9a87bc3bb70947003667309e0f64ff26b47635e30d2ba218b007"

URI_x86_64_v2_rust-gix+mailmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+mailmap-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+mailmap-devel}"
SRC_URI[x86_64_v2_rust-gix+mailmap-devel.sha256sum] = "51a12092de2d0bc704a9eb00c4a966b396e0eccca49d36069be8a853ee2b5dad"

URI_x86_64_v2_rust-gix+max-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-control-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-control-devel}"
SRC_URI[x86_64_v2_rust-gix+max-control-devel.sha256sum] = "aaea7a8a7efa2a519b242a495f28cb137e953f7eb4fab78e13d111fe67b20584"

URI_x86_64_v2_rust-gix+max-performance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-performance-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-performance-devel}"
SRC_URI[x86_64_v2_rust-gix+max-performance-devel.sha256sum] = "f8e51777ada0a67d076dafb3ebd8d8dd63aef5620caf384ac7e632ff58557ac7"

URI_x86_64_v2_rust-gix+max-performance-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-performance-safe-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-performance-safe-devel}"
SRC_URI[x86_64_v2_rust-gix+max-performance-safe-devel.sha256sum] = "909f197617ec69637cc9e1a9ed2a81cf8a3786ba00086c8ead2fdd4389ced9e2"

URI_x86_64_v2_rust-gix+merge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+merge-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+merge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+merge-devel}"
SRC_URI[x86_64_v2_rust-gix+merge-devel.sha256sum] = "2278523fc59fff6781a9807bd328e066edceb74850fd9cf7aaa68c4ac8ee5a29"

URI_x86_64_v2_rust-gix+need-more-recent-msrv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+need-more-recent-msrv-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+need-more-recent-msrv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+need-more-recent-msrv-devel}"
SRC_URI[x86_64_v2_rust-gix+need-more-recent-msrv-devel.sha256sum] = "24726ddadb725c29ce6026b77aa2e1d294a1791ade962bb6d563084f19f0a2b7"

URI_x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+pack-cache-lru-dynamic-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel.sha256sum] = "1dc57735d64b1fa2316a4c4350fb882b4f740152a436cf0ae052cd94858b572d"

URI_x86_64_v2_rust-gix+pack-cache-lru-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+pack-cache-lru-static-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+pack-cache-lru-static-devel}"
SRC_URI[x86_64_v2_rust-gix+pack-cache-lru-static-devel.sha256sum] = "d92dee95a7652450fde83cde5f31b8e7d9f1dda9abd70c4f65b65815d3dd429f"

URI_x86_64_v2_rust-gix+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+parallel-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix+parallel-devel.sha256sum] = "0208d8062c66263182e53b45a942ea0ee1da5f7265a1fe7b0d659789be3c8680"

URI_x86_64_v2_rust-gix+prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+prodash-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+prodash-devel}"
SRC_URI[x86_64_v2_rust-gix+prodash-devel.sha256sum] = "2fb49c8e2e93fc2efce55e7d5ebc7618b48e9fdd446639a38f1c979489dd5276"

URI_x86_64_v2_rust-gix+progress-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+progress-tree-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+progress-tree-devel}"
SRC_URI[x86_64_v2_rust-gix+progress-tree-devel.sha256sum] = "7f75673894c2e8c2b9d68b1113b1fdf1fd949d3ac7179ade3845bcd7dd59b41d"

URI_x86_64_v2_rust-gix+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+regex-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+regex-devel}"
SRC_URI[x86_64_v2_rust-gix+regex-devel.sha256sum] = "85c13adbe1fa04552c17de5c6a146c9f3ccf1c6bfd036dadc8a83edab4301b8b"

URI_x86_64_v2_rust-gix+revision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+revision-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+revision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+revision-devel}"
SRC_URI[x86_64_v2_rust-gix+revision-devel.sha256sum] = "3404d2e40cd0752827d09d61035d113e52cc389c776ab64d927e235b4443d196"

URI_x86_64_v2_rust-gix+revparse-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+revparse-regex-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+revparse-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+revparse-regex-devel}"
SRC_URI[x86_64_v2_rust-gix+revparse-regex-devel.sha256sum] = "a97ea39c664c99f185ce2c7dea53a4e442dd45530142d1b21d8d96aac6b4e1a4"

URI_x86_64_v2_rust-gix+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+serde-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+serde-devel}"
SRC_URI[x86_64_v2_rust-gix+serde-devel.sha256sum] = "ec5523043ab3399e25a44eaa1c4d94cc21113b7f5877e8a845e6744ad2cbfc11"

URI_x86_64_v2_rust-gix+status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+status-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+status-devel}"
SRC_URI[x86_64_v2_rust-gix+status-devel.sha256sum] = "150c738e2def24ed9388a406cd35bbe7e39fd1f2f93e3982c4adddbcb12acd0f"

URI_x86_64_v2_rust-gix+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tracing-detail-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix+tracing-detail-devel.sha256sum] = "1d6f0ba8eadb425957384ca237190afae598c331a0da8933292f0ff74846f5b6"

URI_x86_64_v2_rust-gix+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tracing-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix+tracing-devel.sha256sum] = "55fb3f1a25ee0d0e3080575b6273f44bcb694e9bcee91b1f2cf0cc0542b7076f"

URI_x86_64_v2_rust-gix+tree-editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tree-editor-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tree-editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tree-editor-devel}"
SRC_URI[x86_64_v2_rust-gix+tree-editor-devel.sha256sum] = "51cad60518bf46ea1f3e9c58a20c33f4a1b323d68a9be592042ffe4d0d843460"

URI_x86_64_v2_rust-gix+verbose-object-parsing-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+verbose-object-parsing-errors-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+verbose-object-parsing-errors-devel}"
SRC_URI[x86_64_v2_rust-gix+verbose-object-parsing-errors-devel.sha256sum] = "973fb94bf137405c1f7476ba30e53a320fc823791e53e7a90522e7db74abf3ee"

URI_x86_64_v2_rust-gix+worktree-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-archive-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-archive-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-archive-devel.sha256sum] = "8b58fadbe6f7e66adcf9848b35925dd5c1734143dfbfc57235beba50ed4e6fd7"

URI_x86_64_v2_rust-gix+worktree-mutation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-mutation-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-mutation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-mutation-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-mutation-devel.sha256sum] = "abad1a1cbf3f9a971484a91cc938f4ffa8e0f6f77fb6d29d379b3c6dbe5da4d7"

URI_x86_64_v2_rust-gix+worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-stream-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-stream-devel.sha256sum] = "b332e28b34f0cbc0028722518f26ebd856fbfdca970fc617f806320cb9a8ac39"

URI_x86_64_v2_rust-gix+zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-ng-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-ng-devel.sha256sum] = "d2eb582f0f60c82dd40be95e1a17a3b9ddff0c9a739774cc2cf1948477bfbc95"

URI_x86_64_v2_rust-gix+zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-rs-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-rs-devel.sha256sum] = "8d203f7012cf785bc6849d5a8424e41079cb9ddc77724253830b40db497baaeb"

URI_x86_64_v2_rust-gix+zlib-stock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-stock-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-stock-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-stock-devel.sha256sum] = "4c29a2793d7281d98e0761b5dbe427a45cc8d8d3af994a31aef864724ba6b662"

URI_x86_64_v2_rust-gix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-devel-0.73.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-devel}"
SRC_URI[x86_64_v2_rust-gix-devel.sha256sum] = "9395e15ac339312062e0eb527d3267d4e0ef7135e99706ba60950c19832873ae"

URI_aarch64_rust-gix+async-network-client-async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-network-client-async-std-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+async-network-client-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-network-client-async-std-devel}"
SRC_URI[aarch64_rust-gix+async-network-client-async-std-devel.sha256sum] = "333664addb66faca289a64a2a90e19ff7689d5bc560b15b8d310bf6551bc67e3"

URI_aarch64_rust-gix+async-network-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-network-client-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+async-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-network-client-devel}"
SRC_URI[aarch64_rust-gix+async-network-client-devel.sha256sum] = "a1d98c857abb0a50560181728ad9f2e13ab1fb278bbae2aac7e3eb7942c78cd2"

URI_aarch64_rust-gix+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-std-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-std-devel}"
SRC_URI[aarch64_rust-gix+async-std-devel.sha256sum] = "d0a2ba3479272e8a4ea16fb300ff9b5048362c8ff583aca6b33864a20f6157c2"

URI_aarch64_rust-gix+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+attributes-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+attributes-devel}"
SRC_URI[aarch64_rust-gix+attributes-devel.sha256sum] = "cdbe70f8cfe9c6d25608aafda4f652a5be9c76237d39f0f4c0c5bf6d5855a84c"

URI_aarch64_rust-gix+basic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+basic-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+basic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+basic-devel}"
SRC_URI[aarch64_rust-gix+basic-devel.sha256sum] = "169b1ef1c73b2ac4116c8b7f0e12b2092c762dff6832b66ef420631893ee483f"

URI_aarch64_rust-gix+blame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blame-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+blame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blame-devel}"
SRC_URI[aarch64_rust-gix+blame-devel.sha256sum] = "a3fc0bfd7dc4f646b2aac4a6d3e870e3b19189359df12a6798d3f72436e6e0ce"

URI_aarch64_rust-gix+blob-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blob-diff-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+blob-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blob-diff-devel}"
SRC_URI[aarch64_rust-gix+blob-diff-devel.sha256sum] = "2b8637f6cb9c6951b914150023d0230a14a3cc68f130a8652de6da4aae632d3f"

URI_aarch64_rust-gix+blocking-http-transport-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-curl-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-curl-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-curl-devel.sha256sum] = "314302c5cb8cc981456a85dbf9ba41b9eecf6e232731d0cd04547d3c075cfb28"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-devel.sha256sum] = "a4754f87517f9ad9891b0fbdd8ea9118f04ae6d23c3095138e8812e79f1c56f9"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-native-tls-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel.sha256sum] = "43a884aa2c68426b61f1e1dacd03e2bc7126985b781391e12bc3e28c215180bd"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-rust-tls-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel.sha256sum] = "4d8e1df236f1c963fcff0a1f1753f44eba4f3777526a32ad8d373599bcfd862c"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel.sha256sum] = "1f568ae0a92904ab72574c2d536f3b0db39385ef47495c705d4522197821b4c4"

URI_aarch64_rust-gix+blocking-network-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-network-client-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+blocking-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-network-client-devel}"
SRC_URI[aarch64_rust-gix+blocking-network-client-devel.sha256sum] = "2b2dad612450b0661c5e0554b34fc7e86fc13035803566765e2be7e0f9b26f7f"

URI_aarch64_rust-gix+cache-efficiency-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+cache-efficiency-debug-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+cache-efficiency-debug-devel}"
SRC_URI[aarch64_rust-gix+cache-efficiency-debug-devel.sha256sum] = "1ac6e75b17e687a1a40f92e718879d6bf0492a443e5816104ea6b1ac7e7c2fc0"

URI_aarch64_rust-gix+comfort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+comfort-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+comfort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+comfort-devel}"
SRC_URI[aarch64_rust-gix+comfort-devel.sha256sum] = "492b1ce6f8068356e14e39913b5694b6f9e03df0432e4f4ec92ca6c4b6b1a408"

URI_aarch64_rust-gix+command-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+command-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+command-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+command-devel}"
SRC_URI[aarch64_rust-gix+command-devel.sha256sum] = "6ee3706fb72d9f87732979161786167656a5929b120240570156c233aeee5605"

URI_aarch64_rust-gix+credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+credentials-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+credentials-devel}"
SRC_URI[aarch64_rust-gix+credentials-devel.sha256sum] = "28f99979e8a804768cc56a736aa66e6d4541bac7083f8c0ad0bc02a4b023cef7"

URI_aarch64_rust-gix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+default-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+default-devel}"
SRC_URI[aarch64_rust-gix+default-devel.sha256sum] = "2a7e9111d5f287f03ef2d1332f13727608eab05a6a699f3a3d5f5b4f8a60aa13"

URI_aarch64_rust-gix+dirwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+dirwalk-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+dirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+dirwalk-devel}"
SRC_URI[aarch64_rust-gix+dirwalk-devel.sha256sum] = "b20d3253140ca061027463470a3922cdff8e7edc9693475f7968cfd4258ac377"

URI_aarch64_rust-gix+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+document-features-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+document-features-devel}"
SRC_URI[aarch64_rust-gix+document-features-devel.sha256sum] = "086aef0e89a1486cb6cdf8689030da0063b751a55ea03fcedc210c96e8e5cec8"

URI_aarch64_rust-gix+excludes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+excludes-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+excludes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+excludes-devel}"
SRC_URI[aarch64_rust-gix+excludes-devel.sha256sum] = "9a12aa5e8b730196c6447c4d7d13bd5cb7fbc6fb5fc929a6871c260adacbe7b3"

URI_aarch64_rust-gix+extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+extras-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+extras-devel}"
SRC_URI[aarch64_rust-gix+extras-devel.sha256sum] = "a2fbd63ffdc707b68f387e718a7d7ac50fd5a7d457cecbf524cbc1a988931bba"

URI_aarch64_rust-gix+gix-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-archive-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-archive-devel}"
SRC_URI[aarch64_rust-gix+gix-archive-devel.sha256sum] = "079c6e8800f6c10b32dc636324390937f118cb42f08eb76cbf82a5608604ded0"

URI_aarch64_rust-gix+gix-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-status-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-status-devel}"
SRC_URI[aarch64_rust-gix+gix-status-devel.sha256sum] = "735724ff14b5157cfce24a446679ed316311d2c98af66803a75afdb6d1179bea"

URI_aarch64_rust-gix+gix-worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-worktree-stream-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-worktree-stream-devel}"
SRC_URI[aarch64_rust-gix+gix-worktree-stream-devel.sha256sum] = "9852f147520defe5bd68b44c9c9a9dd67c2031fda9989cf20fe6e54bfd02dfa3"

URI_aarch64_rust-gix+hp-tempfile-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+hp-tempfile-registry-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+hp-tempfile-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+hp-tempfile-registry-devel}"
SRC_URI[aarch64_rust-gix+hp-tempfile-registry-devel.sha256sum] = "3d51cbc3ca798763532ee1fb482701b577a0a4673f6afebea33f602c4d5d0255"

URI_aarch64_rust-gix+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+index-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+index-devel}"
SRC_URI[aarch64_rust-gix+index-devel.sha256sum] = "fff85cbd82c6ab9b5e729114c02aefd3bc8926c6c1e28958d96c7ac6959a8a0c"

URI_aarch64_rust-gix+interrupt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+interrupt-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+interrupt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+interrupt-devel}"
SRC_URI[aarch64_rust-gix+interrupt-devel.sha256sum] = "2d4e359ed0d77a31781beedda040376c5a86b7ce37302b4d0bbc555cb51ed670"

URI_aarch64_rust-gix+mailmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+mailmap-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+mailmap-devel}"
SRC_URI[aarch64_rust-gix+mailmap-devel.sha256sum] = "864b8f51eacf69cb40b96553f9b8f90389fbbb7334af68138b69a47bb78be5fc"

URI_aarch64_rust-gix+max-control-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-control-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+max-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-control-devel}"
SRC_URI[aarch64_rust-gix+max-control-devel.sha256sum] = "bfdfe0d9b56eb36357978dd772f7a23d929bb6b078992869b353dfc66843fe06"

URI_aarch64_rust-gix+max-performance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-performance-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-performance-devel}"
SRC_URI[aarch64_rust-gix+max-performance-devel.sha256sum] = "0416d26d3def77338dfa9a529e737a5907f57ddd8b55adc1c6ceb7e367dc0afb"

URI_aarch64_rust-gix+max-performance-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-performance-safe-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-performance-safe-devel}"
SRC_URI[aarch64_rust-gix+max-performance-safe-devel.sha256sum] = "9d473ae708bd36fa7abdcc5613a5679574be2a93a7c01b9926b42a4e778f71c9"

URI_aarch64_rust-gix+merge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+merge-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+merge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+merge-devel}"
SRC_URI[aarch64_rust-gix+merge-devel.sha256sum] = "049b26079df16bbd33f5062a575e0be24b9631c6e79c162f5a63defa45d0a99d"

URI_aarch64_rust-gix+need-more-recent-msrv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+need-more-recent-msrv-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+need-more-recent-msrv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+need-more-recent-msrv-devel}"
SRC_URI[aarch64_rust-gix+need-more-recent-msrv-devel.sha256sum] = "7005f5790370bd3da67932444e8ca8fba44455c758ed54a019c91d508a01ce9e"

URI_aarch64_rust-gix+pack-cache-lru-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+pack-cache-lru-dynamic-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+pack-cache-lru-dynamic-devel}"
SRC_URI[aarch64_rust-gix+pack-cache-lru-dynamic-devel.sha256sum] = "0e810b716a88998479bc1041d4bd6c5256d43fbf0dede877d5a883cfe1f9618d"

URI_aarch64_rust-gix+pack-cache-lru-static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+pack-cache-lru-static-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+pack-cache-lru-static-devel}"
SRC_URI[aarch64_rust-gix+pack-cache-lru-static-devel.sha256sum] = "3beaa893a66f2fd93d35f1e09192fe46404da660b68cd6fca408ee9d14db733b"

URI_aarch64_rust-gix+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+parallel-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+parallel-devel}"
SRC_URI[aarch64_rust-gix+parallel-devel.sha256sum] = "1820493df475a39820bc050722d8e1e83c984e23c2534981ae7254c3d85c893c"

URI_aarch64_rust-gix+prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+prodash-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+prodash-devel}"
SRC_URI[aarch64_rust-gix+prodash-devel.sha256sum] = "02d8cda4b2ff94120c880c67f11a59120972862bd8f2ee856358f4a51449fe15"

URI_aarch64_rust-gix+progress-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+progress-tree-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+progress-tree-devel}"
SRC_URI[aarch64_rust-gix+progress-tree-devel.sha256sum] = "9674ac0a757be2d4673a88afd9af5b0b447e8c6369fccaee6f35b13ce27be5e9"

URI_aarch64_rust-gix+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+regex-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+regex-devel}"
SRC_URI[aarch64_rust-gix+regex-devel.sha256sum] = "ef824cb63a759c6a3f8d24db08b0d255215936fb75f237c54c3eae75aaabcfcb"

URI_aarch64_rust-gix+revision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+revision-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+revision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+revision-devel}"
SRC_URI[aarch64_rust-gix+revision-devel.sha256sum] = "42197b0af09696166976b1a2c38f5a0297eca3b48667fafaedf2d82e1c9bae9b"

URI_aarch64_rust-gix+revparse-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+revparse-regex-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+revparse-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+revparse-regex-devel}"
SRC_URI[aarch64_rust-gix+revparse-regex-devel.sha256sum] = "cb306ee164b3e036716e6206d1038425d18c3161b6ea2fb9729443f1f3db0cac"

URI_aarch64_rust-gix+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+serde-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+serde-devel}"
SRC_URI[aarch64_rust-gix+serde-devel.sha256sum] = "99ae092307e0906362082570807fbbd468c88c8743927b480a75301b7a7b91f2"

URI_aarch64_rust-gix+status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+status-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+status-devel}"
SRC_URI[aarch64_rust-gix+status-devel.sha256sum] = "da2c2d07293aa70bbe717f2b15f8601746c4d7e6f482053b9c8ec86d9f00eedb"

URI_aarch64_rust-gix+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tracing-detail-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix+tracing-detail-devel.sha256sum] = "a7597bf3200f3a020f95070d9c11f706ff17dd230ec13c1a1e418d660c83d989"

URI_aarch64_rust-gix+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tracing-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tracing-devel}"
SRC_URI[aarch64_rust-gix+tracing-devel.sha256sum] = "490fc165e21f6797b50788217aff12bd338f46449066f9f3e6a8f06a2e2af894"

URI_aarch64_rust-gix+tree-editor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tree-editor-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+tree-editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tree-editor-devel}"
SRC_URI[aarch64_rust-gix+tree-editor-devel.sha256sum] = "c50641682bb33339bff68e46dd78b6bde26287dfd82b67b2300a43a63ea448d7"

URI_aarch64_rust-gix+verbose-object-parsing-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+verbose-object-parsing-errors-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+verbose-object-parsing-errors-devel}"
SRC_URI[aarch64_rust-gix+verbose-object-parsing-errors-devel.sha256sum] = "11668ea7369094e0d8082099d644905d0bcbf3ad57aac81c35c278aa257a4089"

URI_aarch64_rust-gix+worktree-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-archive-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+worktree-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-archive-devel}"
SRC_URI[aarch64_rust-gix+worktree-archive-devel.sha256sum] = "1e15ded448c25a41107864d1aa9af3d073cb7d78dee48b7c98645a2947020681"

URI_aarch64_rust-gix+worktree-mutation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-mutation-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+worktree-mutation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-mutation-devel}"
SRC_URI[aarch64_rust-gix+worktree-mutation-devel.sha256sum] = "7d96197e1413533c2575a5eb6a1dcf3c1ebe8661937f23dfba6fd33243ee0714"

URI_aarch64_rust-gix+worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-stream-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-stream-devel}"
SRC_URI[aarch64_rust-gix+worktree-stream-devel.sha256sum] = "60c83a812eba986a9c7b555c572ed32b5197d858562ac2b39d206fa77a8734ae"

URI_aarch64_rust-gix+zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-ng-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-ng-devel}"
SRC_URI[aarch64_rust-gix+zlib-ng-devel.sha256sum] = "d7acd3796f409e74e3c34f0d6fd183764cc1f92d648fb28d5221c011a20499d0"

URI_aarch64_rust-gix+zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-rs-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-rs-devel}"
SRC_URI[aarch64_rust-gix+zlib-rs-devel.sha256sum] = "4bbfb5280ffffc22adc4e6c53ce2dd9d0c8708308148a741390f9ae70f6242d3"

URI_aarch64_rust-gix+zlib-stock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-stock-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-stock-devel}"
SRC_URI[aarch64_rust-gix+zlib-stock-devel.sha256sum] = "df1cd8389058dcad177b161b3d3ab1d2dc51954e35b232c12f31a0ebdcaef620"

URI_aarch64_rust-gix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-devel-0.73.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-devel}"
SRC_URI[aarch64_rust-gix-devel.sha256sum] = "c416136f2b01896c9239b5a5da84c05819cf67aa84dfdbf3d25b4eed335bde59"

RDEPENDS:rust-gix+async-network-client-async-std-devel = " \
 cargo \
 rust-gix+async-network-client-devel \
 rust-gix+async-std-devel \
 rust-gix-devel \
 rust-gix-transport+async-std-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+async-network-client-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-protocol+async-client-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+attributes-devel = " \
 cargo \
 rust-gix+command-devel \
 rust-gix+excludes-devel \
 rust-gix-attributes+default-devel \
 rust-gix-devel \
 rust-gix-filter+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-submodule+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix+basic-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix+index-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+blame-devel = " \
 cargo \
 rust-gix-blame+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+blob-diff-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix-devel \
 rust-gix-diff+blob-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-curl-devel = " \
 cargo \
 rust-gix+blocking-network-client-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-curl-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-devel = " \
 cargo \
 rust-gix+blocking-network-client-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-native-tls-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-native-tls-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-rust-tls-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel \
 "
RDEPENDS:rust-gix+blocking-network-client-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-protocol+blocking-client-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+cache-efficiency-debug-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+cache-efficiency-debug-devel \
 "
RDEPENDS:rust-gix+comfort-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+progress-unit-bytes-devel \
 rust-gix-features+progress-unit-human-numbers-devel \
 "
RDEPENDS:rust-gix+command-devel = " \
 cargo \
 rust-gix-command+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+credentials-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-devel \
 rust-gix-negotiate+default-devel \
 rust-gix-prompt+default-devel \
 "
RDEPENDS:rust-gix+default-devel = " \
 cargo \
 rust-gix+basic-devel \
 rust-gix+comfort-devel \
 rust-gix+extras-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+dirwalk-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+excludes-devel \
 rust-gix-devel \
 rust-gix-dir+default-devel \
 "
RDEPENDS:rust-gix+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+excludes-devel = " \
 cargo \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-ignore+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix+extras-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix+dirwalk-devel \
 rust-gix+excludes-devel \
 rust-gix+interrupt-devel \
 rust-gix+mailmap-devel \
 rust-gix+revparse-regex-devel \
 rust-gix+status-devel \
 rust-gix+worktree-archive-devel \
 rust-gix+worktree-mutation-devel \
 rust-gix+worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+gix-archive-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+gix-status-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-status+default-devel \
 rust-gix-status+worktree-rewrites-devel \
 "
RDEPENDS:rust-gix+gix-worktree-stream-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-worktree-stream+default-devel \
 "
RDEPENDS:rust-gix+hp-tempfile-registry-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-tempfile+hp-hashmap-devel \
 "
RDEPENDS:rust-gix+index-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-index+default-devel \
 "
RDEPENDS:rust-gix+interrupt-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-tempfile+signals-devel \
 rust-parking_lot+default-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-gix+mailmap-devel = " \
 cargo \
 rust-gix+revision-devel \
 rust-gix-devel \
 rust-gix-mailmap+default-devel \
 "
RDEPENDS:rust-gix+max-control-devel = " \
 cargo \
 rust-gix+pack-cache-lru-dynamic-devel \
 rust-gix+pack-cache-lru-static-devel \
 rust-gix+parallel-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+max-performance-devel = " \
 cargo \
 rust-gix+max-control-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+max-performance-safe-devel = " \
 cargo \
 rust-gix+max-control-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+merge-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+blob-diff-devel \
 rust-gix+tree-editor-devel \
 rust-gix-devel \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix+need-more-recent-msrv-devel = " \
 cargo \
 rust-gix+merge-devel \
 rust-gix+tree-editor-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+pack-cache-lru-dynamic-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-pack+pack-cache-lru-dynamic-devel \
 "
RDEPENDS:rust-gix+pack-cache-lru-static-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-pack+pack-cache-lru-static-devel \
 "
RDEPENDS:rust-gix+parallel-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+parallel-devel \
 "
RDEPENDS:rust-gix+prodash-devel = " \
 cargo \
 rust-gix-devel \
 rust-prodash+default-devel \
 rust-prodash+progress-tree-devel \
 "
RDEPENDS:rust-gix+progress-tree-devel = " \
 cargo \
 rust-gix-devel \
 rust-prodash+default-devel \
 rust-prodash+progress-tree-devel \
 "
RDEPENDS:rust-gix+regex-devel = " \
 cargo \
 rust-gix-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-gix+revision-devel = " \
 cargo \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-revision+describe-devel \
 rust-gix-revision+merge_base-devel \
 "
RDEPENDS:rust-gix+revparse-regex-devel = " \
 cargo \
 rust-gix+regex-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+serde-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-commitgraph+serde-devel \
 rust-gix-credentials+default-devel \
 rust-gix-credentials+serde-devel \
 rust-gix-devel \
 rust-gix-ignore+default-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-index+default-devel \
 rust-gix-index+serde-devel \
 rust-gix-mailmap+default-devel \
 rust-gix-mailmap+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-odb+serde-devel \
 rust-gix-pack+serde-devel \
 rust-gix-protocol+serde-devel \
 rust-gix-ref+serde-devel \
 rust-gix-revision+serde-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+serde-devel \
 rust-gix-url+serde-devel \
 rust-gix-worktree+serde-devel \
 rust-gix-worktree-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix+status-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix+dirwalk-devel \
 rust-gix+gix-status-devel \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-diff+index-devel \
 "
RDEPENDS:rust-gix+tracing-detail-devel = " \
 cargo \
 rust-gix+tracing-devel \
 rust-gix-devel \
 rust-gix-features+tracing-detail-devel \
 "
RDEPENDS:rust-gix+tracing-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+tracing-devel \
 "
RDEPENDS:rust-gix+tree-editor-devel = " \
 cargo \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+verbose-object-parsing-errors-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-object+verbose-object-parsing-errors-devel \
 "
RDEPENDS:rust-gix+worktree-archive-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+gix-archive-devel \
 rust-gix+worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+worktree-mutation-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix-devel \
 rust-gix-worktree-state+default-devel \
 "
RDEPENDS:rust-gix+worktree-stream-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+gix-worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+zlib-ng-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-devel \
 "
RDEPENDS:rust-gix+zlib-rs-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-devel \
 "
RDEPENDS:rust-gix+zlib-stock-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-devel \
 "
RDEPENDS:rust-gix-devel = " \
 bash \
 cargo \
 rust \
 rust-gix-actor+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-config+default-devel \
 rust-gix-date+default-devel \
 rust-gix-diff-devel \
 rust-gix-discover+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+once_cell-devel \
 rust-gix-features+progress-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-odb+default-devel \
 rust-gix-pack+object-cache-dynamic-devel \
 rust-gix-pack-devel \
 rust-gix-path+default-devel \
 rust-gix-protocol+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-refspec+default-devel \
 rust-gix-revision-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-shallow+default-devel \
 rust-gix-tempfile-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-url+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-once_cell+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
