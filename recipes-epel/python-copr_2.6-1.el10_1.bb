# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-copr"
PV = "2.6"
PR = "1.el10_1"
PACKAGES = " \
 python-copr-doc \
 python3-copr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-copr-2.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa3c2a79622cc531ea252a410c55a5c9b386bd627f6bddc939e0f0467709c751"

URI_x86_64_v2_python-copr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-copr-doc-2.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-copr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-copr-doc}"
SRC_URI[x86_64_v2_python-copr-doc.sha256sum] = "3bcde553bb8f6c311c2c78af0e847f0457c3205089f594c2c9e8e1176b54ac7d"

URI_x86_64_v2_python3-copr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-copr-2.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-copr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-copr}"
SRC_URI[x86_64_v2_python3-copr.sha256sum] = "8e74bfcfa4ac817931a022e29232edd5183f123d47a93a55462192bc4036e4cf"

URI_aarch64_python-copr-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-copr-doc-2.6-1.el10_1.noarch.rpm;name=aarch64_python-copr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-copr-doc}"
SRC_URI[aarch64_python-copr-doc.sha256sum] = "ed63e77fb59320b11b5ac27adaaa5bae5ba9b33a583063b29471ac0e11444c77"

URI_aarch64_python3-copr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-copr-2.6-1.el10_1.noarch.rpm;name=aarch64_python3-copr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-copr}"
SRC_URI[aarch64_python3-copr.sha256sum] = "98453e6c13fedf5353e9fbe988db74f719310b8aaa63d782e0e09b7d2b912823"

RDEPENDS:python-copr-doc = " \
 "
RDEPENDS:python3-copr = " \
 python3 \
 python3-filelock \
 python3-munch \
 python3-requests \
 python3-requests-gssapi \
 python3-requests-toolbelt \
 python3-setuptools \
 "
