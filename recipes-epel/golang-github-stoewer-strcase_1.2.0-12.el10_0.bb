# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-stoewer-strcase"
PV = "1.2.0"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-stoewer-strcase-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-stoewer-strcase-1.2.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "548fd7ba63f619ddc6d5a778044b3eb1cc52a373423f7f9ef4d8165a20c37053"

URI_x86_64_v2_golang-github-stoewer-strcase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-stoewer-strcase-devel-1.2.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-stoewer-strcase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-stoewer-strcase-devel}"
SRC_URI[x86_64_v2_golang-github-stoewer-strcase-devel.sha256sum] = "ac1e082645d50e3fc946a03469e993298d6e4c3434443ab9e8847b42d58fa580"

URI_aarch64_golang-github-stoewer-strcase-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-stoewer-strcase-devel-1.2.0-12.el10_0.noarch.rpm;name=aarch64_golang-github-stoewer-strcase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-stoewer-strcase-devel}"
SRC_URI[aarch64_golang-github-stoewer-strcase-devel.sha256sum] = "257fcb18638069d30cd3909e97e4bef2198202066ca521f7ba3d88d13faf3247"

RDEPENDS:golang-github-stoewer-strcase-devel = " \
 go-filesystem \
 "
