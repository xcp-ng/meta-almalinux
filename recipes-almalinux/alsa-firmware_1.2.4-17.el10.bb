# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-firmware"
PV = "1.2.4"
PR = "17.el10"
PACKAGES = " \
 alsa-firmware \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-firmware-1.2.4-17.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ae1413204dad815555b615bcbd07a8d8dd4cc9afde675e9e3454d894b97289d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-firmware-1.2.4-17.el10.noarch.rpm;name=x86_64_v2_alsa-firmware;unpack=0"
SRC_URI[x86_64_v2_alsa-firmware.sha256sum] = "f14924ab61ece7fbb75af81e86707430eea7dbd2ba37d62bb50e0ef3370ecfbd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-firmware-1.2.4-17.el10.noarch.rpm;name=aarch64_alsa-firmware;unpack=0"
SRC_URI[aarch64_alsa-firmware.sha256sum] = "f14924ab61ece7fbb75af81e86707430eea7dbd2ba37d62bb50e0ef3370ecfbd"

RDEPENDS:alsa-firmware = " \
 alsa-tools-firmware \
 systemd \
 "
