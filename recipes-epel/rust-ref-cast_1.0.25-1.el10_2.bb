# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ref-cast"
PV = "1.0.25"
PR = "1.el10_2"
PACKAGES = " \
 rust-ref-cast+default-devel \
 rust-ref-cast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ref-cast-1.0.25-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd310f50c3e3e9a15f476083da6a354a78fae77e0c117fba84b139e7d33b1d25"

URI_x86_64_v2_rust-ref-cast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast+default-devel-1.0.25-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast+default-devel}"
SRC_URI[x86_64_v2_rust-ref-cast+default-devel.sha256sum] = "4f95016c0d887323d6f2fc6bdea8bb732d245624af66f0331b0563bd57436f08"

URI_x86_64_v2_rust-ref-cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-devel-1.0.25-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast-devel}"
SRC_URI[x86_64_v2_rust-ref-cast-devel.sha256sum] = "800a6e743bcd76ebb23f5d152bf1ddf732cd96dcb57155bdec08693c9cd13c9d"

URI_aarch64_rust-ref-cast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast+default-devel-1.0.25-1.el10_2.noarch.rpm;name=aarch64_rust-ref-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast+default-devel}"
SRC_URI[aarch64_rust-ref-cast+default-devel.sha256sum] = "552f7e8e2337c1a015879f6bfe1512179302642fb17c7c7cf8470a7b68176201"

URI_aarch64_rust-ref-cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-devel-1.0.25-1.el10_2.noarch.rpm;name=aarch64_rust-ref-cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast-devel}"
SRC_URI[aarch64_rust-ref-cast-devel.sha256sum] = "752a808d3c777c49b76f202410c4ee55a74eb1511d13b2eef0651f471d2ee690"

RDEPENDS:rust-ref-cast+default-devel = " \
 cargo \
 rust-ref-cast-devel \
 "
RDEPENDS:rust-ref-cast-devel = " \
 cargo \
 rust \
 rust-ref-cast-impl+default-devel \
 "
