# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enumflags2_derive"
PV = "0.7.12"
PR = "2.el10_2"
PACKAGES = " \
 rust-enumflags2_derive+default-devel \
 rust-enumflags2_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enumflags2_derive-0.7.12-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b79b25fe1d2dfd1d664c2fe273eda334644a5046f1963244731f7cc35be7ae3"

URI_x86_64_v2_rust-enumflags2_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumflags2_derive+default-devel-0.7.12-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumflags2_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumflags2_derive+default-devel}"
SRC_URI[x86_64_v2_rust-enumflags2_derive+default-devel.sha256sum] = "87f7050247cdcb928d0b10ae18bd1fc1ab638c8a137b2b751b17109ca6d075c0"

URI_x86_64_v2_rust-enumflags2_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumflags2_derive-devel-0.7.12-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumflags2_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumflags2_derive-devel}"
SRC_URI[x86_64_v2_rust-enumflags2_derive-devel.sha256sum] = "3d3ba64a5c48cc2d7adb55b32bbc9734dca7d46ce982c8490973b34c8cda59cd"

URI_aarch64_rust-enumflags2_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumflags2_derive+default-devel-0.7.12-2.el10_2.noarch.rpm;name=aarch64_rust-enumflags2_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumflags2_derive+default-devel}"
SRC_URI[aarch64_rust-enumflags2_derive+default-devel.sha256sum] = "2a04c0549f08edf95869f2e959b312329cf8df3f6b0934e47300f1e836ec924a"

URI_aarch64_rust-enumflags2_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumflags2_derive-devel-0.7.12-2.el10_2.noarch.rpm;name=aarch64_rust-enumflags2_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumflags2_derive-devel}"
SRC_URI[aarch64_rust-enumflags2_derive-devel.sha256sum] = "6e905e9e8d39295506a2d45ea397e71b7ea0d41898676f2211602aa1c7510af2"

RDEPENDS:rust-enumflags2_derive+default-devel = " \
 cargo \
 rust-enumflags2_derive-devel \
 "
RDEPENDS:rust-enumflags2_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
