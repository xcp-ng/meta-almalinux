# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-protocol"
PV = "13.6"
PR = "5.el10_0"
PACKAGES = " \
 globus-gram-protocol \
 globus-gram-protocol-devel \
 globus-gram-protocol-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-protocol-13.6-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27ded4031c721ccb1d8fe0bd264db0bff837690b191d44a6f095e174e9e572b7"

URI_x86_64_v2_globus-gram-protocol = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-protocol-13.6-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-protocol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-protocol}"
SRC_URI[x86_64_v2_globus-gram-protocol.sha256sum] = "0460622b1587cadfc34039341b058e7621d954a6c23d8c3d56eec2863f781509"

URI_x86_64_v2_globus-gram-protocol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-protocol-devel-13.6-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-protocol-devel}"
SRC_URI[x86_64_v2_globus-gram-protocol-devel.sha256sum] = "20e47eca3e6ed33a7990527ba71b910ee0b4cd543fc7f979b84c4d174f633510"

URI_x86_64_v2_globus-gram-protocol-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-protocol-doc-13.6-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-protocol-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-protocol-doc}"
SRC_URI[x86_64_v2_globus-gram-protocol-doc.sha256sum] = "99928418eca65ffa3c30f92ddd9a059cfd4df8cb3c4ef6980b14a1ac385daaca"

URI_aarch64_globus-gram-protocol = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-protocol-13.6-5.el10_0.aarch64.rpm;name=aarch64_globus-gram-protocol;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-protocol}"
SRC_URI[aarch64_globus-gram-protocol.sha256sum] = "00a19c67ff6e47637e43a6fcf722a3a7d645bfecb0272a8ca37a7df64e903aab"

URI_aarch64_globus-gram-protocol-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-protocol-devel-13.6-5.el10_0.aarch64.rpm;name=aarch64_globus-gram-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-protocol-devel}"
SRC_URI[aarch64_globus-gram-protocol-devel.sha256sum] = "a20ce777a9493bbd98659daa776702a6bee272ea3f02afe26ecb4d21c779bee9"

URI_aarch64_globus-gram-protocol-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-protocol-doc-13.6-5.el10_0.noarch.rpm;name=aarch64_globus-gram-protocol-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-protocol-doc}"
SRC_URI[aarch64_globus-gram-protocol-doc.sha256sum] = "458173726de303d5aaf5cf3c7c003c1dc1781705fe80f95247b002f1bfa3ce2c"

RDEPENDS:globus-gram-protocol = " \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-io \
 perl-libs \
 "
RDEPENDS:globus-gram-protocol-devel = " \
 globus-common-devel \
 globus-gram-protocol \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 globus-io-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gram-protocol-doc = " \
 "
