# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stockfish"
PV = "18"
PR = "1.el10_2"
PACKAGES = " \
 stockfish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stockfish-18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c507c1e2f4a895ce550d7c913da870296591a814fae1dde0f21452ed50ee065"

URI_x86_64_v2_stockfish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stockfish-18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stockfish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stockfish}"
SRC_URI[x86_64_v2_stockfish.sha256sum] = "efe9e4fb803ed2ddd89db4d6f32e77caffd57067e3176e90d6af0b202f5d2e0a"

URI_aarch64_stockfish = "${EPEL_MIRROR}/aarch64/Packages/s/stockfish-18-1.el10_2.aarch64.rpm;name=aarch64_stockfish;unpack=0"
SRC_URI:append = " ${URI_aarch64_stockfish}"
SRC_URI[aarch64_stockfish.sha256sum] = "83eda810c333f1c478d43a571d853461255d1303036c24c012ae5915d9369cdf"

RDEPENDS:stockfish = " \
 glibc \
 libgcc \
 libstdc++ \
 "
