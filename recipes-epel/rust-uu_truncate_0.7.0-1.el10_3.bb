# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_truncate"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_truncate+default-devel \
 rust-uu_truncate-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-uu_truncate-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "449d4c211750abd06398bffff3f622c398f4f841885891c70a36eb7ecdaed77e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_truncate+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_truncate+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uu_truncate+default-devel.sha256sum] = "04d2152680f2533d45412cfef9096f1e842f9b409beb4b0803267e3ca3060719"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_truncate-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_truncate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uu_truncate-devel.sha256sum] = "d0e347b605be3a7392fa08b015a61875b5aba86f4ca0b3ca4e19e2d24a0cb117"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_truncate+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_truncate+default-devel;unpack=0"
SRC_URI[aarch64_rust-uu_truncate+default-devel.sha256sum] = "686e0e35c19d5ca0049201d6ad5ec8e41737e0e190fbb32e9db05c8ee211b716"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_truncate-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_truncate-devel;unpack=0"
SRC_URI[aarch64_rust-uu_truncate-devel.sha256sum] = "ead7b7a56baea4c6cab25bcf6022479ead85e0886d2c0d96e7cf9c85419f6d5f"

RDEPENDS:rust-uu_truncate+default-devel = " \
 cargo \
 rust-uu_truncate-devel \
 "
RDEPENDS:rust-uu_truncate-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+parser-size-devel \
 "
