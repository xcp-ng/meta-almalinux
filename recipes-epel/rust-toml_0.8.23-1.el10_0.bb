# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml"
PV = "0.8.23"
PR = "1.el10_0"
PACKAGES = " \
 rust-toml+default-devel \
 rust-toml+display-devel \
 rust-toml+indexmap-devel \
 rust-toml+parse-devel \
 rust-toml+preserve_order-devel \
 rust-toml+unbounded-devel \
 rust-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml-0.8.23-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e88c8c899edfa39712a6a2425815fa7c6712a36ce0f1e9e9957201ea61a9b7b9"

URI_x86_64_v2_rust-toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+default-devel-0.8.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+default-devel}"
SRC_URI[x86_64_v2_rust-toml+default-devel.sha256sum] = "d959fb547aec1906a3e011287f014c084f7a2b82800303b253c3c2ba566afb30"

URI_x86_64_v2_rust-toml+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+display-devel-0.8.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+display-devel}"
SRC_URI[x86_64_v2_rust-toml+display-devel.sha256sum] = "f8e85056d8cbf6b88445c1d9103044993e2b152f18bc50bfaf75e0be135feeb6"

URI_x86_64_v2_rust-toml+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+indexmap-devel-0.8.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+indexmap-devel}"
SRC_URI[x86_64_v2_rust-toml+indexmap-devel.sha256sum] = "659b2564009ad32cdbe85f1aedcc90c34722c96b098e63788a565296e8c289b5"

URI_x86_64_v2_rust-toml+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+parse-devel-0.8.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+parse-devel}"
SRC_URI[x86_64_v2_rust-toml+parse-devel.sha256sum] = "9e9e03993d218239683ddad668a94afda71d1f0a268261dc4483bf7daecef901"

URI_x86_64_v2_rust-toml+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+preserve_order-devel-0.8.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-toml+preserve_order-devel.sha256sum] = "46d4499f57e2175b21965311aadeb0cad772537727890d8309f7ad6e00a64d9a"

URI_x86_64_v2_rust-toml+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+unbounded-devel-0.8.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml+unbounded-devel.sha256sum] = "3b5f2f2fcad4bb2b10fbc3d424a5e47d7a390c3792ad4ffbd93a7154415aac04"

URI_x86_64_v2_rust-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml-devel-0.8.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml-devel}"
SRC_URI[x86_64_v2_rust-toml-devel.sha256sum] = "d5bbdae72dc6c5b7d0f9abb6286a4ccc55c281e11170d970f5f3fa21b2610447"

URI_aarch64_rust-toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+default-devel-0.8.23-1.el10_0.noarch.rpm;name=aarch64_rust-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+default-devel}"
SRC_URI[aarch64_rust-toml+default-devel.sha256sum] = "43d626004ed9a439d89987b69f9ba6c73f2d026d497ff745f38315a04f56ff6c"

URI_aarch64_rust-toml+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+display-devel-0.8.23-1.el10_0.noarch.rpm;name=aarch64_rust-toml+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+display-devel}"
SRC_URI[aarch64_rust-toml+display-devel.sha256sum] = "eca49e61591d937534eddf7b8fc9687a6562c512f63cd68485c6a6d4a7ed1cf8"

URI_aarch64_rust-toml+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+indexmap-devel-0.8.23-1.el10_0.noarch.rpm;name=aarch64_rust-toml+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+indexmap-devel}"
SRC_URI[aarch64_rust-toml+indexmap-devel.sha256sum] = "e76bc606d92c4dd4a6ddf7fa549b49eccaeec1ecebc54fa3f8b021c004e2c54b"

URI_aarch64_rust-toml+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+parse-devel-0.8.23-1.el10_0.noarch.rpm;name=aarch64_rust-toml+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+parse-devel}"
SRC_URI[aarch64_rust-toml+parse-devel.sha256sum] = "2f163c964050e544ac885e3c71bfddc3c73700bf2d572ee587d7f50051424c7d"

URI_aarch64_rust-toml+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+preserve_order-devel-0.8.23-1.el10_0.noarch.rpm;name=aarch64_rust-toml+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+preserve_order-devel}"
SRC_URI[aarch64_rust-toml+preserve_order-devel.sha256sum] = "74f83dc6f656e51e96179d5dd0018e042b2e20327986da8ae7f6e45bef9b72fc"

URI_aarch64_rust-toml+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+unbounded-devel-0.8.23-1.el10_0.noarch.rpm;name=aarch64_rust-toml+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+unbounded-devel}"
SRC_URI[aarch64_rust-toml+unbounded-devel.sha256sum] = "86edc8cab3190b4a516af3cdad469b7006425299b4c1945294a4ae7fc598077f"

URI_aarch64_rust-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml-devel-0.8.23-1.el10_0.noarch.rpm;name=aarch64_rust-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml-devel}"
SRC_URI[aarch64_rust-toml-devel.sha256sum] = "9cf87913885e496ecaa3d882afa454d92566038f57fca033e530b9f3b012d9ee"

RDEPENDS:rust-toml+default-devel = " \
 cargo \
 rust-toml+display-devel \
 rust-toml+parse-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+display-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit+serde-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+parse-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit+serde-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml+preserve_order-devel = " \
 cargo \
 rust-toml+indexmap-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+unbounded-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_edit+serde-devel \
 rust-toml_edit+unbounded-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-toml_datetime+default-devel \
 rust-toml_datetime+serde-devel \
 "
