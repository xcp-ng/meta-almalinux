# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-python"
PV = "0.23.6"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-python+default-devel \
 rust-tree-sitter-python-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-python-0.23.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7d27cbf80404f74ae336fec6150daef7baa1e7fe3ab364e28930d010d4c2afa"

URI_x86_64_v2_rust-tree-sitter-python+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-python+default-devel-0.23.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-python+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-python+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-python+default-devel.sha256sum] = "2023e849b2c080be7abf79ed873db7c34d71c8c66adb6f21b405e25e3923b8b2"

URI_x86_64_v2_rust-tree-sitter-python-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-python-devel-0.23.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-python-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-python-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-python-devel.sha256sum] = "54e8bf123faa078ebbeda42eebc187935ce885a23f4a0191688e2bf37a61313a"

URI_aarch64_rust-tree-sitter-python+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-python+default-devel-0.23.6-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-python+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-python+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-python+default-devel.sha256sum] = "4bc108ddff87b1b71c596c89686fd2b745a144be5cea18dfe855570106010928"

URI_aarch64_rust-tree-sitter-python-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-python-devel-0.23.6-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-python-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-python-devel}"
SRC_URI[aarch64_rust-tree-sitter-python-devel.sha256sum] = "5435297bb64a3229957638e86ecdfa9bb48c2b3eafe57503e4b83dacc8760c72"

RDEPENDS:rust-tree-sitter-python+default-devel = " \
 cargo \
 rust-tree-sitter-python-devel \
 "
RDEPENDS:rust-tree-sitter-python-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
