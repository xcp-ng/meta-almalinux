# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcalc"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kcalc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcalc-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45a35b7a85ed409fd9be06723db98b80a92bc0f80b83210780a0c6cd5f59b8c5"

URI_x86_64_v2_kcalc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalc-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalc}"
SRC_URI[x86_64_v2_kcalc.sha256sum] = "39931a790f90c71acfc18e31ae11d3e69247b6a52cd3f3c0c16d976f589d56f6"

URI_aarch64_kcalc = "${EPEL_MIRROR}/aarch64/Packages/k/kcalc-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kcalc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalc}"
SRC_URI[aarch64_kcalc.sha256sum] = "69a7e7fcd1e7a0fcff6d4e618edcbef26d4c4f9a7d6a8256a1812d8828e85c38"

RDEPENDS:kcalc = " \
 glibc \
 gmp \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libmpc \
 libstdc++ \
 mpfr \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
