# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gridmap-callout-error"
PV = "3.2"
PR = "7.el10_0"
PACKAGES = " \
 globus-gridmap-callout-error \
 globus-gridmap-callout-error-devel \
 globus-gridmap-callout-error-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gridmap-callout-error-3.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b2405748ee13f0617c8cc5f46b7dffa3876e77867f37f9fba457523f8974280"

URI_x86_64_v2_globus-gridmap-callout-error = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridmap-callout-error-3.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridmap-callout-error;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridmap-callout-error}"
SRC_URI[x86_64_v2_globus-gridmap-callout-error.sha256sum] = "62eacbef44204142d320389f47b5020ac39f5e37a9d6afdf004dad0a44d71e76"

URI_x86_64_v2_globus-gridmap-callout-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridmap-callout-error-devel-3.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridmap-callout-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridmap-callout-error-devel}"
SRC_URI[x86_64_v2_globus-gridmap-callout-error-devel.sha256sum] = "daffcdde0fcd6ff1e30130f57a374d8e5a504fc57f23b5f431157d9feeeabbff"

URI_x86_64_v2_globus-gridmap-callout-error-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridmap-callout-error-doc-3.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gridmap-callout-error-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridmap-callout-error-doc}"
SRC_URI[x86_64_v2_globus-gridmap-callout-error-doc.sha256sum] = "219fac488cd260495f7bd192536ead971609c68b8f8042902c33f3131becd14e"

URI_aarch64_globus-gridmap-callout-error = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridmap-callout-error-3.2-7.el10_0.aarch64.rpm;name=aarch64_globus-gridmap-callout-error;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridmap-callout-error}"
SRC_URI[aarch64_globus-gridmap-callout-error.sha256sum] = "616b0bb9ddbafbb9bf9f51ef7c6076080c3309c031fc35a0c315f92b4abe0377"

URI_aarch64_globus-gridmap-callout-error-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridmap-callout-error-devel-3.2-7.el10_0.aarch64.rpm;name=aarch64_globus-gridmap-callout-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridmap-callout-error-devel}"
SRC_URI[aarch64_globus-gridmap-callout-error-devel.sha256sum] = "67d27a91ac0329bf49764a9d54e653b5951cd5b0b4ae0c80ba61ba6939d97e8d"

URI_aarch64_globus-gridmap-callout-error-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridmap-callout-error-doc-3.2-7.el10_0.noarch.rpm;name=aarch64_globus-gridmap-callout-error-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridmap-callout-error-doc}"
SRC_URI[aarch64_globus-gridmap-callout-error-doc.sha256sum] = "e2fc586fead3b3ccfc2c1d3e6b4933d78c2a1b2e955c3cbd098521ef0f92f03c"

RDEPENDS:globus-gridmap-callout-error = " \
 glibc \
 globus-common \
 "
RDEPENDS:globus-gridmap-callout-error-devel = " \
 globus-common-devel \
 globus-gridmap-callout-error \
 globus-gssapi-error-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gridmap-callout-error-doc = " \
 "
