# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apr-util"
PV = "1.6.3"
PR = "23.el10_1"
PACKAGES = " \
 apr-util \
 apr-util-devel \
 apr-util-ldap \
 apr-util-lmdb \
 apr-util-mysql \
 apr-util-odbc \
 apr-util-openssl \
 apr-util-pgsql \
 apr-util-sqlite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apr-util-1.6.3-23.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78e9a9b709d9657c74ea955beb31580ca31e4df6ea5a61fb00c9eea472c8d3ea"

URI_x86_64_v2_apr-util = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-1.6.3-23.el10_1.x86_64_v2.rpm;name=x86_64_v2_apr-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util}"
SRC_URI[x86_64_v2_apr-util.sha256sum] = "78a77f6e70093daebd4abfd188bc6a8aae318ffad1d5898217c5c199795ad7da"

URI_x86_64_v2_apr-util-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-devel-1.6.3-23.el10_1.x86_64_v2.rpm;name=x86_64_v2_apr-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-devel}"
SRC_URI[x86_64_v2_apr-util-devel.sha256sum] = "b7e25dbcf8f464fb75dfaa95e671a9a8886e774dc8954da9998b83a956d7277c"

URI_x86_64_v2_apr-util-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-ldap-1.6.3-23.el10_1.x86_64_v2.rpm;name=x86_64_v2_apr-util-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-ldap}"
SRC_URI[x86_64_v2_apr-util-ldap.sha256sum] = "b7106dad77a540658aa78d0dc16b03985db486b993519e83e5375eec82b4cb25"

URI_x86_64_v2_apr-util-lmdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-lmdb-1.6.3-23.el10_1.x86_64_v2.rpm;name=x86_64_v2_apr-util-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-lmdb}"
SRC_URI[x86_64_v2_apr-util-lmdb.sha256sum] = "0d3cb6e2a879b9c3457752ba56ffa5b45efa7795926b11551b4fa255416b4a78"

URI_x86_64_v2_apr-util-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-mysql-1.6.3-23.el10_1.x86_64_v2.rpm;name=x86_64_v2_apr-util-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-mysql}"
SRC_URI[x86_64_v2_apr-util-mysql.sha256sum] = "68f541eb569a2cde4fec507fc091b614ef265b6b0d78738fbd33d9a08db897cb"

URI_x86_64_v2_apr-util-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-odbc-1.6.3-23.el10_1.x86_64_v2.rpm;name=x86_64_v2_apr-util-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-odbc}"
SRC_URI[x86_64_v2_apr-util-odbc.sha256sum] = "05aa0d9ac031ab1776ae39fd9c50f03829f1c61e73a9c50c91b3aab7fd8ca624"

URI_x86_64_v2_apr-util-openssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-openssl-1.6.3-23.el10_1.x86_64_v2.rpm;name=x86_64_v2_apr-util-openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-openssl}"
SRC_URI[x86_64_v2_apr-util-openssl.sha256sum] = "5078c33b6ed39d64282f659cc576c2914c28e9e058d126cd3558d8458b020308"

URI_x86_64_v2_apr-util-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-pgsql-1.6.3-23.el10_1.x86_64_v2.rpm;name=x86_64_v2_apr-util-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-pgsql}"
SRC_URI[x86_64_v2_apr-util-pgsql.sha256sum] = "01a5d2ce8b0d0f362eb231f318c4a6b11047614711524c1969f60c88f1216233"

URI_x86_64_v2_apr-util-sqlite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-sqlite-1.6.3-23.el10_1.x86_64_v2.rpm;name=x86_64_v2_apr-util-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-util-sqlite}"
SRC_URI[x86_64_v2_apr-util-sqlite.sha256sum] = "3f7283d59ab5f65725ea616e954cf04aec3464607d61afc79929fd8968bc1a98"

URI_aarch64_apr-util = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-1.6.3-23.el10_1.aarch64.rpm;name=aarch64_apr-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util}"
SRC_URI[aarch64_apr-util.sha256sum] = "cbc5176150ce46141f8356e8edae4d53840caa337cdc9fa6a4363a5deff8968f"

URI_aarch64_apr-util-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-devel-1.6.3-23.el10_1.aarch64.rpm;name=aarch64_apr-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-devel}"
SRC_URI[aarch64_apr-util-devel.sha256sum] = "59044c48db64dd1b2b24c13b648c83e34d97edd56fce4925586f2ff9b92fe86a"

URI_aarch64_apr-util-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-ldap-1.6.3-23.el10_1.aarch64.rpm;name=aarch64_apr-util-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-ldap}"
SRC_URI[aarch64_apr-util-ldap.sha256sum] = "1162197b530b9a12cc9dc0731582aac57b2b0d56ecd4f62a2d1e70a12f5a20eb"

URI_aarch64_apr-util-lmdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-lmdb-1.6.3-23.el10_1.aarch64.rpm;name=aarch64_apr-util-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-lmdb}"
SRC_URI[aarch64_apr-util-lmdb.sha256sum] = "544e2c5a74e8c8fdcca0e7c0a81d55155b3c2920d90bc55408b3bb55369a7177"

URI_aarch64_apr-util-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-mysql-1.6.3-23.el10_1.aarch64.rpm;name=aarch64_apr-util-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-mysql}"
SRC_URI[aarch64_apr-util-mysql.sha256sum] = "5966632ef8dfc275f23d76df1c5b6f56a49d0b0989357f7d48cfd76088203470"

URI_aarch64_apr-util-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-odbc-1.6.3-23.el10_1.aarch64.rpm;name=aarch64_apr-util-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-odbc}"
SRC_URI[aarch64_apr-util-odbc.sha256sum] = "f1c63635fe6b09c8dfd4f79c3c73a49171ec262cdacd91be36a718f27f3d2ff1"

URI_aarch64_apr-util-openssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-openssl-1.6.3-23.el10_1.aarch64.rpm;name=aarch64_apr-util-openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-openssl}"
SRC_URI[aarch64_apr-util-openssl.sha256sum] = "65b0f134f01a445c96a109fb86a79b6870b953e67213dd85e48100b82ef9d2d0"

URI_aarch64_apr-util-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-pgsql-1.6.3-23.el10_1.aarch64.rpm;name=aarch64_apr-util-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-pgsql}"
SRC_URI[aarch64_apr-util-pgsql.sha256sum] = "46767a676dad9e1dac0ef1f336aed793e6b10e26be9a793f4ddbc7c742b4ef47"

URI_aarch64_apr-util-sqlite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-sqlite-1.6.3-23.el10_1.aarch64.rpm;name=aarch64_apr-util-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-util-sqlite}"
SRC_URI[aarch64_apr-util-sqlite.sha256sum] = "c9d8f354c3fedb1806c2fedf3b7a1bd7372a5eeb619e8f0c6dbd0f9d7edb7366"

RDEPENDS:apr-util = " \
 apr \
 expat \
 glibc \
 libuuid \
 libxcrypt \
 "
RDEPENDS:apr-util-devel = " \
 apr-devel \
 apr-util \
 bash \
 expat-devel \
 openldap-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:apr-util-ldap = " \
 apr-util \
 glibc \
 openldap \
 "
RDEPENDS:apr-util-lmdb = " \
 apr-util \
 glibc \
 lmdb-libs \
 "
RDEPENDS:apr-util-mysql = " \
 apr-util \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:apr-util-odbc = " \
 apr-util \
 glibc \
 unixODBC \
 "
RDEPENDS:apr-util-openssl = " \
 apr-util \
 glibc \
 openssl-libs \
 "
RDEPENDS:apr-util-pgsql = " \
 apr-util \
 glibc \
 libpq \
 "
RDEPENDS:apr-util-sqlite = " \
 apr-util \
 glibc \
 sqlite-libs \
 "
