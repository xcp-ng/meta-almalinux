# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-venusian"
PV = "3.1.1"
PR = "8.el10_3"
PACKAGES = " \
 python3-venusian \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-venusian-3.1.1-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca6d0911167fc35c8190c542fe9852ed0307ad6317d9b54a443f58adacc34045"

URI_x86_64_v2_python3-venusian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-venusian-3.1.1-8.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-venusian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-venusian}"
SRC_URI[x86_64_v2_python3-venusian.sha256sum] = "87c8305287c9f9f9ce9a4ce1f9c7adab7181c6f8fc03732d6362b28a269dd66d"

URI_aarch64_python3-venusian = "${EPEL_MIRROR}/aarch64/Packages/p/python3-venusian-3.1.1-8.el10_3.noarch.rpm;name=aarch64_python3-venusian;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-venusian}"
SRC_URI[aarch64_python3-venusian.sha256sum] = "203c940403efd9ba0b9c9c2093d2e4ddad6dad5b185d41b4439da6493bee838a"

RDEPENDS:python3-venusian = " \
 python3 \
 "
