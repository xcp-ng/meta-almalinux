# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lazy-object-proxy"
PV = "1.11.0"
PR = "5.el10_2"
PACKAGES = " \
 python3-lazy-object-proxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-lazy-object-proxy-1.11.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b780b59644bf9f0a08b84794a84a449ae29161edf4ec2116e6968e8f40bbfeb"

URI_x86_64_v2_python3-lazy-object-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lazy-object-proxy-1.11.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lazy-object-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lazy-object-proxy}"
SRC_URI[x86_64_v2_python3-lazy-object-proxy.sha256sum] = "31d15cff7cb8f6d2c914f78bbefe184cec95e2952cb0748d196635540c392e48"

URI_aarch64_python3-lazy-object-proxy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lazy-object-proxy-1.11.0-5.el10_2.aarch64.rpm;name=aarch64_python3-lazy-object-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lazy-object-proxy}"
SRC_URI[aarch64_python3-lazy-object-proxy.sha256sum] = "e1dce98a9963fd9ef911fb229a4a52b67906f0dcde76116ee747a9b593951470"

RDEPENDS:python3-lazy-object-proxy = " \
 glibc \
 python3 \
 "
