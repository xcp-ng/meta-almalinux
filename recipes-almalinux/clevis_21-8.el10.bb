# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clevis"
PV = "21"
PR = "8.el10"
PACKAGES = " \
 clevis \
 clevis-dracut \
 clevis-luks \
 clevis-pin-pkcs11 \
 clevis-systemd \
 clevis-udisks2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/clevis-21-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83d9df58fb4d54f5031806921e8c43231e6658980ffa3649d66eb64e3c2ae220"

URI_x86_64_v2_clevis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-21-8.el10.x86_64_v2.rpm;name=x86_64_v2_clevis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis}"
SRC_URI[x86_64_v2_clevis.sha256sum] = "341fb00837a41044a076962bbea979feee86405cf28075f8a4b59da8b4c5be84"

URI_x86_64_v2_clevis-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-dracut-21-8.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-dracut}"
SRC_URI[x86_64_v2_clevis-dracut.sha256sum] = "9a685d50253c823012e0f02558464a1d6b511d393d69f419caeeebe9385061e2"

URI_x86_64_v2_clevis-luks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-luks-21-8.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-luks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-luks}"
SRC_URI[x86_64_v2_clevis-luks.sha256sum] = "632ca86d85857289c35080222334270587cabdd11ac6b5a9e5ae52433704f7bb"

URI_x86_64_v2_clevis-pin-pkcs11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-pin-pkcs11-21-8.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-pin-pkcs11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-pin-pkcs11}"
SRC_URI[x86_64_v2_clevis-pin-pkcs11.sha256sum] = "b972f96ca4c92040f325405117a2b1ad30f0c8da130000daa62b84bf6ffeb8a6"

URI_x86_64_v2_clevis-systemd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-systemd-21-8.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-systemd}"
SRC_URI[x86_64_v2_clevis-systemd.sha256sum] = "a5ff56db3d240e82381f78353d78532995beaeb6d36477989eb1e42f7730a6d9"

URI_x86_64_v2_clevis-udisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-udisks2-21-8.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-udisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-udisks2}"
SRC_URI[x86_64_v2_clevis-udisks2.sha256sum] = "52366f65609091d73c88919d6908f32c10a8e2e5a07db3b971cde312fbad7b08"

URI_aarch64_clevis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-21-8.el10.aarch64.rpm;name=aarch64_clevis;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis}"
SRC_URI[aarch64_clevis.sha256sum] = "96cf6e6a7b9a60d92eab361f3f25e2928f17141477cf9e6cb47acfa946130a0d"

URI_aarch64_clevis-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-dracut-21-8.el10.aarch64.rpm;name=aarch64_clevis-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-dracut}"
SRC_URI[aarch64_clevis-dracut.sha256sum] = "e770a62a7a0f489c1a753e2d01f1c9c033a1474e4c4ac9aa266897da95cb5e81"

URI_aarch64_clevis-luks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-luks-21-8.el10.aarch64.rpm;name=aarch64_clevis-luks;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-luks}"
SRC_URI[aarch64_clevis-luks.sha256sum] = "a4e9ec86f88080292e8665d477d2d6f3b29261c8a2027ea47100c9e6386b148d"

URI_aarch64_clevis-pin-pkcs11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-pin-pkcs11-21-8.el10.aarch64.rpm;name=aarch64_clevis-pin-pkcs11;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-pin-pkcs11}"
SRC_URI[aarch64_clevis-pin-pkcs11.sha256sum] = "703b566baf2f4ad8a3d45ed5d962e0fd025a430164dd7706d43caf547ca539b8"

URI_aarch64_clevis-systemd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-systemd-21-8.el10.aarch64.rpm;name=aarch64_clevis-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-systemd}"
SRC_URI[aarch64_clevis-systemd.sha256sum] = "a9d75501c61d820adbf2176ea2c3c20247210ba4e178919c4b2a4f206c6ba240"

URI_aarch64_clevis-udisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-udisks2-21-8.el10.aarch64.rpm;name=aarch64_clevis-udisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-udisks2}"
SRC_URI[aarch64_clevis-udisks2.sha256sum] = "356a1e48b2b96f10c0ae3deae7bc9a96f9e3c9336fa0a4b2237200342c22f17a"

RDEPENDS:clevis = " \
 bash \
 clevis-pin-tpm2 \
 curl \
 glibc \
 jansson \
 jose \
 jq \
 libgcc \
 libjose \
 openssl-libs \
 shadow-utils \
 systemd \
 tpm2-tools \
 virtual/coreutils \
 "
RDEPENDS:clevis-dracut = " \
 bash \
 clevis-systemd \
 dracut-network \
 "
RDEPENDS:clevis-luks = " \
 bash \
 clevis \
 cryptsetup \
 luksmeta \
 "
RDEPENDS:clevis-pin-pkcs11 = " \
 bash \
 clevis-dracut \
 clevis-luks \
 clevis-systemd \
 glibc \
 opensc \
 openssl \
 pcsc-lite \
 socat \
 "
RDEPENDS:clevis-systemd = " \
 bash \
 clevis-luks \
 systemd \
 "
RDEPENDS:clevis-udisks2 = " \
 audit-libs \
 clevis-luks \
 cryptsetup-libs \
 glib2 \
 glibc \
 jansson \
 libgcc \
 libluksmeta \
 libudisks2 \
 "
