# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dragon"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 dragon \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dragon-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec12a25aed434ad198f750ed4a1af97bfe909088958b991f38324e72c4caa56d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dragon-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dragon;unpack=0"
SRC_URI[x86_64_v2_dragon.sha256sum] = "9c4bd18cf851876788883388b3f2728baedfd7e0237c3dd760078b61a98bdb3b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dragon-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_dragon;unpack=0"
SRC_URI[aarch64_dragon.sha256sum] = "b4f3419f4e81d14dc3215c93f25560d730b0b7a5b57b5c5575c3ed599420a4fd"

RDEPENDS:dragon = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 libavcodec-free \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
