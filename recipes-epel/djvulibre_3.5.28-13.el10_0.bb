# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "djvulibre"
PV = "3.5.28"
PR = "13.el10_0"
PACKAGES = " \
 djvulibre \
 djvulibre-devel \
 djvulibre-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/djvulibre-3.5.28-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "748fcdc91cb71c83349d380fcd237fa2b70b5261f2ed8cc08efd47ddb13add32"

URI_x86_64_v2_djvulibre = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/djvulibre-3.5.28-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_djvulibre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_djvulibre}"
SRC_URI[x86_64_v2_djvulibre.sha256sum] = "01e66ff711a86471206b89295b91dfaf474b510979046a1c6ff0ce4869f8636b"

URI_x86_64_v2_djvulibre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/djvulibre-devel-3.5.28-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_djvulibre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_djvulibre-devel}"
SRC_URI[x86_64_v2_djvulibre-devel.sha256sum] = "938337b379a6440a522efd5fa280116f4da189fd2a7cb7c83cd0b8dcef45eb36"

URI_x86_64_v2_djvulibre-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/djvulibre-libs-3.5.28-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_djvulibre-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_djvulibre-libs}"
SRC_URI[x86_64_v2_djvulibre-libs.sha256sum] = "52e6de377e387a289e8f9c76ff7409803cfac9c0ed092e8b7342832a897aae46"

URI_aarch64_djvulibre = "${EPEL_MIRROR}/aarch64/Packages/d/djvulibre-3.5.28-13.el10_0.aarch64.rpm;name=aarch64_djvulibre;unpack=0"
SRC_URI:append = " ${URI_aarch64_djvulibre}"
SRC_URI[aarch64_djvulibre.sha256sum] = "59d690c75aa849c313b568d9117f84381c5dbbf32f835b96174b5149879fd92d"

URI_aarch64_djvulibre-devel = "${EPEL_MIRROR}/aarch64/Packages/d/djvulibre-devel-3.5.28-13.el10_0.aarch64.rpm;name=aarch64_djvulibre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_djvulibre-devel}"
SRC_URI[aarch64_djvulibre-devel.sha256sum] = "7d41a0dced7477c7407f9270ab63af93d183751ecf579e0ba19a29facca4d5cc"

URI_aarch64_djvulibre-libs = "${EPEL_MIRROR}/aarch64/Packages/d/djvulibre-libs-3.5.28-13.el10_0.aarch64.rpm;name=aarch64_djvulibre-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_djvulibre-libs}"
SRC_URI[aarch64_djvulibre-libs.sha256sum] = "8db1412fbb3eb6e468646e1b71e256ea321b4fc2fe8fcc2123c583980ac6759a"

RDEPENDS:djvulibre = " \
 bash \
 djvulibre-libs \
 glibc \
 libgcc \
 libstdc++ \
 libtiff \
 xdg-utils \
 "
RDEPENDS:djvulibre-devel = " \
 djvulibre-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:djvulibre-libs = " \
 glibc \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 "
