# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fsverity-utils"
PV = "1.7"
PR = "1.el10_3"
PACKAGES = " \
 fsverity-utils \
 fsverity-utils-devel \
 libfsverity \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fsverity-utils-1.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fd427670c7958733aafc733a11e38dbec2f5db0aca4b3e333638e764e71faec"

URI_x86_64_v2_fsverity-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fsverity-utils-1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fsverity-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fsverity-utils}"
SRC_URI[x86_64_v2_fsverity-utils.sha256sum] = "f26bb366dd69912eff991719d950f1f1b4b20f74c4df95f69124e88577af111a"

URI_x86_64_v2_fsverity-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fsverity-utils-devel-1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fsverity-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fsverity-utils-devel}"
SRC_URI[x86_64_v2_fsverity-utils-devel.sha256sum] = "ad498d3bad334e20cfb29491376c8f549dbd31d7a61d9a6d3e30e21dbc4b5a57"

URI_x86_64_v2_libfsverity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libfsverity-1.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libfsverity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfsverity}"
SRC_URI[x86_64_v2_libfsverity.sha256sum] = "51bc1aa777b625d4642c739cf6822ed1b2e8ef04eb5932cd13ecbd7c8af73308"

URI_aarch64_fsverity-utils = "${EPEL_MIRROR}/aarch64/Packages/f/fsverity-utils-1.7-1.el10_3.aarch64.rpm;name=aarch64_fsverity-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_fsverity-utils}"
SRC_URI[aarch64_fsverity-utils.sha256sum] = "8d509c6e83be2f9f0c60322783907b0f2fc36a85fd6121e4706d0de53cf9bdf6"

URI_aarch64_fsverity-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fsverity-utils-devel-1.7-1.el10_3.aarch64.rpm;name=aarch64_fsverity-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fsverity-utils-devel}"
SRC_URI[aarch64_fsverity-utils-devel.sha256sum] = "522259b5cece0f67a851c58eb1a350c0d2c4c0dd5037a12b195a2920ade3627a"

URI_aarch64_libfsverity = "${EPEL_MIRROR}/aarch64/Packages/l/libfsverity-1.7-1.el10_3.aarch64.rpm;name=aarch64_libfsverity;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfsverity}"
SRC_URI[aarch64_libfsverity.sha256sum] = "8c4d9a8ca1617234ad486dddba6caf914202b059e5233033c7d735c429b8935d"

RDEPENDS:fsverity-utils = " \
 glibc \
 libfsverity \
 "
RDEPENDS:fsverity-utils-devel = " \
 fsverity-utils \
 libfsverity \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libfsverity = " \
 glibc \
 openssl-libs \
 "
