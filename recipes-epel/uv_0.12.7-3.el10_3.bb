# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uv"
PV = "0.12.7"
PR = "3.el10_3"
PACKAGES = " \
 python3-uv \
 uv \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/uv-0.12.7-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b8d57cac2f767ab44c955630c7d99182a9ad93fd6a194737b37443ebb8c27a5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uv-0.12.7-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-uv;unpack=0"
SRC_URI[x86_64_v2_python3-uv.sha256sum] = "a0f95c9f1852e79315853462eb16adaddf930a81237d181f8a17b7775d642867"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uv-0.12.7-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uv;unpack=0"
SRC_URI[x86_64_v2_uv.sha256sum] = "beb4d58a8b660124e437f071ae3ab3be8bedbce38a2793a0b1c687254e316930"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-uv-0.12.7-3.el10_3.noarch.rpm;name=aarch64_python3-uv;unpack=0"
SRC_URI[aarch64_python3-uv.sha256sum] = "6a9597be7a70352eca61d5e276f2fa6296c0f7ecb61aa7bd01644e8d8d461c4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/uv-0.12.7-3.el10_3.aarch64.rpm;name=aarch64_uv;unpack=0"
SRC_URI[aarch64_uv.sha256sum] = "cad443108b605680b7eea41cb41e04090759e34af076b21d977c89e42771899b"

RDEPENDS:python3-uv = " \
 python3 \
 uv \
 "
RDEPENDS:uv = " \
 glibc \
 jemalloc \
 libgcc \
 libzstd \
 "
