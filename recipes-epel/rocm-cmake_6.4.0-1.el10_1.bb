# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-cmake"
PV = "6.4.0"
PR = "1.el10_1"
PACKAGES = " \
 rocm-cmake \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rocm-cmake-6.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "abdd2ac28dc7dcde1301fc8464f9a9590b2a91c24aae7acb393675d62d63aa00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-cmake-6.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-cmake;unpack=0"
SRC_URI[x86_64_v2_rocm-cmake.sha256sum] = "0d168eca6d51e77b7107f6dc328a6de91c817aecf7643a5cddc0d29f34bb8de3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rocm-cmake-6.4.0-1.el10_1.noarch.rpm;name=aarch64_rocm-cmake;unpack=0"
SRC_URI[aarch64_rocm-cmake.sha256sum] = "0bb345771199e7449cc2eab0a9d66528c80a5bd22f1117c15a8b32d9393ce953"

RDEPENDS:rocm-cmake = " \
 cmake \
 "
