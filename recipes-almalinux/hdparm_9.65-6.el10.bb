# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hdparm"
PV = "9.65"
PR = "6.el10"
PACKAGES = " \
 hdparm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/hdparm-9.65-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "36d50b27e71e87166238b8bc2bf894a2423a6ba099649847d49b98e20fc9a9db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/hdparm-9.65-6.el10.x86_64_v2.rpm;name=x86_64_v2_hdparm;unpack=0"
SRC_URI[x86_64_v2_hdparm.sha256sum] = "a178332d4e4d08e84caa223aa99fa02183c17be4ee4d15a14b7bdd04dcb30bd4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/hdparm-9.65-6.el10.aarch64.rpm;name=aarch64_hdparm;unpack=0"
SRC_URI[aarch64_hdparm.sha256sum] = "0bb254135820e3ca52a29fb92e223878a3303a6f6d1ab9f2effacd7d624c3dce"

RDEPENDS:hdparm = " \
 glibc \
 "
