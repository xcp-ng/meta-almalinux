# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audex"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 audex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audex-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "081d343b8aa12ce65f84b250b3350ff8da307c08966773a9e2770d1cc002c7af"

URI_x86_64_v2_audex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audex-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audex}"
SRC_URI[x86_64_v2_audex.sha256sum] = "7a4ff393a907b04f324df11ef2c4c5fe6e0ae6d18a0873e644b725d074d31ab0"

URI_aarch64_audex = "${EPEL_MIRROR}/aarch64/Packages/a/audex-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_audex;unpack=0"
SRC_URI:append = " ${URI_aarch64_audex}"
SRC_URI[aarch64_audex.sha256sum] = "ee91f612e889686b5c96b9dc371567f01c9d811afaab7c547f52a30a60317d40"

RDEPENDS:audex = " \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 libcdio-paranoia \
 libkcddb \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
