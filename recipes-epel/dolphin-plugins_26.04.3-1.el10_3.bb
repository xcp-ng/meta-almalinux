# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dolphin-plugins"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 dolphin-plugins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dolphin-plugins-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e90a7e950b2c2abb022b3ce24c91c5aed32c1899ce4c8fa40aaaceaf34c4544c"

URI_x86_64_v2_dolphin-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-plugins-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin-plugins}"
SRC_URI[x86_64_v2_dolphin-plugins.sha256sum] = "70c5be7c14dc60673a38e1b29270521b2731f7c03b85ce4d9bd7a8999d1198c8"

URI_aarch64_dolphin-plugins = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-plugins-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_dolphin-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin-plugins}"
SRC_URI[aarch64_dolphin-plugins.sha256sum] = "ac48828c4bfae38d2a606669822738fc99b358251d2b45983706d08bbe01e68b"

RDEPENDS:dolphin-plugins = " \
 dolphin \
 dolphin-libs \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
