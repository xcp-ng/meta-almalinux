# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colord-gtk"
PV = "0.3.1"
PR = "4.el10"
PACKAGES = " \
 colord-gtk \
 colord-gtk-devel \
 colord-gtk4 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/colord-gtk-0.3.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70d4b3ed84c4dd7d5299594be297ff8962a7930c91ed271d5b504dc9b9816a29"

URI_x86_64_v2_colord-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/colord-gtk-0.3.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_colord-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-gtk}"
SRC_URI[x86_64_v2_colord-gtk.sha256sum] = "d788d328288706fe0bb51a514447132852e36a3e1cb52da5349c9ff3222845a9"

URI_x86_64_v2_colord-gtk-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/colord-gtk-devel-0.3.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_colord-gtk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-gtk-devel}"
SRC_URI[x86_64_v2_colord-gtk-devel.sha256sum] = "2d659b5c681bb912c5138d1bb4b461c5732713d385945cc45402f43ebd0e835a"

URI_x86_64_v2_colord-gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/colord-gtk4-0.3.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_colord-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-gtk4}"
SRC_URI[x86_64_v2_colord-gtk4.sha256sum] = "38df37ff593312ada691b30a1b318ee679fcefc873ad4755c70e7722531fd262"

URI_aarch64_colord-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/colord-gtk-0.3.1-4.el10.aarch64.rpm;name=aarch64_colord-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-gtk}"
SRC_URI[aarch64_colord-gtk.sha256sum] = "01027dcf108dedf77576e9bb29054be83ef1db68f5f5ca6ffda8545a082221e7"

URI_aarch64_colord-gtk-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/colord-gtk-devel-0.3.1-4.el10.aarch64.rpm;name=aarch64_colord-gtk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-gtk-devel}"
SRC_URI[aarch64_colord-gtk-devel.sha256sum] = "740352ad8c79b50a9a6313ac0d8dfd6ae8b61d40e7f8156cf9db83ae854625e9"

URI_aarch64_colord-gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/colord-gtk4-0.3.1-4.el10.aarch64.rpm;name=aarch64_colord-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-gtk4}"
SRC_URI[aarch64_colord-gtk4.sha256sum] = "1153a36a7cae4bac7f37fb960bdeec5f3c0b1821a1b8dee6a2dc3bcd4ca132a3"

RDEPENDS:colord-gtk = " \
 cairo \
 colord-libs \
 glib2 \
 glibc \
 gtk3 \
 "
RDEPENDS:colord-gtk-devel = " \
 colord-devel \
 colord-gtk \
 gtk3-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:colord-gtk4 = " \
 cairo \
 colord-libs \
 glib2 \
 glibc \
 gtk4 \
 "
