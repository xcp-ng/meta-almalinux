# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtnetworkauth"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtnetworkauth \
 qt5-qtnetworkauth-devel \
 qt5-qtnetworkauth-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtnetworkauth-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "744c14ff2ca3fc068768ce940be977e9511ecd6bead38d3143ce39cc072c929b"

URI_x86_64_v2_qt5-qtnetworkauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtnetworkauth-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtnetworkauth}"
SRC_URI[x86_64_v2_qt5-qtnetworkauth.sha256sum] = "d98e33bac908711ed57991e2cf9190b7ec6beaf452b9e28718077bcd445e5a70"

URI_x86_64_v2_qt5-qtnetworkauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtnetworkauth-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtnetworkauth-devel}"
SRC_URI[x86_64_v2_qt5-qtnetworkauth-devel.sha256sum] = "522232924346fe287528e49b91eb988d97e4278699d519eb5c28ee242e54d052"

URI_x86_64_v2_qt5-qtnetworkauth-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtnetworkauth-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtnetworkauth-examples}"
SRC_URI[x86_64_v2_qt5-qtnetworkauth-examples.sha256sum] = "c55c0613566c4142b5bfb3eb063d6d191cd342fcf336967afbb5bb121d33d8ce"

URI_aarch64_qt5-qtnetworkauth = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtnetworkauth-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtnetworkauth}"
SRC_URI[aarch64_qt5-qtnetworkauth.sha256sum] = "3beb91260de732985debde0c643b2d8070d90d343b14645639dd1a67c9596d3e"

URI_aarch64_qt5-qtnetworkauth-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtnetworkauth-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtnetworkauth-devel}"
SRC_URI[aarch64_qt5-qtnetworkauth-devel.sha256sum] = "bf9853ce199652ba139e31ecc1a6389091ec1ae8f4bc33479bdabd6c538eae54"

URI_aarch64_qt5-qtnetworkauth-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtnetworkauth-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtnetworkauth-examples}"
SRC_URI[aarch64_qt5-qtnetworkauth-examples.sha256sum] = "92b015a265803180fd5b4e8d95012872d31f3852b1d94162a35f26547e7e32c5"

RDEPENDS:qt5-qtnetworkauth = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtnetworkauth-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtnetworkauth \
 "
RDEPENDS:qt5-qtnetworkauth-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtnetworkauth \
 "
