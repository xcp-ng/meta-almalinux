# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemmodels"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kitemmodels \
 kf6-kitemmodels-devel \
 kf6-kitemmodels-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemmodels-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f63ad5ad382aa0c19d5e50db0997d5e12ec0b7b9fb57e2bacf39567112934733"

URI_x86_64_v2_kf6-kitemmodels = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels}"
SRC_URI[x86_64_v2_kf6-kitemmodels.sha256sum] = "9a54812816b4f6d87ef295e5fda2fd1554394accfe27c6ef5df2ca61a8cf418e"

URI_x86_64_v2_kf6-kitemmodels-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-devel}"
SRC_URI[x86_64_v2_kf6-kitemmodels-devel.sha256sum] = "3f7d9f62e4d23273aaf6eff8b2402df2660e8f8ed81e91bbf51016001edc1076"

URI_x86_64_v2_kf6-kitemmodels-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemmodels-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-doc}"
SRC_URI[x86_64_v2_kf6-kitemmodels-doc.sha256sum] = "068353f49ade68bf9820fb24e34c2eb27eab56a8e7ff05dc93aba2c3f3d1a0b3"

URI_aarch64_kf6-kitemmodels = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kitemmodels;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels}"
SRC_URI[aarch64_kf6-kitemmodels.sha256sum] = "d50e1b79e8a6382f3750820407c753a7d97059d6cd1310632e73141413f49fbd"

URI_aarch64_kf6-kitemmodels-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kitemmodels-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-devel}"
SRC_URI[aarch64_kf6-kitemmodels-devel.sha256sum] = "62521842d6ee65f3584f3bba23c002f425fb8c75c43a933b96429029eb8cd1f8"

URI_aarch64_kf6-kitemmodels-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kitemmodels-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-doc}"
SRC_URI[aarch64_kf6-kitemmodels-doc.sha256sum] = "3e90de43f2a2b3927c975bc4c517bc6f95752624d34deb51cdd649780b991ddd"

RDEPENDS:kf6-kitemmodels = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kitemmodels-devel = " \
 cmake-filesystem \
 kf6-kitemmodels \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kitemmodels-doc = " \
 "
