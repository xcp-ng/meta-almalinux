# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdc"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 krdc \
 krdc-devel \
 krdc-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/krdc-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "894cbb8ceaf86ab915ce313bc95d6212d20c632ebe1ee348303774d7e79b3bed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc;unpack=0"
SRC_URI[x86_64_v2_krdc.sha256sum] = "1f5c545ef64d02c431b89de8e67799bd720c12ff717bc2cfc17beff63f9ce981"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-devel;unpack=0"
SRC_URI[x86_64_v2_krdc-devel.sha256sum] = "30d99d730d8f0886e7857a3110abc4269242a8cf5b2fd92a00c66759b6f90b73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdc-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdc-libs;unpack=0"
SRC_URI[x86_64_v2_krdc-libs.sha256sum] = "717fa870fbf111c05139494052a175745a8bdcdb155c506bcbdbc26babfe7181"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/krdc-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_krdc;unpack=0"
SRC_URI[aarch64_krdc.sha256sum] = "6e43fd1d0f63213fb64d2ecf68a1eeab27656a732c7aa8d152e68ce0d723dcf7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/krdc-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_krdc-devel;unpack=0"
SRC_URI[aarch64_krdc-devel.sha256sum] = "3352050c03b67a3a43e7e8abab0b9ea701ae82d1dd0d54616e91551b311ac0a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/krdc-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_krdc-libs;unpack=0"
SRC_URI[aarch64_krdc-libs.sha256sum] = "11552440ccdf1d0549ba0ee3572c5a90bf33354db6f96de639c92ff9629653fd"

RDEPENDS:krdc = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:krdc-devel = " \
 krdc-libs \
 "
RDEPENDS:krdc-libs = " \
 freerdp-libs \
 glibc \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 krdc \
 libssh \
 libstdc++ \
 libvncserver \
 libwinpr \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
