# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-imagesize"
PV = "1.4.1"
PR = "9.el10"
PACKAGES = " \
 python3-imagesize \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-imagesize-1.4.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45b1c83ab378850ad6e3b6bba18388852830a381fbff5818febab857ccec95f1"

URI_x86_64_v2_python3-imagesize = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-imagesize-1.4.1-9.el10.noarch.rpm;name=x86_64_v2_python3-imagesize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-imagesize}"
SRC_URI[x86_64_v2_python3-imagesize.sha256sum] = "a2c359c6dd2f97fd17d9fd6187f6382b151348811bbc5986768b5b7c1f424bb1"

URI_aarch64_python3-imagesize = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-imagesize-1.4.1-9.el10.noarch.rpm;name=aarch64_python3-imagesize;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-imagesize}"
SRC_URI[aarch64_python3-imagesize.sha256sum] = "a2c359c6dd2f97fd17d9fd6187f6382b151348811bbc5986768b5b7c1f424bb1"

RDEPENDS:python3-imagesize = " \
 python3 \
 "
