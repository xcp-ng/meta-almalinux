# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enumflags2"
PV = "0.7.12"
PR = "2.el10_2"
PACKAGES = " \
 rust-enumflags2+default-devel \
 rust-enumflags2+serde-devel \
 rust-enumflags2+std-devel \
 rust-enumflags2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enumflags2-0.7.12-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a0656d0abf2004da9a6cbae9313121fb244c45d481dea609ddf4703648ebc00"

URI_x86_64_v2_rust-enumflags2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumflags2+default-devel-0.7.12-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumflags2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumflags2+default-devel}"
SRC_URI[x86_64_v2_rust-enumflags2+default-devel.sha256sum] = "5ee3bbb469755be4cd0dfe8f6d5e1d07015f82ee7eb9222f42b980061daefcaa"

URI_x86_64_v2_rust-enumflags2+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumflags2+serde-devel-0.7.12-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumflags2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumflags2+serde-devel}"
SRC_URI[x86_64_v2_rust-enumflags2+serde-devel.sha256sum] = "270459522af051e9092285ffcb369900785c8706fced251e9ef66a2edece4a72"

URI_x86_64_v2_rust-enumflags2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumflags2+std-devel-0.7.12-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumflags2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumflags2+std-devel}"
SRC_URI[x86_64_v2_rust-enumflags2+std-devel.sha256sum] = "235a405e152163bea38d248eb8be263430a58df18cc6fe9402a0f4751d4b61b9"

URI_x86_64_v2_rust-enumflags2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumflags2-devel-0.7.12-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumflags2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumflags2-devel}"
SRC_URI[x86_64_v2_rust-enumflags2-devel.sha256sum] = "20c1af70e71a7e61e2c952c80db9e0f42ed8eb0ddc791f92cbb900ef37634961"

URI_aarch64_rust-enumflags2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumflags2+default-devel-0.7.12-2.el10_2.noarch.rpm;name=aarch64_rust-enumflags2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumflags2+default-devel}"
SRC_URI[aarch64_rust-enumflags2+default-devel.sha256sum] = "15359bf2675e4b99315a12e955e0f16ef71bf701e05055c77b2bd197dc08a9a7"

URI_aarch64_rust-enumflags2+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumflags2+serde-devel-0.7.12-2.el10_2.noarch.rpm;name=aarch64_rust-enumflags2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumflags2+serde-devel}"
SRC_URI[aarch64_rust-enumflags2+serde-devel.sha256sum] = "eed501957daf1a521ab16ed3e1cf2a3011674e188c9cae71f5c30267851a63e7"

URI_aarch64_rust-enumflags2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumflags2+std-devel-0.7.12-2.el10_2.noarch.rpm;name=aarch64_rust-enumflags2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumflags2+std-devel}"
SRC_URI[aarch64_rust-enumflags2+std-devel.sha256sum] = "e4b26040085e0653549d1b8ed572f75bae6a9210cc2c274fa3384c411b315a34"

URI_aarch64_rust-enumflags2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumflags2-devel-0.7.12-2.el10_2.noarch.rpm;name=aarch64_rust-enumflags2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumflags2-devel}"
SRC_URI[aarch64_rust-enumflags2-devel.sha256sum] = "be36aa3b28de71943c3cbc06ce233196821dbdec68c99851e43e0e7a6ee1b10a"

RDEPENDS:rust-enumflags2+default-devel = " \
 cargo \
 rust-enumflags2-devel \
 "
RDEPENDS:rust-enumflags2+serde-devel = " \
 cargo \
 rust-enumflags2-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-enumflags2+std-devel = " \
 cargo \
 rust-enumflags2-devel \
 "
RDEPENDS:rust-enumflags2-devel = " \
 cargo \
 rust \
 rust-enumflags2_derive+default-devel \
 "
