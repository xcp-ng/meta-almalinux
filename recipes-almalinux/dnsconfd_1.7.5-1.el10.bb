# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsconfd"
PV = "1.7.5"
PR = "1.el10"
PACKAGES = " \
 dnsconfd \
 dnsconfd-dracut \
 dnsconfd-micro \
 dnsconfd-selinux \
 dnsconfd-unbound \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dnsconfd-1.7.5-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33eaacdf1e185253478bb7b051efe717bcfa213b49b58e8130f07ab080089b73"

URI_x86_64_v2_dnsconfd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-1.7.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_dnsconfd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd}"
SRC_URI[x86_64_v2_dnsconfd.sha256sum] = "5938a0a02cf4e85749edaa51852699d8378ae2b26e45a64bc709618f67617ef2"

URI_x86_64_v2_dnsconfd-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-dracut-1.7.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_dnsconfd-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd-dracut}"
SRC_URI[x86_64_v2_dnsconfd-dracut.sha256sum] = "9e7503c1df0ca0bfef8a65a279ba52c5169b593f90ba94143b819a18fe396d3a"

URI_x86_64_v2_dnsconfd-micro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-micro-1.7.5-1.el10.x86_64_v2.rpm;name=x86_64_v2_dnsconfd-micro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd-micro}"
SRC_URI[x86_64_v2_dnsconfd-micro.sha256sum] = "6b20aa08ef8909b83740b2e21d2a055e36e342bf46087e7b5bc55b6707a47240"

URI_x86_64_v2_dnsconfd-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-selinux-1.7.5-1.el10.noarch.rpm;name=x86_64_v2_dnsconfd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd-selinux}"
SRC_URI[x86_64_v2_dnsconfd-selinux.sha256sum] = "b2587093c7f47baa956f17c64b60cdbf9099d6cec622f5ee91f296e133342209"

URI_x86_64_v2_dnsconfd-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-unbound-1.7.5-1.el10.noarch.rpm;name=x86_64_v2_dnsconfd-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsconfd-unbound}"
SRC_URI[x86_64_v2_dnsconfd-unbound.sha256sum] = "e65e1f985f5ba25b82c2d3e4c65cb3cfb3c4c4f3f6f05665675cf76259b90c6d"

URI_aarch64_dnsconfd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-1.7.5-1.el10.aarch64.rpm;name=aarch64_dnsconfd;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd}"
SRC_URI[aarch64_dnsconfd.sha256sum] = "ad31a1751f335624f2baf5f76493ff83f938ad932658e487b0d4bf23ac5e6f6c"

URI_aarch64_dnsconfd-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-dracut-1.7.5-1.el10.aarch64.rpm;name=aarch64_dnsconfd-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd-dracut}"
SRC_URI[aarch64_dnsconfd-dracut.sha256sum] = "782bfc47fb603c4ff81bf59138e6ca6d966a91af2f4cf7b07d462e194396cc7c"

URI_aarch64_dnsconfd-micro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-micro-1.7.5-1.el10.aarch64.rpm;name=aarch64_dnsconfd-micro;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd-micro}"
SRC_URI[aarch64_dnsconfd-micro.sha256sum] = "657dd0cd3387a400e28e5f5b8e6da524df424fac0f58183189d1db02b44dcf8c"

URI_aarch64_dnsconfd-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-selinux-1.7.5-1.el10.noarch.rpm;name=aarch64_dnsconfd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd-selinux}"
SRC_URI[aarch64_dnsconfd-selinux.sha256sum] = "b2587093c7f47baa956f17c64b60cdbf9099d6cec622f5ee91f296e133342209"

URI_aarch64_dnsconfd-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-unbound-1.7.5-1.el10.noarch.rpm;name=aarch64_dnsconfd-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsconfd-unbound}"
SRC_URI[aarch64_dnsconfd-unbound.sha256sum] = "e65e1f985f5ba25b82c2d3e4c65cb3cfb3c4c4f3f6f05665675cf76259b90c6d"

RDEPENDS:dnsconfd = " \
 bash \
 dbus-common \
 dnsconfd-selinux \
 dnsconfd-unbound \
 polkit \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-pyyaml \
 python3-systemd \
 shadow-utils \
 "
RDEPENDS:dnsconfd-dracut = " \
 bash \
 dnsconfd-micro \
 dracut \
 dracut-network \
 unbound \
 "
RDEPENDS:dnsconfd-micro = " \
 dnsconfd \
 dnsconfd-selinux \
 glib2 \
 glibc \
 systemd-libs \
 unbound-dracut \
 virtual/libcurl \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:dnsconfd-selinux = " \
 bash \
 dnsconfd \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:dnsconfd-unbound = " \
 bash \
 dnsconfd \
 unbound \
 "
