# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "usbmuxd"
PV = "1.1.1^20240915git0b1b233"
PR = "1.el10_0"
PACKAGES = " \
 usbmuxd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/usbmuxd-1.1.1^20240915git0b1b233-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b40c77095db1ae65a8166670d782a31ab71c07204e24c62eff77b72ca87698a"

URI_x86_64_v2_usbmuxd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/usbmuxd-1.1.1^20240915git0b1b233-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_usbmuxd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_usbmuxd}"
SRC_URI[x86_64_v2_usbmuxd.sha256sum] = "d5245fe423d37522b9f8aab9752503920d871868c059828d0c3332b282e8bf3f"

URI_aarch64_usbmuxd = "${EPEL_MIRROR}/aarch64/Packages/u/usbmuxd-1.1.1^20240915git0b1b233-1.el10_0.aarch64.rpm;name=aarch64_usbmuxd;unpack=0"
SRC_URI:append = " ${URI_aarch64_usbmuxd}"
SRC_URI[aarch64_usbmuxd.sha256sum] = "16a89061474440c005d651712ddc6cad0bcad91af25a95c2ab58c68a5c4a4f81"

RDEPENDS:usbmuxd = " \
 bash \
 glibc \
 libimobiledevice \
 libimobiledevice-glue \
 libplist \
 libusb1 \
 shadow-utils \
 "
