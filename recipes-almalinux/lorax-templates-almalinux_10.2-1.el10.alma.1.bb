# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax-templates-almalinux"
PV = "10.2"
PR = "1.el10.alma.1"
PACKAGES = " \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-templates-almalinux-10.2-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b53d3c55f85f6a761952233739cddebefc4cd9ab6e7eb170d9f8cc2a22b1bce1"

