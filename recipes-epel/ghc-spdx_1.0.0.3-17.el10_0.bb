# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-spdx"
PV = "1.0.0.3"
PR = "17.el10_0"
PACKAGES = " \
 ghc-spdx \
 ghc-spdx-devel \
 ghc-spdx-doc \
 ghc-spdx-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-spdx-1.0.0.3-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "189dadf5f4f61bc3ca8eadbfaf7d006e1def7830a0041fe0d773aaf776dd01e0"

URI_x86_64_v2_ghc-spdx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-spdx-1.0.0.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-spdx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-spdx}"
SRC_URI[x86_64_v2_ghc-spdx.sha256sum] = "6ce1e196830c2ea83ff0861b52d677a781b6862d65b62c8401b2230ade6221a8"

URI_x86_64_v2_ghc-spdx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-spdx-devel-1.0.0.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-spdx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-spdx-devel}"
SRC_URI[x86_64_v2_ghc-spdx-devel.sha256sum] = "1c3bae83bd6cd6490b7c6b1eb6312a314ac522c6b318582bed72337e55737d5a"

URI_x86_64_v2_ghc-spdx-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-spdx-doc-1.0.0.3-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-spdx-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-spdx-doc}"
SRC_URI[x86_64_v2_ghc-spdx-doc.sha256sum] = "1177163b5f17d6d6b19837f8e10206b93c32f87d20d668df45163fbb79cf5a7f"

URI_x86_64_v2_ghc-spdx-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-spdx-prof-1.0.0.3-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-spdx-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-spdx-prof}"
SRC_URI[x86_64_v2_ghc-spdx-prof.sha256sum] = "d634e411bd9ab342571e64cdc590860065e2211c3442691e2ecdf0b39b9a557d"

URI_aarch64_ghc-spdx = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-spdx-1.0.0.3-17.el10_0.aarch64.rpm;name=aarch64_ghc-spdx;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-spdx}"
SRC_URI[aarch64_ghc-spdx.sha256sum] = "070ecfc1cfc52ee881c689187d7600f87208b97f2496909ef08a4bea8817aaf9"

URI_aarch64_ghc-spdx-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-spdx-devel-1.0.0.3-17.el10_0.aarch64.rpm;name=aarch64_ghc-spdx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-spdx-devel}"
SRC_URI[aarch64_ghc-spdx-devel.sha256sum] = "66d77ff4f522e8397b5bd0e503fca3dd7c44aab3f532874461cbb723be7256ff"

URI_aarch64_ghc-spdx-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-spdx-doc-1.0.0.3-17.el10_0.noarch.rpm;name=aarch64_ghc-spdx-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-spdx-doc}"
SRC_URI[aarch64_ghc-spdx-doc.sha256sum] = "85073e66b95d9da4dc2066cb9436a0cbfc3b114b98ba5e9fe279aa63f0d154fa"

URI_aarch64_ghc-spdx-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-spdx-prof-1.0.0.3-17.el10_0.aarch64.rpm;name=aarch64_ghc-spdx-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-spdx-prof}"
SRC_URI[aarch64_ghc-spdx-prof.sha256sum] = "5158e2ec63ed7fa6ec3d7a979ce51126568759f4c3881b66ccc1179b6fd24277"

RDEPENDS:ghc-spdx = " \
 ghc-Cabal \
 ghc-Cabal-syntax \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-spdx-devel = " \
 ghc-Cabal-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-spdx \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-spdx-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-spdx-prof = " \
 ghc-Cabal-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-spdx-devel \
 ghc-transformers-prof \
 "
