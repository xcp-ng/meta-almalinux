# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "packit"
PV = "1.16.3"
PR = "1.el10_3"
PACKAGES = " \
 packit \
 python3-packit \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/packit-1.16.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "211d13043efc66658941b964e912346a89ef961e8ea5778c4cd2c52c211aa981"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/packit-1.16.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_packit;unpack=0"
SRC_URI[x86_64_v2_packit.sha256sum] = "14a2dc56cc52f142445e31e4299a49a2954fe2c0efe06230831c0c7a91711198"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-packit-1.16.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-packit;unpack=0"
SRC_URI[x86_64_v2_python3-packit.sha256sum] = "18c43cf33aa484ca89c39094b7b9bc2c3aa643f4408aa57aa853732299b32660"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/packit-1.16.3-1.el10_3.noarch.rpm;name=aarch64_packit;unpack=0"
SRC_URI[aarch64_packit.sha256sum] = "9222020dae4f62db1b8f4bf4ea49ebf18d5085f157867aa1c0509794971e30bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-packit-1.16.3-1.el10_3.noarch.rpm;name=aarch64_python3-packit;unpack=0"
SRC_URI[aarch64_python3-packit.sha256sum] = "663895ee6e5cc092b247233bb0e79d431bd60dec5defe930415982905278a32c"

RDEPENDS:packit = " \
 python3 \
 python3-packit \
 "
RDEPENDS:python3-packit = " \
 bash \
 bodhi-client \
 fedpkg \
 git-core \
 krb5-workstation \
 osc \
 python3 \
 python3-GitPython \
 python3-backoff \
 python3-bugzilla \
 python3-cachetools \
 python3-cccolutils \
 python3-click \
 python3-copr \
 python3-fedora-distro-aliases \
 python3-gnupg \
 python3-koji \
 python3-lazy-object-proxy \
 python3-marshmallow \
 python3-munch \
 python3-ogr \
 python3-opensuse-distro-aliases \
 python3-packaging \
 python3-pyyaml \
 python3-requests \
 python3-requests-kerberos \
 python3-rpkg \
 python3-specfile \
 python3-tabulate \
 rpm-build \
 rpmdevtools \
 rsync \
 "
