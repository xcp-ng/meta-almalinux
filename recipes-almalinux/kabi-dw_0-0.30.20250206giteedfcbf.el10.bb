# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kabi-dw"
PV = "0"
PR = "0.30.20250206giteedfcbf.el10"
PACKAGES = " \
 kabi-dw \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kabi-dw-0-0.30.20250206giteedfcbf.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ba0a1914c8afe82b33328324680cd0e204d66923988dab94866d8ead99f30bc"

URI_x86_64_v2_kabi-dw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kabi-dw-0-0.30.20250206giteedfcbf.el10.x86_64_v2.rpm;name=x86_64_v2_kabi-dw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kabi-dw}"
SRC_URI[x86_64_v2_kabi-dw.sha256sum] = "6939eb1c4b7a202c98255abc099b61695e6f801a3c2ec8dff439afa81614ad1e"

URI_aarch64_kabi-dw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kabi-dw-0-0.30.20250206giteedfcbf.el10.aarch64.rpm;name=aarch64_kabi-dw;unpack=0"
SRC_URI:append = " ${URI_aarch64_kabi-dw}"
SRC_URI[aarch64_kabi-dw.sha256sum] = "500f5e2c7ea82f03a7199fbe56dd9bc937ec76a95bd2fdc55f1e8eb6ae3a5f34"

RDEPENDS:kabi-dw = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 "
