# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plutosvg"
PV = "0.0.7"
PR = "2.el10_1"
PACKAGES = " \
 plutosvg \
 plutosvg-devel \
 plutosvg-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plutosvg-0.0.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d23faff2decfd79226cd232dec8b6562ad37851dd7b190d681797912d085307b"

URI_x86_64_v2_plutosvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-0.0.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg}"
SRC_URI[x86_64_v2_plutosvg.sha256sum] = "56348298afc64ea2ea89c1b6260dc9944a684dcc1bb8d350b8818cad1bbe7c59"

URI_x86_64_v2_plutosvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-devel-0.0.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg-devel}"
SRC_URI[x86_64_v2_plutosvg-devel.sha256sum] = "6e59cc20d8469123956dfea95742152a2f721f55790e6d605a25bb45654ab3d4"

URI_x86_64_v2_plutosvg-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-samples-0.0.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg-samples}"
SRC_URI[x86_64_v2_plutosvg-samples.sha256sum] = "dc7e4a0d8f485bbe7ee217a8050091da234bde847ffca720433cd4e4db4ab27a"

URI_aarch64_plutosvg = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-0.0.7-2.el10_1.aarch64.rpm;name=aarch64_plutosvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg}"
SRC_URI[aarch64_plutosvg.sha256sum] = "8d0efffd018c2847f608330a60f724a7538ae137ecdf3306370378336010c4c5"

URI_aarch64_plutosvg-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-devel-0.0.7-2.el10_1.aarch64.rpm;name=aarch64_plutosvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg-devel}"
SRC_URI[aarch64_plutosvg-devel.sha256sum] = "b97df7472d4ecc105b62feec196e6b8dae80ec1bff30ebb8969ff20155dbfb6e"

URI_aarch64_plutosvg-samples = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-samples-0.0.7-2.el10_1.aarch64.rpm;name=aarch64_plutosvg-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg-samples}"
SRC_URI[aarch64_plutosvg-samples.sha256sum] = "d49898faabce088e5d82d7006af028978683f4b2256e4ad8a49440c78b7486df"

RDEPENDS:plutosvg = " \
 freetype \
 glibc \
 plutovg \
 "
RDEPENDS:plutosvg-devel = " \
 cmake-filesystem \
 freetype-devel \
 pkgconf-pkg-config \
 plutosvg \
 plutovg-devel \
 "
RDEPENDS:plutosvg-samples = " \
 freetype \
 glibc \
 plutosvg \
 plutovg \
 "
