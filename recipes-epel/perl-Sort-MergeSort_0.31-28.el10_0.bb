# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sort-MergeSort"
PV = "0.31"
PR = "28.el10_0"
PACKAGES = " \
 perl-Sort-MergeSort \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sort-MergeSort-0.31-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4eb9d2c7da43338c2357bc0c2c2d1e139fba38f6cc6eecb5dc6b94ec03c7712a"

URI_x86_64_v2_perl-Sort-MergeSort = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sort-MergeSort-0.31-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sort-MergeSort;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sort-MergeSort}"
SRC_URI[x86_64_v2_perl-Sort-MergeSort.sha256sum] = "573321a6730e79d3aa57d57c66bd86908c066a3955929e1dd3c4a98012caabee"

URI_aarch64_perl-Sort-MergeSort = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sort-MergeSort-0.31-28.el10_0.noarch.rpm;name=aarch64_perl-Sort-MergeSort;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sort-MergeSort}"
SRC_URI[aarch64_perl-Sort-MergeSort.sha256sum] = "07229bd4f373dcc839de1839d2aa98fad892c34a497e0a0e69192824a600c730"

RDEPENDS:perl-Sort-MergeSort = " \
 perl-Carp \
 perl-Exporter \
 perl-Sort-MergeSort \
 perl-Symbol \
 perl-libs \
 "
