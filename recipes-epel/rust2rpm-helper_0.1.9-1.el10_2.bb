# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust2rpm-helper"
PV = "0.1.9"
PR = "1.el10_2"
PACKAGES = " \
 rust2rpm-helper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust2rpm-helper-0.1.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a068ab13fdcbfe594476d9249e3df182a447f1ef3b0c1326087e17b627bb4d63"

URI_x86_64_v2_rust2rpm-helper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust2rpm-helper-0.1.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rust2rpm-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust2rpm-helper}"
SRC_URI[x86_64_v2_rust2rpm-helper.sha256sum] = "58a6d07fb8d6d1e4d2e21f81dcf66f1fa62e18256201434bff2b662392f5dada"

URI_aarch64_rust2rpm-helper = "${EPEL_MIRROR}/aarch64/Packages/r/rust2rpm-helper-0.1.9-1.el10_2.aarch64.rpm;name=aarch64_rust2rpm-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust2rpm-helper}"
SRC_URI[aarch64_rust2rpm-helper.sha256sum] = "55e84a4b63daf64f34aaa348259b1a930a441969fef5e948426a0c774cbb7d52"

RDEPENDS:rust2rpm-helper = " \
 glibc \
 libgcc \
 "
