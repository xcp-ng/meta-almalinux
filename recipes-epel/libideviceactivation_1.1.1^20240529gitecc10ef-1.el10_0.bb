# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libideviceactivation"
PV = "1.1.1^20240529gitecc10ef"
PR = "1.el10_0"
PACKAGES = " \
 libideviceactivation \
 libideviceactivation-devel \
 libideviceactivation-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libideviceactivation-1.1.1^20240529gitecc10ef-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cc8ec3542da4df1bbfae4279f8dfa6cb9b14ad8be308606b3f6b698ea535a87"

URI_x86_64_v2_libideviceactivation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libideviceactivation-1.1.1^20240529gitecc10ef-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libideviceactivation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libideviceactivation}"
SRC_URI[x86_64_v2_libideviceactivation.sha256sum] = "6f7a891c82b85ad80003d211a47a3618e54bb6356e598bada5232b654d75a3d7"

URI_x86_64_v2_libideviceactivation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libideviceactivation-devel-1.1.1^20240529gitecc10ef-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libideviceactivation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libideviceactivation-devel}"
SRC_URI[x86_64_v2_libideviceactivation-devel.sha256sum] = "7de68619a826a3645b42c8613c54cc83232171617dd9de3013e241491b1f82bd"

URI_x86_64_v2_libideviceactivation-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libideviceactivation-utils-1.1.1^20240529gitecc10ef-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libideviceactivation-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libideviceactivation-utils}"
SRC_URI[x86_64_v2_libideviceactivation-utils.sha256sum] = "56bae431e1b0e4200192fe19fdce9008b848602da7fcff952022a252127c1367"

URI_aarch64_libideviceactivation = "${EPEL_MIRROR}/aarch64/Packages/l/libideviceactivation-1.1.1^20240529gitecc10ef-1.el10_0.aarch64.rpm;name=aarch64_libideviceactivation;unpack=0"
SRC_URI:append = " ${URI_aarch64_libideviceactivation}"
SRC_URI[aarch64_libideviceactivation.sha256sum] = "8548127162b8d4e811cebd23e87faeaa8cdf4ebbf424e54cbf9fb3ac422c91c7"

URI_aarch64_libideviceactivation-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libideviceactivation-devel-1.1.1^20240529gitecc10ef-1.el10_0.aarch64.rpm;name=aarch64_libideviceactivation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libideviceactivation-devel}"
SRC_URI[aarch64_libideviceactivation-devel.sha256sum] = "ea9bde5ff4d2178cb26f8175cd44855fa51db21e46b55bc500ca57ff9171d00f"

URI_aarch64_libideviceactivation-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libideviceactivation-utils-1.1.1^20240529gitecc10ef-1.el10_0.aarch64.rpm;name=aarch64_libideviceactivation-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libideviceactivation-utils}"
SRC_URI[aarch64_libideviceactivation-utils.sha256sum] = "e7de8784dfe98a1b5de8a6c4d407b3123d6fccae59efb80bc9006dc8b775e16d"

RDEPENDS:libideviceactivation = " \
 glibc \
 libimobiledevice \
 libplist \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libideviceactivation-devel = " \
 libcurl-devel \
 libideviceactivation \
 libimobiledevice-devel \
 libplist-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libideviceactivation-utils = " \
 glibc \
 libideviceactivation \
 libimobiledevice \
 libplist \
 "
