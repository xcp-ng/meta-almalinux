# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debconf"
PV = "1.5.91"
PR = "1.el10_1"
PACKAGES = " \
 debconf \
 debconf-LDAP \
 debconf-doc \
 debconf-i18n \
 debconf-utils \
 python3-debconf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debconf-1.5.91-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e51a3e402c734f9040957cacd765e18dff54bfb23d2a16866d62b3fe0831889"

URI_x86_64_v2_debconf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-1.5.91-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_debconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf}"
SRC_URI[x86_64_v2_debconf.sha256sum] = "cf009a546229d4654d6b5a77d4e099014c615b98838f1c5665cfd81f93df8840"

URI_x86_64_v2_debconf-LDAP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-LDAP-1.5.91-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_debconf-LDAP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf-LDAP}"
SRC_URI[x86_64_v2_debconf-LDAP.sha256sum] = "cacd2acae54738a6d2f568dc0d85ee00d141edbeff19b7fbc8edc3b0a90f9107"

URI_x86_64_v2_debconf-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-doc-1.5.91-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_debconf-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf-doc}"
SRC_URI[x86_64_v2_debconf-doc.sha256sum] = "28209adecad5f95f6979a79ecc98b3f0d5b41d6e17038478f676742e254a1471"

URI_x86_64_v2_debconf-i18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-i18n-1.5.91-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_debconf-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf-i18n}"
SRC_URI[x86_64_v2_debconf-i18n.sha256sum] = "37f85d7e8bcfb395f501f5703d219db53e680e6c6ccb113e6860db20d073d225"

URI_x86_64_v2_debconf-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-utils-1.5.91-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_debconf-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf-utils}"
SRC_URI[x86_64_v2_debconf-utils.sha256sum] = "8372ba90b83f413571ff4dea30ecf5b667e2ad1ed0e1cd5294586ac3fc6f2cfa"

URI_x86_64_v2_python3-debconf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-debconf-1.5.91-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-debconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debconf}"
SRC_URI[x86_64_v2_python3-debconf.sha256sum] = "c1a6e86d75fcf82d28ce910eb90a9a105e6e03c3affc5cb42d9bb759d9c0244e"

URI_aarch64_debconf = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-1.5.91-1.el10_1.noarch.rpm;name=aarch64_debconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf}"
SRC_URI[aarch64_debconf.sha256sum] = "4ee48cd2cf448e4d9a5f1da4a0933942c0b08d7805a0d670525df1c53de613a0"

URI_aarch64_debconf-LDAP = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-LDAP-1.5.91-1.el10_1.noarch.rpm;name=aarch64_debconf-LDAP;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf-LDAP}"
SRC_URI[aarch64_debconf-LDAP.sha256sum] = "b5b2989517b026985db229b209c8bb0a14d301ad128dc1b7d00d9bcba9d2943f"

URI_aarch64_debconf-doc = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-doc-1.5.91-1.el10_1.noarch.rpm;name=aarch64_debconf-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf-doc}"
SRC_URI[aarch64_debconf-doc.sha256sum] = "378ddc73db1668be4376bae4e2329c07ff4d116bd51e779b2f5144d25d2222e6"

URI_aarch64_debconf-i18n = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-i18n-1.5.91-1.el10_1.noarch.rpm;name=aarch64_debconf-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf-i18n}"
SRC_URI[aarch64_debconf-i18n.sha256sum] = "496a75f8e883acda7ae04e5c574d9a72e9da962531fd628f394d29a2cf2dd40f"

URI_aarch64_debconf-utils = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-utils-1.5.91-1.el10_1.noarch.rpm;name=aarch64_debconf-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf-utils}"
SRC_URI[aarch64_debconf-utils.sha256sum] = "0e0f0ca4144c49502e2a566151fcbedf934aa4a7fec1a9b2927c6dfb5f312f96"

URI_aarch64_python3-debconf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-debconf-1.5.91-1.el10_1.noarch.rpm;name=aarch64_python3-debconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debconf}"
SRC_URI[aarch64_python3-debconf.sha256sum] = "8ef512288f2e0aa4d273de1fc41c2ecfca7a4faa44362bb695773e9c3f0fa90f"

RDEPENDS:debconf = " \
 bash \
 perl-CGI \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Locale-gettext \
 perl-POSIX \
 perl-PathTools \
 perl-Term-ReadLine \
 perl-Text-CharWidth \
 perl-Text-Iconv \
 perl-Text-Tabs+Wrap \
 perl-Text-WrapI18N \
 perl-base \
 perl-fields \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:debconf-LDAP = " \
 debconf \
 perl-LDAP \
 perl-base \
 perl-fields \
 perl-libs \
 "
RDEPENDS:debconf-doc = " \
 debconf \
 "
RDEPENDS:debconf-i18n = " \
 debconf \
 "
RDEPENDS:debconf-utils = " \
 debconf \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:python3-debconf = " \
 python3 \
 "
