# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-phonebook"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-phonebook \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-phonebook-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1829f564a1485148676dba0299c28bc7e1b7e87e87ecf6c4f37405ef7f87182"

URI_x86_64_v2_plasma-phonebook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-phonebook-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-phonebook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-phonebook}"
SRC_URI[x86_64_v2_plasma-phonebook.sha256sum] = "a43edc7268513ce3795954339277d64851a98159412885753c82c5180447501a"

URI_aarch64_plasma-phonebook = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-phonebook-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-phonebook;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-phonebook}"
SRC_URI[aarch64_plasma-phonebook.sha256sum] = "ce60097d0b0b88aebe02e62df86dd755891cac005028fec44a285c9e72b2eedf"

RDEPENDS:plasma-phonebook = " \
 glibc \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpeople \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
