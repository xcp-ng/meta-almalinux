# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpm-sequoia"
PV = "1.10.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rpm-sequoia \
 rpm-sequoia-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rust-rpm-sequoia-1.10.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "36dbe9d15848baf423190511b9d994ad08b577b8dd8ccf1e831f465aa9f924c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sequoia-1.10.2.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_rpm-sequoia;unpack=0"
SRC_URI[x86_64_v2_rpm-sequoia.sha256sum] = "b01bc5a960ce949d22db72067cf581b94aad1f88b57dcd0e522fe03ab6fc0bb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rpm-sequoia-devel-1.10.2.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_rpm-sequoia-devel;unpack=0"
SRC_URI[x86_64_v2_rpm-sequoia-devel.sha256sum] = "a29334f11b3bc537f3d5bf2507155a37e7379ca61b1d59eb4aac6a91e8ae6f66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sequoia-1.10.2.1-1.el10_2.aarch64.rpm;name=aarch64_rpm-sequoia;unpack=0"
SRC_URI[aarch64_rpm-sequoia.sha256sum] = "aa7ad81a0f4a78036fca5475aeda7667ec441f5acaa8ceaf0509de41b36fe994"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rpm-sequoia-devel-1.10.2.1-1.el10_2.aarch64.rpm;name=aarch64_rpm-sequoia-devel;unpack=0"
SRC_URI[aarch64_rpm-sequoia-devel.sha256sum] = "ef3218a4849a867536a05a450b96bc035d3ede4d444d1622f532ac52efc5a687"

RDEPENDS:rpm-sequoia = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:rpm-sequoia-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 rpm-sequoia \
 "
