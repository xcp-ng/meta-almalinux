# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-minijinja"
PV = "2.23.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+custom_syntax-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+default-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+fuel-devel \
 rust-minijinja+indexmap-devel \
 rust-minijinja+internal_debug-devel \
 rust-minijinja+internal_safe_search-devel \
 rust-minijinja+json-devel \
 rust-minijinja+key_interning-devel \
 rust-minijinja+loader-devel \
 rust-minijinja+loop_controls-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja+preserve_order-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+serde_json-devel \
 rust-minijinja+speedups-devel \
 rust-minijinja+stacker-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja+unstable_machinery_serde-devel \
 rust-minijinja+urlencode-devel \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-minijinja-2.23.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2e6e96df8893e9ccc55dabac87aa41713d0569300a58e12a891660c3b4c428b"

URI_x86_64_v2_rust-minijinja+adjacent_loop_items-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+adjacent_loop_items-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+adjacent_loop_items-devel}"
SRC_URI[x86_64_v2_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "792a8d923ec6879607f9c3f33c65a1f2a280b04d2030a038a69a0a65f861ec97"

URI_x86_64_v2_rust-minijinja+builtins-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+builtins-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+builtins-devel}"
SRC_URI[x86_64_v2_rust-minijinja+builtins-devel.sha256sum] = "0368f35c3105fa39909a5f8804106f86303abc1f54b7774ed8afb4e63764c8ef"

URI_x86_64_v2_rust-minijinja+custom_syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+custom_syntax-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+custom_syntax-devel}"
SRC_URI[x86_64_v2_rust-minijinja+custom_syntax-devel.sha256sum] = "b97785b38fcb435e9ff6e9298fc6596943f591573a26dbf1bc97adee938951c2"

URI_x86_64_v2_rust-minijinja+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+debug-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+debug-devel}"
SRC_URI[x86_64_v2_rust-minijinja+debug-devel.sha256sum] = "d94f10c1fe19ce394de4aa258837e83fb449dd3e2435b2855f437d65f2da2934"

URI_x86_64_v2_rust-minijinja+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+default-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+default-devel}"
SRC_URI[x86_64_v2_rust-minijinja+default-devel.sha256sum] = "eb014e9495005362d7c8b44ae42ca84315ea26f3914adc3195c06f668aceb377"

URI_x86_64_v2_rust-minijinja+deserialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+deserialization-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+deserialization-devel}"
SRC_URI[x86_64_v2_rust-minijinja+deserialization-devel.sha256sum] = "997f1277fa07ce64d6f57a35cf6535a61ab6e7e5eb1846b637f9c7a6c0404fd4"

URI_x86_64_v2_rust-minijinja+fuel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+fuel-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+fuel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+fuel-devel}"
SRC_URI[x86_64_v2_rust-minijinja+fuel-devel.sha256sum] = "8b49274d10b702c3ae05057f5043d1add79249347cf59ef0b533bdbb68d057cd"

URI_x86_64_v2_rust-minijinja+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+indexmap-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+indexmap-devel}"
SRC_URI[x86_64_v2_rust-minijinja+indexmap-devel.sha256sum] = "184f9a6ddac079519eb9f7461bbae49f6b62a7ce2994006bc8d4a77391c6f1f1"

URI_x86_64_v2_rust-minijinja+internal_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_debug-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+internal_debug-devel}"
SRC_URI[x86_64_v2_rust-minijinja+internal_debug-devel.sha256sum] = "ca6d527e64412220ba15ce51c7018e8c43fbef8ac73a0673b8b24446b41293b1"

URI_x86_64_v2_rust-minijinja+internal_safe_search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_safe_search-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+internal_safe_search-devel}"
SRC_URI[x86_64_v2_rust-minijinja+internal_safe_search-devel.sha256sum] = "84242b4388644f1ac602329525191669197bd4012d54170ce8b55a51ea515ded"

URI_x86_64_v2_rust-minijinja+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+json-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+json-devel}"
SRC_URI[x86_64_v2_rust-minijinja+json-devel.sha256sum] = "afd04aec40008cf42c4226a0141d2542c5847bad5378b8dd1ba6a11e07345a07"

URI_x86_64_v2_rust-minijinja+key_interning-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+key_interning-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+key_interning-devel}"
SRC_URI[x86_64_v2_rust-minijinja+key_interning-devel.sha256sum] = "e2733f0fdfa5eb766029af992968266df08336d8aede70a528e86ad8fe8ab670"

URI_x86_64_v2_rust-minijinja+loader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loader-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+loader-devel}"
SRC_URI[x86_64_v2_rust-minijinja+loader-devel.sha256sum] = "5ae7501f3e8aa10ccd6ff6d1f9a2563c02a822f46aeb6761fb58329fbaeb483d"

URI_x86_64_v2_rust-minijinja+loop_controls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loop_controls-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+loop_controls-devel}"
SRC_URI[x86_64_v2_rust-minijinja+loop_controls-devel.sha256sum] = "928895460b391cd6b650a7c0855ecb08cfd412fdc4225507870df83930b36730"

URI_x86_64_v2_rust-minijinja+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+macros-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+macros-devel}"
SRC_URI[x86_64_v2_rust-minijinja+macros-devel.sha256sum] = "4008a6f48b629105cb32ec474447125640bf009f4a5f51c7e66617bb30233ef9"

URI_x86_64_v2_rust-minijinja+multi_template-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+multi_template-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+multi_template-devel}"
SRC_URI[x86_64_v2_rust-minijinja+multi_template-devel.sha256sum] = "f3f144d2581f66a07c3b8ee6a987f546f510cfe81d0be01eba0dfed6e3322fef"

URI_x86_64_v2_rust-minijinja+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+percent-encoding-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-minijinja+percent-encoding-devel.sha256sum] = "54a75a21d0d70355f8f1015fd0901c9b9643d2660f79bf1f984c05f68cf96d46"

URI_x86_64_v2_rust-minijinja+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+preserve_order-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-minijinja+preserve_order-devel.sha256sum] = "aa722848ce1632af47c348a93b7d72d3f2ba3f242e4a3859169019fa9e8ee26e"

URI_x86_64_v2_rust-minijinja+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+serde-devel}"
SRC_URI[x86_64_v2_rust-minijinja+serde-devel.sha256sum] = "850c3fe023a8567163d4e62cc34dd09061bc0985a7b6a04258aaa4abf16a3c04"

URI_x86_64_v2_rust-minijinja+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde_json-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+serde_json-devel}"
SRC_URI[x86_64_v2_rust-minijinja+serde_json-devel.sha256sum] = "edf68dd93c48fb7fc21b9b5ef973e6a7a878420bacd225a76c2241139599f558"

URI_x86_64_v2_rust-minijinja+speedups-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+speedups-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+speedups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+speedups-devel}"
SRC_URI[x86_64_v2_rust-minijinja+speedups-devel.sha256sum] = "2481a450798d2a79317566bf55cada6df2d09ca08ee15bb5fe2fa383d3da90db"

URI_x86_64_v2_rust-minijinja+stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+stacker-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+stacker-devel}"
SRC_URI[x86_64_v2_rust-minijinja+stacker-devel.sha256sum] = "5b506eb32c128d018ba473fe9d082823522ce62d12a28ef372d39dd0bc859129"

URI_x86_64_v2_rust-minijinja+std_collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+std_collections-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+std_collections-devel}"
SRC_URI[x86_64_v2_rust-minijinja+std_collections-devel.sha256sum] = "621a954386ced1d9ffad29264aa2eaa5fbbb0559a87d27a9045aede158e1439f"

URI_x86_64_v2_rust-minijinja+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicase-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicase-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicase-devel.sha256sum] = "9e1cb5cb48ba3486a4c1720aeeca2ff1005e2b1bef9e5c5e12314aea94228d19"

URI_x86_64_v2_rust-minijinja+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicode-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicode-devel.sha256sum] = "d58e36d5635b37a5e04e8a93717641470d8587d4e406a6fe4d678597fe9da648"

URI_x86_64_v2_rust-minijinja+unicode-ident-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-ident-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicode-ident-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicode-ident-devel.sha256sum] = "5ad9f38be510482b6a414ca0a4a16da7913fc933916d931a654147e4de0e58dc"

URI_x86_64_v2_rust-minijinja+unstable_machinery-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unstable_machinery-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery-devel.sha256sum] = "5d67d438dac2647d5689c322195f9deb9f625dd227dace3bf1c5fe902d618f47"

URI_x86_64_v2_rust-minijinja+unstable_machinery_serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery_serde-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unstable_machinery_serde-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "bddc0f4d9388923081b23ddc6f5c52c32bae291f15f9109af5eccc2e775d2917"

URI_x86_64_v2_rust-minijinja+urlencode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+urlencode-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+urlencode-devel}"
SRC_URI[x86_64_v2_rust-minijinja+urlencode-devel.sha256sum] = "6e63bc3f1665853ccbefd95aa6b1ed6c41e0f742e622b0ee13b44ac92d3c546f"

URI_x86_64_v2_rust-minijinja+v_htmlescape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+v_htmlescape-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+v_htmlescape-devel}"
SRC_URI[x86_64_v2_rust-minijinja+v_htmlescape-devel.sha256sum] = "ee1e91b924496d567d077a7e9962d93561e9830dde254571f4f5cb24da464f1f"

URI_x86_64_v2_rust-minijinja-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja-devel-2.23.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja-devel}"
SRC_URI[x86_64_v2_rust-minijinja-devel.sha256sum] = "d68a73abd99e871c012375d36e80c7f9903c9b521ac8dbc0bcf1761da08caba5"

URI_aarch64_rust-minijinja+adjacent_loop_items-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+adjacent_loop_items-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+adjacent_loop_items-devel}"
SRC_URI[aarch64_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "7393d75af0c37679324058912038cddad9017a024c8567598bc94ffde913df97"

URI_aarch64_rust-minijinja+builtins-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+builtins-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+builtins-devel}"
SRC_URI[aarch64_rust-minijinja+builtins-devel.sha256sum] = "b0be210de55ddb2598352f34901329bb807d8d1956944ec2012ce3ecd954092a"

URI_aarch64_rust-minijinja+custom_syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+custom_syntax-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+custom_syntax-devel}"
SRC_URI[aarch64_rust-minijinja+custom_syntax-devel.sha256sum] = "47ff52b694c75d32970cd742559a3ccc8ae813a69ccfd767f770d117833f551e"

URI_aarch64_rust-minijinja+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+debug-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+debug-devel}"
SRC_URI[aarch64_rust-minijinja+debug-devel.sha256sum] = "69bfa86217d6304608eaaae06c7ca7d496fb1eedbb14d8002c97511c21fc4fb3"

URI_aarch64_rust-minijinja+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+default-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+default-devel}"
SRC_URI[aarch64_rust-minijinja+default-devel.sha256sum] = "933e18b6409138656249b51a9297e7858f06b5bcb94423888469c1728db1f2d5"

URI_aarch64_rust-minijinja+deserialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+deserialization-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+deserialization-devel}"
SRC_URI[aarch64_rust-minijinja+deserialization-devel.sha256sum] = "db56dbaa7bd8e70b4dfaa7c86469b0bbadb94426b21f4474a17dc97de0e9c834"

URI_aarch64_rust-minijinja+fuel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+fuel-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+fuel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+fuel-devel}"
SRC_URI[aarch64_rust-minijinja+fuel-devel.sha256sum] = "8dff044e2a75fd1d7a43865df4e053a50688cd5c383976f98c5763249256376f"

URI_aarch64_rust-minijinja+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+indexmap-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+indexmap-devel}"
SRC_URI[aarch64_rust-minijinja+indexmap-devel.sha256sum] = "e65cfcfafdf312433e9b53830220242243dc401029d9808f3038efbc57745824"

URI_aarch64_rust-minijinja+internal_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_debug-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+internal_debug-devel}"
SRC_URI[aarch64_rust-minijinja+internal_debug-devel.sha256sum] = "f44f4301cdb24f82251b2f4ecb22f29c5309035e54e5a166b1b7a44945706fd6"

URI_aarch64_rust-minijinja+internal_safe_search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_safe_search-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+internal_safe_search-devel}"
SRC_URI[aarch64_rust-minijinja+internal_safe_search-devel.sha256sum] = "13758dbb7615b732ef1919cf214167dca52621735d2b1b29cb99ea397d6ae991"

URI_aarch64_rust-minijinja+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+json-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+json-devel}"
SRC_URI[aarch64_rust-minijinja+json-devel.sha256sum] = "bac19b59a32faff827905b7b3722565ed7a0344ab44857ebf7e88c384dd37e5b"

URI_aarch64_rust-minijinja+key_interning-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+key_interning-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+key_interning-devel}"
SRC_URI[aarch64_rust-minijinja+key_interning-devel.sha256sum] = "38dbc750f6024d511551005b8dbfe5e7f6b2be636ee4655eb9577542e07ab6c7"

URI_aarch64_rust-minijinja+loader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loader-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+loader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+loader-devel}"
SRC_URI[aarch64_rust-minijinja+loader-devel.sha256sum] = "c66b60e91000cb67648b1671eb996e0853f6c30ec8ec291271d9a6deecf65dd6"

URI_aarch64_rust-minijinja+loop_controls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loop_controls-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+loop_controls-devel}"
SRC_URI[aarch64_rust-minijinja+loop_controls-devel.sha256sum] = "18129109ae6ab11547d6c65348b86822977339eb369f168b56bc73b453d05f98"

URI_aarch64_rust-minijinja+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+macros-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+macros-devel}"
SRC_URI[aarch64_rust-minijinja+macros-devel.sha256sum] = "62a625dbc4185756c48186cf8cab880fbf33dcb74d1837a41dc727a6d89d00d6"

URI_aarch64_rust-minijinja+multi_template-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+multi_template-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+multi_template-devel}"
SRC_URI[aarch64_rust-minijinja+multi_template-devel.sha256sum] = "c251f43ac1b09ce7f997f98226ff68a96fc6856ce5d4324de49c6638bd6c7b96"

URI_aarch64_rust-minijinja+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+percent-encoding-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+percent-encoding-devel}"
SRC_URI[aarch64_rust-minijinja+percent-encoding-devel.sha256sum] = "6a3de823447ae749516da15248ed4f9c305cd438163c739b6672b6f426046be8"

URI_aarch64_rust-minijinja+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+preserve_order-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+preserve_order-devel}"
SRC_URI[aarch64_rust-minijinja+preserve_order-devel.sha256sum] = "930c4322c92d0b1e4015b9e6c8511f00339535e1d5d391c5121a820f5a281405"

URI_aarch64_rust-minijinja+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+serde-devel}"
SRC_URI[aarch64_rust-minijinja+serde-devel.sha256sum] = "275e0e58d4101d70168a8fe383fcc7505eda0febfaf8e783670badee9eda43bb"

URI_aarch64_rust-minijinja+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde_json-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+serde_json-devel}"
SRC_URI[aarch64_rust-minijinja+serde_json-devel.sha256sum] = "e580f65604c558c54bba8b98e8a5e2f2e2c55507385ac53e1cd88da8cdc9a5ee"

URI_aarch64_rust-minijinja+speedups-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+speedups-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+speedups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+speedups-devel}"
SRC_URI[aarch64_rust-minijinja+speedups-devel.sha256sum] = "086a16f28e1031d9af854ef0e5bc8d7c6114cd9ffd7f209860f39e2ddace9a88"

URI_aarch64_rust-minijinja+stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+stacker-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+stacker-devel}"
SRC_URI[aarch64_rust-minijinja+stacker-devel.sha256sum] = "1352aa2add163697cf357064d115b13e99f1d378b43c7594016005ed57685bbc"

URI_aarch64_rust-minijinja+std_collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+std_collections-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+std_collections-devel}"
SRC_URI[aarch64_rust-minijinja+std_collections-devel.sha256sum] = "b0ffd9fa7f0d11b488dbb974c38ea067faaf88a60b3a1caac7180c058bbad389"

URI_aarch64_rust-minijinja+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicase-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicase-devel}"
SRC_URI[aarch64_rust-minijinja+unicase-devel.sha256sum] = "6790182077ab0ed7402d35ce99eb869e00d1b1843e6badb976b0edbf8676fb8d"

URI_aarch64_rust-minijinja+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicode-devel}"
SRC_URI[aarch64_rust-minijinja+unicode-devel.sha256sum] = "48da898ebbabfe10f86521d67753414814a4b889a64098e43a7d15ac7c6a5d32"

URI_aarch64_rust-minijinja+unicode-ident-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-ident-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicode-ident-devel}"
SRC_URI[aarch64_rust-minijinja+unicode-ident-devel.sha256sum] = "7cde3ad265e5d2f5f3c701524fbf90a739d6c4af2519a64ddc000fd0a96cdc36"

URI_aarch64_rust-minijinja+unstable_machinery-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unstable_machinery-devel}"
SRC_URI[aarch64_rust-minijinja+unstable_machinery-devel.sha256sum] = "b5ee5946993b941e77daf355f7a6e33a02204487a220843045f1aaef77bd45de"

URI_aarch64_rust-minijinja+unstable_machinery_serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery_serde-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unstable_machinery_serde-devel}"
SRC_URI[aarch64_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "8ea8c6f73ae3793b2ae70453ef2cfab25747578d5139e4029e007c2eb55470d2"

URI_aarch64_rust-minijinja+urlencode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+urlencode-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+urlencode-devel}"
SRC_URI[aarch64_rust-minijinja+urlencode-devel.sha256sum] = "3836160b1bf4600b1cb386d5fdab1c21c2fee60dfac3b4d51a4c758182e472b4"

URI_aarch64_rust-minijinja+v_htmlescape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+v_htmlescape-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+v_htmlescape-devel}"
SRC_URI[aarch64_rust-minijinja+v_htmlescape-devel.sha256sum] = "fb7e39fdca665fd0d47f0121919abff0e45a76e5be826609b9c3162f87f498a4"

URI_aarch64_rust-minijinja-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja-devel-2.23.0-1.el10_3.noarch.rpm;name=aarch64_rust-minijinja-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja-devel}"
SRC_URI[aarch64_rust-minijinja-devel.sha256sum] = "ff506fa5efda39af3d1b46ac0f51162ec9ce1a50041989d5e4066a3b242f4885"

RDEPENDS:rust-minijinja+adjacent_loop_items-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+builtins-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+custom_syntax-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+default-devel = " \
 cargo \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+deserialization-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+fuel-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_safe_search-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+json-devel = " \
 cargo \
 rust-minijinja+serde_json-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+key_interning-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loader-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loop_controls-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+macros-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+multi_template-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+percent-encoding-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-minijinja+preserve_order-devel = " \
 cargo \
 rust-minijinja+indexmap-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde_json-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-minijinja+speedups-devel = " \
 cargo \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+stacker-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-stacker+default-devel \
 "
RDEPENDS:rust-minijinja+std_collections-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicase-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-minijinja+unicode-devel = " \
 cargo \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicode-ident-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicode-ident+default-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery-devel = " \
 cargo \
 rust-minijinja+internal_debug-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery_serde-devel = " \
 cargo \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-minijinja+urlencode-devel = " \
 cargo \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+v_htmlescape-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-v_htmlescape+default-devel \
 "
RDEPENDS:rust-minijinja-devel = " \
 cargo \
 rust \
 rust-memo-map+default-devel \
 rust-serde+default-devel \
 "
