# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-gdrive"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kio-gdrive \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-gdrive-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4e7913efceed3847fbe544e1134de7eb8ef05549215888180bd6095ea1bccaa"

URI_x86_64_v2_kio-gdrive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-gdrive-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-gdrive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-gdrive}"
SRC_URI[x86_64_v2_kio-gdrive.sha256sum] = "9324facb0bb041ffc4f2e5f6b8d26e52c20ce6f8cd86a5ec7b0b9f155442486c"

URI_aarch64_kio-gdrive = "${EPEL_MIRROR}/aarch64/Packages/k/kio-gdrive-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kio-gdrive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-gdrive}"
SRC_URI[aarch64_kio-gdrive.sha256sum] = "f57e8d93961b9b9e695be25f6c0510f45c505e46e32589e96ad16e3c56a3395a"

RDEPENDS:kio-gdrive = " \
 accounts-qml-module-qt6 \
 glibc \
 kaccounts-integration-qt6 \
 kaccounts-providers \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-purpose \
 libaccounts-qt6 \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
