# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sassc"
PV = "3.6.2"
PR = "10.el10_0"
PACKAGES = " \
 sassc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sassc-3.6.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b8fef33a182b90e9e6cf5c74edfd4dcf5971cf9ce071964a3400843bfbeec19"

URI_x86_64_v2_sassc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sassc-3.6.2-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sassc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sassc}"
SRC_URI[x86_64_v2_sassc.sha256sum] = "9a170c22acf622bc4c75a7cab2df66675396a047d5b7c7e8be17039889ec7765"

URI_aarch64_sassc = "${EPEL_MIRROR}/aarch64/Packages/s/sassc-3.6.2-10.el10_0.aarch64.rpm;name=aarch64_sassc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sassc}"
SRC_URI[aarch64_sassc.sha256sum] = "9dd6270718d929069b5b2d8b673f84d68265b51d212c637f94e73e41af05927a"

RDEPENDS:sassc = " \
 glibc \
 libsass \
 "
