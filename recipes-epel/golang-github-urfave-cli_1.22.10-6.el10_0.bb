# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-urfave-cli"
PV = "1.22.10"
PR = "6.el10_0"
PACKAGES = " \
 compat-golang-github-codegangsta-cli-devel \
 compat-golang-gopkg-urfave-cli-1-devel \
 golang-github-urfave-cli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-urfave-cli-1.22.10-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "570bb0578593df86b6275cb65ede447a18c825e57422505a0c2868b22fdea4aa"

URI_x86_64_v2_compat-golang-github-codegangsta-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-codegangsta-cli-devel-1.22.10-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-codegangsta-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-codegangsta-cli-devel}"
SRC_URI[x86_64_v2_compat-golang-github-codegangsta-cli-devel.sha256sum] = "8d87d46480472fc96b921880bd604f9cbe561b8b71db46323e010f96f555f844"

URI_x86_64_v2_compat-golang-gopkg-urfave-cli-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-gopkg-urfave-cli-1-devel-1.22.10-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-gopkg-urfave-cli-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-gopkg-urfave-cli-1-devel}"
SRC_URI[x86_64_v2_compat-golang-gopkg-urfave-cli-1-devel.sha256sum] = "5829b2a9a2d28a735e8266e8e0df636a568478b3f5f8e4dd4f32049ff90956d6"

URI_x86_64_v2_golang-github-urfave-cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-urfave-cli-devel-1.22.10-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-urfave-cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-urfave-cli-devel}"
SRC_URI[x86_64_v2_golang-github-urfave-cli-devel.sha256sum] = "0526ffaf9c90eb0f7feaae224a279c962297785730c530ab4b9ea776edda7d73"

URI_aarch64_compat-golang-github-codegangsta-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-codegangsta-cli-devel-1.22.10-6.el10_0.noarch.rpm;name=aarch64_compat-golang-github-codegangsta-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-codegangsta-cli-devel}"
SRC_URI[aarch64_compat-golang-github-codegangsta-cli-devel.sha256sum] = "ff3c27be4366403449f3fb8e9781210d3ecc3bc10427d34b788c354b54595262"

URI_aarch64_compat-golang-gopkg-urfave-cli-1-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-gopkg-urfave-cli-1-devel-1.22.10-6.el10_0.noarch.rpm;name=aarch64_compat-golang-gopkg-urfave-cli-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-gopkg-urfave-cli-1-devel}"
SRC_URI[aarch64_compat-golang-gopkg-urfave-cli-1-devel.sha256sum] = "53423b5d76d9fbb75555c7247470112e3a2f2653df6990eec99e4d7fce1a697e"

URI_aarch64_golang-github-urfave-cli-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-urfave-cli-devel-1.22.10-6.el10_0.noarch.rpm;name=aarch64_golang-github-urfave-cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-urfave-cli-devel}"
SRC_URI[aarch64_golang-github-urfave-cli-devel.sha256sum] = "d68d4bca2b3fd0fcd31d602cafe8d00a4dd5752f8da0808982e8ae638befb113"

RDEPENDS:compat-golang-github-codegangsta-cli-devel = " \
 go-filesystem \
 golang-github-urfave-cli-devel \
 "
RDEPENDS:compat-golang-gopkg-urfave-cli-1-devel = " \
 go-filesystem \
 golang-github-urfave-cli-devel \
 "
RDEPENDS:golang-github-urfave-cli-devel = " \
 compat-golang-github-cpuguy83-md2man2-devel \
 go-filesystem \
 golang-github-burntsushi-toml-devel \
 golang-gopkg-yaml-2-devel \
 "
