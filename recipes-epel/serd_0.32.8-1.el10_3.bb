# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "serd"
PV = "0.32.8"
PR = "1.el10_3"
PACKAGES = " \
 serd \
 serd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/serd-0.32.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5be15793a119bd66dacccb9f3d7aeae32d9cb0ce0b9bb55c1b02cfa9e76e8f11"

URI_x86_64_v2_serd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/serd-0.32.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_serd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_serd}"
SRC_URI[x86_64_v2_serd.sha256sum] = "20dbb01915a6ab072bcf7e1402f18bb564722d83fcb9d2ae7a5b958372f78584"

URI_x86_64_v2_serd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/serd-devel-0.32.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_serd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_serd-devel}"
SRC_URI[x86_64_v2_serd-devel.sha256sum] = "911491a7a505ce9716e70571dca2d70bf7f1a07e9dea6fd1f395c51487fb5bca"

URI_aarch64_serd = "${EPEL_MIRROR}/aarch64/Packages/s/serd-0.32.8-1.el10_3.aarch64.rpm;name=aarch64_serd;unpack=0"
SRC_URI:append = " ${URI_aarch64_serd}"
SRC_URI[aarch64_serd.sha256sum] = "e79707a368332f76866463c767db60a9f05da005d7443240356307825ffd2adf"

URI_aarch64_serd-devel = "${EPEL_MIRROR}/aarch64/Packages/s/serd-devel-0.32.8-1.el10_3.aarch64.rpm;name=aarch64_serd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_serd-devel}"
SRC_URI[aarch64_serd-devel.sha256sum] = "251187b5720551bbff6473c8febc20b732d9617a1617f4fd3ca259f62ac66df6"

RDEPENDS:serd = " \
 glibc \
 "
RDEPENDS:serd-devel = " \
 pkgconf-pkg-config \
 serd \
 "
