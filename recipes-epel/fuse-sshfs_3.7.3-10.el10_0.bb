# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fuse-sshfs"
PV = "3.7.3"
PR = "10.el10_0"
PACKAGES = " \
 fuse-sshfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fuse-sshfs-3.7.3-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d5863c3f0182b790c3c9be99d8e8aaef19149076d5ebe3263c366bb8c5bd450"

URI_x86_64_v2_fuse-sshfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fuse-sshfs-3.7.3-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fuse-sshfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fuse-sshfs}"
SRC_URI[x86_64_v2_fuse-sshfs.sha256sum] = "f8bed5ba141304fd91929e15f4937348052728d3d0b9de9ce57e9ec5e5012e91"

URI_aarch64_fuse-sshfs = "${EPEL_MIRROR}/aarch64/Packages/f/fuse-sshfs-3.7.3-10.el10_0.aarch64.rpm;name=aarch64_fuse-sshfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fuse-sshfs}"
SRC_URI[aarch64_fuse-sshfs.sha256sum] = "944e9b381cdf0bcab6adb28b1b253e48366ee87fced06eff0e1520a0cd24cedc"

RDEPENDS:fuse-sshfs = " \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 openssh-clients \
 "
