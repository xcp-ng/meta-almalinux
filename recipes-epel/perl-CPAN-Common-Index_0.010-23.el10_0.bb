# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Common-Index"
PV = "0.010"
PR = "23.el10_0"
PACKAGES = " \
 perl-CPAN-Common-Index \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CPAN-Common-Index-0.010-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fdebb1b8e7cd5ca2428e84acc65f1aa3f6a5f61f8d51414423c992de6c38361"

URI_x86_64_v2_perl-CPAN-Common-Index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-Common-Index-0.010-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-Common-Index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-Common-Index}"
SRC_URI[x86_64_v2_perl-CPAN-Common-Index.sha256sum] = "69a96949a52d58d0659d94826364fd9518991ea4f1e559415b4b94171469fd5f"

URI_aarch64_perl-CPAN-Common-Index = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-Common-Index-0.010-23.el10_0.noarch.rpm;name=aarch64_perl-CPAN-Common-Index;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-Common-Index}"
SRC_URI[aarch64_perl-CPAN-Common-Index.sha256sum] = "fa441cb7c9218a564239bac5a35399004c6fb79bd20a1e7ffbf8fb8f6bf67f67"

RDEPENDS:perl-CPAN-Common-Index = " \
 perl-CPAN-Common-Index \
 perl-CPAN-DistnameInfo \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Tiny \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Fetch \
 perl-File-Temp \
 perl-File-stat \
 perl-HTTP-Tiny \
 perl-Module-Load \
 perl-PathTools \
 perl-Search-Dict \
 perl-Tie-Handle-Offset \
 perl-URI \
 perl-libs \
 perl-parent \
 "
