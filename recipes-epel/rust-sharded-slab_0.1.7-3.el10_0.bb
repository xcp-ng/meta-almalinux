# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sharded-slab"
PV = "0.1.7"
PR = "3.el10_0"
PACKAGES = " \
 rust-sharded-slab+default-devel \
 rust-sharded-slab-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sharded-slab-0.1.7-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fda1e65739653e26447971511e11e386fd420d443ad50d6f2ad3eccfb6d3690"

URI_x86_64_v2_rust-sharded-slab+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sharded-slab+default-devel-0.1.7-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sharded-slab+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sharded-slab+default-devel}"
SRC_URI[x86_64_v2_rust-sharded-slab+default-devel.sha256sum] = "38b69f74e54ad0fa61afad27a371bfa7fdb52c24ef796b3d64035fe2fa47cddf"

URI_x86_64_v2_rust-sharded-slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sharded-slab-devel-0.1.7-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sharded-slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sharded-slab-devel}"
SRC_URI[x86_64_v2_rust-sharded-slab-devel.sha256sum] = "bb0d925c1a95e9351fb11c305f95ca30b63044cd4f2c936d75e53fb90e8e2128"

URI_aarch64_rust-sharded-slab+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sharded-slab+default-devel-0.1.7-3.el10_0.noarch.rpm;name=aarch64_rust-sharded-slab+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sharded-slab+default-devel}"
SRC_URI[aarch64_rust-sharded-slab+default-devel.sha256sum] = "27dbd6b53e6eb173580ee43ae76dd4d4556ab3222b8bd0c7e9a3e07d3672c50b"

URI_aarch64_rust-sharded-slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sharded-slab-devel-0.1.7-3.el10_0.noarch.rpm;name=aarch64_rust-sharded-slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sharded-slab-devel}"
SRC_URI[aarch64_rust-sharded-slab-devel.sha256sum] = "c6fcb2e9d630ecac38885b887f9b43ffa7a8661296df2c0f577c96d36db80116"

RDEPENDS:rust-sharded-slab+default-devel = " \
 cargo \
 rust-sharded-slab-devel \
 "
RDEPENDS:rust-sharded-slab-devel = " \
 bash \
 cargo \
 rust \
 rust-lazy_static+default-devel \
 "
