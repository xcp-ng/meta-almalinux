# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knewstuff"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-knewstuff \
 kf6-knewstuff-devel \
 kf6-knewstuff-doc \
 kf6-knewstuff-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knewstuff-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92e442d2e267215201016cbf2fb4c9563a73b9e6394c7ae266ab71d04a3f5a5b"

URI_x86_64_v2_kf6-knewstuff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff}"
SRC_URI[x86_64_v2_kf6-knewstuff.sha256sum] = "d8460e4793fd1bc6d89b93cfe353e88662bb84737cb5c92a2a09900dbe046648"

URI_x86_64_v2_kf6-knewstuff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-devel}"
SRC_URI[x86_64_v2_kf6-knewstuff-devel.sha256sum] = "33b6f075993d88f4cad6d72168080c4f7a0c5afbb4f21183885d5360c2848db6"

URI_x86_64_v2_kf6-knewstuff-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knewstuff-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-doc}"
SRC_URI[x86_64_v2_kf6-knewstuff-doc.sha256sum] = "6fa3eaa8d1cfbfe6bc9a66b94bdc1a1518b1515de83a931b81c7f7ddd61f4955"

URI_x86_64_v2_kf6-knewstuff-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knewstuff-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-html}"
SRC_URI[x86_64_v2_kf6-knewstuff-html.sha256sum] = "41ae84444625d8f5b541441bab607b02d641a827264ba77b01cd78875c613262"

URI_aarch64_kf6-knewstuff = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-knewstuff;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff}"
SRC_URI[aarch64_kf6-knewstuff.sha256sum] = "74a3337a12d2520dd7ab95f396bb9832542fb18eff9c8d56a598a55c6bc8d618"

URI_aarch64_kf6-knewstuff-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-knewstuff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-devel}"
SRC_URI[aarch64_kf6-knewstuff-devel.sha256sum] = "bd21955dedfc1d81497b1989bf2b48efeeff977ec8af925f7b691705abfa1a2e"

URI_aarch64_kf6-knewstuff-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-knewstuff-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-doc}"
SRC_URI[aarch64_kf6-knewstuff-doc.sha256sum] = "85ab4dbf995aef22a5cc7470b8dbc4831c6ddbcee8e51b9b8d366f63a5eb1e46"

URI_aarch64_kf6-knewstuff-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-knewstuff-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-html}"
SRC_URI[aarch64_kf6-knewstuff-html.sha256sum] = "65a9e35395c9c1120737a3d31f84275782cabc82d2d67a5609c46859304703b9"

RDEPENDS:kf6-knewstuff = " \
 glibc \
 kf6-attica \
 kf6-filesystem \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kwidgetsaddons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knewstuff-devel = " \
 cmake-filesystem \
 glibc \
 kf6-attica-devel \
 kf6-knewstuff \
 kf6-kservice-devel \
 kf6-kxmlgui-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knewstuff-doc = " \
 "
RDEPENDS:kf6-knewstuff-html = " \
 "
