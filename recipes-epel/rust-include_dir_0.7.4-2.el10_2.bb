# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-include_dir"
PV = "0.7.4"
PR = "2.el10_2"
PACKAGES = " \
 rust-include_dir+default-devel \
 rust-include_dir+glob-devel \
 rust-include_dir+metadata-devel \
 rust-include_dir+nightly-devel \
 rust-include_dir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-include_dir-0.7.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73aefa7a5a273fef0a0b6ed29e4e6410a8a00534ed8a770eb9ac3117fd6737e8"

URI_x86_64_v2_rust-include_dir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-include_dir+default-devel-0.7.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-include_dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-include_dir+default-devel}"
SRC_URI[x86_64_v2_rust-include_dir+default-devel.sha256sum] = "939068b4fffff14122383a4092536f0851601b654948f77796ecadbac454d2fe"

URI_x86_64_v2_rust-include_dir+glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-include_dir+glob-devel-0.7.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-include_dir+glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-include_dir+glob-devel}"
SRC_URI[x86_64_v2_rust-include_dir+glob-devel.sha256sum] = "1160cf811f0d904fddf354e16a699444986d1b43a91e20f4db5fc5ae5d8eae2d"

URI_x86_64_v2_rust-include_dir+metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-include_dir+metadata-devel-0.7.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-include_dir+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-include_dir+metadata-devel}"
SRC_URI[x86_64_v2_rust-include_dir+metadata-devel.sha256sum] = "2adbee1717d362a53b0c0be3cc500bc1d069ccc20dd0aac4652a20b628891536"

URI_x86_64_v2_rust-include_dir+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-include_dir+nightly-devel-0.7.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-include_dir+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-include_dir+nightly-devel}"
SRC_URI[x86_64_v2_rust-include_dir+nightly-devel.sha256sum] = "f38d904012696be51ab29b0b05ef89ee1a139b261b2e474357e534169960e25d"

URI_x86_64_v2_rust-include_dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-include_dir-devel-0.7.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-include_dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-include_dir-devel}"
SRC_URI[x86_64_v2_rust-include_dir-devel.sha256sum] = "fcfc4f80e6e5b63f9f3eab50d8eefd223cf8ceeb52f588f30860e50266b19832"

URI_aarch64_rust-include_dir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-include_dir+default-devel-0.7.4-2.el10_2.noarch.rpm;name=aarch64_rust-include_dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-include_dir+default-devel}"
SRC_URI[aarch64_rust-include_dir+default-devel.sha256sum] = "30146736df8ff05ae2695566b686c008c3bfb599aa2d526a041e8a25d0ac68d2"

URI_aarch64_rust-include_dir+glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-include_dir+glob-devel-0.7.4-2.el10_2.noarch.rpm;name=aarch64_rust-include_dir+glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-include_dir+glob-devel}"
SRC_URI[aarch64_rust-include_dir+glob-devel.sha256sum] = "aa36455af458e7a903194849dc30044b263ee672b0ad2088b57dac0b004b80d7"

URI_aarch64_rust-include_dir+metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-include_dir+metadata-devel-0.7.4-2.el10_2.noarch.rpm;name=aarch64_rust-include_dir+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-include_dir+metadata-devel}"
SRC_URI[aarch64_rust-include_dir+metadata-devel.sha256sum] = "320f809f83033fa6075772ce63a70d056bb0301447d7fdda02a3e51d03316f4f"

URI_aarch64_rust-include_dir+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-include_dir+nightly-devel-0.7.4-2.el10_2.noarch.rpm;name=aarch64_rust-include_dir+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-include_dir+nightly-devel}"
SRC_URI[aarch64_rust-include_dir+nightly-devel.sha256sum] = "085d766948802480025f75266f73f956b17134f170f9c464e7c13ba2ea260fc2"

URI_aarch64_rust-include_dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-include_dir-devel-0.7.4-2.el10_2.noarch.rpm;name=aarch64_rust-include_dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-include_dir-devel}"
SRC_URI[aarch64_rust-include_dir-devel.sha256sum] = "8473d9191a7eefcc3253fd5946a979e8567781bf7e80741201c5e8ac946f57ee"

RDEPENDS:rust-include_dir+default-devel = " \
 cargo \
 rust-include_dir-devel \
 "
RDEPENDS:rust-include_dir+glob-devel = " \
 cargo \
 rust-glob+default-devel \
 rust-include_dir-devel \
 "
RDEPENDS:rust-include_dir+metadata-devel = " \
 cargo \
 rust-include_dir-devel \
 rust-include_dir_macros+metadata-devel \
 "
RDEPENDS:rust-include_dir+nightly-devel = " \
 cargo \
 rust-include_dir-devel \
 rust-include_dir_macros+nightly-devel \
 "
RDEPENDS:rust-include_dir-devel = " \
 cargo \
 rust \
 rust-include_dir_macros+default-devel \
 "
