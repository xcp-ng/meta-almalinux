# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Lmod"
PV = "8.7.65"
PR = "2.el10_2"
PACKAGES = " \
 Lmod \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/Lmod-8.7.65-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6c499e01239d9f85841a5a9741f2358e97e5e61fb3f2529f030a2347f7281739"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Lmod-8.7.65-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Lmod;unpack=0"
SRC_URI[x86_64_v2_Lmod.sha256sum] = "353ff63de00d0cf0badd278bbe1c1e038b0ef7bd9de999a84abb01b14fd382bf"
RPROVIDES:Lmod:append:x86_64_v2 = " virtual/environment_modules_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/Lmod-8.7.65-2.el10_2.aarch64.rpm;name=aarch64_Lmod;unpack=0"
SRC_URI[aarch64_Lmod.sha256sum] = "1adc2176df525bce7a39e2862e71250318f80be8fefed66245a1be440c99f05d"
RPROVIDES:Lmod:append:aarch64 = " virtual/environment_modules_"

RDEPENDS:Lmod = " \
 alternatives \
 bash \
 glibc \
 lua-filesystem \
 lua-json \
 lua-posix \
 lua-term \
 procps-ng \
 tcl \
 virtual/coreutils \
 "
