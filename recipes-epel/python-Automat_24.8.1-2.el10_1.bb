# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-Automat"
PV = "24.8.1"
PR = "2.el10_1"
PACKAGES = " \
 python3-Automat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-Automat-24.8.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c184fe225ab7d7a2842a89182f6afcfb5c3917f0f146b6bf47e9328dc557917"

URI_x86_64_v2_python3-Automat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-Automat-24.8.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-Automat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-Automat}"
SRC_URI[x86_64_v2_python3-Automat.sha256sum] = "8f5ef455a45e3dc13edbfb85cd8c97090f349edc58b13332277b7a6b352fcd2e"

URI_aarch64_python3-Automat = "${EPEL_MIRROR}/aarch64/Packages/p/python3-Automat-24.8.1-2.el10_1.noarch.rpm;name=aarch64_python3-Automat;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-Automat}"
SRC_URI[aarch64_python3-Automat.sha256sum] = "426614b2fefb933cf963eb978b886d89c9efe09e8e70b5cd3f7950d7ffcb283a"

RDEPENDS:python3-Automat = " \
 python3 \
 "
