# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyqt6-webengine"
PV = "6.9.0"
PR = "0.1.el10_2"
PACKAGES = " \
 python3-pyqt6-webengine \
 python3-pyqt6-webengine-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyqt6-webengine-6.9.0-0.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0268d24638c21b66b1be9ed9f06ba39824aa424fc7aad152bffce00a4aab4fe4"

URI_x86_64_v2_python3-pyqt6-webengine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyqt6-webengine-6.9.0-0.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-webengine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-webengine}"
SRC_URI[x86_64_v2_python3-pyqt6-webengine.sha256sum] = "6b3af443adf0df4240c6ea3c44e60cbd3f8930f87a7a86e5dc3f3a7643e37b77"

URI_x86_64_v2_python3-pyqt6-webengine-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyqt6-webengine-devel-6.9.0-0.1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-webengine-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-webengine-devel}"
SRC_URI[x86_64_v2_python3-pyqt6-webengine-devel.sha256sum] = "3f8e2b2106d45192fb910f79a717f0d46278fde4f02bbd5d6483b9cd370c5534"

URI_aarch64_python3-pyqt6-webengine = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyqt6-webengine-6.9.0-0.1.el10_2.aarch64.rpm;name=aarch64_python3-pyqt6-webengine;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-webengine}"
SRC_URI[aarch64_python3-pyqt6-webengine.sha256sum] = "63eb18c7347c138268a22626c84c75b9a08a8a935b04b5e422226fbcbe3edbc3"

URI_aarch64_python3-pyqt6-webengine-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyqt6-webengine-devel-6.9.0-0.1.el10_2.aarch64.rpm;name=aarch64_python3-pyqt6-webengine-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-webengine-devel}"
SRC_URI[aarch64_python3-pyqt6-webengine-devel.sha256sum] = "c113d6e320c8bec38287e38d674f1c000e4ed2c00d6aa26dc49e2abce1a3530b"

RDEPENDS:python3-pyqt6-webengine = " \
 glibc \
 libstdc++ \
 python3 \
 python3-pyqt6 \
 python3-pyqt6-base \
 python3-pyqt6-sip \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:python3-pyqt6-webengine-devel = " \
 python3-pyqt6-devel \
 python3-pyqt6-webengine \
 "
