# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ossl"
PV = "1.5.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-ossl+default-devel \
 rust-ossl+openssl-sys-devel \
 rust-ossl+ossl320-devel \
 rust-ossl+ossl350-devel \
 rust-ossl+ossl400-devel \
 rust-ossl+rfc9580-devel \
 rust-ossl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ossl-1.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4aaab7b61bb6ec8e785cdf65b5af00dce4da60511f924d280a272f2b03b5cfe"

URI_x86_64_v2_rust-ossl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+default-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+default-devel}"
SRC_URI[x86_64_v2_rust-ossl+default-devel.sha256sum] = "196f985a32a5edd34a0fd6014b2696f978c1ae417c7ebcd48ce45aaa89e4d980"

URI_x86_64_v2_rust-ossl+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+openssl-sys-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-ossl+openssl-sys-devel.sha256sum] = "87487a845489a076ccf3b28166680e12ae551bbfc516574b2c10ea257348888c"

URI_x86_64_v2_rust-ossl+ossl320-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+ossl320-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+ossl320-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+ossl320-devel}"
SRC_URI[x86_64_v2_rust-ossl+ossl320-devel.sha256sum] = "f25511a34483bea3372c3a80fa4e9ec79080ee96de30ffad69c4e7126cafd959"

URI_x86_64_v2_rust-ossl+ossl350-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+ossl350-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+ossl350-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+ossl350-devel}"
SRC_URI[x86_64_v2_rust-ossl+ossl350-devel.sha256sum] = "748dd065696eca4084b701d36bd00213200c8b6c5f35cc6b42b00cba73146b5a"

URI_x86_64_v2_rust-ossl+ossl400-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+ossl400-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+ossl400-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+ossl400-devel}"
SRC_URI[x86_64_v2_rust-ossl+ossl400-devel.sha256sum] = "d9c9f528394dda721b579252de734521c43d4efaeafcb214e8240e56dd1c52f2"

URI_x86_64_v2_rust-ossl+rfc9580-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+rfc9580-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+rfc9580-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+rfc9580-devel}"
SRC_URI[x86_64_v2_rust-ossl+rfc9580-devel.sha256sum] = "d02c32ebcd3cb121a49c5103bb47080c2da44f32808ed71ee3a7f3eeaa0cb46d"

URI_x86_64_v2_rust-ossl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl-devel-1.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl-devel}"
SRC_URI[x86_64_v2_rust-ossl-devel.sha256sum] = "79e3bcc74f14977ebf299c4a805cc2109ff1b7406b8fa0612412cb5f2f3328e7"

URI_aarch64_rust-ossl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+default-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+default-devel}"
SRC_URI[aarch64_rust-ossl+default-devel.sha256sum] = "87adac05db36336a2834e16d2043d0189da78961b12807308936be6ee11356eb"

URI_aarch64_rust-ossl+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+openssl-sys-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+openssl-sys-devel}"
SRC_URI[aarch64_rust-ossl+openssl-sys-devel.sha256sum] = "a645cbf4352d6bc846be8240c275f103c2c0464791d88418bdbd7ff79bcd1e9f"

URI_aarch64_rust-ossl+ossl320-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+ossl320-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+ossl320-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+ossl320-devel}"
SRC_URI[aarch64_rust-ossl+ossl320-devel.sha256sum] = "138e39c99afe413e6040d253d8df5e514d8e54449fb85442772af8e5c251c47c"

URI_aarch64_rust-ossl+ossl350-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+ossl350-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+ossl350-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+ossl350-devel}"
SRC_URI[aarch64_rust-ossl+ossl350-devel.sha256sum] = "3ac20a603064ced2b0dee127ef4f36508ac3968651beeac6f45b3301fb8a01cc"

URI_aarch64_rust-ossl+ossl400-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+ossl400-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+ossl400-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+ossl400-devel}"
SRC_URI[aarch64_rust-ossl+ossl400-devel.sha256sum] = "9b3584c72a12c8436b3e1d0342c8ea2d107dd159c656fb5cfa30baf2f786740c"

URI_aarch64_rust-ossl+rfc9580-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+rfc9580-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-ossl+rfc9580-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+rfc9580-devel}"
SRC_URI[aarch64_rust-ossl+rfc9580-devel.sha256sum] = "a1f4bf773c5f7a93db255fa3271f6e1e3a5050f8f504823a93b1c5cea5c281a0"

URI_aarch64_rust-ossl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl-devel-1.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-ossl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl-devel}"
SRC_URI[aarch64_rust-ossl-devel.sha256sum] = "178058f226930f5584379537104cdc6a905ff7c4f3b1117790ba5d612d4298e8"

RDEPENDS:rust-ossl+default-devel = " \
 cargo \
 rust-ossl+openssl-sys-devel \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+openssl-sys-devel = " \
 cargo \
 rust-openssl-sys+bindgen-devel \
 rust-openssl-sys+default-devel \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+ossl320-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+ossl350-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+ossl400-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+rfc9580-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl-devel = " \
 cargo \
 rust-bindgen+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
