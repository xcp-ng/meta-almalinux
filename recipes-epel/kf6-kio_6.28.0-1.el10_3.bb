# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kio"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kio \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-devel \
 kf6-kio-doc \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-html \
 kf6-kio-qch-doc \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kio-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f3d1c0ff0cc48b70c114e85dce27b03499770f4daa69d077387991ee66f340f"

URI_x86_64_v2_kf6-kio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio}"
SRC_URI[x86_64_v2_kf6-kio.sha256sum] = "a2a4657d3268fef258e0250ea8c65dc8d9d96eb65bb7c78c89567dbc924aff96"

URI_x86_64_v2_kf6-kio-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-core}"
SRC_URI[x86_64_v2_kf6-kio-core.sha256sum] = "bebad295fde5f63f2778fc37262ec3da0560adb0c2f3f32fe6f648c3c3783b27"

URI_x86_64_v2_kf6-kio-core-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-core-libs-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-core-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-core-libs}"
SRC_URI[x86_64_v2_kf6-kio-core-libs.sha256sum] = "5a75a699c2584ddbdda4657db33ef6f592e69ce004e099507868e04b8cf3ad43"

URI_x86_64_v2_kf6-kio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-devel}"
SRC_URI[x86_64_v2_kf6-kio-devel.sha256sum] = "a10765a83b99fb1eeadbdfb9feddd5cd17f8e7b380971084a57ab40b51bb70df"

URI_x86_64_v2_kf6-kio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-doc}"
SRC_URI[x86_64_v2_kf6-kio-doc.sha256sum] = "5ecc787f690684493dd754b85e420e61eb33e43c4ef13838b281b227cf77831d"

URI_x86_64_v2_kf6-kio-file-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-file-widgets-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-file-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-file-widgets}"
SRC_URI[x86_64_v2_kf6-kio-file-widgets.sha256sum] = "6e2b591616269600ae80f4989022ff599d323381dc384fe4fd3c8e9d06fb4513"

URI_x86_64_v2_kf6-kio-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-gui-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-gui}"
SRC_URI[x86_64_v2_kf6-kio-gui.sha256sum] = "464cbbcb884ffae20d88e48bede78baa06b9e43da5753564f49d9cc7f51232ca"

URI_x86_64_v2_kf6-kio-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-html}"
SRC_URI[x86_64_v2_kf6-kio-html.sha256sum] = "639297dad4e66d7ea02a7e6938979922b3619295cfd99421e443f079b47162cc"

URI_x86_64_v2_kf6-kio-qch-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-qch-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kio-qch-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-qch-doc}"
SRC_URI[x86_64_v2_kf6-kio-qch-doc.sha256sum] = "bfd7da3a850d751e0aa4e4e4d613c7fedc3fcc537b46e3f1beeda9b7041583e5"

URI_x86_64_v2_kf6-kio-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-widgets}"
SRC_URI[x86_64_v2_kf6-kio-widgets.sha256sum] = "02a81103f3ce50b74dc0404f0997780dbaea6359011324449d749b22708efbbe"

URI_x86_64_v2_kf6-kio-widgets-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kio-widgets-libs-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kio-widgets-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kio-widgets-libs}"
SRC_URI[x86_64_v2_kf6-kio-widgets-libs.sha256sum] = "e2b0df9d3bc89a0ee6715c5efafc07bda9ba8d29d9eea5ae7a1428c4264f3b83"

URI_aarch64_kf6-kio = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio}"
SRC_URI[aarch64_kf6-kio.sha256sum] = "b507a3f4efbac65a1122678cea69bea5230ef840dda43e48e67e28e8ea39050b"

URI_aarch64_kf6-kio-core = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-core}"
SRC_URI[aarch64_kf6-kio-core.sha256sum] = "565733ccc9d5e5475a56b4e435053d04b1e37816b1b261cbc97cab53646f0db0"

URI_aarch64_kf6-kio-core-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-core-libs-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-core-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-core-libs}"
SRC_URI[aarch64_kf6-kio-core-libs.sha256sum] = "e12c713fca3d924f70305a1a8d21680350e815585585ed54e92b0de15951d655"

URI_aarch64_kf6-kio-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-devel}"
SRC_URI[aarch64_kf6-kio-devel.sha256sum] = "392bbc289060921336ca41815e0e610cacb1077e524ba5f53bd4da1e308c5fe4"

URI_aarch64_kf6-kio-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-doc}"
SRC_URI[aarch64_kf6-kio-doc.sha256sum] = "f2298f0e730e8b4a9582c8887ba31fe198436fee4a0d9935cd423e495c9a7cbb"

URI_aarch64_kf6-kio-file-widgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-file-widgets-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-file-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-file-widgets}"
SRC_URI[aarch64_kf6-kio-file-widgets.sha256sum] = "1f5b0266e9c8c1533ba0949a0ef547f709720be32a52898ec3a5ac7a1a285ddd"

URI_aarch64_kf6-kio-gui = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-gui-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-gui}"
SRC_URI[aarch64_kf6-kio-gui.sha256sum] = "8bdc18be0cab3f8b53a722a94ae031c4836acf28f205e65295cecc20dd29981f"

URI_aarch64_kf6-kio-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kio-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-html}"
SRC_URI[aarch64_kf6-kio-html.sha256sum] = "ab3a40cc809b145c1d90334cb2be20cd7d9114003ab2f8f5b9cf7f76ba47e456"

URI_aarch64_kf6-kio-qch-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-qch-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kio-qch-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-qch-doc}"
SRC_URI[aarch64_kf6-kio-qch-doc.sha256sum] = "7ae9101673b86b2e881d35023a67b6399592ec544df11af7b4363f1215f23075"

URI_aarch64_kf6-kio-widgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-widgets}"
SRC_URI[aarch64_kf6-kio-widgets.sha256sum] = "5251c51931a68b922ec5d4f485f970fd19920fffd2ad93621ad19ce55b91af0d"

URI_aarch64_kf6-kio-widgets-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kio-widgets-libs-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kio-widgets-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kio-widgets-libs}"
SRC_URI[aarch64_kf6-kio-widgets-libs.sha256sum] = "9aa052f7fe5a1d07e037220167834ad36cb4db98da3d0f078ba743ecf0a4d846"

RDEPENDS:kf6-kio = " \
 kf6-kded \
 kf6-kio-core \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 "
RDEPENDS:kf6-kio-core = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdoctools \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-doc \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libacl \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-core-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kservice \
 libacl \
 libmount \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kbookmarks-devel \
 kf6-kcompletion-devel \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kio \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews-devel \
 kf6-kjobwidgets-devel \
 kf6-kservice-devel \
 kf6-kwindowsystem-devel \
 kf6-kxmlgui-devel \
 kf6-solid-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-doc = " \
 kf6-kio-core \
 "
RDEPENDS:kf6-kio-file-widgets = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-gui = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kio-html = " \
 "
RDEPENDS:kf6-kio-qch-doc = " \
 "
RDEPENDS:kf6-kio-widgets = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kservice \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kio-widgets-libs = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
