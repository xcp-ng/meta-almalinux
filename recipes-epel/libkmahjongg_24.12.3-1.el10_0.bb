# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkmahjongg"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkmahjongg \
 libkmahjongg-data \
 libkmahjongg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkmahjongg-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8999c0bbb7de9b805cb74ead16df160867430050d67b888a1dbafe7bcf86109"

URI_x86_64_v2_libkmahjongg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkmahjongg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkmahjongg}"
SRC_URI[x86_64_v2_libkmahjongg.sha256sum] = "38b61da015e27b2bafb2f44233ec21d77914f3dd3596f00fb699b2b73c5a8922"

URI_x86_64_v2_libkmahjongg-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-data-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libkmahjongg-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkmahjongg-data}"
SRC_URI[x86_64_v2_libkmahjongg-data.sha256sum] = "de72cb4da9f999dd8e6b9442ebd58928e8116fc5bc87b6cf64059137b025cb8e"

URI_x86_64_v2_libkmahjongg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkmahjongg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkmahjongg-devel}"
SRC_URI[x86_64_v2_libkmahjongg-devel.sha256sum] = "a0b8ae25c31a4ddcc5043745f8391100aa23543a638224f435aae6bacf20421a"

URI_aarch64_libkmahjongg = "${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkmahjongg;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkmahjongg}"
SRC_URI[aarch64_libkmahjongg.sha256sum] = "ae383cfab1ece46628af0589adf701aa01567628ca8c53b210099b401d6a8f5c"

URI_aarch64_libkmahjongg-data = "${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-data-24.12.3-1.el10_0.noarch.rpm;name=aarch64_libkmahjongg-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkmahjongg-data}"
SRC_URI[aarch64_libkmahjongg-data.sha256sum] = "c7049f34402104b90870262e9c6858bc3ff613c33c0e64c1b0f858c83743bc89"

URI_aarch64_libkmahjongg-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkmahjongg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkmahjongg-devel}"
SRC_URI[aarch64_libkmahjongg-devel.sha256sum] = "26562beb5a5095ac12981e462956dd945cff9e5aa461bad89b199ee71d400b3d"

RDEPENDS:libkmahjongg = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libkmahjongg-data \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:libkmahjongg-data = " \
 "
RDEPENDS:libkmahjongg-devel = " \
 cmake-filesystem \
 kf6-kconfigwidgets-devel \
 libkmahjongg \
 qt6-qtbase-devel \
 "
