# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simd-adler32"
PV = "0.3.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-simd-adler32+const-generics-devel \
 rust-simd-adler32+default-devel \
 rust-simd-adler32+nightly-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-simd-adler32-0.3.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "68bde78dbdc88376ffef98a63d4a127663dad3cceea53bcf0afab0b3d8451412"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+const-generics-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+const-generics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-simd-adler32+const-generics-devel.sha256sum] = "93ea06d5790ffbecdab8b655b2db66909845e2cf2752771d37c7cdad70423fb0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+default-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-simd-adler32+default-devel.sha256sum] = "02019f446f6508d6f5f3342cd3b13d636c86db114fe8d4fa099224aa149ea341"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+nightly-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-simd-adler32+nightly-devel.sha256sum] = "a748ab41feee836e22404e58e22b6023faebf1988cb7a480d092d0a8b7b7ce64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+std-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-simd-adler32+std-devel.sha256sum] = "1ae3fead9c5dd88d3bc1e228dbde09deeb93604c6bc30f65870fd8b21691f4e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32-devel;unpack=0"
SRC_URI[x86_64_v2_rust-simd-adler32-devel.sha256sum] = "7fa438cae0f32c0fe2bbeba9aa078733aa7c1b8f8bf7d01eb6b85fdc14c32013"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+const-generics-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-simd-adler32+const-generics-devel;unpack=0"
SRC_URI[aarch64_rust-simd-adler32+const-generics-devel.sha256sum] = "d408aa52d4a6772de9ec4360b0fca5b005c2d84d57d184a54aa564ef2d7602fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+default-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-simd-adler32+default-devel;unpack=0"
SRC_URI[aarch64_rust-simd-adler32+default-devel.sha256sum] = "d556476ca4ea9e2a013d688c6a8eb25e8ca227b67e00ef9b55979ec876a8591d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+nightly-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-simd-adler32+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-simd-adler32+nightly-devel.sha256sum] = "7bb7b49f37109792e55b72ccc9b25897a3026fe052f831678ac4806db47e69bd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+std-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-simd-adler32+std-devel;unpack=0"
SRC_URI[aarch64_rust-simd-adler32+std-devel.sha256sum] = "ddc973370a179204cfdfc8202cf7ac2d95ac305f52d1eb04f7cf827dd7fc18d1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-simd-adler32-devel;unpack=0"
SRC_URI[aarch64_rust-simd-adler32-devel.sha256sum] = "4aef02813bfcbdcecd89d66411c2281d1f29ea7c625b312a0ff84c5caed9e5c0"

RDEPENDS:rust-simd-adler32+const-generics-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+default-devel = " \
 cargo \
 rust-simd-adler32+const-generics-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+nightly-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+std-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32-devel = " \
 cargo \
 "
