# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kspaceduel"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kspaceduel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kspaceduel-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e665e3a6aba476a0ad0a2ac3f12d3e9c1bc5d2a249b302139b5d317e157631fe"

URI_x86_64_v2_kspaceduel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kspaceduel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kspaceduel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kspaceduel}"
SRC_URI[x86_64_v2_kspaceduel.sha256sum] = "e3c25ec7b0df008ef1968dd1487a3df624d21b308c38ba82dee335ad119e81e6"

URI_aarch64_kspaceduel = "${EPEL_MIRROR}/aarch64/Packages/k/kspaceduel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kspaceduel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kspaceduel}"
SRC_URI[aarch64_kspaceduel.sha256sum] = "9f8c20f3e766fcde309308ca221ef8202fec0aa92b03a1a3e2745e968c4592f5"

RDEPENDS:kspaceduel = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
