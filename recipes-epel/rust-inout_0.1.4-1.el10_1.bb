# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inout"
PV = "0.1.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-inout+block-padding-devel \
 rust-inout+default-devel \
 rust-inout+std-devel \
 rust-inout-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inout-0.1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9893e720f38f5c39b2536dd4ec943947930e3449fa6f047cbbb303704bd15605"

URI_x86_64_v2_rust-inout+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout+block-padding-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout+block-padding-devel}"
SRC_URI[x86_64_v2_rust-inout+block-padding-devel.sha256sum] = "4233f6beefdd6a67f2504c01aed00e03bcd6e9d85bc73155c5c2444e560e447c"

URI_x86_64_v2_rust-inout+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout+default-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout+default-devel}"
SRC_URI[x86_64_v2_rust-inout+default-devel.sha256sum] = "54e798165850e0102c5208a2e24d872ffa6567a824219b1b50d4fe61e3e81ec5"

URI_x86_64_v2_rust-inout+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout+std-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout+std-devel}"
SRC_URI[x86_64_v2_rust-inout+std-devel.sha256sum] = "6859b567ce8aa67ec9d2c46c481e7dd0dbaba4b004b3e1374926f0724c3213ed"

URI_x86_64_v2_rust-inout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout-devel}"
SRC_URI[x86_64_v2_rust-inout-devel.sha256sum] = "fe76d1b41e209f655048364a0eb2ac6f4f8fac056ba990123c9fac0331af0dc1"

URI_aarch64_rust-inout+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout+block-padding-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-inout+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout+block-padding-devel}"
SRC_URI[aarch64_rust-inout+block-padding-devel.sha256sum] = "9a86aa8754d845a52183ca7729b616ca60dda9d1eb4de40c2d1d0fa0ce4ac1b7"

URI_aarch64_rust-inout+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout+default-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-inout+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout+default-devel}"
SRC_URI[aarch64_rust-inout+default-devel.sha256sum] = "1e5f9f7584eee83eaaafa5490a6f69a1e0f45fe781be5f497de3f628e4ecacf3"

URI_aarch64_rust-inout+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout+std-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-inout+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout+std-devel}"
SRC_URI[aarch64_rust-inout+std-devel.sha256sum] = "9fd7899f089a6d1e4c51eda3ef2b52818b4713deeaded3e00fdde09c28738603"

URI_aarch64_rust-inout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-inout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout-devel}"
SRC_URI[aarch64_rust-inout-devel.sha256sum] = "b3c13dd73d7fcec67bd70d7955085e01ceb3317b0f505bc180245be7d0a2c81a"

RDEPENDS:rust-inout+block-padding-devel = " \
 cargo \
 rust-block-padding+default-devel \
 rust-inout-devel \
 "
RDEPENDS:rust-inout+default-devel = " \
 cargo \
 rust-inout-devel \
 "
RDEPENDS:rust-inout+std-devel = " \
 cargo \
 rust-block-padding+default-devel \
 rust-block-padding+std-devel \
 rust-inout-devel \
 "
RDEPENDS:rust-inout-devel = " \
 cargo \
 rust \
 rust-generic-array+default-devel \
 "
