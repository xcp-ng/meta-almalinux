# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql18-pg_partman"
PV = "5.4.3"
PR = "2.el10_2"
PACKAGES = " \
 postgresql18-pg_partman \
 postgresql18-pg_partman-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/postgresql18-pg_partman-5.4.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba05dbdb980dab9b8f1d8edd39ad6e94cdcef3e13ddb012c3642ed22c923b67b"

URI_x86_64_v2_postgresql18-pg_partman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/postgresql18-pg_partman-5.4.3-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_postgresql18-pg_partman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-pg_partman}"
SRC_URI[x86_64_v2_postgresql18-pg_partman.sha256sum] = "068c61e47d49ca3599ee249cf491fbbe3ebc2ae8f616517d8f30030664d311ea"

URI_x86_64_v2_postgresql18-pg_partman-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/postgresql18-pg_partman-doc-5.4.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_postgresql18-pg_partman-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-pg_partman-doc}"
SRC_URI[x86_64_v2_postgresql18-pg_partman-doc.sha256sum] = "06abf3e01c96ecccd4dc9a93d2ba1a9e641794ba29608e0c3dd1103fb01fe894"

URI_aarch64_postgresql18-pg_partman = "${EPEL_MIRROR}/aarch64/Packages/p/postgresql18-pg_partman-5.4.3-2.el10_2.aarch64.rpm;name=aarch64_postgresql18-pg_partman;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-pg_partman}"
SRC_URI[aarch64_postgresql18-pg_partman.sha256sum] = "77ca47b43250cc4c4f257ded292eb46d206423f6adc221c762d2a7876726623e"

URI_aarch64_postgresql18-pg_partman-doc = "${EPEL_MIRROR}/aarch64/Packages/p/postgresql18-pg_partman-doc-5.4.3-2.el10_2.noarch.rpm;name=aarch64_postgresql18-pg_partman-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-pg_partman-doc}"
SRC_URI[aarch64_postgresql18-pg_partman-doc.sha256sum] = "1d6127740825d8d89831469c9d285810aea73ec30cfc78ba745d10ea84fc9d37"

RDEPENDS:postgresql18-pg_partman = " \
 glibc \
 postgresql18-server \
 python3 \
 "
RDEPENDS:postgresql18-pg_partman-doc = " \
 postgresql18-pg_partman \
 "
