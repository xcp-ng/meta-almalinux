# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nix"
PV = "0.29.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-nix+acct-devel \
 rust-nix+aio-devel \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+env-devel \
 rust-nix+event-devel \
 rust-nix+fanotify-devel \
 rust-nix+feature-devel \
 rust-nix+fs-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+kmod-devel \
 rust-nix+memoffset-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+mqueue-devel \
 rust-nix+net-devel \
 rust-nix+personality-devel \
 rust-nix+pin-utils-devel \
 rust-nix+poll-devel \
 rust-nix+process-devel \
 rust-nix+pthread-devel \
 rust-nix+ptrace-devel \
 rust-nix+quota-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+socket-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+ucontext-devel \
 rust-nix+uio-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-nix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nix-0.29.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da7ab9c420951c88cb72a13514b56d9acd357ea4137ed4a62c629d7232877b98"

URI_x86_64_v2_rust-nix+acct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+acct-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+acct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+acct-devel}"
SRC_URI[x86_64_v2_rust-nix+acct-devel.sha256sum] = "9f7b237a2b2fb89d33ee3048c5a1ff1b97688c711532dfcbdf7d958ec1d60656"

URI_x86_64_v2_rust-nix+aio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+aio-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+aio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+aio-devel}"
SRC_URI[x86_64_v2_rust-nix+aio-devel.sha256sum] = "65ea1ebc63409a9a1e415a57442058d198b9c6cf27c734b29daf7379d2445e6e"

URI_x86_64_v2_rust-nix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+default-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+default-devel}"
SRC_URI[x86_64_v2_rust-nix+default-devel.sha256sum] = "f9458f216f8e82a6bda3f65205c705df198b59da046ee21b42d6693cbadc8d55"

URI_x86_64_v2_rust-nix+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+dir-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+dir-devel}"
SRC_URI[x86_64_v2_rust-nix+dir-devel.sha256sum] = "0dfda6fe9b8af1fdb873c3e71e4e927ef15a94dbdc4c685487e086fb9d309e74"

URI_x86_64_v2_rust-nix+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+env-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+env-devel}"
SRC_URI[x86_64_v2_rust-nix+env-devel.sha256sum] = "9c967b14504d706f76da0d4c87af8d4d9189fd3364d111210971e3d467a5aa86"

URI_x86_64_v2_rust-nix+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+event-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+event-devel}"
SRC_URI[x86_64_v2_rust-nix+event-devel.sha256sum] = "e610f3ef4183daf47fc02e3dfeb37064d5bb73f14de3dfbb8de28e6035f7d0a7"

URI_x86_64_v2_rust-nix+fanotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+fanotify-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+fanotify-devel}"
SRC_URI[x86_64_v2_rust-nix+fanotify-devel.sha256sum] = "4e6179eb96b2e334217f732fd78d0f76b88595eb9db90ff57b680117a554c06c"

URI_x86_64_v2_rust-nix+feature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+feature-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+feature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+feature-devel}"
SRC_URI[x86_64_v2_rust-nix+feature-devel.sha256sum] = "1c99fbc744a2fc94dc2392415f524da26e6600d1ee3150ada470162de9bca590"
RPROVIDES:rust-nix+feature-devel:x86_64_v2 = "virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~"

URI_x86_64_v2_rust-nix+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+fs-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+fs-devel}"
SRC_URI[x86_64_v2_rust-nix+fs-devel.sha256sum] = "22ed89a46748f6e0cc25ded72d6156cb53d1617c01ea46ad9f0cff609e1fa4af"

URI_x86_64_v2_rust-nix+hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+hostname-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+hostname-devel}"
SRC_URI[x86_64_v2_rust-nix+hostname-devel.sha256sum] = "a3445b7852d0407797c9e4c4859e0dcee099af3e2b22ac4da51ad8895ea4648a"

URI_x86_64_v2_rust-nix+inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+inotify-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+inotify-devel}"
SRC_URI[x86_64_v2_rust-nix+inotify-devel.sha256sum] = "4168d156a623cf90fcdda2676abc23af5140bc61f9b5ed03a29abfb4e9ac0eb9"

URI_x86_64_v2_rust-nix+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ioctl-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ioctl-devel}"
SRC_URI[x86_64_v2_rust-nix+ioctl-devel.sha256sum] = "6b2674cdc6810b1fc3c2f2d8a4f0343cd6ab27d726a101c1feb5afb93cef98ab"

URI_x86_64_v2_rust-nix+kmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+kmod-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+kmod-devel}"
SRC_URI[x86_64_v2_rust-nix+kmod-devel.sha256sum] = "23b92bb84859b9f5f702c07bfc555ccb00bbb109ff9e71ba6218b88bcc6186b0"

URI_x86_64_v2_rust-nix+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+memoffset-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+memoffset-devel}"
SRC_URI[x86_64_v2_rust-nix+memoffset-devel.sha256sum] = "ef6952a8ab737259ff240e9935746adda7b3589706963450c553d2d326ea2edf"

URI_x86_64_v2_rust-nix+mman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mman-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mman-devel}"
SRC_URI[x86_64_v2_rust-nix+mman-devel.sha256sum] = "3bf54b8266263e473f726d885876f8b0205cc131df6eb0ca2b7241865cd054d3"

URI_x86_64_v2_rust-nix+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mount-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mount-devel}"
SRC_URI[x86_64_v2_rust-nix+mount-devel.sha256sum] = "7f91f45aee84844f9bda1f7c79650cf61846a92468d2f58ed45e9b298747247d"

URI_x86_64_v2_rust-nix+mqueue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mqueue-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mqueue-devel}"
SRC_URI[x86_64_v2_rust-nix+mqueue-devel.sha256sum] = "bb823451c9bc3b64c611247891dc7ab17a89a555da90e4f7223765d9fc4855a0"

URI_x86_64_v2_rust-nix+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+net-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+net-devel}"
SRC_URI[x86_64_v2_rust-nix+net-devel.sha256sum] = "66f54781611f24eff729ec0b18dab2d591b7cdeda7c3bd30162e5dbd011e9e23"

URI_x86_64_v2_rust-nix+personality-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+personality-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+personality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+personality-devel}"
SRC_URI[x86_64_v2_rust-nix+personality-devel.sha256sum] = "8d8a48afc2d182f927c960e4e0a4e4f70e6f4b71e5dc90816c52199298f71abb"

URI_x86_64_v2_rust-nix+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+pin-utils-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-nix+pin-utils-devel.sha256sum] = "a3709cef8641355f5af542a5a932754b85d597739f2d3fa2d2227ec79d262284"

URI_x86_64_v2_rust-nix+poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+poll-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+poll-devel}"
SRC_URI[x86_64_v2_rust-nix+poll-devel.sha256sum] = "00cb4965aff4112e8479ba5c812143d3c270de1713385a29125cea92a58f527c"

URI_x86_64_v2_rust-nix+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+process-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+process-devel}"
SRC_URI[x86_64_v2_rust-nix+process-devel.sha256sum] = "4f8e839e54c0ce0ad1b9eb3bdd7f86397f0947a74e7bbd2ea71da53b620057ef"

URI_x86_64_v2_rust-nix+pthread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+pthread-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+pthread-devel}"
SRC_URI[x86_64_v2_rust-nix+pthread-devel.sha256sum] = "2e1faa5c2422a157bd1753d8f1831f95a3ac4c8975f163944d579351ffb9c2b3"

URI_x86_64_v2_rust-nix+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ptrace-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ptrace-devel}"
SRC_URI[x86_64_v2_rust-nix+ptrace-devel.sha256sum] = "6c96fc46cf86ca960deff09d9fde1910a65632e8c3fc4fc3caf06174f32acbbe"

URI_x86_64_v2_rust-nix+quota-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+quota-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+quota-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+quota-devel}"
SRC_URI[x86_64_v2_rust-nix+quota-devel.sha256sum] = "13182ccb403b59404dfbda45fa5d25c797a4c6f648f3f7bb250db2c8c93d97f4"

URI_x86_64_v2_rust-nix+reboot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+reboot-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+reboot-devel}"
SRC_URI[x86_64_v2_rust-nix+reboot-devel.sha256sum] = "5ea5c0abc4ac96e77dc92f71ca3ec7c7089af76332faa270c53242ec4b319358"

URI_x86_64_v2_rust-nix+resource-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+resource-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+resource-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+resource-devel}"
SRC_URI[x86_64_v2_rust-nix+resource-devel.sha256sum] = "e5f21e55bbdbac9cbe425a34b3c2ad1da3b1c65d3aea57d4896652d1451f73e9"

URI_x86_64_v2_rust-nix+sched-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+sched-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+sched-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+sched-devel}"
SRC_URI[x86_64_v2_rust-nix+sched-devel.sha256sum] = "ea26234f6c8c859704f167f490ea3bcdb6df7f1d0b75036c0ab446ba026503c4"

URI_x86_64_v2_rust-nix+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+signal-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+signal-devel}"
SRC_URI[x86_64_v2_rust-nix+signal-devel.sha256sum] = "df14c75ba7baf1330cc48df7ccacd497854fd127d76271b7714ed04ccd2dcac0"

URI_x86_64_v2_rust-nix+socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+socket-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+socket-devel}"
SRC_URI[x86_64_v2_rust-nix+socket-devel.sha256sum] = "54e68b363991a922a66dd07d8492b7e6814f7bced16b30637ee50023b9f66233"

URI_x86_64_v2_rust-nix+term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+term-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+term-devel}"
SRC_URI[x86_64_v2_rust-nix+term-devel.sha256sum] = "165cc3f19cd6214a1c4b61c29298ef54f57f45a475b32ce7129ac5fe91bfab5b"

URI_x86_64_v2_rust-nix+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+time-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+time-devel}"
SRC_URI[x86_64_v2_rust-nix+time-devel.sha256sum] = "779c444ee1fa1670a6b1bbd3a7e2edd130c3e50f8674c7be328d225e963cad85"

URI_x86_64_v2_rust-nix+ucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ucontext-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ucontext-devel}"
SRC_URI[x86_64_v2_rust-nix+ucontext-devel.sha256sum] = "56aef2bf6a5601f01bdb6984fa4d052e057b02e44048b68ece1eea1c1bf71998"

URI_x86_64_v2_rust-nix+uio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+uio-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+uio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+uio-devel}"
SRC_URI[x86_64_v2_rust-nix+uio-devel.sha256sum] = "aad7fb124d598a36880c200708ac2c429a43db5a947e40899479fc9e83cb79d5"

URI_x86_64_v2_rust-nix+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+user-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+user-devel}"
SRC_URI[x86_64_v2_rust-nix+user-devel.sha256sum] = "aa62e7e8f56f7824d316b22b2e7ae26ca373112a44f7e3974405805c041e7ed4"

URI_x86_64_v2_rust-nix+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+zerocopy-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-nix+zerocopy-devel.sha256sum] = "bcb05ce40ff2eceef1612c1cef506054ef5128e26e17085ef3e5c5362c22a2b7"

URI_x86_64_v2_rust-nix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix-devel}"
SRC_URI[x86_64_v2_rust-nix-devel.sha256sum] = "5a495231e4e1aba44256e8ee54b50be8b2dd2f68169757d3087948178ddfecd3"
RPROVIDES:rust-nix-devel:x86_64_v2 = "virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"

URI_aarch64_rust-nix+acct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+acct-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+acct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+acct-devel}"
SRC_URI[aarch64_rust-nix+acct-devel.sha256sum] = "088605725476f65d64905c60f397f62aba1209c3cff83e2733f85144f253024e"

URI_aarch64_rust-nix+aio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+aio-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+aio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+aio-devel}"
SRC_URI[aarch64_rust-nix+aio-devel.sha256sum] = "34a97c38bc73b636a4e52951ec4e5a295dd2900e3b671df9511024121e089f5d"

URI_aarch64_rust-nix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+default-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+default-devel}"
SRC_URI[aarch64_rust-nix+default-devel.sha256sum] = "72e616647e818dce286bc9f04d8ffd61891397a8bc893862b6a30306fe1f25db"

URI_aarch64_rust-nix+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+dir-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+dir-devel}"
SRC_URI[aarch64_rust-nix+dir-devel.sha256sum] = "8f42286b1f3b95fd038042f52f00e48617df926eba21fa9e23c7850c583f583c"

URI_aarch64_rust-nix+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+env-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+env-devel}"
SRC_URI[aarch64_rust-nix+env-devel.sha256sum] = "a539b54a562084a5a98e74f0f23240eba7e0350322ecac7326829b5f83a1fbb2"

URI_aarch64_rust-nix+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+event-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+event-devel}"
SRC_URI[aarch64_rust-nix+event-devel.sha256sum] = "b25fcfd7733bfdfba2976d99d454e10484ec24841de0c30fd3f578430b63a2db"

URI_aarch64_rust-nix+fanotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+fanotify-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+fanotify-devel}"
SRC_URI[aarch64_rust-nix+fanotify-devel.sha256sum] = "7512ab962409a47b7d6e64e1aa682bac528d2773560bd17138a4b2e54aebd797"

URI_aarch64_rust-nix+feature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+feature-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+feature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+feature-devel}"
SRC_URI[aarch64_rust-nix+feature-devel.sha256sum] = "fb8e539c9dd4f40724b1b2737180570dd2ebdc623f9d085898dc78e2657f2719"
RPROVIDES:rust-nix+feature-devel:aarch64 = "virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~"

URI_aarch64_rust-nix+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+fs-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+fs-devel}"
SRC_URI[aarch64_rust-nix+fs-devel.sha256sum] = "b9871c42b55a29d8fb9d496d95662309983e345c94a99f3abfbb0fdeb88adf56"

URI_aarch64_rust-nix+hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+hostname-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+hostname-devel}"
SRC_URI[aarch64_rust-nix+hostname-devel.sha256sum] = "f95e2958c9f090fa940636565d28aa204764c748729796a5ed88e24b29b07555"

URI_aarch64_rust-nix+inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+inotify-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+inotify-devel}"
SRC_URI[aarch64_rust-nix+inotify-devel.sha256sum] = "1f95b77efbf090cea5f21b824b6b1efb7a3d8705df22b22c2236e2686b5a93c8"

URI_aarch64_rust-nix+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ioctl-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ioctl-devel}"
SRC_URI[aarch64_rust-nix+ioctl-devel.sha256sum] = "fd5fe9bb0625001b720720caa8064592e6ac1332fb4d9374f0995f911d3b5c7b"

URI_aarch64_rust-nix+kmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+kmod-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+kmod-devel}"
SRC_URI[aarch64_rust-nix+kmod-devel.sha256sum] = "6730011c0805d2748ebb6191c7156c1f6da2660c37ecf116a046aaa1bca270fb"

URI_aarch64_rust-nix+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+memoffset-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+memoffset-devel}"
SRC_URI[aarch64_rust-nix+memoffset-devel.sha256sum] = "ee975ecc78ba6ad1777505f6cf0c9559e2a4808e498c9f66be5516dabde65a78"

URI_aarch64_rust-nix+mman-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mman-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+mman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mman-devel}"
SRC_URI[aarch64_rust-nix+mman-devel.sha256sum] = "f378971a67b694b57436feca9f4258ed25f8eae3cfaa5e8e1bc8fd30f64ab7b4"

URI_aarch64_rust-nix+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mount-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mount-devel}"
SRC_URI[aarch64_rust-nix+mount-devel.sha256sum] = "3e9aa2b498473c3af2559a9124047c7ee4c4478110ee1fb1f23398db2dd71acb"

URI_aarch64_rust-nix+mqueue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mqueue-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mqueue-devel}"
SRC_URI[aarch64_rust-nix+mqueue-devel.sha256sum] = "7e51bda716c347eea25ba69c831ec2261be9df92d9bdaa3b5584a476a580eb0a"

URI_aarch64_rust-nix+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+net-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+net-devel}"
SRC_URI[aarch64_rust-nix+net-devel.sha256sum] = "b5deedda7c7449d8dc8bed85e24a1b2d5727f674b37fb4e539b690edf72d2d17"

URI_aarch64_rust-nix+personality-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+personality-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+personality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+personality-devel}"
SRC_URI[aarch64_rust-nix+personality-devel.sha256sum] = "41bf28d8aa661b4c897ec6a5e639a61ba12a57ade96879d4ddccd01343d8bd1b"

URI_aarch64_rust-nix+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+pin-utils-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+pin-utils-devel}"
SRC_URI[aarch64_rust-nix+pin-utils-devel.sha256sum] = "7a23ebbfa9dfe35f83d85387cbab521054e8b1568b0b7924dcf8b27f5569a11b"

URI_aarch64_rust-nix+poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+poll-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+poll-devel}"
SRC_URI[aarch64_rust-nix+poll-devel.sha256sum] = "293b6b1bc9239d4b25fd3e97fad011c9ecc8048856322005abdc35c3083a471b"

URI_aarch64_rust-nix+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+process-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+process-devel}"
SRC_URI[aarch64_rust-nix+process-devel.sha256sum] = "f23896ba80aafe5385d2027d36fa9e269a80d8c529c3102a693f81c57fa75ce5"

URI_aarch64_rust-nix+pthread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+pthread-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+pthread-devel}"
SRC_URI[aarch64_rust-nix+pthread-devel.sha256sum] = "a5f986e1a080a0c0eaa0464cf8caf1c9e0eca6a7fe3d09b0e5e51362b577138c"

URI_aarch64_rust-nix+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ptrace-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ptrace-devel}"
SRC_URI[aarch64_rust-nix+ptrace-devel.sha256sum] = "97c8eb316d19a97e76932d91fde0ad0e6b98848e410c5ae9276cd1e980e7c18a"

URI_aarch64_rust-nix+quota-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+quota-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+quota-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+quota-devel}"
SRC_URI[aarch64_rust-nix+quota-devel.sha256sum] = "4bc81534c33cc56db7aa90ec4a41477ec46fd60f95a33bcd06fff202da838190"

URI_aarch64_rust-nix+reboot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+reboot-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+reboot-devel}"
SRC_URI[aarch64_rust-nix+reboot-devel.sha256sum] = "d6b5426562ace72f9ec50659b735d645130370312e97c215fce08e68c1a2166f"

URI_aarch64_rust-nix+resource-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+resource-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+resource-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+resource-devel}"
SRC_URI[aarch64_rust-nix+resource-devel.sha256sum] = "a76ef82356c98b6f85c89b2765d9762f1d25fdefe32648d0ce7524bce69d20e0"

URI_aarch64_rust-nix+sched-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+sched-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+sched-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+sched-devel}"
SRC_URI[aarch64_rust-nix+sched-devel.sha256sum] = "d0bebcef0ff6c29322920d5c868275d38fad78a22a0ab887f9a06a5626e41c14"

URI_aarch64_rust-nix+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+signal-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+signal-devel}"
SRC_URI[aarch64_rust-nix+signal-devel.sha256sum] = "db3ad0d6052e418e02baa2513b308a7948f60c026b92ad680452e729c2f30a06"

URI_aarch64_rust-nix+socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+socket-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+socket-devel}"
SRC_URI[aarch64_rust-nix+socket-devel.sha256sum] = "a35da55578a40a84f7833e681758ffd22e2a0cbedd3f0c014c4722167010be27"

URI_aarch64_rust-nix+term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+term-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+term-devel}"
SRC_URI[aarch64_rust-nix+term-devel.sha256sum] = "3a8a7e01ff7e53743a44f40d1bb153161ab9ffa464a6fc9140f495b0597a6cf4"

URI_aarch64_rust-nix+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+time-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+time-devel}"
SRC_URI[aarch64_rust-nix+time-devel.sha256sum] = "bfac3c037097b6fe0fa6a2d355919284253f058025beb8c357d61b75f7bb58e4"

URI_aarch64_rust-nix+ucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ucontext-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ucontext-devel}"
SRC_URI[aarch64_rust-nix+ucontext-devel.sha256sum] = "8fc729b502e1098ca2481d8b21eb5552fa09055bb362d0243c9b84bbd93fed16"

URI_aarch64_rust-nix+uio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+uio-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+uio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+uio-devel}"
SRC_URI[aarch64_rust-nix+uio-devel.sha256sum] = "9b384d5c1ab6f441522492ebb8a72ccfeae4b0ac326b95b2cabab61e81b91762"

URI_aarch64_rust-nix+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+user-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+user-devel}"
SRC_URI[aarch64_rust-nix+user-devel.sha256sum] = "72999cf48333449172aaa2d948bc7f9f3442cdc130094a8aa04616d9fca2c6cb"

URI_aarch64_rust-nix+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+zerocopy-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+zerocopy-devel}"
SRC_URI[aarch64_rust-nix+zerocopy-devel.sha256sum] = "ffceddfdacd7c960e84fa975bd73abb6b8efe12225726495016f06d291ee87e0"

URI_aarch64_rust-nix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-nix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix-devel}"
SRC_URI[aarch64_rust-nix-devel.sha256sum] = "e4e06a7639959d9160b7cc31f3c3d966439d7aa447b8502af33d22c9fc70a877"
RPROVIDES:rust-nix-devel:aarch64 = "virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"

RDEPENDS:rust-nix+acct-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+aio-devel = " \
 cargo \
 rust-nix+pin-utils-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+default-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+dir-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+env-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+event-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+fanotify-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+feature-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+fs-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+hostname-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+inotify-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ioctl-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+kmod-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mman-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mount-devel = " \
 cargo \
 rust-nix+uio-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mqueue-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+net-devel = " \
 cargo \
 rust-nix+socket-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+personality-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+pin-utils-devel = " \
 cargo \
 rust-nix-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-nix+poll-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+process-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+pthread-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ptrace-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+quota-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+reboot-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+resource-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+sched-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+signal-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+socket-devel = " \
 cargo \
 rust-nix+memoffset-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+term-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+time-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ucontext-devel = " \
 cargo \
 rust-nix+signal-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+uio-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+user-devel = " \
 cargo \
 rust-nix+feature-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+zerocopy-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix+uio-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-cfg_aliases+default-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~ rpm/virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_nix/feature__ge_0.24.2_with_crate_nix/feature__lt_0.30.0~ rpm/virtual/crate_nix__ge_0.24.2_with_crate_nix__lt_0.30.0~"
