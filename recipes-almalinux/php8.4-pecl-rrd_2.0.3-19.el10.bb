# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4-pecl-rrd"
PV = "2.0.3"
PR = "19.el10"
PACKAGES = " \
 php8.4-pecl-rrd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php8.4-pecl-rrd-2.0.3-19.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a8b370484edf6caf3c0c0e77e3e7537704b3c21643dd9b2f468466f3a79c7354"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-pecl-rrd-2.0.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-pecl-rrd;unpack=0"
SRC_URI[x86_64_v2_php8.4-pecl-rrd.sha256sum] = "471c5a04530bdf990089ab1d67434120f695755f70b1f06a8eeaff0027c07434"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-pecl-rrd-2.0.3-19.el10.aarch64.rpm;name=aarch64_php8.4-pecl-rrd;unpack=0"
SRC_URI[aarch64_php8.4-pecl-rrd.sha256sum] = "84ca222ddba42bbf44d456029f03a3b7815bb2e74cabbd897a6498f159ea81cf"

RDEPENDS:php8.4-pecl-rrd = " \
 glibc \
 php8.4-common \
 rrdtool \
 "
