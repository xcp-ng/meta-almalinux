# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-TreeBuilder-LibXML"
PV = "0.28"
PR = "3.el10_0"
PACKAGES = " \
 perl-HTML-TreeBuilder-LibXML \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-TreeBuilder-LibXML-0.28-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fce488bd5577cc1915c3b477a41a000e6effb92dd3aed416287ddd6ef6e6fe98"

URI_x86_64_v2_perl-HTML-TreeBuilder-LibXML = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-TreeBuilder-LibXML-0.28-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-TreeBuilder-LibXML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-TreeBuilder-LibXML}"
SRC_URI[x86_64_v2_perl-HTML-TreeBuilder-LibXML.sha256sum] = "13da349f42e6d6ac897a98c91fca831ab7b9269e0208c482c742998ab1195912"

URI_aarch64_perl-HTML-TreeBuilder-LibXML = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-TreeBuilder-LibXML-0.28-3.el10_0.noarch.rpm;name=aarch64_perl-HTML-TreeBuilder-LibXML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-TreeBuilder-LibXML}"
SRC_URI[aarch64_perl-HTML-TreeBuilder-LibXML.sha256sum] = "a1e2a5fe1b33280b203b47d63b1654075a86f9c0868fa17f46c93ccd385b75b3"

RDEPENDS:perl-HTML-TreeBuilder-LibXML = " \
 perl-Carp \
 perl-HTML-TreeBuilder-XPath \
 perl-XML-LibXML \
 perl-base \
 perl-libs \
 "
