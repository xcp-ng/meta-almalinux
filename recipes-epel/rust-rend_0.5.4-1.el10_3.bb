# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rend"
PV = "0.5.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-rend+bytecheck-devel \
 rust-rend+bytemuck-1-devel \
 rust-rend+default-devel \
 rust-rend+zerocopy-0_8-devel \
 rust-rend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rend-0.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "762adf54a93972e78a3c90c64af7ceb327d74283c25ba9282ac21e67f7214eaa"

URI_x86_64_v2_rust-rend+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend+bytecheck-devel-0.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rend+bytecheck-devel.sha256sum] = "0b884fc8c90ccebe8f8b96ac83263f228d640dd06e694f56cc445d8bba47cd66"

URI_x86_64_v2_rust-rend+bytemuck-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend+bytemuck-1-devel-0.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend+bytemuck-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend+bytemuck-1-devel}"
SRC_URI[x86_64_v2_rust-rend+bytemuck-1-devel.sha256sum] = "a79254e8d13f64e60183596e0eaca5e4b3844453b13be0fe930e013c5771b3c9"

URI_x86_64_v2_rust-rend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend+default-devel-0.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend+default-devel}"
SRC_URI[x86_64_v2_rust-rend+default-devel.sha256sum] = "18d48a35c8fd0981a796a55a6523bad88267395317a878a409876ea07f580af2"

URI_x86_64_v2_rust-rend+zerocopy-0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend+zerocopy-0_8-devel-0.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend+zerocopy-0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend+zerocopy-0_8-devel}"
SRC_URI[x86_64_v2_rust-rend+zerocopy-0_8-devel.sha256sum] = "49bd53d17527b1a3a4e2f3ce688f4c649b2c75017db7a9d639221df35629c57d"

URI_x86_64_v2_rust-rend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend-devel-0.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend-devel}"
SRC_URI[x86_64_v2_rust-rend-devel.sha256sum] = "81884442eb59fe3c3ae1e50e2d3c435e9b99cdb6db01a697848a0f4ac0fbb8d6"

URI_aarch64_rust-rend+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend+bytecheck-devel-0.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-rend+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend+bytecheck-devel}"
SRC_URI[aarch64_rust-rend+bytecheck-devel.sha256sum] = "1b9700fc7c7e590703e989c4187ae1158b78d24f1551aa84fffd8fc59244b000"

URI_aarch64_rust-rend+bytemuck-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend+bytemuck-1-devel-0.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-rend+bytemuck-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend+bytemuck-1-devel}"
SRC_URI[aarch64_rust-rend+bytemuck-1-devel.sha256sum] = "e816d95ac6f8dc226cb45ba95a76400f14419e1801a06585846caad0235f4f80"

URI_aarch64_rust-rend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend+default-devel-0.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-rend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend+default-devel}"
SRC_URI[aarch64_rust-rend+default-devel.sha256sum] = "267def7058df84de7cfbadd3b2c939ac9ca5f9cfe582f96f57dd67571ab9267f"

URI_aarch64_rust-rend+zerocopy-0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend+zerocopy-0_8-devel-0.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-rend+zerocopy-0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend+zerocopy-0_8-devel}"
SRC_URI[aarch64_rust-rend+zerocopy-0_8-devel.sha256sum] = "bd06ecca09b6cc2c9ab60fa3d30b4d542d9afae65cc72058e8d3160df32e6a7c"

URI_aarch64_rust-rend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend-devel-0.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-rend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend-devel}"
SRC_URI[aarch64_rust-rend-devel.sha256sum] = "d11b1431dcdd8a19299753d658afb26c33b1e14ac899dccbb7fd8c95ea90ff9b"

RDEPENDS:rust-rend+bytecheck-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-rend-devel \
 "
RDEPENDS:rust-rend+bytemuck-1-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-rend-devel \
 "
RDEPENDS:rust-rend+default-devel = " \
 cargo \
 rust-rend-devel \
 "
RDEPENDS:rust-rend+zerocopy-0_8-devel = " \
 cargo \
 rust-rend-devel \
 rust-zerocopy-derive-devel \
 rust-zerocopy-devel \
 "
RDEPENDS:rust-rend-devel = " \
 cargo \
 "
