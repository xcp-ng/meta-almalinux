# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typenum"
PV = "1.18.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-typenum+const-generics-devel \
 rust-typenum+default-devel \
 rust-typenum+force_unix_path_separator-devel \
 rust-typenum+i128-devel \
 rust-typenum+no_std-devel \
 rust-typenum+strict-devel \
 rust-typenum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typenum-1.18.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b33962920f6b96414c6da9de855861dd9eff4cb7ad6d04bc1db82104442dbae"

URI_x86_64_v2_rust-typenum+const-generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+const-generics-devel-1.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+const-generics-devel}"
SRC_URI[x86_64_v2_rust-typenum+const-generics-devel.sha256sum] = "9544ecd157901e8dfd3a327b5d789665fc791948376a400087bd9f643814597b"

URI_x86_64_v2_rust-typenum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+default-devel-1.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+default-devel}"
SRC_URI[x86_64_v2_rust-typenum+default-devel.sha256sum] = "830982e263f23437a2129bdee8f15b3980b3c10cc1210017656762165acb68a3"

URI_x86_64_v2_rust-typenum+force_unix_path_separator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+force_unix_path_separator-devel-1.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+force_unix_path_separator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+force_unix_path_separator-devel}"
SRC_URI[x86_64_v2_rust-typenum+force_unix_path_separator-devel.sha256sum] = "3d9304fde3c2e3459618c7da5c113bcc548b6aabfea7561abcc586cf494eb306"

URI_x86_64_v2_rust-typenum+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+i128-devel-1.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+i128-devel}"
SRC_URI[x86_64_v2_rust-typenum+i128-devel.sha256sum] = "d11a1d3dfeebff0ec67e52b21ce8b7184aa3af39b4a5218c3e4648e05c5da62f"

URI_x86_64_v2_rust-typenum+no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+no_std-devel-1.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+no_std-devel}"
SRC_URI[x86_64_v2_rust-typenum+no_std-devel.sha256sum] = "9ea224f864425a0e5bb2575fbdcc0d8211a2fbd57aab829418e011c04eab621e"

URI_x86_64_v2_rust-typenum+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum+strict-devel-1.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum+strict-devel}"
SRC_URI[x86_64_v2_rust-typenum+strict-devel.sha256sum] = "d23e9823f38d9a090aba21a287557a596d994446e8e884edbd2e45c6a6a7cb06"

URI_x86_64_v2_rust-typenum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typenum-devel-1.18.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typenum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typenum-devel}"
SRC_URI[x86_64_v2_rust-typenum-devel.sha256sum] = "ca5d3dc2493e4b21ea2977375855a2e1f65eae6d6f38cac81129af7f36a410bf"

URI_aarch64_rust-typenum+const-generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+const-generics-devel-1.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-typenum+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+const-generics-devel}"
SRC_URI[aarch64_rust-typenum+const-generics-devel.sha256sum] = "df8b14dc93125674f1dc6b663a77fe68a0ee855c5bdc4dff63041d9c8f3ba4d9"

URI_aarch64_rust-typenum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+default-devel-1.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-typenum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+default-devel}"
SRC_URI[aarch64_rust-typenum+default-devel.sha256sum] = "5bb2ae85e9c561b3b11ebac38e29c85b52d5121746a430ab47dcf68552ff884e"

URI_aarch64_rust-typenum+force_unix_path_separator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+force_unix_path_separator-devel-1.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-typenum+force_unix_path_separator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+force_unix_path_separator-devel}"
SRC_URI[aarch64_rust-typenum+force_unix_path_separator-devel.sha256sum] = "cc7c777d373e788f84e2e3b02e116ea106268c275279798e366fd57496da8c41"

URI_aarch64_rust-typenum+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+i128-devel-1.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-typenum+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+i128-devel}"
SRC_URI[aarch64_rust-typenum+i128-devel.sha256sum] = "8a9d958f67883fb63cd0c3327755e67b653406495646b02d3c91e0254fae6e5f"

URI_aarch64_rust-typenum+no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+no_std-devel-1.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-typenum+no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+no_std-devel}"
SRC_URI[aarch64_rust-typenum+no_std-devel.sha256sum] = "90f5cb2169f492dd052af52ac8bffd038c4733df6d2e6f2fc1c7bb3c86eba2ce"

URI_aarch64_rust-typenum+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum+strict-devel-1.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-typenum+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum+strict-devel}"
SRC_URI[aarch64_rust-typenum+strict-devel.sha256sum] = "effbfaf1ae541653e353ccad9e54689df87230fcf6e3bde32f4c2b2829ad1d59"

URI_aarch64_rust-typenum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typenum-devel-1.18.0-1.el10_0.noarch.rpm;name=aarch64_rust-typenum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typenum-devel}"
SRC_URI[aarch64_rust-typenum-devel.sha256sum] = "9570bb58aaa647fd03f54cefe616ecbfb3f85c7f1afc7b98194be0815807dcaf"

RDEPENDS:rust-typenum+const-generics-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+default-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+force_unix_path_separator-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+i128-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+no_std-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum+strict-devel = " \
 cargo \
 rust-typenum-devel \
 "
RDEPENDS:rust-typenum-devel = " \
 cargo \
 rust \
 "
