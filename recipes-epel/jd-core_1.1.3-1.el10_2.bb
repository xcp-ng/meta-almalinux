# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jd-core"
PV = "1.1.3"
PR = "1.el10_2"
PACKAGES = " \
 jd-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jd-core-1.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42b52b058ca2db2ba415f028fe6eb3dc64cc6fc23497eeab92a1bee353566fed"

URI_x86_64_v2_jd-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jd-core-1.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_jd-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jd-core}"
SRC_URI[x86_64_v2_jd-core.sha256sum] = "23ed27f8fd90ec941d35d19ddba4143f0f1342049d9b287ae264529d71a3e68d"

URI_aarch64_jd-core = "${EPEL_MIRROR}/aarch64/Packages/j/jd-core-1.1.3-1.el10_2.noarch.rpm;name=aarch64_jd-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_jd-core}"
SRC_URI[aarch64_jd-core.sha256sum] = "b628044a703e48b328af3db5fb253ff082309d1fb17d5f9aa330f589f9655c32"

RDEPENDS:jd-core = " \
 javapackages-tools \
 "
