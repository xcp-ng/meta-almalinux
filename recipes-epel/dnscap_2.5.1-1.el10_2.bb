# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnscap"
PV = "2.5.1"
PR = "1.el10_2"
PACKAGES = " \
 dnscap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnscap-2.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c9d8af29cae33297c64fd94eec52df9e628c45dd93abaf0c3f7ca43bd8d589b"

URI_x86_64_v2_dnscap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnscap-2.5.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnscap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnscap}"
SRC_URI[x86_64_v2_dnscap.sha256sum] = "f97fd6107c5427c4cca0d6aaaf2d2ea0764dd1453f59636cc87e609b42a23705"

URI_aarch64_dnscap = "${EPEL_MIRROR}/aarch64/Packages/d/dnscap-2.5.1-1.el10_2.aarch64.rpm;name=aarch64_dnscap;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnscap}"
SRC_URI[aarch64_dnscap.sha256sum] = "d73f27b9f005746937b750577e024911cd4f376584df292ab4fd0603bdc146b6"

RDEPENDS:dnscap = " \
 bzip2-libs \
 cryptopant \
 glibc \
 ldns \
 libpcap \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-interpreter \
 xz-libs \
 zlib-ng-compat \
 "
