# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam-kwallet"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 pam-kwallet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam-kwallet-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfe9840ed673288d776693810d4f7cf267fa297d33ae1a22951f9f97dbd4bf0f"

URI_x86_64_v2_pam-kwallet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam-kwallet-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam-kwallet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-kwallet}"
SRC_URI[x86_64_v2_pam-kwallet.sha256sum] = "8823bbc75d04b72e937041471d2827c05b9d13697cbfda8b1440163b484502c9"

URI_aarch64_pam-kwallet = "${EPEL_MIRROR}/aarch64/Packages/p/pam-kwallet-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_pam-kwallet;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-kwallet}"
SRC_URI[aarch64_pam-kwallet.sha256sum] = "b4f9f6635daf9cd870555dff297f85c5bbb2280954151606c1f2efa776d5e659"

RDEPENDS:pam-kwallet = " \
 bash \
 glibc \
 kf6-kwallet \
 libgcrypt \
 pam-libs \
 socat \
 "
