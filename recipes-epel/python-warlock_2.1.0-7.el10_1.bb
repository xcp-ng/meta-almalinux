# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-warlock"
PV = "2.1.0"
PR = "7.el10_1"
PACKAGES = " \
 python3-warlock \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-warlock-2.1.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df838821d89674ecc6f213ab7cd25891ac6f11e7ea9da1fa290e6a990193473d"

URI_x86_64_v2_python3-warlock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-warlock-2.1.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-warlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-warlock}"
SRC_URI[x86_64_v2_python3-warlock.sha256sum] = "872dacf51bc253385d1b572ec306207f53f466f11b50624265b8e7b74700d0e5"

URI_aarch64_python3-warlock = "${EPEL_MIRROR}/aarch64/Packages/p/python3-warlock-2.1.0-7.el10_1.noarch.rpm;name=aarch64_python3-warlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-warlock}"
SRC_URI[aarch64_python3-warlock.sha256sum] = "259f3e1c6d2e08cdfac89720fc96f1427ea2268fc9b4606dcfa882d035ae2a7d"

RDEPENDS:python3-warlock = " \
 python3 \
 python3-jsonpatch \
 python3-jsonschema \
 "
