# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colord"
PV = "1.4.7"
PR = "6.el10"
PACKAGES = " \
 colord \
 colord-devel \
 colord-devel-docs \
 colord-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/colord-1.4.7-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8e2fc08d2a25a61343184ceec844939fa2472d3e5f48c2467f3bab12e204690"

URI_x86_64_v2_colord = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/colord-1.4.7-6.el10.x86_64_v2.rpm;name=x86_64_v2_colord;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord}"
SRC_URI[x86_64_v2_colord.sha256sum] = "aff8d712471ec9ab8ea1b0b76b48fc839ef432da8b560d3195a16233de102198"

URI_x86_64_v2_colord-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/colord-devel-1.4.7-6.el10.x86_64_v2.rpm;name=x86_64_v2_colord-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-devel}"
SRC_URI[x86_64_v2_colord-devel.sha256sum] = "4407191d25a5612ef507e0c4682c21c5756b26c0a5bf9c11a994f9db9efd6573"

URI_x86_64_v2_colord-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/colord-devel-docs-1.4.7-6.el10.noarch.rpm;name=x86_64_v2_colord-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-devel-docs}"
SRC_URI[x86_64_v2_colord-devel-docs.sha256sum] = "c74eed313e24bee4acd1f7f4af65c77073f2d3024790247bc98c542c5de5f70e"

URI_x86_64_v2_colord-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/colord-libs-1.4.7-6.el10.x86_64_v2.rpm;name=x86_64_v2_colord-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colord-libs}"
SRC_URI[x86_64_v2_colord-libs.sha256sum] = "c99fa827e465b1588957555047441b0973c8cf56d213b4cddcd8ba4fcdb61fa5"

URI_aarch64_colord = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/colord-1.4.7-6.el10.aarch64.rpm;name=aarch64_colord;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord}"
SRC_URI[aarch64_colord.sha256sum] = "3ef19bd1e65a2a2a087fc0539a707fa2815e15565b68780f3106579608492325"

URI_aarch64_colord-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/colord-devel-1.4.7-6.el10.aarch64.rpm;name=aarch64_colord-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-devel}"
SRC_URI[aarch64_colord-devel.sha256sum] = "f20ece0c906087ac6b28ea8289000840d49b2b04c576d707a632e8307d65fa03"

URI_aarch64_colord-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/colord-devel-docs-1.4.7-6.el10.noarch.rpm;name=aarch64_colord-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-devel-docs}"
SRC_URI[aarch64_colord-devel-docs.sha256sum] = "c74eed313e24bee4acd1f7f4af65c77073f2d3024790247bc98c542c5de5f70e"

URI_aarch64_colord-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/colord-libs-1.4.7-6.el10.aarch64.rpm;name=aarch64_colord-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_colord-libs}"
SRC_URI[aarch64_colord-libs.sha256sum] = "f7538e24961d610bf09c85d1186a56f7d43c3fd2a1e7fcfb0b6a36e79dad640e"

RDEPENDS:colord = " \
 bash \
 color-filesystem \
 colord-libs \
 glib2 \
 glibc \
 lcms2 \
 libgcc \
 libgudev \
 libgusb \
 polkit-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:colord-devel = " \
 colord \
 colord-devel \
 colord-libs \
 glib2-devel \
 libgusb-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:colord-devel-docs = " \
 colord \
 "
RDEPENDS:colord-libs = " \
 glib2 \
 glibc \
 lcms2 \
 libgcc \
 libgusb \
 systemd-libs \
 "
