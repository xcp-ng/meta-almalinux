# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distribution-gpg-keys"
PV = "1.119"
PR = "1.el10_1"
PACKAGES = " \
 distribution-gpg-keys \
 distribution-gpg-keys-copr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/distribution-gpg-keys-1.119-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adb40ca370a84f551b5cc84716afadff95db5556dc30b4fc4737de8ef79ce210"

URI_x86_64_v2_distribution-gpg-keys = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-1.119-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distribution-gpg-keys}"
SRC_URI[x86_64_v2_distribution-gpg-keys.sha256sum] = "6f87cdfbb697e7a784b05f3387e5f20ff67abfcb522e7b4ef2dd0189cba16c2e"

URI_x86_64_v2_distribution-gpg-keys-copr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-copr-1.119-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys-copr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distribution-gpg-keys-copr}"
SRC_URI[x86_64_v2_distribution-gpg-keys-copr.sha256sum] = "b0ce1503614ad5a1547d227edbae5cb4db57f2a153295d2d96f59ae9b284b0b4"

URI_aarch64_distribution-gpg-keys = "${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-1.119-1.el10_1.noarch.rpm;name=aarch64_distribution-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_aarch64_distribution-gpg-keys}"
SRC_URI[aarch64_distribution-gpg-keys.sha256sum] = "bf3c63a0d0e238b8fd7a1ef2ddcfa4f865204bf6eaa2d2d4f391c0164a8d66f3"

URI_aarch64_distribution-gpg-keys-copr = "${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-copr-1.119-1.el10_1.noarch.rpm;name=aarch64_distribution-gpg-keys-copr;unpack=0"
SRC_URI:append = " ${URI_aarch64_distribution-gpg-keys-copr}"
SRC_URI[aarch64_distribution-gpg-keys-copr.sha256sum] = "da19bf2a94dd1c8b102e0d91e11b7a50100515bfd9f673868078ffcd013595c7"

RDEPENDS:distribution-gpg-keys = " \
 "
RDEPENDS:distribution-gpg-keys-copr = " \
 "
