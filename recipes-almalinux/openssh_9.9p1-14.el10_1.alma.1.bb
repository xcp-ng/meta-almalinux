# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openssh"
PV = "9.9p1"
PR = "14.el10_1.alma.1"
PACKAGES = " \
 openssh \
 openssh-askpass \
 openssh-clients \
 openssh-keycat \
 openssh-keysign \
 openssh-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openssh-9.9p1-14.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "475c2c1ea834c24c1c76d6dbb0315f9292784484dca9b54c327be8b1c34668cd"

URI_x86_64_v2_openssh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-9.9p1-14.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh}"
SRC_URI[x86_64_v2_openssh.sha256sum] = "d5d1bc351f2af902c6bcb23882b13a724ea52b0340ff7427f792e0a8344f313c"

URI_x86_64_v2_openssh-askpass = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-askpass-9.9p1-14.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-askpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-askpass}"
SRC_URI[x86_64_v2_openssh-askpass.sha256sum] = "2957f46b2070369d623b31d3528495a2400cf397e5849531aecb1843a05f9e0c"

URI_x86_64_v2_openssh-clients = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-clients-9.9p1-14.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-clients}"
SRC_URI[x86_64_v2_openssh-clients.sha256sum] = "ff67404a9c395cb5a2459f865bc12e9438995de208a4efd631a84217bb6d3516"

URI_x86_64_v2_openssh-keycat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-keycat-9.9p1-14.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keycat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-keycat}"
SRC_URI[x86_64_v2_openssh-keycat.sha256sum] = "fbf6aa1220bad8f7b0b168321adda6a55636a293076840c96549f212fd7f15b4"

URI_x86_64_v2_openssh-keysign = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openssh-keysign-9.9p1-14.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-keysign}"
SRC_URI[x86_64_v2_openssh-keysign.sha256sum] = "efacd67a5d3e7469f806fea1d276a31bf0347e4fdb87f3f81abd984e655057e9"

URI_x86_64_v2_openssh-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openssh-server-9.9p1-14.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_openssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openssh-server}"
SRC_URI[x86_64_v2_openssh-server.sha256sum] = "de542e4a24410a2ff9c4ec630e768793af67e379aa562d4be42a74bfc2512cf7"

URI_aarch64_openssh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-9.9p1-14.el10_1.alma.1.aarch64.rpm;name=aarch64_openssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh}"
SRC_URI[aarch64_openssh.sha256sum] = "c1cd9f1ac0e702b703754f33c2b9430c8253caef10671196fb4eacad205adf8d"

URI_aarch64_openssh-askpass = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-askpass-9.9p1-14.el10_1.alma.1.aarch64.rpm;name=aarch64_openssh-askpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-askpass}"
SRC_URI[aarch64_openssh-askpass.sha256sum] = "ed17f5d3c4c94a28cba91f6e39ed3a45639d2c4998359700acef0eee2663831e"

URI_aarch64_openssh-clients = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-clients-9.9p1-14.el10_1.alma.1.aarch64.rpm;name=aarch64_openssh-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-clients}"
SRC_URI[aarch64_openssh-clients.sha256sum] = "ba628393dffd749bbc0bb0e37e4f8d5f0dfad0e3d5e6f23dad2356e2bfa023d8"

URI_aarch64_openssh-keycat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-keycat-9.9p1-14.el10_1.alma.1.aarch64.rpm;name=aarch64_openssh-keycat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-keycat}"
SRC_URI[aarch64_openssh-keycat.sha256sum] = "44a482f0a1dcf68f17b88a6aaa19af17d3aabd19c5fe7553ea7d98b3d1b97f65"

URI_aarch64_openssh-keysign = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openssh-keysign-9.9p1-14.el10_1.alma.1.aarch64.rpm;name=aarch64_openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-keysign}"
SRC_URI[aarch64_openssh-keysign.sha256sum] = "b55feec498e42cf40109fcf88bc03f0d6522afbfdf8280119176e6d2139e1171"

URI_aarch64_openssh-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openssh-server-9.9p1-14.el10_1.alma.1.aarch64.rpm;name=aarch64_openssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_openssh-server}"
SRC_URI[aarch64_openssh-server.sha256sum] = "79a3ce52f5d560b73d730300f3cf71e8c348a778645f79c32f8f1ed5413e1aba"

RDEPENDS:openssh = " \
 audit-libs \
 glibc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:openssh-askpass = " \
 glib2 \
 glibc \
 gtk3 \
 openssh \
 "
RDEPENDS:openssh-clients = " \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libedit \
 libfido2 \
 libselinux \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-keycat = " \
 glibc \
 openssh \
 pam-libs \
 "
RDEPENDS:openssh-keysign = " \
 glibc \
 openssh \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 krb5-libs \
 libcom_err \
 libselinux \
 libxcrypt \
 openssh \
 openssl-libs \
 pam \
 pam-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
