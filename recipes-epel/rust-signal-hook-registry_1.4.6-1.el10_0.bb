# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook-registry"
PV = "1.4.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-signal-hook-registry+default-devel \
 rust-signal-hook-registry-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook-registry-1.4.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f45b8e9f98dde20b2b811bc5f560786c4c8be20c78781969ee3c8eeb4ae9e72"

URI_x86_64_v2_rust-signal-hook-registry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-registry+default-devel-1.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-registry+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-registry+default-devel.sha256sum] = "44a4fdafc77f05cca2a4768304fc9bae003426b6a310df3e1fad0516cddc70cb"

URI_x86_64_v2_rust-signal-hook-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-registry-devel-1.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-registry-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-registry-devel.sha256sum] = "5c7ec80306f4c92de101b61c2ff4cbde45638f4c5e9921bcfd8998542c79cc1d"

URI_aarch64_rust-signal-hook-registry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-registry+default-devel-1.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-registry+default-devel}"
SRC_URI[aarch64_rust-signal-hook-registry+default-devel.sha256sum] = "c15e07f4f84334f9db6557d8757eba50a630909f478d823945891bf5880b86b1"

URI_aarch64_rust-signal-hook-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-registry-devel-1.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-registry-devel}"
SRC_URI[aarch64_rust-signal-hook-registry-devel.sha256sum] = "ccd951ac0a642f98040130c5e214054266fabb92f1419fc038081fb5fb0ebe02"

RDEPENDS:rust-signal-hook-registry+default-devel = " \
 cargo \
 rust-signal-hook-registry-devel \
 "
RDEPENDS:rust-signal-hook-registry-devel = " \
 cargo \
 rust-libc+default-devel \
 "
