# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nano"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-nano \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-nano-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9756891248b549d7282b24f4b4a9c16cfb4b162eea808783936be3dc6b8836d6"

URI_x86_64_v2_plasma-nano = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nano-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nano;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nano}"
SRC_URI[x86_64_v2_plasma-nano.sha256sum] = "83951f7577c7d9c0217dbc46a8949f459a9d64d3a5a13b24d30a6f065daacbb5"

URI_aarch64_plasma-nano = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nano-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-nano;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nano}"
SRC_URI[aarch64_plasma-nano.sha256sum] = "4f29036b625df2a52ebff28e4aa0c12fdb22dda317a0f4c868886115e96238b7"

RDEPENDS:plasma-nano = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kwayland \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
