# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdcraw"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libkdcraw \
 libkdcraw-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdcraw-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e38be9094d64d5890aec2c02f2877b3e4d28bd1557c67bcc926e4c889c19a887"

URI_x86_64_v2_libkdcraw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdcraw}"
SRC_URI[x86_64_v2_libkdcraw.sha256sum] = "faf35fbd4c6346cf6f4ab023624cd0e3d280acdc969c695754991d3acfa0bdc4"

URI_x86_64_v2_libkdcraw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdcraw-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdcraw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdcraw-devel}"
SRC_URI[x86_64_v2_libkdcraw-devel.sha256sum] = "b5ce699a350977edace2a3e68a5a3c15888cad71fdba4f878a56ea259d41a9b9"

URI_aarch64_libkdcraw = "${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkdcraw;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdcraw}"
SRC_URI[aarch64_libkdcraw.sha256sum] = "3cc2dddb0a3a38719b5de887485f1d8be8b5739bba3ecc2001464cf2e9cfc536"

URI_aarch64_libkdcraw-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdcraw-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkdcraw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdcraw-devel}"
SRC_URI[aarch64_libkdcraw-devel.sha256sum] = "2755510bbdd16e85bc57434c6ac8fb16429bacc7a39d7cc58d5697feaccde36f"

RDEPENDS:libkdcraw = " \
 LibRaw \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdcraw-devel = " \
 cmake-filesystem \
 libkdcraw \
 qt6-qtbase-devel \
 "
