# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aho-corasick"
PV = "1.1.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-aho-corasick+default-devel \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aho-corasick-1.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca80d7756d54d23109d0e1e3671e3865741be2ce62158dd4213561822eade2c2"

URI_x86_64_v2_rust-aho-corasick+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+default-devel-1.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+default-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+default-devel.sha256sum] = "a848e77be4bf0b6eb8ed4a3678c3a449f024abfb60a1c16e733f6b07d26dc51a"

URI_x86_64_v2_rust-aho-corasick+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+logging-devel-1.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+logging-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+logging-devel.sha256sum] = "1224a636388a198d3fb483dcfaa3842b146d4e0239ad40f598729addf6066798"

URI_x86_64_v2_rust-aho-corasick+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+perf-literal-devel-1.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+perf-literal-devel.sha256sum] = "d47d932af07deb4deb6f5cb2162bf469bfee1b304a1d2c6b7a5b399b0ae2ccc2"

URI_x86_64_v2_rust-aho-corasick+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+std-devel-1.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+std-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+std-devel.sha256sum] = "adf08c4416ac80ff5341a232453aaec39293ffea656f64a7c2bf175e0b6df98d"

URI_x86_64_v2_rust-aho-corasick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick-devel-1.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick-devel.sha256sum] = "720ba9b5fd1f75f22e3dc58bca4e6e9b9496f909bcd419d6cd8209383ab95ff2"

URI_aarch64_rust-aho-corasick+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+default-devel-1.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-aho-corasick+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+default-devel}"
SRC_URI[aarch64_rust-aho-corasick+default-devel.sha256sum] = "5f535a7a13bb67f727dacc64c3f2e35b4d43d818bde1f87870ca040ea0c52a13"

URI_aarch64_rust-aho-corasick+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+logging-devel-1.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-aho-corasick+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+logging-devel}"
SRC_URI[aarch64_rust-aho-corasick+logging-devel.sha256sum] = "ef0d03bb910dae27ebab74ca3d1d6f193c29bc729efd12a26f208f90b8165079"

URI_aarch64_rust-aho-corasick+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+perf-literal-devel-1.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-aho-corasick+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+perf-literal-devel}"
SRC_URI[aarch64_rust-aho-corasick+perf-literal-devel.sha256sum] = "3a1a58bdaf26817cc80963f0bcebed42ccf9b621a928edc0bd2625b4b444ddd1"

URI_aarch64_rust-aho-corasick+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+std-devel-1.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-aho-corasick+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+std-devel}"
SRC_URI[aarch64_rust-aho-corasick+std-devel.sha256sum] = "4707934a2c758b221aad851695258c90660edeec69be96e9e2b3853b79fcab3d"

URI_aarch64_rust-aho-corasick-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick-devel-1.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-aho-corasick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick-devel}"
SRC_URI[aarch64_rust-aho-corasick-devel.sha256sum] = "c6b364fdaf4d66e64697854c2423a6738eb56e0b359b453cabba9fa179bc1986"

RDEPENDS:rust-aho-corasick+default-devel = " \
 cargo \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 "
RDEPENDS:rust-aho-corasick+logging-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-aho-corasick+perf-literal-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-aho-corasick+std-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-aho-corasick-devel = " \
 cargo \
 rust \
 "
