# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-flags"
PV = "1.0.197"
PR = "1.el10_2"
PACKAGES = " \
 rust-cxxbridge-flags+c++14-devel \
 rust-cxxbridge-flags+c++17-devel \
 rust-cxxbridge-flags+c++20-devel \
 rust-cxxbridge-flags+default-devel \
 rust-cxxbridge-flags-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-flags-1.0.197-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab1df750f40eb3dd1a0c0907eb548a25f49ce0cfa5bfa32a130825d7e102b890"

URI_x86_64_v2_rust-cxxbridge-flags+c++14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++14-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++14-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++14-devel.sha256sum] = "ddfd494195febe719e0ac768b4fa72b28f07ffa4bfa8f91c4c6039c8bb13a4fa"

URI_x86_64_v2_rust-cxxbridge-flags+c++17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++17-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++17-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++17-devel.sha256sum] = "8fbb2a9dd4050fda6e51ef4b0cc7699b34eafe667a2b2d90d9cb813ed76f8c2a"

URI_x86_64_v2_rust-cxxbridge-flags+c++20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++20-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+c++20-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++20-devel.sha256sum] = "577e7926c3a4a279bd22d5e8cff9f5dba0858ce14c7bf5d7427e2fd8ebb7b1c3"

URI_x86_64_v2_rust-cxxbridge-flags+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+default-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags+default-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+default-devel.sha256sum] = "6fd756823c17d07282dded9fb478f73a95e1d155fc425456686eb475b5b1f6a7"

URI_x86_64_v2_rust-cxxbridge-flags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-flags-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-flags-devel.sha256sum] = "411bae86912ec70037bc554873d10b9bf5d7e9c707453fe7d276f9309b9e2002"

URI_aarch64_rust-cxxbridge-flags+c++14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++14-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++14-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++14-devel.sha256sum] = "a8fbdd825c5ffff15d46a9973e693fddd98c303ca4fa14a69bfd0847cc8bbac7"

URI_aarch64_rust-cxxbridge-flags+c++17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++17-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++17-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++17-devel.sha256sum] = "faade2d850a47ced8434672543a47615a5ffd1ca53b414f59519c3af76c2f7ec"

URI_aarch64_rust-cxxbridge-flags+c++20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++20-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+c++20-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+c++20-devel.sha256sum] = "3ebf4910cf4c30ee30c248367c59a23cd7321f0e8efc512359485b4a18f6698e"

URI_aarch64_rust-cxxbridge-flags+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+default-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags+default-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags+default-devel.sha256sum] = "cac5bd583afefa12d80c6d4935a6a44ace3f72c6d8bc12ea6a82ee50b789c4e7"

URI_aarch64_rust-cxxbridge-flags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-flags-devel}"
SRC_URI[aarch64_rust-cxxbridge-flags-devel.sha256sum] = "e0f462988f10045ec08befb8d8843029e36faf2dd0b92512d4e52c8f35bc5ec4"

RDEPENDS:rust-cxxbridge-flags+c++14-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++17-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++20-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+default-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags-devel = " \
 cargo \
 rust \
 "
