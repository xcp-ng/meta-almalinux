# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fast-srgb8"
PV = "1.0.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-fast-srgb8+default-devel \
 rust-fast-srgb8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fast-srgb8-1.0.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "deacaa1dfaadb5e01a5c0d8f014d4fcd54d54feb813116a1cba7ec78392bdf81"

URI_x86_64_v2_rust-fast-srgb8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fast-srgb8+default-devel-1.0.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fast-srgb8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fast-srgb8+default-devel}"
SRC_URI[x86_64_v2_rust-fast-srgb8+default-devel.sha256sum] = "d81b7a2746a982b08225ec968fbffa796a18f140204e3343c4cc05b6634cf7c0"

URI_x86_64_v2_rust-fast-srgb8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fast-srgb8-devel-1.0.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fast-srgb8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fast-srgb8-devel}"
SRC_URI[x86_64_v2_rust-fast-srgb8-devel.sha256sum] = "d5273b1fa0ead031359be62d3161b2fd0399f7bde811e171705b69b7b5c8b4ec"

URI_aarch64_rust-fast-srgb8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fast-srgb8+default-devel-1.0.0-5.el10_1.noarch.rpm;name=aarch64_rust-fast-srgb8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fast-srgb8+default-devel}"
SRC_URI[aarch64_rust-fast-srgb8+default-devel.sha256sum] = "5a63be08f6cad62f29d96872ac3c9d3cd535adcc339b86a50ef0fae8580ca249"

URI_aarch64_rust-fast-srgb8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fast-srgb8-devel-1.0.0-5.el10_1.noarch.rpm;name=aarch64_rust-fast-srgb8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fast-srgb8-devel}"
SRC_URI[aarch64_rust-fast-srgb8-devel.sha256sum] = "9c807a2c7fa9560dbfcc6ae36676a9a2c9fa09b7e048000ff1ef9b6d09ae9784"

RDEPENDS:rust-fast-srgb8+default-devel = " \
 cargo \
 rust-fast-srgb8-devel \
 "
RDEPENDS:rust-fast-srgb8-devel = " \
 cargo \
 "
