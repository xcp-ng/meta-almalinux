# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nativefiledialog-extended"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 nativefiledialog-extended \
 nativefiledialog-extended-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nativefiledialog-extended-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8849ce114904470a7d121d03c39b5ba6d46d6becaff178ae88f87321ccbca3c0"

URI_x86_64_v2_nativefiledialog-extended = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nativefiledialog-extended-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nativefiledialog-extended;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nativefiledialog-extended}"
SRC_URI[x86_64_v2_nativefiledialog-extended.sha256sum] = "9ee822128670b1b14a9e46aba3fee44a68f234a6729f317db46228d2c2508baa"

URI_x86_64_v2_nativefiledialog-extended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nativefiledialog-extended-devel-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nativefiledialog-extended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nativefiledialog-extended-devel}"
SRC_URI[x86_64_v2_nativefiledialog-extended-devel.sha256sum] = "9ca9c87d67209a7f64f7b86b318c93fff427442834264da938d50626bd282b91"

URI_aarch64_nativefiledialog-extended = "${EPEL_MIRROR}/aarch64/Packages/n/nativefiledialog-extended-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_nativefiledialog-extended;unpack=0"
SRC_URI:append = " ${URI_aarch64_nativefiledialog-extended}"
SRC_URI[aarch64_nativefiledialog-extended.sha256sum] = "350f2997f850ff985cb72407349b97deb3c422ca476f990ef959110654e1254d"

URI_aarch64_nativefiledialog-extended-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nativefiledialog-extended-devel-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_nativefiledialog-extended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nativefiledialog-extended-devel}"
SRC_URI[aarch64_nativefiledialog-extended-devel.sha256sum] = "fca569302715a67d328d9f760ea81c863b32a0dc4639da5dd79f06642dd882db"

RDEPENDS:nativefiledialog-extended = " \
 glib2 \
 glibc \
 gtk3 \
 "
RDEPENDS:nativefiledialog-extended-devel = " \
 nativefiledialog-extended \
 "
