# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "greenboot"
PV = "0.15.9"
PR = "1.el10_0"
PACKAGES = " \
 greenboot \
 greenboot-default-health-checks \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/greenboot-0.15.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f01eefd016fec6fe8f26715a9c794b39f25fb2949d1da251ca734d63c43e1c8"

URI_x86_64_v2_greenboot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-0.15.9-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_greenboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_greenboot}"
SRC_URI[x86_64_v2_greenboot.sha256sum] = "7992c7c5ee81b9d78ffd6dae2167524a968c17165f1c3a59c2ce60dca7f37b05"

URI_x86_64_v2_greenboot-default-health-checks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-default-health-checks-0.15.9-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_greenboot-default-health-checks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_greenboot-default-health-checks}"
SRC_URI[x86_64_v2_greenboot-default-health-checks.sha256sum] = "ce76380165f5876d8fd4cf539605cd2a62a9f4494c00cc4b9bfa901e8895372a"

URI_aarch64_greenboot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-0.15.9-1.el10_0.aarch64.rpm;name=aarch64_greenboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_greenboot}"
SRC_URI[aarch64_greenboot.sha256sum] = "acd3ea3fd5e51d1ee0fa503ed92dc929aa83f902675a9e520924c313570e80bc"

URI_aarch64_greenboot-default-health-checks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-default-health-checks-0.15.9-1.el10_0.aarch64.rpm;name=aarch64_greenboot-default-health-checks;unpack=0"
SRC_URI:append = " ${URI_aarch64_greenboot-default-health-checks}"
SRC_URI[aarch64_greenboot-default-health-checks.sha256sum] = "609b34d2aec00b1433e7a975377fcb26e1d0bd33568241acf61660db52bb5bc3"

RDEPENDS:greenboot = " \
 bash \
 grub2-tools-minimal \
 pam \
 rpm-ostree \
 systemd \
 "
RDEPENDS:greenboot-default-health-checks = " \
 bash \
 greenboot \
 jq \
 util-linux \
 "
