# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha2"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-sha2+alloc-devel \
 rust-sha2+default-devel \
 rust-sha2+oid-devel \
 rust-sha2+zeroize-devel \
 rust-sha2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha2-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d31426893a8b57651d5332b7bacac16a642b92c3fe67bd6cbf1645437e619c89"

URI_x86_64_v2_rust-sha2+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+alloc-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+alloc-devel}"
SRC_URI[x86_64_v2_rust-sha2+alloc-devel.sha256sum] = "09316f60659aa59ce7a697ac3987549876765e65211442139094ef04be8b2902"

URI_x86_64_v2_rust-sha2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+default-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+default-devel}"
SRC_URI[x86_64_v2_rust-sha2+default-devel.sha256sum] = "ceaf881ce220f8559e95b94155d8fda07225b3d59475c3ad9305dc15701239ce"

URI_x86_64_v2_rust-sha2+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+oid-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+oid-devel}"
SRC_URI[x86_64_v2_rust-sha2+oid-devel.sha256sum] = "919340c6b15fec57793b0ff23ded624e79845633b6034ebd3b44fcb7e641a390"

URI_x86_64_v2_rust-sha2+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2+zeroize-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2+zeroize-devel}"
SRC_URI[x86_64_v2_rust-sha2+zeroize-devel.sha256sum] = "02b53b9074dbb189377e9a1cfbdd57fb8819c97a245bb3930d5a403bcc03eb9d"

URI_x86_64_v2_rust-sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha2-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha2-devel}"
SRC_URI[x86_64_v2_rust-sha2-devel.sha256sum] = "1b6213dc81df6bb3a06d630a8620f0fae22f23a99a43ae560b5a7e3871f32887"

URI_aarch64_rust-sha2+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+alloc-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+alloc-devel}"
SRC_URI[aarch64_rust-sha2+alloc-devel.sha256sum] = "30c52284968d14c4311151e154b0c4c7a442043f82b47adafe9317474055af6f"

URI_aarch64_rust-sha2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+default-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+default-devel}"
SRC_URI[aarch64_rust-sha2+default-devel.sha256sum] = "92566dd0b66a56871b0f43ba37f43534431f907afad8125f591813ad61993132"

URI_aarch64_rust-sha2+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+oid-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha2+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+oid-devel}"
SRC_URI[aarch64_rust-sha2+oid-devel.sha256sum] = "3816258f2467b0eec6e00ae347351abc11c589cff7faec76765ae229daec4ec7"

URI_aarch64_rust-sha2+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2+zeroize-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2+zeroize-devel}"
SRC_URI[aarch64_rust-sha2+zeroize-devel.sha256sum] = "cf4c099878613409b5ff084b530d29434eb7700f52f0852794efb42fa522be09"

URI_aarch64_rust-sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha2-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha2-devel}"
SRC_URI[aarch64_rust-sha2-devel.sha256sum] = "a6fd6782a96b1c62c3f62833910f1cdf361381b821556745c81bad1a0569a583"

RDEPENDS:rust-sha2+alloc-devel = " \
 cargo \
 rust-digest+alloc-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+default-devel = " \
 cargo \
 rust-sha2+alloc-devel \
 rust-sha2+oid-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2+zeroize-devel = " \
 cargo \
 rust-digest+zeroize-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-sha2-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cpufeatures+default-devel \
 rust-digest+default-devel \
 "
