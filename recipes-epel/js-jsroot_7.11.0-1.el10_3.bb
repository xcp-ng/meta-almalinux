# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jsroot"
PV = "7.11.0"
PR = "1.el10_3"
PACKAGES = " \
 js-jsroot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/js-jsroot-7.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ceabb8c53126bb470695fb08897d14dc460655a4c924f2aa33b3a434c1ab44d"

URI_x86_64_v2_js-jsroot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jsroot-7.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_js-jsroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_js-jsroot}"
SRC_URI[x86_64_v2_js-jsroot.sha256sum] = "e66272373a5485333e443ae30ef99fc1cfee81402a0814c02fae5bd818b13d3c"

URI_aarch64_js-jsroot = "${EPEL_MIRROR}/aarch64/Packages/j/js-jsroot-7.11.0-1.el10_3.noarch.rpm;name=aarch64_js-jsroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_js-jsroot}"
SRC_URI[aarch64_js-jsroot.sha256sum] = "f6b48f15fbf9fe20b2c16689fe723aff31f6a4e258f6d0b23e28ba15b7138709"

RDEPENDS:js-jsroot = " \
 mathjax3 \
 web-assets-filesystem \
 "
