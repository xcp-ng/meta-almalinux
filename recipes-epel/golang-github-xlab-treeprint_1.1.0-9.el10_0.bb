# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-xlab-treeprint"
PV = "1.1.0"
PR = "9.el10_0"
PACKAGES = " \
 golang-github-xlab-treeprint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-xlab-treeprint-1.1.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76aba967923dcedd5005eac907fb7f8493d6ee09597ff856b774e7df4a328f7f"

URI_x86_64_v2_golang-github-xlab-treeprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-xlab-treeprint-devel-1.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-xlab-treeprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-xlab-treeprint-devel}"
SRC_URI[x86_64_v2_golang-github-xlab-treeprint-devel.sha256sum] = "afcf0c44a1151aabf2c0354392340ffa35d6b1d3579238e2e9235035db12be99"

URI_aarch64_golang-github-xlab-treeprint-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-xlab-treeprint-devel-1.1.0-9.el10_0.noarch.rpm;name=aarch64_golang-github-xlab-treeprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-xlab-treeprint-devel}"
SRC_URI[aarch64_golang-github-xlab-treeprint-devel.sha256sum] = "c3b02adf036ac18c87f9aac7d3496c82b30855e0ec4933b90faa2bdb2eb018a3"

RDEPENDS:golang-github-xlab-treeprint-devel = " \
 go-filesystem \
 "
