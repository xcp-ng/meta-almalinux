# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xosview"
PV = "1.24"
PR = "7.el10_1"
PACKAGES = " \
 xosview \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xosview-1.24-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5796338dce9a1fc9ebd991731adca10be70b0fe37f6fbcb98fc03116ce4d6552"

URI_x86_64_v2_xosview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xosview-1.24-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xosview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xosview}"
SRC_URI[x86_64_v2_xosview.sha256sum] = "d39ff0ff72237ccb0d736818a06bd43322a04c65f5348c6b6e04569478172b57"

URI_aarch64_xosview = "${EPEL_MIRROR}/aarch64/Packages/x/xosview-1.24-7.el10_1.aarch64.rpm;name=aarch64_xosview;unpack=0"
SRC_URI:append = " ${URI_aarch64_xosview}"
SRC_URI[aarch64_xosview.sha256sum] = "4c0fe822c6f5dd3dde55d5ca28a96c76b9e96364862adc6db1c8d177c4260aaf"

RDEPENDS:xosview = " \
 glibc \
 libX11 \
 libXpm \
 libgcc \
 libstdc++ \
 xorg-x11-fonts-misc \
 "
