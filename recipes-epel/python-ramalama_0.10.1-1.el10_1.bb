# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ramalama"
PV = "0.10.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-ramalama \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ramalama-0.10.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f084a1f7996b335cb035ed86eca7f83d1fe4179ea9a993e279505661ca3da8fb"

URI_x86_64_v2_python3-ramalama = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ramalama-0.10.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ramalama;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ramalama}"
SRC_URI[x86_64_v2_python3-ramalama.sha256sum] = "e04c97a22a2a873db597a65e99d50f221fe187bec647f4c034801d128b2a0188"

URI_aarch64_python3-ramalama = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ramalama-0.10.1-1.el10_1.noarch.rpm;name=aarch64_python3-ramalama;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ramalama}"
SRC_URI[aarch64_python3-ramalama.sha256sum] = "5cbc25fd3e33d0254008b1c2da036b197b4f16fc70f2ff2a895d87ef8e7473a3"

RDEPENDS:python3-ramalama = " \
 python3 \
 python3-argcomplete \
 "
