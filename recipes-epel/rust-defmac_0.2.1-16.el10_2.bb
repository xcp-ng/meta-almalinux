# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-defmac"
PV = "0.2.1"
PR = "16.el10_2"
PACKAGES = " \
 rust-defmac+default-devel \
 rust-defmac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-defmac-0.2.1-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "870ddb1dab809b241c9ecf403d405e8cc0b973542e38ccc1c932d43b450bff26"

URI_x86_64_v2_rust-defmac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-defmac+default-devel-0.2.1-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-defmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-defmac+default-devel}"
SRC_URI[x86_64_v2_rust-defmac+default-devel.sha256sum] = "533c5ae3d406392dc01fe7161a6df450e8375c47b60ea692610d0ae43c3153b9"

URI_x86_64_v2_rust-defmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-defmac-devel-0.2.1-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-defmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-defmac-devel}"
SRC_URI[x86_64_v2_rust-defmac-devel.sha256sum] = "a82efd0bc8bed8728ff5a0e33c4c869fac5ce231fecc9c3606bf34883b10dc7c"

URI_aarch64_rust-defmac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-defmac+default-devel-0.2.1-16.el10_2.noarch.rpm;name=aarch64_rust-defmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-defmac+default-devel}"
SRC_URI[aarch64_rust-defmac+default-devel.sha256sum] = "e9350d12010325610069ddf491c7791cc214bee6a2f551617d00109e4156a956"

URI_aarch64_rust-defmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-defmac-devel-0.2.1-16.el10_2.noarch.rpm;name=aarch64_rust-defmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-defmac-devel}"
SRC_URI[aarch64_rust-defmac-devel.sha256sum] = "31e33fae84d9f02d430b0860c907e88a78d8e964295db068ce159e4deb7282e2"

RDEPENDS:rust-defmac+default-devel = " \
 cargo \
 rust-defmac-devel \
 "
RDEPENDS:rust-defmac-devel = " \
 cargo \
 "
