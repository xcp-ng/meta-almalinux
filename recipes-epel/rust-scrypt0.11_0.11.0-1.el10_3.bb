# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scrypt0.11"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-scrypt0.11+default-devel \
 rust-scrypt0.11+password-hash-devel \
 rust-scrypt0.11+simple-devel \
 rust-scrypt0.11+std-devel \
 rust-scrypt0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scrypt0.11-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fe5dcb68e2ed531f89c5df03209e94216a17bcaeb18778c03b61982d00ad523"

URI_x86_64_v2_rust-scrypt0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt0.11+default-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt0.11+default-devel}"
SRC_URI[x86_64_v2_rust-scrypt0.11+default-devel.sha256sum] = "d420b0fda1483f7e921eceeb80e0806a3ce229b4f9444a2da7234d026cc59138"

URI_x86_64_v2_rust-scrypt0.11+password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt0.11+password-hash-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt0.11+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt0.11+password-hash-devel}"
SRC_URI[x86_64_v2_rust-scrypt0.11+password-hash-devel.sha256sum] = "a08677f57389d8bf5f8ab0a7bb950f8e92a34f39e68e687e7f562ebd7ed276f6"

URI_x86_64_v2_rust-scrypt0.11+simple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt0.11+simple-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt0.11+simple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt0.11+simple-devel}"
SRC_URI[x86_64_v2_rust-scrypt0.11+simple-devel.sha256sum] = "cf899f97abfe7a2a17086dad836ccbf824f4bcc1750764a3c4421da3197fc4a3"

URI_x86_64_v2_rust-scrypt0.11+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt0.11+std-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt0.11+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt0.11+std-devel}"
SRC_URI[x86_64_v2_rust-scrypt0.11+std-devel.sha256sum] = "e381e8ade2a562a92fec30e49c94c92d0579279f0c41fdc9fd8aff2d35a9db29"

URI_x86_64_v2_rust-scrypt0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scrypt0.11-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scrypt0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scrypt0.11-devel}"
SRC_URI[x86_64_v2_rust-scrypt0.11-devel.sha256sum] = "98c4ab7939e8172878ccf17a19cc739cd88eb7c6060ec0ebd70d4a88336d7c2e"

URI_aarch64_rust-scrypt0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt0.11+default-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt0.11+default-devel}"
SRC_URI[aarch64_rust-scrypt0.11+default-devel.sha256sum] = "e471add2bebb6647a7efb84b2fd7d6fd7e295c5babaafde86b446ec20b07b27e"

URI_aarch64_rust-scrypt0.11+password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt0.11+password-hash-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt0.11+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt0.11+password-hash-devel}"
SRC_URI[aarch64_rust-scrypt0.11+password-hash-devel.sha256sum] = "7ba60f5aa19da29918cc54a41517215ea750e2d3a8dd491a201beba48b435dc1"

URI_aarch64_rust-scrypt0.11+simple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt0.11+simple-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt0.11+simple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt0.11+simple-devel}"
SRC_URI[aarch64_rust-scrypt0.11+simple-devel.sha256sum] = "9233bcd42d62aa08d34511b71a7abd41f2539aec11d2b5b7a1ddb6cccc2aa4a9"

URI_aarch64_rust-scrypt0.11+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt0.11+std-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt0.11+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt0.11+std-devel}"
SRC_URI[aarch64_rust-scrypt0.11+std-devel.sha256sum] = "fe4ddbf6027e91a7ffe29c2b6c9c297f777544f1711d8aedf582685d2d923f8a"

URI_aarch64_rust-scrypt0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scrypt0.11-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-scrypt0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scrypt0.11-devel}"
SRC_URI[aarch64_rust-scrypt0.11-devel.sha256sum] = "14e4310d0cb6e8d97abe7dbc0f9f1f83e4d73afff857c138b6c85c7e93e202f9"

RDEPENDS:rust-scrypt0.11+default-devel = " \
 cargo \
 rust-scrypt0.11+simple-devel \
 rust-scrypt0.11+std-devel \
 rust-scrypt0.11-devel \
 "
RDEPENDS:rust-scrypt0.11+password-hash-devel = " \
 cargo \
 rust-password-hash0.5+rand_core-devel \
 rust-password-hash0.5-devel \
 rust-scrypt0.11-devel \
 "
RDEPENDS:rust-scrypt0.11+simple-devel = " \
 cargo \
 rust-scrypt0.11+password-hash-devel \
 rust-scrypt0.11-devel \
 "
RDEPENDS:rust-scrypt0.11+std-devel = " \
 cargo \
 rust-password-hash0.5+rand_core-devel \
 rust-password-hash0.5+std-devel \
 rust-password-hash0.5-devel \
 rust-scrypt0.11-devel \
 "
RDEPENDS:rust-scrypt0.11-devel = " \
 cargo \
 rust \
 rust-pbkdf2_0.12+default-devel \
 rust-salsa20_0.10-devel \
 rust-sha2_0.10-devel \
 "
