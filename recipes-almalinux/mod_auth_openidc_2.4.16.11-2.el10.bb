# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_auth_openidc"
PV = "2.4.16.11"
PR = "2.el10"
PACKAGES = " \
 mod_auth_openidc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_auth_openidc-2.4.16.11-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c54205fc4b9a80758201197b8c092b4b589fe4b47ba13de0b6b5a817069899ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_auth_openidc-2.4.16.11-2.el10.x86_64_v2.rpm;name=x86_64_v2_mod_auth_openidc;unpack=0"
SRC_URI[x86_64_v2_mod_auth_openidc.sha256sum] = "baa317f791610a63b93b9240a43a16a3b91b5ab281a492866b975011a2b4a71c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_auth_openidc-2.4.16.11-2.el10.aarch64.rpm;name=aarch64_mod_auth_openidc;unpack=0"
SRC_URI[aarch64_mod_auth_openidc.sha256sum] = "cbed5f393fd2b0a16498c7c5c8144c6c85516ef39bb9233c360afe88dd13cb44"

RDEPENDS:mod_auth_openidc = " \
 apr \
 apr-util \
 cjose \
 expat \
 glibc \
 httpd-core \
 jansson \
 jq \
 libxcrypt \
 openldap \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
