# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuned"
PV = "2.25.1"
PR = "2.el10_0"
PACKAGES = " \
 tuned \
 tuned-gtk \
 tuned-ppd \
 tuned-profiles-atomic \
 tuned-profiles-cpu-partitioning \
 tuned-profiles-mssql \
 tuned-profiles-oracle \
 tuned-profiles-postgresql \
 tuned-profiles-spectrumscale \
 tuned-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tuned-2.25.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33731593ccff66aa66c74ab56c63a52c831178219910f0a793eab256c2e782f6"

URI_x86_64_v2_tuned = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned}"
SRC_URI[x86_64_v2_tuned.sha256sum] = "dcd1cf9110833a581aaf29aace67b22d0b5eaf32ea9eb78406c81ff64cea1cc3"

URI_x86_64_v2_tuned-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-gtk-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-gtk}"
SRC_URI[x86_64_v2_tuned-gtk.sha256sum] = "b5e8d87f0f08871d4099fdf3feb4f09d17ae2227234a682bfe3287ad540e5a0b"

URI_x86_64_v2_tuned-ppd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-ppd-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned-ppd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-ppd}"
SRC_URI[x86_64_v2_tuned-ppd.sha256sum] = "0b0b8e7784f7bd9028ff784409b66b0ae1ac347fecfef724fbb620f38705d9d1"

URI_x86_64_v2_tuned-profiles-atomic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-atomic-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned-profiles-atomic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-atomic}"
SRC_URI[x86_64_v2_tuned-profiles-atomic.sha256sum] = "1fe177ddbf42804fa6c37cf6200c32b7c1019fd1e321129ccbb36d487f651ceb"

URI_x86_64_v2_tuned-profiles-cpu-partitioning = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-profiles-cpu-partitioning-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-cpu-partitioning}"
SRC_URI[x86_64_v2_tuned-profiles-cpu-partitioning.sha256sum] = "5ea8498793b122ab644e41637bf30cefb9781af4a06ddd2ffcb59f7f331a5c42"

URI_x86_64_v2_tuned-profiles-mssql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-mssql-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned-profiles-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-mssql}"
SRC_URI[x86_64_v2_tuned-profiles-mssql.sha256sum] = "7d62d718e64cc556d265e44095bb847125d7df06188d1503a45f750115333a1d"

URI_x86_64_v2_tuned-profiles-oracle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-oracle-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned-profiles-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-oracle}"
SRC_URI[x86_64_v2_tuned-profiles-oracle.sha256sum] = "2b155aa885721a0e76f9cefab2be06c343fbd2750520f81c5ce99d14a5c6cfca"

URI_x86_64_v2_tuned-profiles-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-postgresql-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned-profiles-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-postgresql}"
SRC_URI[x86_64_v2_tuned-profiles-postgresql.sha256sum] = "c4166da41e38366faab1a38aba703a0e90dee5cf14a47ea8a5eee4b9b1737411"

URI_x86_64_v2_tuned-profiles-spectrumscale = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-spectrumscale-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned-profiles-spectrumscale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-profiles-spectrumscale}"
SRC_URI[x86_64_v2_tuned-profiles-spectrumscale.sha256sum] = "8dd00163019cdae69617da7640883b95e5403644b4c08a6c928ab2f2b4914a3d"

URI_x86_64_v2_tuned-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-utils-2.25.1-2.el10_0.noarch.rpm;name=x86_64_v2_tuned-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuned-utils}"
SRC_URI[x86_64_v2_tuned-utils.sha256sum] = "2b357e65e5b7ab9c51258fe6bb6c46e04165fdaefb74f471a9af20656e8db6f0"

URI_aarch64_tuned = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned}"
SRC_URI[aarch64_tuned.sha256sum] = "dcd1cf9110833a581aaf29aace67b22d0b5eaf32ea9eb78406c81ff64cea1cc3"

URI_aarch64_tuned-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-gtk-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-gtk}"
SRC_URI[aarch64_tuned-gtk.sha256sum] = "b5e8d87f0f08871d4099fdf3feb4f09d17ae2227234a682bfe3287ad540e5a0b"

URI_aarch64_tuned-ppd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-ppd-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned-ppd;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-ppd}"
SRC_URI[aarch64_tuned-ppd.sha256sum] = "0b0b8e7784f7bd9028ff784409b66b0ae1ac347fecfef724fbb620f38705d9d1"

URI_aarch64_tuned-profiles-atomic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-atomic-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned-profiles-atomic;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-atomic}"
SRC_URI[aarch64_tuned-profiles-atomic.sha256sum] = "1fe177ddbf42804fa6c37cf6200c32b7c1019fd1e321129ccbb36d487f651ceb"

URI_aarch64_tuned-profiles-cpu-partitioning = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-profiles-cpu-partitioning-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-cpu-partitioning}"
SRC_URI[aarch64_tuned-profiles-cpu-partitioning.sha256sum] = "5ea8498793b122ab644e41637bf30cefb9781af4a06ddd2ffcb59f7f331a5c42"

URI_aarch64_tuned-profiles-mssql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-mssql-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned-profiles-mssql;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-mssql}"
SRC_URI[aarch64_tuned-profiles-mssql.sha256sum] = "7d62d718e64cc556d265e44095bb847125d7df06188d1503a45f750115333a1d"

URI_aarch64_tuned-profiles-oracle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-oracle-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned-profiles-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-oracle}"
SRC_URI[aarch64_tuned-profiles-oracle.sha256sum] = "2b155aa885721a0e76f9cefab2be06c343fbd2750520f81c5ce99d14a5c6cfca"

URI_aarch64_tuned-profiles-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-postgresql-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned-profiles-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-postgresql}"
SRC_URI[aarch64_tuned-profiles-postgresql.sha256sum] = "c4166da41e38366faab1a38aba703a0e90dee5cf14a47ea8a5eee4b9b1737411"

URI_aarch64_tuned-profiles-spectrumscale = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-spectrumscale-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned-profiles-spectrumscale;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-profiles-spectrumscale}"
SRC_URI[aarch64_tuned-profiles-spectrumscale.sha256sum] = "8dd00163019cdae69617da7640883b95e5403644b4c08a6c928ab2f2b4914a3d"

URI_aarch64_tuned-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-utils-2.25.1-2.el10_0.noarch.rpm;name=aarch64_tuned-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuned-utils}"
SRC_URI[aarch64_tuned-utils.sha256sum] = "2b357e65e5b7ab9c51258fe6bb6c46e04165fdaefb74f471a9af20656e8db6f0"

RDEPENDS:tuned = " \
 bash \
 dbus \
 ethtool \
 gawk \
 hdparm \
 iproute \
 kmod \
 polkit \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-inotify \
 python3-linux-procfs \
 python3-pyudev \
 systemd \
 util-linux \
 virt-what \
 "
RDEPENDS:tuned-gtk = " \
 polkit \
 powertop \
 python3 \
 python3-gobject-base \
 tuned \
 "
RDEPENDS:tuned-ppd = " \
 bash \
 python3 \
 tuned \
 "
RDEPENDS:tuned-profiles-atomic = " \
 tuned \
 "
RDEPENDS:tuned-profiles-cpu-partitioning = " \
 bash \
 tuned \
 "
RDEPENDS:tuned-profiles-mssql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-oracle = " \
 tuned \
 "
RDEPENDS:tuned-profiles-postgresql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-spectrumscale = " \
 tuned \
 "
RDEPENDS:tuned-utils = " \
 powertop \
 python3 \
 tuned \
 "
