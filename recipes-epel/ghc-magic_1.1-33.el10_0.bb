# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-magic"
PV = "1.1"
PR = "33.el10_0"
PACKAGES = " \
 ghc-magic \
 ghc-magic-devel \
 ghc-magic-doc \
 ghc-magic-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-magic-1.1-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a74e568351007be99468d6277f34525032024ee982d3c3eb69279bac060d8d4"

URI_x86_64_v2_ghc-magic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-magic-1.1-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-magic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-magic}"
SRC_URI[x86_64_v2_ghc-magic.sha256sum] = "73004779e266b315a788332c5937db87349e1b0be8f406c533034614be9f3d96"

URI_x86_64_v2_ghc-magic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-magic-devel-1.1-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-magic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-magic-devel}"
SRC_URI[x86_64_v2_ghc-magic-devel.sha256sum] = "5d1a7a4b2d0c551511b562268ebd7ce758c5d2f1c6ffb110842e4183c3581945"

URI_x86_64_v2_ghc-magic-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-magic-doc-1.1-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-magic-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-magic-doc}"
SRC_URI[x86_64_v2_ghc-magic-doc.sha256sum] = "3e1dfadf5792b2661d7ae8c8ebfcd0758232b30720e2e44d555568fdba6f8955"

URI_x86_64_v2_ghc-magic-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-magic-prof-1.1-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-magic-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-magic-prof}"
SRC_URI[x86_64_v2_ghc-magic-prof.sha256sum] = "6d9d7a75bb736014d932261525ff5457fdeccd165823bfd34c6f983e7f8c9aee"

URI_aarch64_ghc-magic = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-magic-1.1-33.el10_0.aarch64.rpm;name=aarch64_ghc-magic;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-magic}"
SRC_URI[aarch64_ghc-magic.sha256sum] = "6aa927df74acba1c65661c879fd1404e7add539c24cf1cac03b32be8b7f56f32"

URI_aarch64_ghc-magic-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-magic-devel-1.1-33.el10_0.aarch64.rpm;name=aarch64_ghc-magic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-magic-devel}"
SRC_URI[aarch64_ghc-magic-devel.sha256sum] = "7a2b953bb8c1ba0f209b7633e1a783f6c76aba3479fdfee83d02cb7b3c79f503"

URI_aarch64_ghc-magic-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-magic-doc-1.1-33.el10_0.noarch.rpm;name=aarch64_ghc-magic-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-magic-doc}"
SRC_URI[aarch64_ghc-magic-doc.sha256sum] = "55cd998054b5819956bd5f0a49dcc5bec8e4673b4e9736af9eb705253fa97435"

URI_aarch64_ghc-magic-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-magic-prof-1.1-33.el10_0.aarch64.rpm;name=aarch64_ghc-magic-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-magic-prof}"
SRC_URI[aarch64_ghc-magic-prof.sha256sum] = "859abdc3e3754a3a6c9bb807d9d2e307f2bd716b4e670908e9a0c7db05b9ca25"

RDEPENDS:ghc-magic = " \
 file-libs \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-magic-devel = " \
 file-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-magic \
 "
RDEPENDS:ghc-magic-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-magic-prof = " \
 ghc-base-prof \
 ghc-magic-devel \
 "
