# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa"
PV = "26.1.1"
PR = "1.el10.alma.2"
PACKAGES = " \
 mesa-dri-drivers \
 mesa-filesystem \
 mesa-libEGL \
 mesa-libEGL-devel \
 mesa-libGL \
 mesa-libGL-devel \
 mesa-libgbm \
 mesa-libgbm-devel \
 mesa-vulkan-drivers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-26.1.1-1.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "744f7f0661b15228deb515ff96b1ee68a33ff9feb8620574c20b8dc9b06df4d7"

URI_x86_64_v2_mesa-dri-drivers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-dri-drivers-26.1.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-dri-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-dri-drivers}"
SRC_URI[x86_64_v2_mesa-dri-drivers.sha256sum] = "a5451d481773a00736e5aebee0f9b4ce986d19545f45eb146dfe977e087614d3"

URI_x86_64_v2_mesa-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-filesystem-26.1.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-filesystem}"
SRC_URI[x86_64_v2_mesa-filesystem.sha256sum] = "0cc8954790254ce5604ca7ce52a8088e98820d53c14c24ca09cb9f91bbbad112"

URI_x86_64_v2_mesa-libEGL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-26.1.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libEGL}"
SRC_URI[x86_64_v2_mesa-libEGL.sha256sum] = "b639a325da8f15ea940884b7a5cb319e34bc18ba0075f075692399a304adb79f"

URI_x86_64_v2_mesa-libEGL-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-devel-26.1.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libEGL-devel}"
SRC_URI[x86_64_v2_mesa-libEGL-devel.sha256sum] = "2386e086d37b9b0da7db65ec76b269f7626f27f86f0e4292fbde010854edc90e"

URI_x86_64_v2_mesa-libGL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-26.1.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGL}"
SRC_URI[x86_64_v2_mesa-libGL.sha256sum] = "2704b06727f895ddec8699c25cbc55d854744a83da6883ccc354eb991b9f77e8"

URI_x86_64_v2_mesa-libGL-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-devel-26.1.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGL-devel}"
SRC_URI[x86_64_v2_mesa-libGL-devel.sha256sum] = "224f434289b8b1b4c2f2e14d4d369bfeebf3aa0631563b244c7b0b4504f4a008"

URI_x86_64_v2_mesa-libgbm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-26.1.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libgbm}"
SRC_URI[x86_64_v2_mesa-libgbm.sha256sum] = "00bea56c9c6bb43c67c590fc313256d3f16779eece48dc04d3fab407bcd9b725"

URI_x86_64_v2_mesa-libgbm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-devel-26.1.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libgbm-devel}"
SRC_URI[x86_64_v2_mesa-libgbm-devel.sha256sum] = "64c609ba22898e5f7d821ea3925f86063b9ed3358e1ea8103f5ccb475f1bc07b"

URI_x86_64_v2_mesa-vulkan-drivers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-vulkan-drivers-26.1.1-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-vulkan-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-vulkan-drivers}"
SRC_URI[x86_64_v2_mesa-vulkan-drivers.sha256sum] = "1371d9c7f1aa877ed9c0ebdda206e33fd01c7622b1f5808f0bd328b3200f811a"

URI_aarch64_mesa-dri-drivers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-dri-drivers-26.1.1-1.el10.alma.2.aarch64.rpm;name=aarch64_mesa-dri-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-dri-drivers}"
SRC_URI[aarch64_mesa-dri-drivers.sha256sum] = "9f6df32bee119a08ae00c00b9de14d6cae093377fc9fd74950a13b4202f718f1"

URI_aarch64_mesa-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-filesystem-26.1.1-1.el10.alma.2.aarch64.rpm;name=aarch64_mesa-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-filesystem}"
SRC_URI[aarch64_mesa-filesystem.sha256sum] = "dd795b6f85a1e530f3678dc69e43f19c3b87bb2bf4570a51fa95ed24047f8de1"

URI_aarch64_mesa-libEGL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-26.1.1-1.el10.alma.2.aarch64.rpm;name=aarch64_mesa-libEGL;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libEGL}"
SRC_URI[aarch64_mesa-libEGL.sha256sum] = "49269ce2a08e3f8db9b9413141b929c20bafea277179222635c9e6a85549400e"

URI_aarch64_mesa-libEGL-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-devel-26.1.1-1.el10.alma.2.aarch64.rpm;name=aarch64_mesa-libEGL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libEGL-devel}"
SRC_URI[aarch64_mesa-libEGL-devel.sha256sum] = "874dcef87d0ab52df035cdb6315514fd27bb324c14c7930548f0b0f8b007ccb7"

URI_aarch64_mesa-libGL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-26.1.1-1.el10.alma.2.aarch64.rpm;name=aarch64_mesa-libGL;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGL}"
SRC_URI[aarch64_mesa-libGL.sha256sum] = "034b7dc6ccf7c9d1b412a9c753fe1eb54c4e64a749cc8c6e35f68bb355cee2ec"

URI_aarch64_mesa-libGL-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-devel-26.1.1-1.el10.alma.2.aarch64.rpm;name=aarch64_mesa-libGL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGL-devel}"
SRC_URI[aarch64_mesa-libGL-devel.sha256sum] = "6f3735cbe1675cfbbcbfa82f1a3fd5ad64ed08df01f7e1cb2208572633ba241e"

URI_aarch64_mesa-libgbm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-26.1.1-1.el10.alma.2.aarch64.rpm;name=aarch64_mesa-libgbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libgbm}"
SRC_URI[aarch64_mesa-libgbm.sha256sum] = "9eb2ba807e55426b056b81d3a216d7c91d7d03d0878a16dec896ec18ea8f0f36"

URI_aarch64_mesa-libgbm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-devel-26.1.1-1.el10.alma.2.aarch64.rpm;name=aarch64_mesa-libgbm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libgbm-devel}"
SRC_URI[aarch64_mesa-libgbm-devel.sha256sum] = "eeca2f6e11f3daee4aed4b346f1cf9c43473883585dd25b462ee19f76358f538"

URI_aarch64_mesa-vulkan-drivers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-vulkan-drivers-26.1.1-1.el10.alma.2.aarch64.rpm;name=aarch64_mesa-vulkan-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-vulkan-drivers}"
SRC_URI[aarch64_mesa-vulkan-drivers.sha256sum] = "96ef156ab4056c704f26c6bc62195aca07834d482f40c78d2d5297d16687ffd1"

RDEPENDS:mesa-dri-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 mesa-libgbm \
 spirv-tools-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-filesystem = " \
 "
RDEPENDS:mesa-libEGL = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libxcb \
 mesa-dri-drivers \
 mesa-libgbm \
 "
RDEPENDS:mesa-libEGL-devel = " \
 libglvnd-devel \
 mesa-libEGL \
 "
RDEPENDS:mesa-libGL = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libXext \
 libXxf86vm \
 libdrm \
 libglvnd-glx \
 libxcb \
 mesa-dri-drivers \
 "
RDEPENDS:mesa-libGL-devel = " \
 libdrm-devel \
 libglvnd-devel \
 mesa-libGL \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-libgbm = " \
 expat \
 glibc \
 libdrm \
 mesa-dri-drivers \
 "
RDEPENDS:mesa-libgbm-devel = " \
 mesa-libgbm \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-vulkan-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libX11-xcb \
 libdisplay-info \
 libdrm \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 spirv-tools-libs \
 systemd-libs \
 vulkan-loader \
 zlib-ng-compat \
 "
