# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-FTP-RetrHandle"
PV = "0.2"
PR = "45.el10_2"
PACKAGES = " \
 perl-Net-FTP-RetrHandle \
 perl-Net-FTP-RetrHandle-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Net-FTP-RetrHandle-0.2-45.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6879c302873564cbe3b113c0072c60cab701d088e90a37138173409a410cd604"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-RetrHandle-0.2-45.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-RetrHandle;unpack=0"
SRC_URI[x86_64_v2_perl-Net-FTP-RetrHandle.sha256sum] = "bd1a16818aa78e1475ed0e3fb4f3947fc51b2c63df5789ef4cb58108e1c988b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-RetrHandle-tests-0.2-45.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-RetrHandle-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Net-FTP-RetrHandle-tests.sha256sum] = "9be8fb67770afec7c0af0c2b206257d53a8e9593fc6e8968870de3a2a669ff30"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-RetrHandle-0.2-45.el10_2.noarch.rpm;name=aarch64_perl-Net-FTP-RetrHandle;unpack=0"
SRC_URI[aarch64_perl-Net-FTP-RetrHandle.sha256sum] = "8eacb69816b1a039b1afbbcb42211be77aa43d7c8c4b4d2d5aa497f84fbee46c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-RetrHandle-tests-0.2-45.el10_2.noarch.rpm;name=aarch64_perl-Net-FTP-RetrHandle-tests;unpack=0"
SRC_URI[aarch64_perl-Net-FTP-RetrHandle-tests.sha256sum] = "da6158090c4dce86a9f3352e4ade409d45ff81e24b36a53ae0c549ae285046d2"

RDEPENDS:perl-Net-FTP-RetrHandle = " \
 perl-Carp \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-base \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Net-FTP-RetrHandle-tests = " \
 bash \
 perl-Net-FTP-RetrHandle \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
