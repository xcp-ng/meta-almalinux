# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnbd"
PV = "1.22.2"
PR = "3.el10_1"
PACKAGES = " \
 libnbd \
 libnbd-bash-completion \
 libnbd-devel \
 nbdfuse \
 ocaml-libnbd \
 ocaml-libnbd-devel \
 python3-libnbd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnbd-1.22.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "741ac4f95a470d7714bcdc12a4bb05819a36a832e81162767273c9e245d7ebc8"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

URI_x86_64_v2_libnbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-1.22.2-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd}"
SRC_URI[x86_64_v2_libnbd.sha256sum] = "e6ca22b502b6dd4b2a39cd65b1098235c3bde23a4e5524e12e86940811c17312"

URI_x86_64_v2_libnbd-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-bash-completion-1.22.2-3.el10_1.noarch.rpm;name=x86_64_v2_libnbd-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd-bash-completion}"
SRC_URI[x86_64_v2_libnbd-bash-completion.sha256sum] = "efdea219538c55dea6cba502d06cbd1b51e3334233119320387abe3cdc9490a3"

URI_x86_64_v2_libnbd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnbd-devel-1.22.2-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd-devel}"
SRC_URI[x86_64_v2_libnbd-devel.sha256sum] = "e4248dcbe05853ca0223689a9eb217314ad4f325537b8f454854fd0e2794c0e8"

URI_x86_64_v2_nbdfuse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdfuse-1.22.2-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdfuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdfuse}"
SRC_URI[x86_64_v2_nbdfuse.sha256sum] = "82be2465bd2a0fdc053dea2c073b8cb425d3882e6b285b40eaf917dff169c7e9"

URI_x86_64_v2_ocaml-libnbd = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-1.22.2-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libnbd}"
SRC_URI[x86_64_v2_ocaml-libnbd.sha256sum] = "1aacc7e069d9ca810a8cba2805bee266022e84483123e1d9d050b1c9bdb7d576"

URI_x86_64_v2_ocaml-libnbd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-devel-1.22.2-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libnbd-devel}"
SRC_URI[x86_64_v2_ocaml-libnbd-devel.sha256sum] = "a2c58f3bfdff582525a62290b1168d268e56a1b6380c0267397c9def796c330b"

URI_x86_64_v2_python3-libnbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnbd-1.22.2-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnbd}"
SRC_URI[x86_64_v2_python3-libnbd.sha256sum] = "a438009d2525da6c3190346092dbbe5e10124b7b965e1e24f51f2e0c5956b669"

URI_aarch64_libnbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-1.22.2-3.el10_1.aarch64.rpm;name=aarch64_libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd}"
SRC_URI[aarch64_libnbd.sha256sum] = "1898f0ba28b8f726bde0ad3a25ab09b55fc02cc7ea0d2b42144de6eccb6a9117"

URI_aarch64_libnbd-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-bash-completion-1.22.2-3.el10_1.noarch.rpm;name=aarch64_libnbd-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd-bash-completion}"
SRC_URI[aarch64_libnbd-bash-completion.sha256sum] = "efdea219538c55dea6cba502d06cbd1b51e3334233119320387abe3cdc9490a3"

URI_aarch64_libnbd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnbd-devel-1.22.2-3.el10_1.aarch64.rpm;name=aarch64_libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd-devel}"
SRC_URI[aarch64_libnbd-devel.sha256sum] = "068a8f1b32fcb39dd87006e42c77c4cc5e8f5cfe945d22a869707a57a5817b76"

URI_aarch64_nbdfuse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdfuse-1.22.2-3.el10_1.aarch64.rpm;name=aarch64_nbdfuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdfuse}"
SRC_URI[aarch64_nbdfuse.sha256sum] = "122636a0a912a477ff9a283f22867033b3647b6f2b31268be824a0dfaae2b734"

URI_aarch64_ocaml-libnbd = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-1.22.2-3.el10_1.aarch64.rpm;name=aarch64_ocaml-libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libnbd}"
SRC_URI[aarch64_ocaml-libnbd.sha256sum] = "4875fe5c372b090c3ad16ba4f5537d236b97a24fc716aba1a39a1701bda7202a"

URI_aarch64_ocaml-libnbd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-devel-1.22.2-3.el10_1.aarch64.rpm;name=aarch64_ocaml-libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libnbd-devel}"
SRC_URI[aarch64_ocaml-libnbd-devel.sha256sum] = "03f99e20bf50479c64dad14cab9fd5af5747a663ecc39f154a2138f5517939cd"

URI_aarch64_python3-libnbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnbd-1.22.2-3.el10_1.aarch64.rpm;name=aarch64_python3-libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnbd}"
SRC_URI[aarch64_python3-libnbd.sha256sum] = "62179f844348760711e99a5ddbb49fb4d778a688cc901a67a6a9723d816d9f6d"

RDEPENDS:libnbd = " \
 glibc \
 gnutls \
 libxml2 \
 "
RDEPENDS:libnbd-bash-completion = " \
 bash-completion \
 libnbd \
 "
RDEPENDS:libnbd-devel = " \
 libnbd \
 pkgconf-pkg-config \
 "
RDEPENDS:nbdfuse = " \
 fuse3-libs \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd = " \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd-devel = " \
 ocaml-libnbd \
 "
RDEPENDS:python3-libnbd = " \
 bash \
 glibc \
 gnutls \
 libnbd \
 libxml2 \
 python3 \
 "
