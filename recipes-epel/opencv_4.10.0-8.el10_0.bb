# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencv"
PV = "4.10.0"
PR = "8.el10_0"
PACKAGES = " \
 opencv \
 opencv-alphamat \
 opencv-aruco \
 opencv-bgsegm \
 opencv-bioinspired \
 opencv-calib3d \
 opencv-ccalib \
 opencv-core \
 opencv-cvv \
 opencv-data \
 opencv-datasets \
 opencv-devel \
 opencv-dnn \
 opencv-dnn_objdetect \
 opencv-dnn_superres \
 opencv-doc \
 opencv-dpm \
 opencv-face \
 opencv-features2d \
 opencv-flann \
 opencv-freetype \
 opencv-fuzzy \
 opencv-gapi \
 opencv-hdf \
 opencv-hfs \
 opencv-highgui \
 opencv-img_hash \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-intensity_transform \
 opencv-java \
 opencv-line_descriptor \
 opencv-mcc \
 opencv-ml \
 opencv-objdetect \
 opencv-optflow \
 opencv-phase_unwrapping \
 opencv-photo \
 opencv-plot \
 opencv-quality \
 opencv-rapid \
 opencv-reg \
 opencv-rgbd \
 opencv-saliency \
 opencv-shape \
 opencv-signal \
 opencv-stereo \
 opencv-stitching \
 opencv-structured_light \
 opencv-superres \
 opencv-surface_matching \
 opencv-text \
 opencv-tracking \
 opencv-video \
 opencv-videoio \
 opencv-videostab \
 opencv-wechat_qrcode \
 opencv-ximgproc \
 opencv-xobjdetect \
 opencv-xphoto \
 python3-opencv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opencv-4.10.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a47c1a73ad0c53a71a9cc8c61c1d20d7bc1fa5ce21d0094c4403127e8cf749cd"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - opencv-videoio: libavcodec.so.61()(64bit)
# - opencv-videoio: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - opencv-videoio: libavformat.so.61()(64bit)
# - opencv-videoio: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - opencv-videoio: libavutil.so.59()(64bit)
# - opencv-videoio: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - opencv-videoio: libswscale.so.8()(64bit)
# - opencv-videoio: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_opencv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv}"
SRC_URI[x86_64_v2_opencv.sha256sum] = "ee31279f62e159f0a6ffa463dc2e960154c5585aec0c4c19b9eadf3fcb7dcd61"

URI_x86_64_v2_opencv-alphamat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-alphamat-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-alphamat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-alphamat}"
SRC_URI[x86_64_v2_opencv-alphamat.sha256sum] = "b671d8d3b8307672aec830c22ded5ebfcc25ff51358e679e96e326718258ce53"

URI_x86_64_v2_opencv-aruco = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-aruco-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-aruco;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-aruco}"
SRC_URI[x86_64_v2_opencv-aruco.sha256sum] = "3c34ce24baa0a65cdfa673821a1cfa2c6497adfeacc490155707070dcf5d1c66"

URI_x86_64_v2_opencv-bgsegm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-bgsegm-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-bgsegm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-bgsegm}"
SRC_URI[x86_64_v2_opencv-bgsegm.sha256sum] = "b83205efae34aab29ad0268b569fbf3232aa90eb89a4eb9ad7acd7b53aa3544b"

URI_x86_64_v2_opencv-bioinspired = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-bioinspired-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-bioinspired;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-bioinspired}"
SRC_URI[x86_64_v2_opencv-bioinspired.sha256sum] = "bd58f65530c5b63d3a3e8e280b11b303e3a299d17aba341a32eab3e0c7ede599"

URI_x86_64_v2_opencv-calib3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-calib3d-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-calib3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-calib3d}"
SRC_URI[x86_64_v2_opencv-calib3d.sha256sum] = "02f0c1e634b241aa1722c889c3d2c63613dfe816e93eabfe8d9cfa62a60017e5"

URI_x86_64_v2_opencv-ccalib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-ccalib-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-ccalib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-ccalib}"
SRC_URI[x86_64_v2_opencv-ccalib.sha256sum] = "e1d1d7c55017fcaf067840042a5754e1aa84652164c2ea0308f8bbbbb4b331c2"

URI_x86_64_v2_opencv-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-core-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-core}"
SRC_URI[x86_64_v2_opencv-core.sha256sum] = "67ae1c134abc11aa811ad5f1f66733d7d867af7c934c89092e8d2262eb23f159"

URI_x86_64_v2_opencv-cvv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-cvv-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-cvv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-cvv}"
SRC_URI[x86_64_v2_opencv-cvv.sha256sum] = "7d52c8b12580e62d6224748657a10fdf0355b68f1c843d23ccc9c6e112fbca2c"

URI_x86_64_v2_opencv-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-data-4.10.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_opencv-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-data}"
SRC_URI[x86_64_v2_opencv-data.sha256sum] = "8da02481f254e13733b08c8b16448ec5580bf0257b4aa3b2d8602dd1ec724354"

URI_x86_64_v2_opencv-datasets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-datasets-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-datasets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-datasets}"
SRC_URI[x86_64_v2_opencv-datasets.sha256sum] = "ff59eb5ab19da3750076a193ae9a62638ef175657a1ca866e7d51b3a5cc6bca4"

URI_x86_64_v2_opencv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-devel-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-devel}"
SRC_URI[x86_64_v2_opencv-devel.sha256sum] = "f1ff507897c7ed563a278aae0c16f562f832fa169b9af4623f8a42eeafc404bf"

URI_x86_64_v2_opencv-dnn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-dnn-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-dnn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-dnn}"
SRC_URI[x86_64_v2_opencv-dnn.sha256sum] = "b10ffab89a54da511f6fe754fc76394c4cc3bdf38f4c79cb79a7d4def47a1438"

URI_x86_64_v2_opencv-dnn_objdetect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-dnn_objdetect-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-dnn_objdetect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-dnn_objdetect}"
SRC_URI[x86_64_v2_opencv-dnn_objdetect.sha256sum] = "3cd77219c58995f5916b633bb90d825993dae2700fa1066f19a7f1c569080355"

URI_x86_64_v2_opencv-dnn_superres = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-dnn_superres-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-dnn_superres;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-dnn_superres}"
SRC_URI[x86_64_v2_opencv-dnn_superres.sha256sum] = "5cc963188b2670541fd7bb0fc0d5a3ce19e39c42c5443e9a0358a85f3365651b"

URI_x86_64_v2_opencv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-doc-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-doc}"
SRC_URI[x86_64_v2_opencv-doc.sha256sum] = "9ecc990c7c4ccd6a5c5d78c863d1c80578e2c5a983336173ffd1d1968f0c9618"

URI_x86_64_v2_opencv-dpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-dpm-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-dpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-dpm}"
SRC_URI[x86_64_v2_opencv-dpm.sha256sum] = "5f44cb541336ebd413628af070bc44b979caebd5ebecbbc37a7459b0b244ba03"

URI_x86_64_v2_opencv-face = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-face-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-face;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-face}"
SRC_URI[x86_64_v2_opencv-face.sha256sum] = "06a838f564d1b6470c70f6235344f43df198698bc5588e23294409c40ccaeffb"

URI_x86_64_v2_opencv-features2d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-features2d-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-features2d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-features2d}"
SRC_URI[x86_64_v2_opencv-features2d.sha256sum] = "5ee6424d3a05069bb7ad0e1379b760de24a7daddb8ccb9a82d7879113a6aa4d0"

URI_x86_64_v2_opencv-flann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-flann-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-flann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-flann}"
SRC_URI[x86_64_v2_opencv-flann.sha256sum] = "2f8af3ad7a59a9381e5d2fa61ff5bb3d52efdd0754d2beeec8372ec33703d461"

URI_x86_64_v2_opencv-freetype = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-freetype-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-freetype;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-freetype}"
SRC_URI[x86_64_v2_opencv-freetype.sha256sum] = "27cf318c6129dbf6415de6ee86cbd55579cbb6bd7adc6b7727fee4b2fb46ecc6"

URI_x86_64_v2_opencv-fuzzy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-fuzzy-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-fuzzy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-fuzzy}"
SRC_URI[x86_64_v2_opencv-fuzzy.sha256sum] = "e0df637e5c4603f736fce2fd76651f370f766ceb8e1ef6dfb47fd2e87d135aaf"

URI_x86_64_v2_opencv-gapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-gapi-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-gapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-gapi}"
SRC_URI[x86_64_v2_opencv-gapi.sha256sum] = "97aa9691552e56cf8917f999c3d0bca52f04aefff2c6abd3ebb1795960d0546b"

URI_x86_64_v2_opencv-hdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-hdf-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-hdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-hdf}"
SRC_URI[x86_64_v2_opencv-hdf.sha256sum] = "648c64b2ccc62a2e7926adee759d8b6f403943a64430ba8caeb15adab1d6b25f"

URI_x86_64_v2_opencv-hfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-hfs-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-hfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-hfs}"
SRC_URI[x86_64_v2_opencv-hfs.sha256sum] = "85ab7f46405842793c25949cd97d7ebe227ad1f1bef5f86a5abdf8b7c989c3a1"

URI_x86_64_v2_opencv-highgui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-highgui-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-highgui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-highgui}"
SRC_URI[x86_64_v2_opencv-highgui.sha256sum] = "473ddd1fec6727c6fa5f67b59621eba69304e0bd63c92f59127085d484af2e7b"

URI_x86_64_v2_opencv-img_hash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-img_hash-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-img_hash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-img_hash}"
SRC_URI[x86_64_v2_opencv-img_hash.sha256sum] = "1821245d11ce7009033aec6d9e38cb98fea8453866a42f89d4ae68b1ed48ba1e"

URI_x86_64_v2_opencv-imgcodecs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-imgcodecs-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-imgcodecs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-imgcodecs}"
SRC_URI[x86_64_v2_opencv-imgcodecs.sha256sum] = "4658c1d6094b7dd3aa9348b16e5267d25e3c7b5a0f35513557288a40a8c44c53"

URI_x86_64_v2_opencv-imgproc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-imgproc-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-imgproc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-imgproc}"
SRC_URI[x86_64_v2_opencv-imgproc.sha256sum] = "2165a4424272e74a98b9c11f6bdd3674e5c78550a1703a5b2f0dd40c8daa472c"

URI_x86_64_v2_opencv-intensity_transform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-intensity_transform-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-intensity_transform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-intensity_transform}"
SRC_URI[x86_64_v2_opencv-intensity_transform.sha256sum] = "616cca8739d7b8a636553d257be5e25e3a82011983ad3d7b8274c3d43c8ccc10"

URI_x86_64_v2_opencv-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-java-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-java}"
SRC_URI[x86_64_v2_opencv-java.sha256sum] = "4fb2b4ecd3e3ae4b935a0fe7c968f5a7710f3f512014a7243db18d056ac47c94"

URI_x86_64_v2_opencv-line_descriptor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-line_descriptor-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-line_descriptor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-line_descriptor}"
SRC_URI[x86_64_v2_opencv-line_descriptor.sha256sum] = "fbfb7d9d91439e444a65cca507a94fb88bdc9cb5afd282f2285b7626dfe0d1f6"

URI_x86_64_v2_opencv-mcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-mcc-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-mcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-mcc}"
SRC_URI[x86_64_v2_opencv-mcc.sha256sum] = "0ede8cb3826e08a29e899933f19813c6941d8fc6c6d8e704b789b71de648d957"

URI_x86_64_v2_opencv-ml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-ml-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-ml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-ml}"
SRC_URI[x86_64_v2_opencv-ml.sha256sum] = "1941a24393e1c03a59b6de185610355c56832d41931a005ed1acfadbed8c7c52"

URI_x86_64_v2_opencv-objdetect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-objdetect-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-objdetect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-objdetect}"
SRC_URI[x86_64_v2_opencv-objdetect.sha256sum] = "93cdd8d73a38daf21276557da04ae3b9a20748dea509b402ac271905bef8a912"

URI_x86_64_v2_opencv-optflow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-optflow-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-optflow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-optflow}"
SRC_URI[x86_64_v2_opencv-optflow.sha256sum] = "d634c363c4bdd58b8ba7873b1270ee15f5387aade4e0e8fc8eb5df198f52eff3"

URI_x86_64_v2_opencv-phase_unwrapping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-phase_unwrapping-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-phase_unwrapping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-phase_unwrapping}"
SRC_URI[x86_64_v2_opencv-phase_unwrapping.sha256sum] = "180f4c723f60075afc3e99849b037c90abef6bca99b4ff1c05a40a1bb7112367"

URI_x86_64_v2_opencv-photo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-photo-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-photo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-photo}"
SRC_URI[x86_64_v2_opencv-photo.sha256sum] = "7f382d5590106f6f355836fd992e06d7129ec6ef481c502616df8f80a927a53e"

URI_x86_64_v2_opencv-plot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-plot-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-plot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-plot}"
SRC_URI[x86_64_v2_opencv-plot.sha256sum] = "74b9dd869ca2c0bbd8664cdcf16aae10746524fe4ddd2e1a33583544e8df1894"

URI_x86_64_v2_opencv-quality = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-quality-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-quality;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-quality}"
SRC_URI[x86_64_v2_opencv-quality.sha256sum] = "4815b04758ef34df816de03764bf16a071172654c2264d876f4f4ece715040e4"

URI_x86_64_v2_opencv-rapid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-rapid-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-rapid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-rapid}"
SRC_URI[x86_64_v2_opencv-rapid.sha256sum] = "3647cef8324ef1038604b1bb2bdda829b8c1bc5be7918bc621bce84d37aac47b"

URI_x86_64_v2_opencv-reg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-reg-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-reg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-reg}"
SRC_URI[x86_64_v2_opencv-reg.sha256sum] = "ed578af0f5e949ab2432623e44515161757bf856af0505d3861241bfadaad96b"

URI_x86_64_v2_opencv-rgbd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-rgbd-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-rgbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-rgbd}"
SRC_URI[x86_64_v2_opencv-rgbd.sha256sum] = "16d487969f03333772271e36704896a85b5fae71b65964a3c30af5b009e12099"

URI_x86_64_v2_opencv-saliency = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-saliency-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-saliency;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-saliency}"
SRC_URI[x86_64_v2_opencv-saliency.sha256sum] = "bec3ba3a8f289a7aac6b2399e75010983d4413d2a4b73eefb3c1e248f204c4db"

URI_x86_64_v2_opencv-shape = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-shape-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-shape;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-shape}"
SRC_URI[x86_64_v2_opencv-shape.sha256sum] = "b8d562c143e7406d12a579b3eb031702628e1e20e2ce9558d2f7764bfba0618b"

URI_x86_64_v2_opencv-signal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-signal-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-signal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-signal}"
SRC_URI[x86_64_v2_opencv-signal.sha256sum] = "54e18bbb3c13b1888bf0cd3773cf24a217e76f095790bb5a2ba0e38a1d2a909a"

URI_x86_64_v2_opencv-stereo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-stereo-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-stereo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-stereo}"
SRC_URI[x86_64_v2_opencv-stereo.sha256sum] = "0a24b0be8869d307993053beb581f45d284ece266a206d53a6adc46ad24bf727"

URI_x86_64_v2_opencv-stitching = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-stitching-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-stitching;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-stitching}"
SRC_URI[x86_64_v2_opencv-stitching.sha256sum] = "bdc28d55b0bb8d2df8ad32d08aae0ce2713cdf9dd7286b6d7569afdfb51101f8"

URI_x86_64_v2_opencv-structured_light = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-structured_light-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-structured_light;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-structured_light}"
SRC_URI[x86_64_v2_opencv-structured_light.sha256sum] = "e0ca2d7390f14ded5a4e1a5af43c215c4ad2919299c7f02600ed47f5a178dd76"

URI_x86_64_v2_opencv-superres = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-superres-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-superres;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-superres}"
SRC_URI[x86_64_v2_opencv-superres.sha256sum] = "94c936daa0ffda480474ec456b50acf1a200b4e8349bb3f29c9553d2f2637952"

URI_x86_64_v2_opencv-surface_matching = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-surface_matching-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-surface_matching;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-surface_matching}"
SRC_URI[x86_64_v2_opencv-surface_matching.sha256sum] = "6d0b7c04f658bbcb17c40bd6eae2183e9d8a31d4f0a589c38094f6d7f363875a"

URI_x86_64_v2_opencv-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-text-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-text}"
SRC_URI[x86_64_v2_opencv-text.sha256sum] = "eb5eb9bcf83d362639801e80a90636791db1539855f4446c7320d517e3ccc815"

URI_x86_64_v2_opencv-tracking = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-tracking-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-tracking;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-tracking}"
SRC_URI[x86_64_v2_opencv-tracking.sha256sum] = "a76a86dd30b9f4b086f39639adb6f3f87b9379aa33c148e754620722629cda3a"

URI_x86_64_v2_opencv-video = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-video-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-video;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-video}"
SRC_URI[x86_64_v2_opencv-video.sha256sum] = "035c5e386302f754b4d2d1719c4a9bb5361dc788aa89d3f1dc71bc6c17bfd802"

URI_x86_64_v2_opencv-videoio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-videoio-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-videoio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-videoio}"
SRC_URI[x86_64_v2_opencv-videoio.sha256sum] = "b141cb5f60fa54e58f7432f36e59229fb5d6a25c99132b1b6ece59cb177a60d8"

URI_x86_64_v2_opencv-videostab = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-videostab-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-videostab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-videostab}"
SRC_URI[x86_64_v2_opencv-videostab.sha256sum] = "4d37dfe82138d2cc1bb92217b65d54aeccc76c184b1d128119baa8886ac58021"

URI_x86_64_v2_opencv-wechat_qrcode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-wechat_qrcode-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-wechat_qrcode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-wechat_qrcode}"
SRC_URI[x86_64_v2_opencv-wechat_qrcode.sha256sum] = "d3c3b81131f91160a10c66c41059032a2414631855c6e94526a9cb1780e5454f"

URI_x86_64_v2_opencv-ximgproc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-ximgproc-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-ximgproc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-ximgproc}"
SRC_URI[x86_64_v2_opencv-ximgproc.sha256sum] = "974097362314d8abaa556c28f29271a5405af0e64ac0adedb3deb4ef4c7d697b"

URI_x86_64_v2_opencv-xobjdetect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-xobjdetect-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-xobjdetect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-xobjdetect}"
SRC_URI[x86_64_v2_opencv-xobjdetect.sha256sum] = "a3b32a9432169be8862ad8f8f578e91efba504295fe35dfff995502b99fec458"

URI_x86_64_v2_opencv-xphoto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opencv-xphoto-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opencv-xphoto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opencv-xphoto}"
SRC_URI[x86_64_v2_opencv-xphoto.sha256sum] = "4734e99ecdfad76ff432115bd53b7fd286f384ecfe7d8c33ab7042d31e1530a0"

URI_x86_64_v2_python3-opencv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opencv-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-opencv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opencv}"
SRC_URI[x86_64_v2_python3-opencv.sha256sum] = "2ea9b47ac92a048e96f20984ce3a4ffcf4be2f203c610cdea1e0d812955c164a"

URI_aarch64_opencv = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv}"
SRC_URI[aarch64_opencv.sha256sum] = "463c8a9952cb0a1be97aa1bdb060261cf39ae57238ffb3eb835c0613292331a0"

URI_aarch64_opencv-alphamat = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-alphamat-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-alphamat;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-alphamat}"
SRC_URI[aarch64_opencv-alphamat.sha256sum] = "66a40fed47c17f64bdeac4f1a536705196d53c2c6f94b09262c9a81258661f13"

URI_aarch64_opencv-aruco = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-aruco-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-aruco;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-aruco}"
SRC_URI[aarch64_opencv-aruco.sha256sum] = "e3e647595918f466d5f33d60da77173f172abe10e69aca131ae7c7dde34053bc"

URI_aarch64_opencv-bgsegm = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-bgsegm-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-bgsegm;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-bgsegm}"
SRC_URI[aarch64_opencv-bgsegm.sha256sum] = "7d5d1d629d7a46c34619d97a06f2be4d0b46a3c4cfeba9b5add80ca75a78b8be"

URI_aarch64_opencv-bioinspired = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-bioinspired-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-bioinspired;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-bioinspired}"
SRC_URI[aarch64_opencv-bioinspired.sha256sum] = "1ab9268fc930b84983f815106bcdda43c2c3deb78ee50fa42bc51e942ca5bb60"

URI_aarch64_opencv-calib3d = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-calib3d-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-calib3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-calib3d}"
SRC_URI[aarch64_opencv-calib3d.sha256sum] = "c26a13074968f37dfaf42be6da6cea1b79816eefc57ffbd127f2aea2f25780e5"

URI_aarch64_opencv-ccalib = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-ccalib-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-ccalib;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-ccalib}"
SRC_URI[aarch64_opencv-ccalib.sha256sum] = "01d30ded7862e5368af90ce15ce61fa1346761e96cd5b00dd543c7d84eef2ee3"

URI_aarch64_opencv-core = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-core-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-core}"
SRC_URI[aarch64_opencv-core.sha256sum] = "7e86763a26b21a49deda80681a19805a2014f4d3a2e80c2176e39ad2d06ac244"

URI_aarch64_opencv-cvv = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-cvv-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-cvv;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-cvv}"
SRC_URI[aarch64_opencv-cvv.sha256sum] = "417065fa29ce097ee4d2660faa26595c24c154bb45f63f026cc2da30cf83800c"

URI_aarch64_opencv-data = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-data-4.10.0-8.el10_0.noarch.rpm;name=aarch64_opencv-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-data}"
SRC_URI[aarch64_opencv-data.sha256sum] = "3c8f1e5a74c8b2ffd68789017516170393f2e6d125a05c32fdd95a0ab1902e8c"

URI_aarch64_opencv-datasets = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-datasets-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-datasets;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-datasets}"
SRC_URI[aarch64_opencv-datasets.sha256sum] = "74bb7fc2dd50af0c3f04350c7bfe53829e2d23324b99167b59aeb9327ba8d58d"

URI_aarch64_opencv-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-devel-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-devel}"
SRC_URI[aarch64_opencv-devel.sha256sum] = "d4573ab335b1835c75d959da1a6fc01ca0807f1e6452c1f1d78e801e1acf8685"

URI_aarch64_opencv-dnn = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-dnn-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-dnn;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-dnn}"
SRC_URI[aarch64_opencv-dnn.sha256sum] = "960b494e6d6a60ebff9443bf2e1a01d26142d89cf6d071e39a1b8a6db843215c"

URI_aarch64_opencv-dnn_objdetect = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-dnn_objdetect-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-dnn_objdetect;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-dnn_objdetect}"
SRC_URI[aarch64_opencv-dnn_objdetect.sha256sum] = "852711a5555c87ea18c7e59bbfe627928dfdc1b53cba9e97b5b8d5fb5791527b"

URI_aarch64_opencv-dnn_superres = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-dnn_superres-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-dnn_superres;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-dnn_superres}"
SRC_URI[aarch64_opencv-dnn_superres.sha256sum] = "818be0c8b1a40a2904b6b6ff30351b7f3f64904ea71c7b1282067c60232f59c6"

URI_aarch64_opencv-doc = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-doc-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-doc}"
SRC_URI[aarch64_opencv-doc.sha256sum] = "684c7a83525e05c0b81024b40a2fad0e2e41340c80be04d71598f48f872e87d1"

URI_aarch64_opencv-dpm = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-dpm-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-dpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-dpm}"
SRC_URI[aarch64_opencv-dpm.sha256sum] = "3bda7fc49704dd374c7815db880edeeef5eed7059fc76756a8069a571ab0c2b6"

URI_aarch64_opencv-face = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-face-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-face;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-face}"
SRC_URI[aarch64_opencv-face.sha256sum] = "fa85b1c1eda64b65fe7a2778fced4dd8559e97b599a634fab27675e62b3eb1df"

URI_aarch64_opencv-features2d = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-features2d-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-features2d;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-features2d}"
SRC_URI[aarch64_opencv-features2d.sha256sum] = "27071e93589d79e62e5b9159e75636865d109e8232187f10c83d2b5f9fdb1ec6"

URI_aarch64_opencv-flann = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-flann-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-flann;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-flann}"
SRC_URI[aarch64_opencv-flann.sha256sum] = "a9fddbcb01ca4f3216d7305c94a1d5718b515404bb191bfca37ddd40c898ba42"

URI_aarch64_opencv-freetype = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-freetype-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-freetype;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-freetype}"
SRC_URI[aarch64_opencv-freetype.sha256sum] = "345e5579e5192653e3b73f01675c6344bdaecd6035cb7fdb646367c293d2c2e3"

URI_aarch64_opencv-fuzzy = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-fuzzy-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-fuzzy;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-fuzzy}"
SRC_URI[aarch64_opencv-fuzzy.sha256sum] = "650f16467bb9871cff26df39843d77ad4c1db32e25eef76fee9ff0e51242054e"

URI_aarch64_opencv-gapi = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-gapi-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-gapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-gapi}"
SRC_URI[aarch64_opencv-gapi.sha256sum] = "493b8f29876c29b1623339c97daec67dca9a4bd413f01550a48d0d59bdc8a903"

URI_aarch64_opencv-hdf = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-hdf-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-hdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-hdf}"
SRC_URI[aarch64_opencv-hdf.sha256sum] = "1cd81f7715d3cb2ed101edb42a6cb01e9a005b47963455a33893c4e31d441572"

URI_aarch64_opencv-hfs = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-hfs-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-hfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-hfs}"
SRC_URI[aarch64_opencv-hfs.sha256sum] = "5d788239067a147e1d3d5636ca5607479e284a92b8a7353911d63302e2c750e9"

URI_aarch64_opencv-highgui = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-highgui-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-highgui;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-highgui}"
SRC_URI[aarch64_opencv-highgui.sha256sum] = "7fe09cbe2e54710c564a03212b37ba06610aeeb558c5ed16fb831d93c9b65c52"

URI_aarch64_opencv-img_hash = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-img_hash-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-img_hash;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-img_hash}"
SRC_URI[aarch64_opencv-img_hash.sha256sum] = "cd0f6cdee0970170f40547c49b4ea6f0de71b6025e15e14de9307e421e6b584a"

URI_aarch64_opencv-imgcodecs = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-imgcodecs-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-imgcodecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-imgcodecs}"
SRC_URI[aarch64_opencv-imgcodecs.sha256sum] = "70ccb45a3dccce84be2054918c14623b06b2d352b2e9e36e0d623164e5bf449c"

URI_aarch64_opencv-imgproc = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-imgproc-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-imgproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-imgproc}"
SRC_URI[aarch64_opencv-imgproc.sha256sum] = "de8968edb2d19446f7c878efcd90652886096f1b3e5b9756d9d01692e50c68f7"

URI_aarch64_opencv-intensity_transform = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-intensity_transform-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-intensity_transform;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-intensity_transform}"
SRC_URI[aarch64_opencv-intensity_transform.sha256sum] = "ee950522cf2bff802633d0e06da2863b788a7f5eb298e0a1bd3167c7bed745ce"

URI_aarch64_opencv-java = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-java-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-java}"
SRC_URI[aarch64_opencv-java.sha256sum] = "3c94f571477f6017b5d665ebaee671a939892aa4253c0d70ebf1e559edbcde53"

URI_aarch64_opencv-line_descriptor = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-line_descriptor-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-line_descriptor;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-line_descriptor}"
SRC_URI[aarch64_opencv-line_descriptor.sha256sum] = "e82661145dd3c402823d3309f8d95a638be83e72d4ece63b5403b00ec82bb11d"

URI_aarch64_opencv-mcc = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-mcc-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-mcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-mcc}"
SRC_URI[aarch64_opencv-mcc.sha256sum] = "90019ac8c3b279adcaad9f6ef424782997f1ec09ed7b2e4401e967d1c7876c8f"

URI_aarch64_opencv-ml = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-ml-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-ml;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-ml}"
SRC_URI[aarch64_opencv-ml.sha256sum] = "c460aefc08b7573ea01181379be0f34c4b7db7e4d1e7b043bc327426a929c122"

URI_aarch64_opencv-objdetect = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-objdetect-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-objdetect;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-objdetect}"
SRC_URI[aarch64_opencv-objdetect.sha256sum] = "b7e5b5952e6b92f22d587b568889167fe292fdb68237caac13fb0b9b4552bd4a"

URI_aarch64_opencv-optflow = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-optflow-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-optflow;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-optflow}"
SRC_URI[aarch64_opencv-optflow.sha256sum] = "2e6cc1b18742501f212ba61421a60b10ecb1b9f129eabaf4b3fba81ffd48a388"

URI_aarch64_opencv-phase_unwrapping = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-phase_unwrapping-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-phase_unwrapping;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-phase_unwrapping}"
SRC_URI[aarch64_opencv-phase_unwrapping.sha256sum] = "9f6cce3f02fbb6c960bda952688c31564eb08a46d97d95b78396ebe6f7a9491b"

URI_aarch64_opencv-photo = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-photo-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-photo;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-photo}"
SRC_URI[aarch64_opencv-photo.sha256sum] = "f3a38d971b83495a137db71ff78e52ff98f0b8a3a6ed6771d649cc36ea7a31fc"

URI_aarch64_opencv-plot = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-plot-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-plot;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-plot}"
SRC_URI[aarch64_opencv-plot.sha256sum] = "31d70908f9866220bf480eb63a3854324327f871b386b978a13d4e8d45d206e2"

URI_aarch64_opencv-quality = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-quality-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-quality;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-quality}"
SRC_URI[aarch64_opencv-quality.sha256sum] = "45e9e0a4a4866ff5cd53610f78163bce532f2404d74e7dc184bb277edfea3109"

URI_aarch64_opencv-rapid = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-rapid-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-rapid;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-rapid}"
SRC_URI[aarch64_opencv-rapid.sha256sum] = "0556d2d52ea0fe1b57fae514f8ad89042ccf752e4fdee7ec0681c06647fd9400"

URI_aarch64_opencv-reg = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-reg-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-reg;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-reg}"
SRC_URI[aarch64_opencv-reg.sha256sum] = "035ba498de99c588b4b54150f709f0832cd5d4bb8bade6709ce61dcd8c222e18"

URI_aarch64_opencv-rgbd = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-rgbd-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-rgbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-rgbd}"
SRC_URI[aarch64_opencv-rgbd.sha256sum] = "0fe97e8b540b8c582d031b16cb07591e25c835a3516d64ba4cbd04b4fa5f9ffb"

URI_aarch64_opencv-saliency = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-saliency-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-saliency;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-saliency}"
SRC_URI[aarch64_opencv-saliency.sha256sum] = "43d8fcee6b51f5a9600f8094dc1ca5ed67101d702d9602c4c87307745ab8d9bb"

URI_aarch64_opencv-shape = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-shape-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-shape;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-shape}"
SRC_URI[aarch64_opencv-shape.sha256sum] = "857a2a729da1e2fd357cba0ced6843e8b3bccba056b9f310eb9e9dfbe36335a5"

URI_aarch64_opencv-signal = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-signal-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-signal;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-signal}"
SRC_URI[aarch64_opencv-signal.sha256sum] = "2112718cb30f1f3c9569da68b68d436e2825878f38f3d6bb43ed74670161cd86"

URI_aarch64_opencv-stereo = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-stereo-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-stereo;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-stereo}"
SRC_URI[aarch64_opencv-stereo.sha256sum] = "c714a71cf5470029c1b7744b9a3f3636d4b9de1a9856e8e3f9feba74949f84b1"

URI_aarch64_opencv-stitching = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-stitching-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-stitching;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-stitching}"
SRC_URI[aarch64_opencv-stitching.sha256sum] = "f8fafc2f1c22c170ca2d42d6e39de63cafeba25a9545c7a49dceb0fa0995552d"

URI_aarch64_opencv-structured_light = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-structured_light-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-structured_light;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-structured_light}"
SRC_URI[aarch64_opencv-structured_light.sha256sum] = "cf0a73b720220a3a030a756776a616bec975871d0b12152fee7935ab48ed3e38"

URI_aarch64_opencv-superres = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-superres-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-superres;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-superres}"
SRC_URI[aarch64_opencv-superres.sha256sum] = "2bfe34faedc406d3eb308b9a96e823e1b795f17b47db9e6bfa0b8de14b48f428"

URI_aarch64_opencv-surface_matching = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-surface_matching-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-surface_matching;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-surface_matching}"
SRC_URI[aarch64_opencv-surface_matching.sha256sum] = "c748d0d7581ea7002174ba474a4414dc1c9522661399bd66ab0239895352b0e6"

URI_aarch64_opencv-text = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-text-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-text}"
SRC_URI[aarch64_opencv-text.sha256sum] = "520d9063a8a3816a2302e1c9171b28592d720eeb76c44a3c9de9db7f2cb74cf5"

URI_aarch64_opencv-tracking = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-tracking-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-tracking;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-tracking}"
SRC_URI[aarch64_opencv-tracking.sha256sum] = "f2ec962183393ad331a1e67f9f2ba0ab401e3c2abb246e1fc75af4efeda2afdf"

URI_aarch64_opencv-video = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-video-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-video;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-video}"
SRC_URI[aarch64_opencv-video.sha256sum] = "068ee89d99843510039ea75a3a73746b2705743fb2bbe6eb009ca1ab062f3832"

URI_aarch64_opencv-videoio = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-videoio-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-videoio;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-videoio}"
SRC_URI[aarch64_opencv-videoio.sha256sum] = "0c23b49c124650d0df5227efa0ca1b5d17755d10a6bd160b8d4e996cbaad34de"

URI_aarch64_opencv-videostab = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-videostab-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-videostab;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-videostab}"
SRC_URI[aarch64_opencv-videostab.sha256sum] = "ebd11f8b534671f104d85e53843a7c1334362b2a8cff578ab01f968c457b6d48"

URI_aarch64_opencv-wechat_qrcode = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-wechat_qrcode-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-wechat_qrcode;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-wechat_qrcode}"
SRC_URI[aarch64_opencv-wechat_qrcode.sha256sum] = "d8d3e15d89f5deca0a6682af6afcbf3feb9ff0eca61afcba83298809f6904ae1"

URI_aarch64_opencv-ximgproc = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-ximgproc-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-ximgproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-ximgproc}"
SRC_URI[aarch64_opencv-ximgproc.sha256sum] = "a2297328553b28e13ef57ac383e0fc7e1f7a2c7538279c9756694e6bc5ec38fe"

URI_aarch64_opencv-xobjdetect = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-xobjdetect-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-xobjdetect;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-xobjdetect}"
SRC_URI[aarch64_opencv-xobjdetect.sha256sum] = "a8f67832b18e0a87ecfb499544c3f90ea7da49ad2436d7961d3396167b8813e7"

URI_aarch64_opencv-xphoto = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-xphoto-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_opencv-xphoto;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-xphoto}"
SRC_URI[aarch64_opencv-xphoto.sha256sum] = "9471114d213ec44a90bc237601e967077b38874d4f67ff65098f9e0137bffa52"

URI_aarch64_python3-opencv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opencv-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_python3-opencv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opencv}"
SRC_URI[aarch64_python3-opencv.sha256sum] = "a4f67546273a72461820333fbbfa65ef0301d069041069ae86d65b977932312c"

RDEPENDS:opencv = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-data \
 opencv-dnn \
 opencv-features2d \
 opencv-highgui \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-objdetect \
 opencv-videoio \
 opencv-xobjdetect \
 "
RDEPENDS:opencv-alphamat = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-aruco = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-objdetect \
 "
RDEPENDS:opencv-bgsegm = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-video \
 "
RDEPENDS:opencv-bioinspired = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-calib3d = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-core \
 opencv-features2d \
 opencv-flann \
 opencv-imgproc \
 "
RDEPENDS:opencv-ccalib = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-features2d \
 opencv-highgui \
 opencv-imgcodecs \
 opencv-imgproc \
 "
RDEPENDS:opencv-core = " \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 openblas-serial \
 tbb \
 zlib-ng-compat \
 "
RDEPENDS:opencv-cvv = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:opencv-data = " \
 "
RDEPENDS:opencv-datasets = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgcodecs \
 "
RDEPENDS:opencv-devel = " \
 cmake-filesystem \
 opencv \
 opencv-alphamat \
 opencv-aruco \
 opencv-bgsegm \
 opencv-bioinspired \
 opencv-calib3d \
 opencv-ccalib \
 opencv-core \
 opencv-cvv \
 opencv-data \
 opencv-datasets \
 opencv-dnn \
 opencv-dnn_objdetect \
 opencv-dnn_superres \
 opencv-dpm \
 opencv-face \
 opencv-features2d \
 opencv-flann \
 opencv-freetype \
 opencv-fuzzy \
 opencv-gapi \
 opencv-hdf \
 opencv-hfs \
 opencv-highgui \
 opencv-img_hash \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-intensity_transform \
 opencv-line_descriptor \
 opencv-mcc \
 opencv-ml \
 opencv-objdetect \
 opencv-optflow \
 opencv-phase_unwrapping \
 opencv-photo \
 opencv-plot \
 opencv-quality \
 opencv-rapid \
 opencv-reg \
 opencv-rgbd \
 opencv-saliency \
 opencv-shape \
 opencv-signal \
 opencv-stereo \
 opencv-stitching \
 opencv-structured_light \
 opencv-superres \
 opencv-surface_matching \
 opencv-text \
 opencv-tracking \
 opencv-video \
 opencv-videoio \
 opencv-videostab \
 opencv-wechat_qrcode \
 opencv-ximgproc \
 opencv-xobjdetect \
 opencv-xphoto \
 pkgconf-pkg-config \
 "
RDEPENDS:opencv-dnn = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 protobuf \
 "
RDEPENDS:opencv-dnn_objdetect = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-dnn_superres = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-doc = " \
 opencv-devel \
 "
RDEPENDS:opencv-dpm = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-face = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-objdetect \
 "
RDEPENDS:opencv-features2d = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-flann \
 opencv-imgproc \
 "
RDEPENDS:opencv-flann = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-freetype = " \
 freetype \
 glibc \
 harfbuzz \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-fuzzy = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-gapi:x86_64_v2 = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 libstdc++ \
 libva \
 libvpl \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-video \
 tbb \
"
RDEPENDS:opencv-gapi:aarch64 = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-video \
 tbb \
"
RDEPENDS:opencv-hdf = " \
 glibc \
 hdf5 \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-hfs = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-highgui = " \
 glibc \
 libgcc \
 libglvnd-opengl \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:opencv-img_hash = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-imgcodecs = " \
 gdal-libs \
 gdcm \
 glibc \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 libwebp \
 opencv-core \
 opencv-imgproc \
 openjpeg2 \
 "
RDEPENDS:opencv-imgproc = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-intensity_transform = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-java = " \
 glibc \
 java-21-openjdk-headless \
 javapackages-filesystem \
 libgcc \
 libstdc++ \
 opencv-aruco \
 opencv-bgsegm \
 opencv-bioinspired \
 opencv-calib3d \
 opencv-core \
 opencv-dnn \
 opencv-dnn_superres \
 opencv-face \
 opencv-features2d \
 opencv-flann \
 opencv-img_hash \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-ml \
 opencv-objdetect \
 opencv-phase_unwrapping \
 opencv-photo \
 opencv-plot \
 opencv-structured_light \
 opencv-text \
 opencv-tracking \
 opencv-video \
 opencv-videoio \
 opencv-wechat_qrcode \
 opencv-ximgproc \
 opencv-xphoto \
 "
RDEPENDS:opencv-line_descriptor = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-mcc = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-ml = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-objdetect = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-optflow = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-flann \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-video \
 opencv-ximgproc \
 "
RDEPENDS:opencv-phase_unwrapping = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-photo = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-plot = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-quality = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 opencv-ml \
 "
RDEPENDS:opencv-rapid = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-reg = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-rgbd = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-flann \
 opencv-imgproc \
 "
RDEPENDS:opencv-saliency = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-shape = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-signal = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-stereo = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-video \
 "
RDEPENDS:opencv-stitching = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-features2d \
 opencv-flann \
 opencv-imgproc \
 "
RDEPENDS:opencv-structured_light = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-phase_unwrapping \
 "
RDEPENDS:opencv-superres = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 opencv-optflow \
 opencv-video \
 opencv-videoio \
 "
RDEPENDS:opencv-surface_matching = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-core \
 opencv-flann \
 "
RDEPENDS:opencv-text = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 opencv-ml \
 tesseract \
 "
RDEPENDS:opencv-tracking = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 opencv-video \
 "
RDEPENDS:opencv-video = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-videoio:x86_64_v2 = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 libstdc++ \
 libva \
 libvpl \
 opencv-core \
 opencv-imgcodecs \
 opencv-imgproc \
"
RDEPENDS:opencv-videoio:aarch64 = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libstdc++ \
 libswscale-free \
 opencv-core \
 opencv-imgcodecs \
 opencv-imgproc \
"
RDEPENDS:opencv-videostab = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-features2d \
 opencv-imgproc \
 opencv-photo \
 opencv-video \
 opencv-videoio \
 "
RDEPENDS:opencv-wechat_qrcode = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-ximgproc = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-video \
 "
RDEPENDS:opencv-xobjdetect = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-objdetect \
 "
RDEPENDS:opencv-xphoto = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:python3-opencv = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv \
 opencv-alphamat \
 opencv-aruco \
 opencv-bgsegm \
 opencv-bioinspired \
 opencv-calib3d \
 opencv-ccalib \
 opencv-core \
 opencv-dnn \
 opencv-dnn_superres \
 opencv-face \
 opencv-features2d \
 opencv-flann \
 opencv-freetype \
 opencv-fuzzy \
 opencv-gapi \
 opencv-hdf \
 opencv-hfs \
 opencv-highgui \
 opencv-img_hash \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-intensity_transform \
 opencv-line_descriptor \
 opencv-mcc \
 opencv-ml \
 opencv-objdetect \
 opencv-optflow \
 opencv-phase_unwrapping \
 opencv-photo \
 opencv-plot \
 opencv-quality \
 opencv-rapid \
 opencv-reg \
 opencv-rgbd \
 opencv-saliency \
 opencv-shape \
 opencv-signal \
 opencv-stereo \
 opencv-stitching \
 opencv-structured_light \
 opencv-surface_matching \
 opencv-text \
 opencv-tracking \
 opencv-video \
 opencv-videoio \
 opencv-wechat_qrcode \
 opencv-ximgproc \
 opencv-xphoto \
 python3 \
 python3-numpy \
 "
