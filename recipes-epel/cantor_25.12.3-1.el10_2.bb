# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cantor"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 cantor \
 cantor-devel \
 cantor-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cantor-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9eb9dce6389a902c89bfa5b40d1bba2f046b5a4031ac2738d57ed609ee5db263"

URI_x86_64_v2_cantor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cantor-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cantor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cantor}"
SRC_URI[x86_64_v2_cantor.sha256sum] = "1e7bb0bcdf0289753aa85da6480a841de3ba8a32439324de69856566ce944be7"

URI_x86_64_v2_cantor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cantor-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cantor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cantor-devel}"
SRC_URI[x86_64_v2_cantor-devel.sha256sum] = "41f41ea7b30abf4c5a482befb43f624ae5ae470a8b40f3c936dfa92f9bfa21af"

URI_x86_64_v2_cantor-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cantor-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cantor-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cantor-libs}"
SRC_URI[x86_64_v2_cantor-libs.sha256sum] = "75d92da9ed81ec66e4ad65b863934bcf1bdf5550b71fa808ce16af8f2c653de8"

URI_aarch64_cantor = "${EPEL_MIRROR}/aarch64/Packages/c/cantor-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_cantor;unpack=0"
SRC_URI:append = " ${URI_aarch64_cantor}"
SRC_URI[aarch64_cantor.sha256sum] = "37529b4f934483a8239200b997962843f3038121c7bd1b56f14955f6dc430f23"

URI_aarch64_cantor-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cantor-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_cantor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cantor-devel}"
SRC_URI[aarch64_cantor-devel.sha256sum] = "4a16c4f434ec6295499062da0384a1c0ea4d885c348b2f213d289dc1f33dbe8c"

URI_aarch64_cantor-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cantor-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_cantor-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cantor-libs}"
SRC_URI[aarch64_cantor-libs.sha256sum] = "6bda1b876692c226b4d9d4962f5269fb4bb931e1e0eaf087aefa6201e3520910"

RDEPENDS:cantor = " \
 cantor-libs \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 python3-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:cantor-devel = " \
 cantor-libs \
 cmake-filesystem \
 "
RDEPENDS:cantor-libs = " \
 analitza \
 cantor \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libgcc \
 libqalculate \
 libspectre \
 libstdc++ \
 libxml2 \
 libxslt \
 luajit \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 "
