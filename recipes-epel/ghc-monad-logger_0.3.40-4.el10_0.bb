# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-monad-logger"
PV = "0.3.40"
PR = "4.el10_0"
PACKAGES = " \
 ghc-monad-logger \
 ghc-monad-logger-devel \
 ghc-monad-logger-doc \
 ghc-monad-logger-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-monad-logger-0.3.40-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "064907edced1b1bacefd0a89bc4c054bca680a085d342727cca529284f56c308"

URI_x86_64_v2_ghc-monad-logger = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-logger-0.3.40-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-monad-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-logger}"
SRC_URI[x86_64_v2_ghc-monad-logger.sha256sum] = "11662ec58783aaf114dbc8a8079aa6af519f66b5267eb919e949a779b8fb6df1"

URI_x86_64_v2_ghc-monad-logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-logger-devel-0.3.40-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-monad-logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-logger-devel}"
SRC_URI[x86_64_v2_ghc-monad-logger-devel.sha256sum] = "a31d2ebead83a3fc6a9a4ba1820207bb55f59c4a9603ffd0c7a8d8ecd2289afe"

URI_x86_64_v2_ghc-monad-logger-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-logger-doc-0.3.40-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-monad-logger-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-logger-doc}"
SRC_URI[x86_64_v2_ghc-monad-logger-doc.sha256sum] = "00c496fb410cb597ea6fd8422eb2619a56a9da67cbb6bb68a4e25b7a7fb1364b"

URI_x86_64_v2_ghc-monad-logger-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-monad-logger-prof-0.3.40-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-monad-logger-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-monad-logger-prof}"
SRC_URI[x86_64_v2_ghc-monad-logger-prof.sha256sum] = "3f7ad3718260fcf88e2ad7e28f277316296e83a5a9f81bd6f03a3b014e0564d2"

URI_aarch64_ghc-monad-logger = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-logger-0.3.40-4.el10_0.aarch64.rpm;name=aarch64_ghc-monad-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-logger}"
SRC_URI[aarch64_ghc-monad-logger.sha256sum] = "107e30776adf71a2bf824ec5c78f47c7a2d88fa5bf3ff3c19669bce337bfaa3f"

URI_aarch64_ghc-monad-logger-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-logger-devel-0.3.40-4.el10_0.aarch64.rpm;name=aarch64_ghc-monad-logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-logger-devel}"
SRC_URI[aarch64_ghc-monad-logger-devel.sha256sum] = "8d8f805db0b75eeb1550eb92e38c9f5cbfac8ae2f75c8411b07019595827f190"

URI_aarch64_ghc-monad-logger-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-logger-doc-0.3.40-4.el10_0.noarch.rpm;name=aarch64_ghc-monad-logger-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-logger-doc}"
SRC_URI[aarch64_ghc-monad-logger-doc.sha256sum] = "f51773aaa5072effbcfeddaa82e8c092cb9faf4a012f611bd9c13d62059f6d82"

URI_aarch64_ghc-monad-logger-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-monad-logger-prof-0.3.40-4.el10_0.aarch64.rpm;name=aarch64_ghc-monad-logger-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-monad-logger-prof}"
SRC_URI[aarch64_ghc-monad-logger-prof.sha256sum] = "6740fbb49e493e80b81032a36f52196bea94a5d9b994e4a89addc8805bceb3eb"

RDEPENDS:ghc-monad-logger = " \
 ghc-array \
 ghc-async \
 ghc-attoparsec \
 ghc-auto-update \
 ghc-base \
 ghc-base-orphans \
 ghc-binary \
 ghc-bitvec \
 ghc-bytestring \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-easy-file \
 ghc-exceptions \
 ghc-fast-logger \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-lifted-base \
 ghc-monad-control \
 ghc-monad-loops \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-stm-chans \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-monad-logger-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-conduit-extra-devel \
 ghc-exceptions-devel \
 ghc-fast-logger-devel \
 ghc-lifted-base-devel \
 ghc-monad-control-devel \
 ghc-monad-logger \
 ghc-monad-loops-devel \
 ghc-mtl-devel \
 ghc-resourcet-devel \
 ghc-stm-chans-devel \
 ghc-stm-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-transformers-base-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 ghc-unliftio-core-devel \
 "
RDEPENDS:ghc-monad-logger-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-monad-logger-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-conduit-extra-prof \
 ghc-conduit-prof \
 ghc-exceptions-prof \
 ghc-fast-logger-prof \
 ghc-lifted-base-prof \
 ghc-monad-control-prof \
 ghc-monad-logger-devel \
 ghc-monad-loops-prof \
 ghc-mtl-prof \
 ghc-resourcet-prof \
 ghc-stm-chans-prof \
 ghc-stm-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-transformers-base-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 ghc-unliftio-core-prof \
 "
