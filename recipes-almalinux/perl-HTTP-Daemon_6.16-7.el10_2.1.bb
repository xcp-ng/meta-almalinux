# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Daemon"
PV = "6.16"
PR = "7.el10_2.1"
PACKAGES = " \
 perl-HTTP-Daemon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-HTTP-Daemon-6.16-7.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcd9bd27750e9c0d6827bdb5d9c36571ebcb82b04f221686ea00baa9a81be081"

URI_x86_64_v2_perl-HTTP-Daemon = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-HTTP-Daemon-6.16-7.el10_2.1.noarch.rpm;name=x86_64_v2_perl-HTTP-Daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Daemon}"
SRC_URI[x86_64_v2_perl-HTTP-Daemon.sha256sum] = "32b21a73a65fac12652db9a425de49e0f807cda3630eca4d41682c50de2052ce"

URI_aarch64_perl-HTTP-Daemon = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-HTTP-Daemon-6.16-7.el10_2.1.noarch.rpm;name=aarch64_perl-HTTP-Daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Daemon}"
SRC_URI[aarch64_perl-HTTP-Daemon.sha256sum] = "32b21a73a65fac12652db9a425de49e0f807cda3630eca4d41682c50de2052ce"

RDEPENDS:perl-HTTP-Daemon = " \
 perl-Carp \
 perl-HTTP-Date \
 perl-HTTP-Message \
 perl-IO-Socket-IP \
 perl-LWP-MediaTypes \
 perl-Socket \
 perl-libs \
 "
