# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cgnslib"
PV = "4.5.0"
PR = "5.el10_2"
PACKAGES = " \
 cgnslib \
 cgnslib-common \
 cgnslib-devel \
 cgnslib-libs \
 cgnslib-mpich \
 cgnslib-mpich-devel \
 cgnslib-mpich-libs \
 cgnslib-openmpi \
 cgnslib-openmpi-devel \
 cgnslib-openmpi-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cgnslib-4.5.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0309cb362fd38534c6770471efc1827230332b893d325f1b9d8d3ca97d9db30"

URI_x86_64_v2_cgnslib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-4.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib}"
SRC_URI[x86_64_v2_cgnslib.sha256sum] = "991d71a8b2fa0e8b296852550f9380dd317eadb8b8d2d56c6bcfc4fd7ad01009"

URI_x86_64_v2_cgnslib-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-common-4.5.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cgnslib-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-common}"
SRC_URI[x86_64_v2_cgnslib-common.sha256sum] = "36c4d20fac2ab1c47671f358429f6a3b29d0948f62d790180a91884315906e56"

URI_x86_64_v2_cgnslib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-devel-4.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-devel}"
SRC_URI[x86_64_v2_cgnslib-devel.sha256sum] = "a3b6efce67c8149dd4aedd975ba77cb071ab6fe6eed9ac17d3fd728399b0b5c9"

URI_x86_64_v2_cgnslib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-libs-4.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-libs}"
SRC_URI[x86_64_v2_cgnslib-libs.sha256sum] = "df33df8768c776be44d1c387309f9b80e8550fb22ff41a7cb94d6dca1aa30aa1"

URI_x86_64_v2_cgnslib-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-mpich-4.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-mpich}"
SRC_URI[x86_64_v2_cgnslib-mpich.sha256sum] = "5d815384d3c256ba8b044eccaf6b26085a6eaf823bd502d7660885a05128a876"

URI_x86_64_v2_cgnslib-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-mpich-devel-4.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-mpich-devel}"
SRC_URI[x86_64_v2_cgnslib-mpich-devel.sha256sum] = "e937498970cd4cf61cec674c8cf126e06d4c9a0d4c2e544cdd8fbe1260cf385e"

URI_x86_64_v2_cgnslib-mpich-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-mpich-libs-4.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-mpich-libs}"
SRC_URI[x86_64_v2_cgnslib-mpich-libs.sha256sum] = "67667d094ce1f39e7fffccca1751e4ee46244cca865a2af29f00b9a606154be4"

URI_x86_64_v2_cgnslib-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-openmpi-4.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-openmpi}"
SRC_URI[x86_64_v2_cgnslib-openmpi.sha256sum] = "ef9045009468e4d2a01bee5101b84d2ff7a94398bd790675d0f9f736bdcbea15"

URI_x86_64_v2_cgnslib-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-openmpi-devel-4.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-openmpi-devel}"
SRC_URI[x86_64_v2_cgnslib-openmpi-devel.sha256sum] = "48ac6c003b9df5dc4df61f0c76005047e39aea4e26c132f0d0a378caaf2ff87d"

URI_x86_64_v2_cgnslib-openmpi-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cgnslib-openmpi-libs-4.5.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cgnslib-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cgnslib-openmpi-libs}"
SRC_URI[x86_64_v2_cgnslib-openmpi-libs.sha256sum] = "bec49bc3be82b4dfad34eaa81d0c2c0516e5b2144ac2b959fa433d2e6c25fa80"

URI_aarch64_cgnslib = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-4.5.0-5.el10_2.aarch64.rpm;name=aarch64_cgnslib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib}"
SRC_URI[aarch64_cgnslib.sha256sum] = "6b2b872d2408ff2da04a7aa01b096ceed85223099095aca1a4cb9b3564a7eaa0"

URI_aarch64_cgnslib-common = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-common-4.5.0-5.el10_2.noarch.rpm;name=aarch64_cgnslib-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-common}"
SRC_URI[aarch64_cgnslib-common.sha256sum] = "b3a9576160b312e9f38f8e17a1daeb59f13f4f1490f2e1f2de7a3866094b993c"

URI_aarch64_cgnslib-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-devel-4.5.0-5.el10_2.aarch64.rpm;name=aarch64_cgnslib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-devel}"
SRC_URI[aarch64_cgnslib-devel.sha256sum] = "655128c9ef79b57a30c3806fcbb73cd28daa90882509944b7be97a216f9ca44f"

URI_aarch64_cgnslib-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-libs-4.5.0-5.el10_2.aarch64.rpm;name=aarch64_cgnslib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-libs}"
SRC_URI[aarch64_cgnslib-libs.sha256sum] = "e5a81c29cb061c9b7138212101a6463e04e86a42b8dcd8e2480af9ed991b2a6d"

URI_aarch64_cgnslib-mpich = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-mpich-4.5.0-5.el10_2.aarch64.rpm;name=aarch64_cgnslib-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-mpich}"
SRC_URI[aarch64_cgnslib-mpich.sha256sum] = "eff5e961876569f1d83c9149139368df870b044fddc234221f50dbf4eebbdc44"

URI_aarch64_cgnslib-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-mpich-devel-4.5.0-5.el10_2.aarch64.rpm;name=aarch64_cgnslib-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-mpich-devel}"
SRC_URI[aarch64_cgnslib-mpich-devel.sha256sum] = "824560b1862b73e9a0db15347b61511c51376a519e7dd40a47de837f64e8219e"

URI_aarch64_cgnslib-mpich-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-mpich-libs-4.5.0-5.el10_2.aarch64.rpm;name=aarch64_cgnslib-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-mpich-libs}"
SRC_URI[aarch64_cgnslib-mpich-libs.sha256sum] = "1f2db5de2893e6091906c010af4fac078f6876584d0986d07fe6da56b7f6c82e"

URI_aarch64_cgnslib-openmpi = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-openmpi-4.5.0-5.el10_2.aarch64.rpm;name=aarch64_cgnslib-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-openmpi}"
SRC_URI[aarch64_cgnslib-openmpi.sha256sum] = "c71b2a6019c886ee0e7b1f9236a18c9302b39327676dbcf57e609268e1a4f014"

URI_aarch64_cgnslib-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-openmpi-devel-4.5.0-5.el10_2.aarch64.rpm;name=aarch64_cgnslib-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-openmpi-devel}"
SRC_URI[aarch64_cgnslib-openmpi-devel.sha256sum] = "d65f5a9edb20a21f905faa0d9c1b23e7a1d4d80e9545ebee8af96fbd6d837105"

URI_aarch64_cgnslib-openmpi-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cgnslib-openmpi-libs-4.5.0-5.el10_2.aarch64.rpm;name=aarch64_cgnslib-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cgnslib-openmpi-libs}"
SRC_URI[aarch64_cgnslib-openmpi-libs.sha256sum] = "d718ead2149dc0505fe7efb1ef30819c6f75794e479f84c0df687a291cf0f671"

RDEPENDS:cgnslib = " \
 bash \
 cgnslib-common \
 cgnslib-libs \
 glibc \
 hdf5 \
 libX11 \
 libXmu \
 libglvnd-glx \
 libglvnd-opengl \
 mesa-libGLU \
 tcl \
 tk \
 "
RDEPENDS:cgnslib-common = " \
 "
RDEPENDS:cgnslib-devel = " \
 cgnslib \
 cmake-filesystem \
 gcc-gfortran \
 hdf5-devel \
 "
RDEPENDS:cgnslib-libs:x86_64_v2 = " \
 glibc \
 hdf5 \
 libgcc \
 libgfortran \
"
RDEPENDS:cgnslib-libs:aarch64 = " \
 glibc \
 hdf5 \
 libgfortran \
"
RDEPENDS:cgnslib-mpich = " \
 bash \
 cgnslib-common \
 cgnslib-mpich-libs \
 glibc \
 libX11 \
 libXmu \
 libglvnd-glx \
 libglvnd-opengl \
 mesa-libGLU \
 tcl \
 tk \
 "
RDEPENDS:cgnslib-mpich-devel = " \
 cgnslib-mpich \
 mpich-devel \
 "
RDEPENDS:cgnslib-mpich-libs:x86_64_v2 = " \
 glibc \
 hdf5-mpich \
 libgcc \
 libgfortran \
 mpich \
"
RDEPENDS:cgnslib-mpich-libs:aarch64 = " \
 glibc \
 hdf5-mpich \
 libgfortran \
 mpich \
"
RDEPENDS:cgnslib-openmpi = " \
 bash \
 cgnslib-common \
 cgnslib-openmpi-libs \
 glibc \
 libX11 \
 libXmu \
 libglvnd-glx \
 libglvnd-opengl \
 mesa-libGLU \
 tcl \
 tk \
 "
RDEPENDS:cgnslib-openmpi-devel = " \
 cgnslib-openmpi \
 openmpi-devel \
 "
RDEPENDS:cgnslib-openmpi-libs:x86_64_v2 = " \
 glibc \
 hdf5-openmpi \
 libgcc \
 libgfortran \
 openmpi \
"
RDEPENDS:cgnslib-openmpi-libs:aarch64 = " \
 glibc \
 hdf5-openmpi \
 libgfortran \
 openmpi \
"
