# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailcap"
PV = "2.1.54"
PR = "8.el10"
PACKAGES = " \
 mailcap \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mailcap-2.1.54-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a0ad9df7202ecd09219978ee3879d7fc45e4a09b343fb8c8c2ae76ca6a094db"

URI_x86_64_v2_mailcap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mailcap-2.1.54-8.el10.noarch.rpm;name=x86_64_v2_mailcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcap}"
SRC_URI[x86_64_v2_mailcap.sha256sum] = "0e6cccb4b9e61ea5384b81ed9cd4b45e862393effd979307105d84f9cd8acd26"

URI_aarch64_mailcap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mailcap-2.1.54-8.el10.noarch.rpm;name=aarch64_mailcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcap}"
SRC_URI[aarch64_mailcap.sha256sum] = "0e6cccb4b9e61ea5384b81ed9cd4b45e862393effd979307105d84f9cd8acd26"

RDEPENDS:mailcap = " \
 "
