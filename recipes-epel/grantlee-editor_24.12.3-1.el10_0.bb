# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grantlee-editor"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 grantlee-editor \
 grantlee-editor-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grantlee-editor-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df781fdb0e6de6e8486228a76dac060e54818604f7d11abad034fd4f82f99534"

URI_x86_64_v2_grantlee-editor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantlee-editor-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantlee-editor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantlee-editor}"
SRC_URI[x86_64_v2_grantlee-editor.sha256sum] = "699cc5f72cb83d9cb8b514722b84889612e5949d8655d5fbdb65e882003421d0"

URI_x86_64_v2_grantlee-editor-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantlee-editor-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantlee-editor-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantlee-editor-libs}"
SRC_URI[x86_64_v2_grantlee-editor-libs.sha256sum] = "60371980b6aff2e543731ec4a653759e96cfc4dc0ab084b58e2c341a2adb2c67"

URI_aarch64_grantlee-editor = "${EPEL_MIRROR}/aarch64/Packages/g/grantlee-editor-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_grantlee-editor;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantlee-editor}"
SRC_URI[aarch64_grantlee-editor.sha256sum] = "1f543fd005da2678922ec298d1364b578e0a027ce1080be7685c5b3163196a74"

URI_aarch64_grantlee-editor-libs = "${EPEL_MIRROR}/aarch64/Packages/g/grantlee-editor-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_grantlee-editor-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantlee-editor-libs}"
SRC_URI[aarch64_grantlee-editor-libs.sha256sum] = "79f19cf0998953aff2f702cb26669611b263d0b479e772375228587330c72c37"

RDEPENDS:grantlee-editor = " \
 akonadi-contacts \
 glibc \
 grantlee-editor-libs \
 grantleetheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:grantlee-editor-libs = " \
 glibc \
 grantlee-editor \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
