# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-w64-tools"
PV = "12.0.0"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 mingw-w64-tools \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-w64-tools-12.0.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "22e00d2e7107f06b3065840347e9616b13afeb7e694309bc2861a1ff8b9968e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw-w64-tools-12.0.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_mingw-w64-tools;unpack=0"
SRC_URI[x86_64_v2_mingw-w64-tools.sha256sum] = "b6177833a0f5319766b05ab4a2147a861e0adf9d8e3bee49a2274d0a66d43f3d"

RDEPENDS:mingw-w64-tools = " \
 glibc \
 "
