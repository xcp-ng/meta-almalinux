# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SQL-Statement"
PV = "1.414"
PR = "15.el10_0"
PACKAGES = " \
 perl-SQL-Statement \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-SQL-Statement-1.414-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02cad558e5d567dc66cc395215b87b77970826cf29d16dd8fb1671ff9552e72d"

URI_x86_64_v2_perl-SQL-Statement = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Statement-1.414-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Statement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Statement}"
SRC_URI[x86_64_v2_perl-SQL-Statement.sha256sum] = "3bd1ce5f452538950e4958f8736840b4d8ea824a1ab735e3ee96488da93206c0"

URI_aarch64_perl-SQL-Statement = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Statement-1.414-15.el10_0.noarch.rpm;name=aarch64_perl-SQL-Statement;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Statement}"
SRC_URI[aarch64_perl-SQL-Statement.sha256sum] = "4a084fc5c8b6020d46f29b66eb188a5ec037fd603ce7c73fc0ed7f90e4d30345"

RDEPENDS:perl-SQL-Statement = " \
 perl-Carp \
 perl-Clone \
 perl-DBI \
 perl-Data-Dumper \
 perl-Encode \
 perl-Errno \
 perl-Exporter \
 perl-Math-Base-Convert \
 perl-Math-Complex \
 perl-Module-Runtime \
 perl-Params-Util \
 perl-SQL-Statement \
 perl-Scalar-List-Utils \
 perl-Text-Balanced \
 perl-Text-Soundex \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-libs \
 perl-sort \
 perl-vars \
 "
