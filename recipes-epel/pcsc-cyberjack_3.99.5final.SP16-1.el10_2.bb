# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcsc-cyberjack"
PV = "3.99.5final.SP16"
PR = "1.el10_2"
PACKAGES = " \
 pcsc-cyberjack \
 pcsc-cyberjack-cjflash \
 pcsc-cyberjack-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pcsc-cyberjack-3.99.5final.SP16-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59fc67f0203826ae4df380de717becdbbe0a49249584cb8217bf677d6fb10306"

URI_x86_64_v2_pcsc-cyberjack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-cyberjack-3.99.5final.SP16-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcsc-cyberjack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-cyberjack}"
SRC_URI[x86_64_v2_pcsc-cyberjack.sha256sum] = "c9c4a5ad7362e7f7be550aec36889cac77e67f091107ecbf79166b55608e01dd"

URI_x86_64_v2_pcsc-cyberjack-cjflash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-cyberjack-cjflash-3.99.5final.SP16-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pcsc-cyberjack-cjflash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-cyberjack-cjflash}"
SRC_URI[x86_64_v2_pcsc-cyberjack-cjflash.sha256sum] = "4e399d978d2ba4caef5095b242b1873fbd91e9100217e311def4afaed85288af"

URI_x86_64_v2_pcsc-cyberjack-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcsc-cyberjack-examples-3.99.5final.SP16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pcsc-cyberjack-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcsc-cyberjack-examples}"
SRC_URI[x86_64_v2_pcsc-cyberjack-examples.sha256sum] = "415954b71b83c0bc0958d7c398fb98ff9e6fc852515effd619964cf4c32786a7"

URI_aarch64_pcsc-cyberjack = "${EPEL_MIRROR}/aarch64/Packages/p/pcsc-cyberjack-3.99.5final.SP16-1.el10_2.aarch64.rpm;name=aarch64_pcsc-cyberjack;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-cyberjack}"
SRC_URI[aarch64_pcsc-cyberjack.sha256sum] = "b79806ea827419795e0f9b2ce5a3de267e401d04aa8792e4c6300c93907c4c55"

URI_aarch64_pcsc-cyberjack-cjflash = "${EPEL_MIRROR}/aarch64/Packages/p/pcsc-cyberjack-cjflash-3.99.5final.SP16-1.el10_2.aarch64.rpm;name=aarch64_pcsc-cyberjack-cjflash;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-cyberjack-cjflash}"
SRC_URI[aarch64_pcsc-cyberjack-cjflash.sha256sum] = "1aba074b898bdbea91b42486ced7d648b428053dee77c860f4b6320f6b2856be"

URI_aarch64_pcsc-cyberjack-examples = "${EPEL_MIRROR}/aarch64/Packages/p/pcsc-cyberjack-examples-3.99.5final.SP16-1.el10_2.noarch.rpm;name=aarch64_pcsc-cyberjack-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcsc-cyberjack-examples}"
SRC_URI[aarch64_pcsc-cyberjack-examples.sha256sum] = "348d25448d9eb393bcf25fb64988bb7f7d3732e7bdf8a221de42291b9013687f"

RDEPENDS:pcsc-cyberjack = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 libusb1 \
 pcsc-lite \
 systemd \
 systemd-udev \
 "
RDEPENDS:pcsc-cyberjack-cjflash = " \
 glibc \
 libgcc \
 libstdc++ \
 libusb1 \
 pcsc-cyberjack \
 "
RDEPENDS:pcsc-cyberjack-examples = " \
 pcsc-cyberjack \
 "
