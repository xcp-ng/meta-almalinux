# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtpms"
PV = "0.9.6"
PR = "11.el10_0"
PACKAGES = " \
 libtpms \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libtpms-0.9.6-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec426831dac3d5067d7d35683815c247efcd0ec7b5ec4d559f1787c37fbea823"

URI_x86_64_v2_libtpms = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtpms-0.9.6-11.el10_0.x86_64_v2.rpm;name=x86_64_v2_libtpms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtpms}"
SRC_URI[x86_64_v2_libtpms.sha256sum] = "2a2609c94d85fb6857d4b2635db4b9f694adb51394f355d8adce8cccec322d4c"

URI_aarch64_libtpms = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtpms-0.9.6-11.el10_0.aarch64.rpm;name=aarch64_libtpms;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtpms}"
SRC_URI[aarch64_libtpms.sha256sum] = "60e410fe9550074aa3bc0e68fb022b100bf0ff4f871473d8a23267f91f8aa2f6"

RDEPENDS:libtpms = " \
 glibc \
 openssl-libs \
 "
