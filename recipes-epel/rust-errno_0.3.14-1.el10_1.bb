# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-errno"
PV = "0.3.14"
PR = "1.el10_1"
PACKAGES = " \
 rust-errno+default-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-errno-0.3.14-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72e92a4822d3f97477cdf72b6353e6d8a52b714197c394d897758d5f657017ce"

URI_x86_64_v2_rust-errno+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno+default-devel-0.3.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno+default-devel}"
SRC_URI[x86_64_v2_rust-errno+default-devel.sha256sum] = "1656f6f4b89c814c8baf628c00529acee6600f6f1f41471b377593bc4efd4118"
RPROVIDES:rust-errno+default-devel:x86_64_v2 = "virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"

URI_x86_64_v2_rust-errno+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno+std-devel-0.3.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno+std-devel}"
SRC_URI[x86_64_v2_rust-errno+std-devel.sha256sum] = "ce1a4124c5fadaeeb77eed4c99a5db47447ff9c6476c009f5e28118a811c2633"

URI_x86_64_v2_rust-errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno-devel-0.3.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno-devel}"
SRC_URI[x86_64_v2_rust-errno-devel.sha256sum] = "fc14b43d85e56e214cbdf6ba2f544d394098b81c16ad07615bcc58976853336b"

URI_aarch64_rust-errno+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno+default-devel-0.3.14-1.el10_1.noarch.rpm;name=aarch64_rust-errno+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno+default-devel}"
SRC_URI[aarch64_rust-errno+default-devel.sha256sum] = "144d6853be789df513b1947164583da20084d6770631575f0913ec5fcdf59327"
RPROVIDES:rust-errno+default-devel:aarch64 = "virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"

URI_aarch64_rust-errno+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno+std-devel-0.3.14-1.el10_1.noarch.rpm;name=aarch64_rust-errno+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno+std-devel}"
SRC_URI[aarch64_rust-errno+std-devel.sha256sum] = "1835f59e296212f280d8fbc66cf8ab25e6b7051ed3f1a832cde6396ecbdedf71"

URI_aarch64_rust-errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno-devel-0.3.14-1.el10_1.noarch.rpm;name=aarch64_rust-errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno-devel}"
SRC_URI[aarch64_rust-errno-devel.sha256sum] = "cea362070381bd2d8dccd806b6cec1127eb8ef31738e0ebc160c7b458eb25757"

RDEPENDS:rust-errno+default-devel = " \
 cargo \
 rust-errno+std-devel \
 rust-errno-devel \
 "
RDEPENDS:rust-errno+std-devel = " \
 cargo \
 rust-errno-devel \
 rust-libc+std-devel \
 "
RDEPENDS:rust-errno-devel = " \
 cargo \
 rust \
 rust-libc-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"
