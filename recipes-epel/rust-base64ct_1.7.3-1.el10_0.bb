# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base64ct"
PV = "1.7.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-base64ct+alloc-devel \
 rust-base64ct+default-devel \
 rust-base64ct+std-devel \
 rust-base64ct-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base64ct-1.7.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee90f0d39b5f35026c000fe06d39745e3c594c3204e92d78b8bc34a01c03e2a1"

URI_x86_64_v2_rust-base64ct+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+alloc-devel-1.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct+alloc-devel}"
SRC_URI[x86_64_v2_rust-base64ct+alloc-devel.sha256sum] = "2bfd82088e6318f41670010bcb187ea33328e62eb4b1a13ff42388b4d2c5444c"

URI_x86_64_v2_rust-base64ct+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+default-devel-1.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct+default-devel}"
SRC_URI[x86_64_v2_rust-base64ct+default-devel.sha256sum] = "a041cdd05442ed8e063197729684a4624e2ec170c864e096bc1798a56d94233f"

URI_x86_64_v2_rust-base64ct+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+std-devel-1.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct+std-devel}"
SRC_URI[x86_64_v2_rust-base64ct+std-devel.sha256sum] = "6657707c86ab23280638cc86b65a2f27ea86046f8438991aeb3f73f50ffaf377"

URI_x86_64_v2_rust-base64ct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct-devel-1.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct-devel}"
SRC_URI[x86_64_v2_rust-base64ct-devel.sha256sum] = "6e704abb2aa3808a83f695193e869c0526065224658a3b410c3fe6a3817fa12e"

URI_aarch64_rust-base64ct+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+alloc-devel-1.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-base64ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct+alloc-devel}"
SRC_URI[aarch64_rust-base64ct+alloc-devel.sha256sum] = "11af31c32f91a8824605a32e016c6acda29d94ef79f89fc771c584516193b932"

URI_aarch64_rust-base64ct+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+default-devel-1.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-base64ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct+default-devel}"
SRC_URI[aarch64_rust-base64ct+default-devel.sha256sum] = "2d55a1525007085377e7459c660e0c8d217162bb3930ab6c4ca915c048ed42e4"

URI_aarch64_rust-base64ct+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+std-devel-1.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-base64ct+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct+std-devel}"
SRC_URI[aarch64_rust-base64ct+std-devel.sha256sum] = "b49d0161f92bdbd283824aa49bd4dafad347c93baae851baec6ca491ad84f3d1"

URI_aarch64_rust-base64ct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct-devel-1.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-base64ct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct-devel}"
SRC_URI[aarch64_rust-base64ct-devel.sha256sum] = "4289803a7e9c373c6755f61a8b3e6a09e97aa84d62dc29809a37d61c588f33ed"

RDEPENDS:rust-base64ct+alloc-devel = " \
 cargo \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct+default-devel = " \
 cargo \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct+std-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct-devel = " \
 cargo \
 rust \
 "
