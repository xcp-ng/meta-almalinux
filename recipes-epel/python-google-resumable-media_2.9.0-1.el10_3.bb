# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-resumable-media"
PV = "2.9.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-google-resumable-media \
 python3-google-resumable-media+requests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-resumable-media-2.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65c71b5fac2c99d7811c40c8326668e658e34019a600908ffbd1a09866932589"

URI_x86_64_v2_python3-google-resumable-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-resumable-media-2.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-resumable-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-resumable-media}"
SRC_URI[x86_64_v2_python3-google-resumable-media.sha256sum] = "36e2d759cae6b47625e3441753559fef2c4f57455e1e2ed41842f727fa81014c"

URI_x86_64_v2_python3-google-resumable-media+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-resumable-media+requests-2.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-resumable-media+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-resumable-media+requests}"
SRC_URI[x86_64_v2_python3-google-resumable-media+requests.sha256sum] = "67df60e0ef32a1b00b3a75407f0f2b5c8e3c061d17a96c0995ffbd5991cdef27"

URI_aarch64_python3-google-resumable-media = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-resumable-media-2.9.0-1.el10_3.noarch.rpm;name=aarch64_python3-google-resumable-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-resumable-media}"
SRC_URI[aarch64_python3-google-resumable-media.sha256sum] = "88623598e08b40080688994476f4d5ede4fa3f369a03020f69a9a1e9704c7739"

URI_aarch64_python3-google-resumable-media+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-resumable-media+requests-2.9.0-1.el10_3.noarch.rpm;name=aarch64_python3-google-resumable-media+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-resumable-media+requests}"
SRC_URI[aarch64_python3-google-resumable-media+requests.sha256sum] = "59079af248e9198c5e629722a39cfde0c062c73d80abb971608d028c770c03c4"

RDEPENDS:python3-google-resumable-media = " \
 python3 \
 python3-google-crc32c \
 "
RDEPENDS:python3-google-resumable-media+requests = " \
 python3 \
 python3-google-resumable-media \
 python3-requests \
 "
