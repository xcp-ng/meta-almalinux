# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmad"
PV = "0.16.4"
PR = "5.el10"
PACKAGES = " \
 libmad \
 libmad-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/libmad-0.16.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c302e67733421eca801ac46de7bf39303e7b132c1d490abd1aab854130cce7d7"

URI_x86_64_v2_libmad = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmad-0.16.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_libmad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmad}"
SRC_URI[x86_64_v2_libmad.sha256sum] = "158e7459b242f8401cfdcee0ed62eea0c399dc5e2052b08a23f00fa1760911db"

URI_x86_64_v2_libmad-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmad-devel-0.16.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_libmad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmad-devel}"
SRC_URI[x86_64_v2_libmad-devel.sha256sum] = "3e6b73a2f6f45ed11a7067041f715055af6b81777572ecc37878af5cca547770"

URI_aarch64_libmad = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmad-0.16.4-5.el10.aarch64.rpm;name=aarch64_libmad;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmad}"
SRC_URI[aarch64_libmad.sha256sum] = "22f4563ce872ee2645bc810a61261962467977b739b1617ed193c45c8c810347"

URI_aarch64_libmad-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmad-devel-0.16.4-5.el10.aarch64.rpm;name=aarch64_libmad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmad-devel}"
SRC_URI[aarch64_libmad-devel.sha256sum] = "bee27799d39fb0ca5c3f64c965cd73a246698e159aabe62d14b0ecaecf64d285"

RDEPENDS:libmad = " \
 glibc \
 "
RDEPENDS:libmad-devel = " \
 cmake-filesystem \
 libmad \
 pkgconf-pkg-config \
 "
