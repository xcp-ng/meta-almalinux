# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Cookies"
PV = "6.11"
PR = "5.el10"
PACKAGES = " \
 perl-HTTP-Cookies \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-HTTP-Cookies-6.11-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b07faa99c667cf1a14af6d7d7983eeffeafdb1803aa65ba28c3e6d9b3dfbda7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-HTTP-Cookies-6.11-5.el10.noarch.rpm;name=x86_64_v2_perl-HTTP-Cookies;unpack=0"
SRC_URI[x86_64_v2_perl-HTTP-Cookies.sha256sum] = "e7ffbc35b09cc40b6edfea56219d51328b613cbf294372dcbf8fd3f9a39dca95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-HTTP-Cookies-6.11-5.el10.noarch.rpm;name=aarch64_perl-HTTP-Cookies;unpack=0"
SRC_URI[aarch64_perl-HTTP-Cookies.sha256sum] = "e7ffbc35b09cc40b6edfea56219d51328b613cbf294372dcbf8fd3f9a39dca95"

RDEPENDS:perl-HTTP-Cookies = " \
 perl-Carp \
 perl-HTTP-Cookies \
 perl-HTTP-Date \
 perl-HTTP-Message \
 perl-libs \
 perl-locale \
 "
