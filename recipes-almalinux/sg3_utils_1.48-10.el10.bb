# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sg3_utils"
PV = "1.48"
PR = "10.el10"
PACKAGES = " \
 sg3_utils \
 sg3_utils-devel \
 sg3_utils-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sg3_utils-1.48-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2b16349c859f0cb59bf3d0316e9b125ef3e353737960d3bc897764a60a2d245"

URI_x86_64_v2_sg3_utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sg3_utils-1.48-10.el10.x86_64_v2.rpm;name=x86_64_v2_sg3_utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sg3_utils}"
SRC_URI[x86_64_v2_sg3_utils.sha256sum] = "eb47c3d59e0978b7fa03e44ce63a6818e2a06248eb6eefd453af240ad11a70b0"

URI_x86_64_v2_sg3_utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sg3_utils-devel-1.48-10.el10.x86_64_v2.rpm;name=x86_64_v2_sg3_utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sg3_utils-devel}"
SRC_URI[x86_64_v2_sg3_utils-devel.sha256sum] = "5743b6021e6c7815bef15263be1deb9a6b4dc89b22f27b1e43f7e123c22b76c3"

URI_x86_64_v2_sg3_utils-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sg3_utils-libs-1.48-10.el10.x86_64_v2.rpm;name=x86_64_v2_sg3_utils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sg3_utils-libs}"
SRC_URI[x86_64_v2_sg3_utils-libs.sha256sum] = "e5067c93ab4dc9f968d1e50ca8b9704c0dea161597b8edb067ce0ad76277869d"

URI_aarch64_sg3_utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sg3_utils-1.48-10.el10.aarch64.rpm;name=aarch64_sg3_utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_sg3_utils}"
SRC_URI[aarch64_sg3_utils.sha256sum] = "c6bdc7bb1b4770c431f4c0f5d3bf55f642bc3e211046716a4e1888cfc224f135"

URI_aarch64_sg3_utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sg3_utils-devel-1.48-10.el10.aarch64.rpm;name=aarch64_sg3_utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sg3_utils-devel}"
SRC_URI[aarch64_sg3_utils-devel.sha256sum] = "38449a6b48af7e328e546d62d331e7a657ca954f3de36e8e8cc14db2cd5e3716"

URI_aarch64_sg3_utils-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sg3_utils-libs-1.48-10.el10.aarch64.rpm;name=aarch64_sg3_utils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_sg3_utils-libs}"
SRC_URI[aarch64_sg3_utils-libs.sha256sum] = "9fefcb998cbab55b14832e9d2e74c472c8cf74f75eb94d416d9777d0a90ab12d"

RDEPENDS:sg3_utils = " \
 bash \
 glibc \
 libgcc \
 sg3_utils-libs \
 "
RDEPENDS:sg3_utils-devel = " \
 sg3_utils-libs \
 "
RDEPENDS:sg3_utils-libs = " \
 glibc \
 "
