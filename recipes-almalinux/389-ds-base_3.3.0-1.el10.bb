# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "389-ds-base"
PV = "3.3.0"
PR = "1.el10"
PACKAGES = " \
 389-ds-base \
 389-ds-base-bdb \
 389-ds-base-devel \
 389-ds-base-libs \
 389-ds-base-snmp \
 python3-lib389 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/389-ds-base-3.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e683b2e40b984a479ea4b5c65185048d48b9c5ff32b452a8547a22b5839f0dd9"

URI_x86_64_v2_389-ds-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-3.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base}"
SRC_URI[x86_64_v2_389-ds-base.sha256sum] = "fb8c5761c93d5863f46f9f905e54726e395923d31a9bf4ef704f5ece81954a3e"

URI_x86_64_v2_389-ds-base-bdb = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-bdb-3.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-bdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-bdb}"
SRC_URI[x86_64_v2_389-ds-base-bdb.sha256sum] = "c53d0f0814116cac3b37c35dedda0610b256e21b6de93899523e40f4545246c1"

URI_x86_64_v2_389-ds-base-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-devel-3.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-devel}"
SRC_URI[x86_64_v2_389-ds-base-devel.sha256sum] = "8780a00e8c03ba14ae4beca2d0f13ed99e8f5e2b38f75541cf36398c2d41bb42"

URI_x86_64_v2_389-ds-base-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-libs-3.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-libs}"
SRC_URI[x86_64_v2_389-ds-base-libs.sha256sum] = "5b7609d84f3bc3de0a2e6eaa2bf726d4eb6f5d2660d5f5f14056c5f308c17f55"

URI_x86_64_v2_389-ds-base-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-snmp-3.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-snmp}"
SRC_URI[x86_64_v2_389-ds-base-snmp.sha256sum] = "6b2089ba3deca62cfcee8e1040d64c09b5b52128088675a7d42675511c954245"

URI_x86_64_v2_python3-lib389 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lib389-3.3.0-1.el10.noarch.rpm;name=x86_64_v2_python3-lib389;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lib389}"
SRC_URI[x86_64_v2_python3-lib389.sha256sum] = "d8c38118804dd7824c5fa1f36e2d2f8f35f8a76c95b894dd39d4ed5458f4a9ae"

URI_aarch64_389-ds-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-3.3.0-1.el10.aarch64.rpm;name=aarch64_389-ds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base}"
SRC_URI[aarch64_389-ds-base.sha256sum] = "daea0a10d28a4eadd73a84ce142725b67fc0abc618e3f7713b658fa7fe22d630"

URI_aarch64_389-ds-base-bdb = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-bdb-3.3.0-1.el10.aarch64.rpm;name=aarch64_389-ds-base-bdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-bdb}"
SRC_URI[aarch64_389-ds-base-bdb.sha256sum] = "59b90756faeac15b1f06940a870aff7527eb77e71feb76bc4f0e356d85310950"

URI_aarch64_389-ds-base-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-devel-3.3.0-1.el10.aarch64.rpm;name=aarch64_389-ds-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-devel}"
SRC_URI[aarch64_389-ds-base-devel.sha256sum] = "09c1fd59116baed5470dc2e3bdc7927acd2f82695eb64c2e2833bd555f418adc"

URI_aarch64_389-ds-base-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-libs-3.3.0-1.el10.aarch64.rpm;name=aarch64_389-ds-base-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-libs}"
SRC_URI[aarch64_389-ds-base-libs.sha256sum] = "850221031af4f368a2413755186d557d0b796e4da60baf2cfafcb828ecba497d"

URI_aarch64_389-ds-base-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-snmp-3.3.0-1.el10.aarch64.rpm;name=aarch64_389-ds-base-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-snmp}"
SRC_URI[aarch64_389-ds-base-snmp.sha256sum] = "0ed3f4fd595b974874d7969c6fc9741cab734092d94d56b3fc3a8db81da71ea7"

URI_aarch64_python3-lib389 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lib389-3.3.0-1.el10.noarch.rpm;name=aarch64_python3-lib389;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lib389}"
SRC_URI[aarch64_python3-lib389.sha256sum] = "d8c38118804dd7824c5fa1f36e2d2f8f35f8a76c95b894dd39d4ed5458f4a9ae"

RDEPENDS:389-ds-base = " \
 389-ds-base-libs \
 acl \
 bash \
 cracklib \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 cyrus-sasl-md5 \
 cyrus-sasl-plain \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libstdc++ \
 libxcrypt \
 lmdb-libs \
 nspr \
 nss \
 nss-tools \
 nss-util \
 openldap \
 openldap-clients \
 openssl-libs \
 pam-libs \
 pcre2 \
 perl-Archive-Tar \
 perl-debugger \
 perl-interpreter \
 perl-sigtrap \
 policycoreutils-python-utils \
 python3 \
 python3-file-magic \
 python3-lib389 \
 python3-libsemanage \
 shadow-utils \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:389-ds-base-bdb = " \
 389-ds-base \
 389-ds-base-libs \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 lmdb-libs \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-devel = " \
 389-ds-base-libs \
 nspr-devel \
 nss-devel \
 openldap-devel \
 pkgconf-pkg-config \
 systemd-libs \
 "
RDEPENDS:389-ds-base-libs = " \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-snmp = " \
 389-ds-base \
 bash \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 nspr \
 openldap \
 "
RDEPENDS:python3-lib389 = " \
 389-ds-base \
 iproute \
 openssl \
 openssl-perl \
 python3 \
 python3-argcomplete \
 python3-cryptography \
 python3-dateutil \
 python3-distro \
 python3-ldap \
 python3-libselinux \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-setuptools \
 "
