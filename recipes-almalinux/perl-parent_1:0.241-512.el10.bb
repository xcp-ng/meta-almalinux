# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-parent"
PE = "1"
PV = "0.241"
PR = "512.el10"
PACKAGES = " \
 perl-parent \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-parent-0.241-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "965a06dd78ed10a3f67581b6df0fe5114f13225757157f7ba797c56b098ea247"

URI_x86_64_v2_perl-parent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-parent-0.241-512.el10.noarch.rpm;name=x86_64_v2_perl-parent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-parent}"
SRC_URI[x86_64_v2_perl-parent.sha256sum] = "48d35217133b3b82b86419803e6e0f4b62e5f7eedc987e3c52ade2c541c6b8a9"

URI_aarch64_perl-parent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-parent-0.241-512.el10.noarch.rpm;name=aarch64_perl-parent;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-parent}"
SRC_URI[aarch64_perl-parent.sha256sum] = "48d35217133b3b82b86419803e6e0f4b62e5f7eedc987e3c52ade2c541c6b8a9"

RDEPENDS:perl-parent = " \
 perl-libs \
 "
