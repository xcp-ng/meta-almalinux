# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html5ever"
PV = "0.29.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-html5ever+default-devel \
 rust-html5ever+trace_tokenizer-devel \
 rust-html5ever-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html5ever-0.29.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bb50f118f8936a8811c1cab818150b24fe1d18d9681442c53a6452fbd0ea76b"

URI_x86_64_v2_rust-html5ever+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever+default-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever+default-devel}"
SRC_URI[x86_64_v2_rust-html5ever+default-devel.sha256sum] = "9242ccf3a4d7504e3a2d7665d7e2db522fc3a0125a5b11fa51b84a693d913372"

URI_x86_64_v2_rust-html5ever+trace_tokenizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever+trace_tokenizer-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever+trace_tokenizer-devel}"
SRC_URI[x86_64_v2_rust-html5ever+trace_tokenizer-devel.sha256sum] = "9691e0341343c027a49c57c644a8eba14713e7ad133f998842fdbaed86c44a0d"

URI_x86_64_v2_rust-html5ever-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever-devel-0.29.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever-devel}"
SRC_URI[x86_64_v2_rust-html5ever-devel.sha256sum] = "597b4089b09a6c3e39bca6977598f67774ed6fff550cb542f9e0991a76f60e88"

URI_aarch64_rust-html5ever+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever+default-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-html5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever+default-devel}"
SRC_URI[aarch64_rust-html5ever+default-devel.sha256sum] = "b90fa49075dda6596cfb7ba08004d81108bdc4ad6d5191e29ba1cc6230e58ee4"

URI_aarch64_rust-html5ever+trace_tokenizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever+trace_tokenizer-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-html5ever+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever+trace_tokenizer-devel}"
SRC_URI[aarch64_rust-html5ever+trace_tokenizer-devel.sha256sum] = "d6fea15c374710e27f19e86ea14e9cdca89e0e4c778c703badc1960025b1bea2"

URI_aarch64_rust-html5ever-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever-devel-0.29.0-2.el10_0.noarch.rpm;name=aarch64_rust-html5ever-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever-devel}"
SRC_URI[aarch64_rust-html5ever-devel.sha256sum] = "47eda4b33d326aed1078483d15b86b7856bbf8f8191f0430eb3f87edd612dbdb"

RDEPENDS:rust-html5ever+default-devel = " \
 cargo \
 rust-html5ever-devel \
 "
RDEPENDS:rust-html5ever+trace_tokenizer-devel = " \
 cargo \
 rust-html5ever-devel \
 "
RDEPENDS:rust-html5ever-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mac+default-devel \
 rust-markup5ever+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 "
