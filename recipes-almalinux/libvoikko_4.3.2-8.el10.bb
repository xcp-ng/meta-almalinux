# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvoikko"
PV = "4.3.2"
PR = "8.el10"
PACKAGES = " \
 libvoikko \
 libvoikko-devel \
 python3-libvoikko \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvoikko-4.3.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "021190e333ec26a00f87e48a706472f50b664d9bca239f0146f91e3d57f121ca"

URI_x86_64_v2_libvoikko = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvoikko-4.3.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_libvoikko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvoikko}"
SRC_URI[x86_64_v2_libvoikko.sha256sum] = "a508cc7a61559c92e60bf669a2833cb8f45f8313f1e80f4567b73f71e07be80e"

URI_x86_64_v2_libvoikko-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvoikko-devel-4.3.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_libvoikko-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvoikko-devel}"
SRC_URI[x86_64_v2_libvoikko-devel.sha256sum] = "3e5e7610ed58eb285ec46c6e3414ad76712feab1b7b84d83d9be3a9acfed97db"

URI_x86_64_v2_python3-libvoikko = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libvoikko-4.3.2-8.el10.noarch.rpm;name=x86_64_v2_python3-libvoikko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libvoikko}"
SRC_URI[x86_64_v2_python3-libvoikko.sha256sum] = "dba701b6ad5c757f664c2edef868772ea939bcb1e55b97a3b06e75c77825277c"

URI_aarch64_libvoikko = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvoikko-4.3.2-8.el10.aarch64.rpm;name=aarch64_libvoikko;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvoikko}"
SRC_URI[aarch64_libvoikko.sha256sum] = "8f0b0856cd9f9850e852006080b733fbba4b02b1ab1e1275cf5dd22762492ccf"

URI_aarch64_libvoikko-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvoikko-devel-4.3.2-8.el10.aarch64.rpm;name=aarch64_libvoikko-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvoikko-devel}"
SRC_URI[aarch64_libvoikko-devel.sha256sum] = "517b779939d71c4401b3f52ec513c83b682241ea0f9876e87e1fa6704f7da524"

URI_aarch64_python3-libvoikko = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libvoikko-4.3.2-8.el10.noarch.rpm;name=aarch64_python3-libvoikko;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libvoikko}"
SRC_URI[aarch64_python3-libvoikko.sha256sum] = "dba701b6ad5c757f664c2edef868772ea939bcb1e55b97a3b06e75c77825277c"

RDEPENDS:libvoikko = " \
 glibc \
 libgcc \
 libstdc++ \
 voikko-fi \
 "
RDEPENDS:libvoikko-devel = " \
 libvoikko \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libvoikko = " \
 libvoikko \
 python3 \
 "
