# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISSN"
PV = "1.008"
PR = "3.el10_3"
PACKAGES = " \
 perl-Business-ISSN \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISSN-1.008-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1edb8e118f94fa8c6e4842de1929987246fb482f3154039c54cc719328ca679"

URI_x86_64_v2_perl-Business-ISSN = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISSN-1.008-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISSN;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Business-ISSN}"
SRC_URI[x86_64_v2_perl-Business-ISSN.sha256sum] = "b6f0446ed8d0338c5e6ec2b2450246b95be657617022e9d5ffaa9b1772be777b"

URI_aarch64_perl-Business-ISSN = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISSN-1.008-3.el10_3.noarch.rpm;name=aarch64_perl-Business-ISSN;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Business-ISSN}"
SRC_URI[aarch64_perl-Business-ISSN.sha256sum] = "cbc6fb2a982190a65fa8fce99a5eb90e839ac1abba30adc469ed19c2c43ea58a"

RDEPENDS:perl-Business-ISSN = " \
 perl-Exporter \
 perl-libs \
 perl-subs \
 "
