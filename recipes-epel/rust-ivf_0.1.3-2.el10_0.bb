# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ivf"
PV = "0.1.3"
PR = "2.el10_0"
PACKAGES = " \
 rust-ivf+default-devel \
 rust-ivf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ivf-0.1.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7166d9f1077aa64c9681b3b77dc5432ff54b39d12d487b8d61e1969457b8f2d"

URI_x86_64_v2_rust-ivf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ivf+default-devel-0.1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ivf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ivf+default-devel}"
SRC_URI[x86_64_v2_rust-ivf+default-devel.sha256sum] = "e8399176456e1b008726b236fb6bdb9f52d71dcc43028a71bf2a5291757da730"

URI_x86_64_v2_rust-ivf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ivf-devel-0.1.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ivf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ivf-devel}"
SRC_URI[x86_64_v2_rust-ivf-devel.sha256sum] = "e658e253899c71ce353bb594b925ff332443a675bf54fd66e5046c4a520aaed7"

URI_aarch64_rust-ivf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ivf+default-devel-0.1.3-2.el10_0.noarch.rpm;name=aarch64_rust-ivf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ivf+default-devel}"
SRC_URI[aarch64_rust-ivf+default-devel.sha256sum] = "a1b4e0a1e6e026a353844af0033b2c1c0a5a447469521b151b96258c9d658849"

URI_aarch64_rust-ivf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ivf-devel-0.1.3-2.el10_0.noarch.rpm;name=aarch64_rust-ivf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ivf-devel}"
SRC_URI[aarch64_rust-ivf-devel.sha256sum] = "59f8b939f5b8f4f542a4bae9673444ee5a3d4d47d73cedb527a0ace024e3c50e"

RDEPENDS:rust-ivf+default-devel = " \
 cargo \
 rust-ivf-devel \
 "
RDEPENDS:rust-ivf-devel = " \
 cargo \
 rust-bitstream-io+default-devel \
 "
