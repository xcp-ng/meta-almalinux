# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jobserver"
PV = "0.1.35"
PR = "1.el10_2"
PACKAGES = " \
 rust-jobserver+default-devel \
 rust-jobserver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jobserver-0.1.35-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e66a5b4990464a28b085223550ddeb2967e1ef888cfcc0b7da5d575149b09b0"

URI_x86_64_v2_rust-jobserver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jobserver+default-devel-0.1.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jobserver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jobserver+default-devel}"
SRC_URI[x86_64_v2_rust-jobserver+default-devel.sha256sum] = "f4fad12f76e5af174358db34517b39eac85f39d5c512a3e8ceaef3ee1043f76c"

URI_x86_64_v2_rust-jobserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jobserver-devel-0.1.35-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jobserver-devel}"
SRC_URI[x86_64_v2_rust-jobserver-devel.sha256sum] = "8b38c4c24a272a38a961fa8fac89f994506a7cf5d252cdd56899db626042d4f9"

URI_aarch64_rust-jobserver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jobserver+default-devel-0.1.35-1.el10_2.noarch.rpm;name=aarch64_rust-jobserver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jobserver+default-devel}"
SRC_URI[aarch64_rust-jobserver+default-devel.sha256sum] = "5e6614f86a35e36d6ce969729effedf3645a01702b434f6678555b28bee38518"

URI_aarch64_rust-jobserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jobserver-devel-0.1.35-1.el10_2.noarch.rpm;name=aarch64_rust-jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jobserver-devel}"
SRC_URI[aarch64_rust-jobserver-devel.sha256sum] = "1e1a190a66df106c3e3e2a963e4c77be9b228e7d6fb7c27d4a6dfd15a0a37b74"

RDEPENDS:rust-jobserver+default-devel = " \
 cargo \
 rust-jobserver-devel \
 "
RDEPENDS:rust-jobserver-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
