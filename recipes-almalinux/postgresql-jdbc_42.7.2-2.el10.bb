# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql-jdbc"
PV = "42.7.2"
PR = "2.el10"
PACKAGES = " \
 postgresql-jdbc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql-jdbc-42.7.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdf25f8973d86eabef6eba5b3830e0feece3997dacbf5fe1660dfadd7dcb6f3a"

URI_x86_64_v2_postgresql-jdbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-jdbc-42.7.2-2.el10.noarch.rpm;name=x86_64_v2_postgresql-jdbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-jdbc}"
SRC_URI[x86_64_v2_postgresql-jdbc.sha256sum] = "eb50cf55644d4678c870ed2e33d63b3ecfdda99ea28123f14f659017adcb3bad"

URI_aarch64_postgresql-jdbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-jdbc-42.7.2-2.el10.noarch.rpm;name=aarch64_postgresql-jdbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-jdbc}"
SRC_URI[aarch64_postgresql-jdbc.sha256sum] = "eb50cf55644d4678c870ed2e33d63b3ecfdda99ea28123f14f659017adcb3bad"

RDEPENDS:postgresql-jdbc = " \
 javapackages-filesystem \
 ongres-scram-client \
 "
