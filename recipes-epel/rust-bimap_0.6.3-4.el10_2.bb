# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bimap"
PV = "0.6.3"
PR = "4.el10_2"
PACKAGES = " \
 rust-bimap+default-devel \
 rust-bimap+serde-devel \
 rust-bimap+std-devel \
 rust-bimap-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-bimap-0.6.3-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "762d9f030911960250c4989997aa86444258dfbc1073f479f8898fae7054239f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bimap+default-devel-0.6.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bimap+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bimap+default-devel.sha256sum] = "d3a04d73d8aa9411cbfc2f7e4892c3e7cb826808698062820a8ea52fd756c55b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bimap+serde-devel-0.6.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bimap+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bimap+serde-devel.sha256sum] = "340d1e774bc6c860dc70565f3f0c34e6390ab39a7c1f50c4533ed4b3813e6771"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bimap+std-devel-0.6.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bimap+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bimap+std-devel.sha256sum] = "0089993a74edd6a0a0dc2ea47dfdfd5a039c4da040eb5cdd18d8608ad4606c61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bimap-devel-0.6.3-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bimap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-bimap-devel.sha256sum] = "e897855e9bfc052a94c0b254e511ac8b61857ea50b53b2c27cd790f8dc5160c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bimap+default-devel-0.6.3-4.el10_2.noarch.rpm;name=aarch64_rust-bimap+default-devel;unpack=0"
SRC_URI[aarch64_rust-bimap+default-devel.sha256sum] = "2b146cd28b40ba3e4587bb5863a5e042c7ecb911957f80161789b517f2ebf6eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bimap+serde-devel-0.6.3-4.el10_2.noarch.rpm;name=aarch64_rust-bimap+serde-devel;unpack=0"
SRC_URI[aarch64_rust-bimap+serde-devel.sha256sum] = "f1949c2aad06cf4e93701f3744a2c5765b425403f374b2a8a74bbdc496e08bfd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bimap+std-devel-0.6.3-4.el10_2.noarch.rpm;name=aarch64_rust-bimap+std-devel;unpack=0"
SRC_URI[aarch64_rust-bimap+std-devel.sha256sum] = "7c0389522a00ee279fa2e6cf6ae0dbb056dbe076b33038f1d8e017693bf10f50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-bimap-devel-0.6.3-4.el10_2.noarch.rpm;name=aarch64_rust-bimap-devel;unpack=0"
SRC_URI[aarch64_rust-bimap-devel.sha256sum] = "456fe286ef0a973e47e77a00b3c72a4d7d3a6cf62a286f1af63325e74cbb4414"

RDEPENDS:rust-bimap+default-devel = " \
 cargo \
 rust-bimap+std-devel \
 rust-bimap-devel \
 "
RDEPENDS:rust-bimap+serde-devel = " \
 cargo \
 rust-bimap-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-bimap+std-devel = " \
 cargo \
 rust-bimap-devel \
 "
RDEPENDS:rust-bimap-devel = " \
 cargo \
 "
