# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-match-simple"
PV = "0.012"
PR = "5.el10_0"
PACKAGES = " \
 perl-match-simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-match-simple-0.012-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9198abb4e341401121b188dde6483c47ace04924f82a9ad8bed10747dd403ee"

URI_x86_64_v2_perl-match-simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-match-simple-0.012-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-match-simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-match-simple}"
SRC_URI[x86_64_v2_perl-match-simple.sha256sum] = "d002b9b410a0f04dbaf20765c027aa790baf809ae009b063f325920af495ff58"

URI_aarch64_perl-match-simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-match-simple-0.012-5.el10_0.noarch.rpm;name=aarch64_perl-match-simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-match-simple}"
SRC_URI[aarch64_perl-match-simple.sha256sum] = "cdf9ac850efc8b22fd6a0b23ce70943ebed7c9114cbd171b6ca2a14dce4f5ed0"

RDEPENDS:perl-match-simple = " \
 perl-B \
 perl-Carp \
 perl-Exporter-Tiny \
 perl-Scalar-List-Utils \
 perl-Sub-Infix \
 perl-libs \
 perl-match-simple \
 perl-overload \
 "
