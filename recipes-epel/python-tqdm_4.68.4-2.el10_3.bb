# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tqdm"
PV = "4.68.4"
PR = "2.el10_3"
PACKAGES = " \
 python3-tqdm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tqdm-4.68.4-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f43e2418fd8a7fbd354c7677aa4d30e0f690ce4e08c9448e7f7b1ab5bd365235"

URI_x86_64_v2_python3-tqdm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tqdm-4.68.4-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tqdm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tqdm}"
SRC_URI[x86_64_v2_python3-tqdm.sha256sum] = "4a4d58d2f67c6f0b03a4e41001429ebf5dab8f619ebcae260dba178c5bac0937"

URI_aarch64_python3-tqdm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tqdm-4.68.4-2.el10_3.noarch.rpm;name=aarch64_python3-tqdm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tqdm}"
SRC_URI[aarch64_python3-tqdm.sha256sum] = "a80048308d8702ea725c9a66650d60366b889acf711cdadf845b6e7ff61b0c5e"

RDEPENDS:python3-tqdm = " \
 python3 \
 "
