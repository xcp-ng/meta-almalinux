# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onig_sys"
PV = "69.9.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-onig_sys+bindgen-devel \
 rust-onig_sys+default-devel \
 rust-onig_sys+generate-devel \
 rust-onig_sys+posix-api-devel \
 rust-onig_sys+print-debug-devel \
 rust-onig_sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onig_sys-69.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b35456541525847deb271dfdd500dc655f36a0034664d244e7a1a33d1cd8a58"

URI_x86_64_v2_rust-onig_sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+bindgen-devel-69.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+bindgen-devel.sha256sum] = "da71c58c82c999eb38d395d3885f4cb037777041cde989f7b46c8a16c0c4e548"

URI_x86_64_v2_rust-onig_sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+default-devel-69.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+default-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+default-devel.sha256sum] = "3b47b8b4c19abe3049e5236834efeb241b827ac5063e9578f3b316f45b14badd"

URI_x86_64_v2_rust-onig_sys+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+generate-devel-69.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+generate-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+generate-devel.sha256sum] = "88044ca14bac36f9fe5bbe932da5821b3d5660d584b132a28bcc9e7b025f142b"

URI_x86_64_v2_rust-onig_sys+posix-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+posix-api-devel-69.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+posix-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+posix-api-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+posix-api-devel.sha256sum] = "a1d9ab746a713332f6c23a360a77d6e5ce15907c4e8d4bb8eea1f2c70eb063b0"

URI_x86_64_v2_rust-onig_sys+print-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys+print-debug-devel-69.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys+print-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys+print-debug-devel}"
SRC_URI[x86_64_v2_rust-onig_sys+print-debug-devel.sha256sum] = "106957457da2cd9cf5c8c51cf1886f1ec74998ea1bf83dac231dad3deef430ca"

URI_x86_64_v2_rust-onig_sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onig_sys-devel-69.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onig_sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onig_sys-devel}"
SRC_URI[x86_64_v2_rust-onig_sys-devel.sha256sum] = "a7b4e659c396eecd5eee3b1dee8eb666b346fa90803dc8c7407282cdfe03b4f5"

URI_aarch64_rust-onig_sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+bindgen-devel-69.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig_sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+bindgen-devel}"
SRC_URI[aarch64_rust-onig_sys+bindgen-devel.sha256sum] = "f61c4fa5841aadc97d321ec199e815eadfb713ba13766031f254a4948cf7cbc2"

URI_aarch64_rust-onig_sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+default-devel-69.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig_sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+default-devel}"
SRC_URI[aarch64_rust-onig_sys+default-devel.sha256sum] = "a04b250987bf493d58635d3cf9bdae8fe7a4600e6f21cdff3b30a633b18ffdb4"

URI_aarch64_rust-onig_sys+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+generate-devel-69.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig_sys+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+generate-devel}"
SRC_URI[aarch64_rust-onig_sys+generate-devel.sha256sum] = "a4f3b2e7879284eecedc9bba40f9e836d93cbc7d15c091c713bf0ee2ca945b8f"

URI_aarch64_rust-onig_sys+posix-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+posix-api-devel-69.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig_sys+posix-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+posix-api-devel}"
SRC_URI[aarch64_rust-onig_sys+posix-api-devel.sha256sum] = "f8480e6234f4060d286cf2f4725c13c206ceb6a96e30ff637acce023b0e342b0"

URI_aarch64_rust-onig_sys+print-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys+print-debug-devel-69.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig_sys+print-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys+print-debug-devel}"
SRC_URI[aarch64_rust-onig_sys+print-debug-devel.sha256sum] = "d965f5763852039e5e529afff76e9362e5119e19ead70f36042cd8d4087640a2"

URI_aarch64_rust-onig_sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onig_sys-devel-69.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-onig_sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onig_sys-devel}"
SRC_URI[aarch64_rust-onig_sys-devel.sha256sum] = "89ec2f528f5706f9d6d2903cca5e6ec773ca91a2f2d19c949e3ba3c86cef125f"

RDEPENDS:rust-onig_sys+bindgen-devel = " \
 cargo \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys+default-devel = " \
 cargo \
 rust-onig_sys+generate-devel \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys+generate-devel = " \
 cargo \
 rust-onig_sys+bindgen-devel \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys+posix-api-devel = " \
 cargo \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys+print-debug-devel = " \
 cargo \
 rust-onig_sys-devel \
 "
RDEPENDS:rust-onig_sys-devel = " \
 cargo \
 oniguruma-devel \
 rust \
 rust-bindgen+default-devel \
 rust-bindgen+runtime-devel \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 "
