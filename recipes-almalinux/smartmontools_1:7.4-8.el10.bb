# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smartmontools"
PE = "1"
PV = "7.4"
PR = "8.el10"
PACKAGES = " \
 smartmontools \
 smartmontools-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/smartmontools-7.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0df8f65ccb7de6c434c22fa89e723a8e760c9e9d9b200cdc342d4d1bff5c79e6"

URI_x86_64_v2_smartmontools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/smartmontools-7.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_smartmontools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_smartmontools}"
SRC_URI[x86_64_v2_smartmontools.sha256sum] = "62207e9aaf8eb0e5e95ba51fe9739c6da16988f8f550342ceda0477ef802a18d"

URI_x86_64_v2_smartmontools-selinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/smartmontools-selinux-7.4-8.el10.noarch.rpm;name=x86_64_v2_smartmontools-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_smartmontools-selinux}"
SRC_URI[x86_64_v2_smartmontools-selinux.sha256sum] = "52f3c1de8608faadd3cb09b876bf39b6201767f3cd9cf046adf054516cbdc4a1"

URI_aarch64_smartmontools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/smartmontools-7.4-8.el10.aarch64.rpm;name=aarch64_smartmontools;unpack=0"
SRC_URI:append = " ${URI_aarch64_smartmontools}"
SRC_URI[aarch64_smartmontools.sha256sum] = "669df77d3cc3b20e437c067e12302c510262f62d0cc72e746fe2355e990541af"

URI_aarch64_smartmontools-selinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/smartmontools-selinux-7.4-8.el10.noarch.rpm;name=aarch64_smartmontools-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_smartmontools-selinux}"
SRC_URI[aarch64_smartmontools-selinux.sha256sum] = "52f3c1de8608faadd3cb09b876bf39b6201767f3cd9cf046adf054516cbdc4a1"

RDEPENDS:smartmontools = " \
 bash \
 glibc \
 libcap-ng \
 libgcc \
 libselinux \
 libstdc++ \
 smartmontools-selinux \
 systemd-libs \
 "
RDEPENDS:smartmontools-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 selinux-policy \
 selinux-policy-targeted \
 "
