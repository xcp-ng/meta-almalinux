# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Archive-Zip-SimpleZip"
PV = "1.000"
PR = "8.el10_0"
PACKAGES = " \
 perl-Archive-Zip-SimpleZip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Archive-Zip-SimpleZip-1.000-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b198efc623120f5da1e8336886bbd42e56cbc84b7adb8395cf0ee1d7ca36e8b4"

URI_x86_64_v2_perl-Archive-Zip-SimpleZip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Archive-Zip-SimpleZip-1.000-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Archive-Zip-SimpleZip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Archive-Zip-SimpleZip}"
SRC_URI[x86_64_v2_perl-Archive-Zip-SimpleZip.sha256sum] = "747ee9f6c7fbf12f29ad9c398b2eafa856d6ef192c5d9889159112a6581960fc"

URI_aarch64_perl-Archive-Zip-SimpleZip = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Archive-Zip-SimpleZip-1.000-8.el10_0.noarch.rpm;name=aarch64_perl-Archive-Zip-SimpleZip;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Archive-Zip-SimpleZip}"
SRC_URI[aarch64_perl-Archive-Zip-SimpleZip.sha256sum] = "4336a4f695822d1453e7995260d27d4d3ada5ed4d7392ccc2f8f1ee4e7b4464b"

RDEPENDS:perl-Archive-Zip-SimpleZip = " \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-IO \
 perl-IO-Compress \
 perl-IO-Compress-Lzma \
 perl-IO-Compress-Zstd \
 perl-PathTools \
 perl-Perl-OSType \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 "
