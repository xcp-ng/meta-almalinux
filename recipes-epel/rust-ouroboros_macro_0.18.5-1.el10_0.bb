# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ouroboros_macro"
PV = "0.18.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-ouroboros_macro+default-devel \
 rust-ouroboros_macro+std-devel \
 rust-ouroboros_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ouroboros_macro-0.18.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af704f2a5f40dc5461b14e9c2bd1bc50b83f79aad9e0d2f5805faea0b60e609e"

URI_x86_64_v2_rust-ouroboros_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros_macro+default-devel-0.18.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros_macro+default-devel}"
SRC_URI[x86_64_v2_rust-ouroboros_macro+default-devel.sha256sum] = "36bcea2250dbc16b66c4eaa555ebef448256b3d65eb4b31630dd1674168091b6"

URI_x86_64_v2_rust-ouroboros_macro+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros_macro+std-devel-0.18.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros_macro+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros_macro+std-devel}"
SRC_URI[x86_64_v2_rust-ouroboros_macro+std-devel.sha256sum] = "42a99b15ea0582ce91cdb4f92947557bb1466ff1eb95fc0471273b82cc8cccec"

URI_x86_64_v2_rust-ouroboros_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros_macro-devel-0.18.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros_macro-devel}"
SRC_URI[x86_64_v2_rust-ouroboros_macro-devel.sha256sum] = "1cbd86d93c82f04dcfc9d2147c36aaad22b7c9949424b7e2303d036acd646168"

URI_aarch64_rust-ouroboros_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros_macro+default-devel-0.18.5-1.el10_0.noarch.rpm;name=aarch64_rust-ouroboros_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros_macro+default-devel}"
SRC_URI[aarch64_rust-ouroboros_macro+default-devel.sha256sum] = "9ca003df2030aa0bcb16cf8db2803294f6f9a43cd3b4ff12a118fee23ac3ced5"

URI_aarch64_rust-ouroboros_macro+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros_macro+std-devel-0.18.5-1.el10_0.noarch.rpm;name=aarch64_rust-ouroboros_macro+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros_macro+std-devel}"
SRC_URI[aarch64_rust-ouroboros_macro+std-devel.sha256sum] = "460d0da29ec9d73cd96d070c2d86a9fe95d81918fa669bc218725b0066de4e7a"

URI_aarch64_rust-ouroboros_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros_macro-devel-0.18.5-1.el10_0.noarch.rpm;name=aarch64_rust-ouroboros_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros_macro-devel}"
SRC_URI[aarch64_rust-ouroboros_macro-devel.sha256sum] = "b89e667d73db12eb8bedcfd6eee5c5b919ef461d3752028e69709e7a8314ce3f"

RDEPENDS:rust-ouroboros_macro+default-devel = " \
 cargo \
 rust-ouroboros_macro-devel \
 "
RDEPENDS:rust-ouroboros_macro+std-devel = " \
 cargo \
 rust-ouroboros_macro-devel \
 "
RDEPENDS:rust-ouroboros_macro-devel = " \
 cargo \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-proc-macro2-diagnostics+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
