# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktrip"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ktrip \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ktrip-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0276b8f0a3d82e5d95021bf88ab7d413968bb841cf4d5ece4d8f7a81f1ba4545"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktrip-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktrip;unpack=0"
SRC_URI[x86_64_v2_ktrip.sha256sum] = "1471c7e2ec17241332a32a5129ef8597c9d2e65e40b95a8764a0a72b6ed5e5c7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktrip-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ktrip;unpack=0"
SRC_URI[aarch64_ktrip.sha256sum] = "ae2c2204e09bbb26d4f4a07f05241e32a984faf0d753aa45bcc32dfcc3d39499"

RDEPENDS:ktrip = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
