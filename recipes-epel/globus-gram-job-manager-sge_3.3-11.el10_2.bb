# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-sge"
PV = "3.3"
PR = "11.el10_2"
PACKAGES = " \
 globus-gram-job-manager-sge \
 globus-gram-job-manager-sge-setup-poll \
 globus-gram-job-manager-sge-setup-seg \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-sge-3.3-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b4aedfe2db851ac02c06d4ae57888f41b1f6dc43cf911b68831bef98cfecf90"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-sge-3.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-sge;unpack=0"
SRC_URI[x86_64_v2_globus-gram-job-manager-sge.sha256sum] = "ec5e82d97706fca973be59a6f176c9d7dcab3b7df11f84e5e0086d8fa48e247d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-sge-setup-poll-3.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-sge-setup-poll;unpack=0"
SRC_URI[x86_64_v2_globus-gram-job-manager-sge-setup-poll.sha256sum] = "8209b1ae772fb3a059f0ec5700c4cbf50ebc8a77bb324c1d064070ac221e84db"
RPROVIDES:globus-gram-job-manager-sge-setup-poll:append:x86_64_v2 = " virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_2.alma_altarch"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-sge-setup-seg-3.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-sge-setup-seg;unpack=0"
SRC_URI[x86_64_v2_globus-gram-job-manager-sge-setup-seg.sha256sum] = "77c52f477e4f3bfed9fbfbdf6c2c2fdf1a1ffea8baf3339be8cda2390d0aa8d7"
RPROVIDES:globus-gram-job-manager-sge-setup-seg:append:x86_64_v2 = " virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_2.alma_altarch"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-sge-3.3-11.el10_2.aarch64.rpm;name=aarch64_globus-gram-job-manager-sge;unpack=0"
SRC_URI[aarch64_globus-gram-job-manager-sge.sha256sum] = "3e2ec12ce1546f1cb21dfbd9088c4df304cf9686d6bc994c522d6fc786906df7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-sge-setup-poll-3.3-11.el10_2.noarch.rpm;name=aarch64_globus-gram-job-manager-sge-setup-poll;unpack=0"
SRC_URI[aarch64_globus-gram-job-manager-sge-setup-poll.sha256sum] = "5bc9b4252b6624d14700fd3e485e5ecb16c13e7bc8fd660ae077121028733deb"
RPROVIDES:globus-gram-job-manager-sge-setup-poll:append:aarch64 = " virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-sge-setup-seg-3.3-11.el10_2.aarch64.rpm;name=aarch64_globus-gram-job-manager-sge-setup-seg;unpack=0"
SRC_URI[aarch64_globus-gram-job-manager-sge-setup-seg.sha256sum] = "53c24b20fb16c2984584b4cdda687cd0107ccbe4b70d78c783ed7896f865ca36"
RPROVIDES:globus-gram-job-manager-sge-setup-seg:append:aarch64 = " virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_2"

RDEPENDS:globus-gram-job-manager-sge:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_2.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-sge:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-IO \
 perl-IPC-Open3 \
 perl-libs \
 virtual/globus-gram-job-manager-sge-setup_eq_3.3-11.el10_2 \
"
RDEPENDS:globus-gram-job-manager-sge-setup-poll = " \
 bash \
 globus-gram-job-manager-scripts \
 globus-gram-job-manager-sge \
 "
RDEPENDS:globus-gram-job-manager-sge-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-scripts \
 globus-gram-job-manager-sge \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 systemd \
 "
