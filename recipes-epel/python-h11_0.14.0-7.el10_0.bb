# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-h11"
PV = "0.14.0"
PR = "7.el10_0"
PACKAGES = " \
 python3-h11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-h11-0.14.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce3031dfa1c1befa1786b2fb0226f23201cb1bba3b69af7ff535e3ef19e8ee72"

URI_x86_64_v2_python3-h11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-h11-0.14.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-h11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-h11}"
SRC_URI[x86_64_v2_python3-h11.sha256sum] = "986e73a17b90b0af058eea932d8f9eec5db1596058bf2f2e29a04cfd7b2d5af3"

URI_aarch64_python3-h11 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-h11-0.14.0-7.el10_0.noarch.rpm;name=aarch64_python3-h11;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-h11}"
SRC_URI[aarch64_python3-h11.sha256sum] = "e3c5a541448055d7898af5e567d5a0a9199198a033bfb11e0ab4a22c074a4a0a"

RDEPENDS:python3-h11 = " \
 python3 \
 "
