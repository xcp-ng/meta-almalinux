# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kreversi"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kreversi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kreversi-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e38384ba6a2f47ca34865848accdc03402cd846cb41d6e4ab9e5c81e8b29d2d"

URI_x86_64_v2_kreversi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kreversi-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kreversi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kreversi}"
SRC_URI[x86_64_v2_kreversi.sha256sum] = "d42db8e7a62fbd6088e4e360cd8516b63476f7573ec8cb0e15aab8f14d3122ec"

URI_aarch64_kreversi = "${EPEL_MIRROR}/aarch64/Packages/k/kreversi-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kreversi;unpack=0"
SRC_URI:append = " ${URI_aarch64_kreversi}"
SRC_URI[aarch64_kreversi.sha256sum] = "308e52a09e11af78b38ffa80d93ed37640d3caa170b3865f28dec66db4f415b1"

RDEPENDS:kreversi = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
