# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "advancecomp"
PV = "2.6"
PR = "8.el10_0"
PACKAGES = " \
 advancecomp \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/advancecomp-2.6-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c87f753819b9458dd56f8f8ec1d162412621a9f9be1ed06ae3a67e17861e42cb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/advancecomp-2.6-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_advancecomp;unpack=0"
SRC_URI[x86_64_v2_advancecomp.sha256sum] = "cc812950b9d1b18ed91e248632e3b75375fc86681d41004fa7d42a09543f596a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/advancecomp-2.6-8.el10_0.aarch64.rpm;name=aarch64_advancecomp;unpack=0"
SRC_URI[aarch64_advancecomp.sha256sum] = "d7351d0baab21ed0f09d5ac7230b0d26de9cc9fa757d79a399bf82c228dc2eed"

RDEPENDS:advancecomp = " \
 glibc \
 libdeflate \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 zopfli \
 "
