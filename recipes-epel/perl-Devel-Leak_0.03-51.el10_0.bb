# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-Leak"
PV = "0.03"
PR = "51.el10_0"
PACKAGES = " \
 perl-Devel-Leak \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-Leak-0.03-51.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9a0eecab39bec227b43a82ead3a35993c87268677cf68bfe4b02dab542a29f3"

URI_x86_64_v2_perl-Devel-Leak = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-Leak-0.03-51.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-Leak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Leak}"
SRC_URI[x86_64_v2_perl-Devel-Leak.sha256sum] = "f6dec80da5e01e2a3c1ece80f0a4626799d067b9d6c20cb6dd5c58c78f770bc8"

URI_aarch64_perl-Devel-Leak = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-Leak-0.03-51.el10_0.aarch64.rpm;name=aarch64_perl-Devel-Leak;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Leak}"
SRC_URI[aarch64_perl-Devel-Leak.sha256sum] = "5ce8291d3682415a72367d57ced1c56a731e6e391e3612362251a2709dfe523d"

RDEPENDS:perl-Devel-Leak = " \
 glibc \
 perl-DynaLoader \
 perl-base \
 perl-libs \
 perl-vars \
 "
