# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-scanner"
PV = "0.31.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-wayland-scanner+default-devel \
 rust-wayland-scanner-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-scanner-0.31.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e70b11c15614aaf86a4679b254e6c4b958a93d1280f6f2774abfa23032b6c99"

URI_x86_64_v2_rust-wayland-scanner+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner+default-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-scanner+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-scanner+default-devel.sha256sum] = "7ef5196bd3a0a41bdb96e993a29e4df65f89b5eee728e1900d6f42c0bbed1056"

URI_x86_64_v2_rust-wayland-scanner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner-devel-0.31.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-scanner-devel}"
SRC_URI[x86_64_v2_rust-wayland-scanner-devel.sha256sum] = "45b4d1d67fe287bd929b3a8e771e8e276d4ed363fb717aaa12c655d5d4df1447"

URI_aarch64_rust-wayland-scanner+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner+default-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-scanner+default-devel}"
SRC_URI[aarch64_rust-wayland-scanner+default-devel.sha256sum] = "30724c60da343ba7250cd6e9101ed2ef792cd4a6ac8686454dfb2de876ed2e88"

URI_aarch64_rust-wayland-scanner-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner-devel-0.31.6-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-scanner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-scanner-devel}"
SRC_URI[aarch64_rust-wayland-scanner-devel.sha256sum] = "e52c4796b4fc25f981063d655486a588dd6b8c5480bdf8c97f537e9ee32d0b67"

RDEPENDS:rust-wayland-scanner+default-devel = " \
 cargo \
 rust-wayland-scanner-devel \
 "
RDEPENDS:rust-wayland-scanner-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quick-xml+default-devel \
 rust-quote+default-devel \
 "
