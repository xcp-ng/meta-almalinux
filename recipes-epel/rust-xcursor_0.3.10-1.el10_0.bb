# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xcursor"
PV = "0.3.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-xcursor+default-devel \
 rust-xcursor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xcursor-0.3.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3cd772a0189441c0532f12e7adb3cd4fa0c8a70df1675cfcd0262d085b96225"

URI_x86_64_v2_rust-xcursor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xcursor+default-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xcursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xcursor+default-devel}"
SRC_URI[x86_64_v2_rust-xcursor+default-devel.sha256sum] = "6c7993548dde90a66a76ce4a93245a9cad57a0813d082ea00e358e84476fcbb2"

URI_x86_64_v2_rust-xcursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xcursor-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xcursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xcursor-devel}"
SRC_URI[x86_64_v2_rust-xcursor-devel.sha256sum] = "2630ccec1e6a82a025dc9a15750cd22f18667c61e84f22ee3f11ebf6c9a0dbcd"

URI_aarch64_rust-xcursor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xcursor+default-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-xcursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xcursor+default-devel}"
SRC_URI[aarch64_rust-xcursor+default-devel.sha256sum] = "7f2317e6bb273861d52223e557c98986f769bb6dce4ee9ebc29c139d00cb3c68"

URI_aarch64_rust-xcursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xcursor-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-xcursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xcursor-devel}"
SRC_URI[aarch64_rust-xcursor-devel.sha256sum] = "d0f0cac58e95189cf411aa1f07c44392f6d10c74f7ac5e3acddb1c1955e0695d"

RDEPENDS:rust-xcursor+default-devel = " \
 cargo \
 rust-xcursor-devel \
 "
RDEPENDS:rust-xcursor-devel = " \
 cargo \
 "
