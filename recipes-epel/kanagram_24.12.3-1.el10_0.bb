# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kanagram"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kanagram \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kanagram-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4e68038afb3a94f0cd9bf9e8830ae5451d5e6a9f6b86045ffac3405246a95e70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kanagram-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kanagram;unpack=0"
SRC_URI[x86_64_v2_kanagram.sha256sum] = "676f152b0b1e3b961be3900626060ded01db42d465b6797d66396a140d74a5c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kanagram-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kanagram;unpack=0"
SRC_URI[aarch64_kanagram.sha256sum] = "822863ffb74e6b520c4a7e6cb89fdb7372980c615ce362b90e1107a9baea0501"

RDEPENDS:kanagram = " \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
