# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vcs-diff-lint"
PV = "6.7"
PR = "1.el10_2"
PACKAGES = " \
 vcs-diff-lint \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vcs-diff-lint-6.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31f78d40e4a64182f226e8d96144a912e4b1469dc964091427ffad12a2037450"

URI_x86_64_v2_vcs-diff-lint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vcs-diff-lint-6.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vcs-diff-lint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vcs-diff-lint}"
SRC_URI[x86_64_v2_vcs-diff-lint.sha256sum] = "b1572a0290bd1747a9c196d0543623f6d9bd3e6289ab6f98001db28eda545e7d"

URI_aarch64_vcs-diff-lint = "${EPEL_MIRROR}/aarch64/Packages/v/vcs-diff-lint-6.7-1.el10_2.noarch.rpm;name=aarch64_vcs-diff-lint;unpack=0"
SRC_URI:append = " ${URI_aarch64_vcs-diff-lint}"
SRC_URI[aarch64_vcs-diff-lint.sha256sum] = "fc5f5eb393df4a0b28a64819c996d94c0a412ed175f2a3421486df0e3a040be0"

RDEPENDS:vcs-diff-lint = " \
 csdiff \
 git-core \
 python3 \
 "
