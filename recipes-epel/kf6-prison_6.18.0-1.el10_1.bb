# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-prison"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-prison \
 kf6-prison-devel \
 kf6-prison-doc \
 kf6-prison-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-prison-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a1f567918a5d5b95ebd905b8fed984e64215daf3074c91452bc0fa1aad29353"

URI_x86_64_v2_kf6-prison = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison}"
SRC_URI[x86_64_v2_kf6-prison.sha256sum] = "725c79f62fcb40479361793b9c23afdf50c1fde01c5be4b2e4f61ef48be52a93"

URI_x86_64_v2_kf6-prison-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-devel}"
SRC_URI[x86_64_v2_kf6-prison-devel.sha256sum] = "751a33449051bd46767bacfef581ac5c521db3b6ccc52ab927becdc922a75f3c"

URI_x86_64_v2_kf6-prison-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-prison-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-doc}"
SRC_URI[x86_64_v2_kf6-prison-doc.sha256sum] = "563dbafedb0a6e92e17a056cc09fd394201c1dae55a4810998bdbc3addde7951"

URI_x86_64_v2_kf6-prison-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-prison-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-html}"
SRC_URI[x86_64_v2_kf6-prison-html.sha256sum] = "633249bfb5e0be17a85ca9652b2b44f424addedbd4edc3a13b106e86f206f679"

URI_aarch64_kf6-prison = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-prison;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison}"
SRC_URI[aarch64_kf6-prison.sha256sum] = "da59b2996ede500eafd552742537dddec0437ad94deae38f63566538f825d3cb"

URI_aarch64_kf6-prison-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-prison-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-devel}"
SRC_URI[aarch64_kf6-prison-devel.sha256sum] = "d4758b427f4e3e43d431019d5af00abc8e8d1c4cc1f11ee908dbb8065499855b"

URI_aarch64_kf6-prison-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-prison-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-doc}"
SRC_URI[aarch64_kf6-prison-doc.sha256sum] = "97ce8751aaf7496e0cb28bbb0251d1a643d926bcc76c69b4609d180205ccf1ae"

URI_aarch64_kf6-prison-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-prison-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-html}"
SRC_URI[aarch64_kf6-prison-html.sha256sum] = "85ae96adfcd96bcbf55618563ce855bf9d27670ff2fd7ca1f6893ff49948fde1"

RDEPENDS:kf6-prison = " \
 glibc \
 kf6-filesystem \
 libdmtx \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 zxing-cpp \
 "
RDEPENDS:kf6-prison-devel = " \
 cmake-filesystem \
 kf6-prison \
 "
RDEPENDS:kf6-prison-doc = " \
 "
RDEPENDS:kf6-prison-html = " \
 "
