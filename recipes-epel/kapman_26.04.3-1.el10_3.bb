# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kapman"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kapman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kapman-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7681392a41668b12a75427053996785980db93dbf024ea27efa4a234e13dc1e4"

URI_x86_64_v2_kapman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kapman-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kapman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kapman}"
SRC_URI[x86_64_v2_kapman.sha256sum] = "07990e5fdf1e32ff7f4aae30ed07489a68a8cd479b5e116615c569fb8b8d4fd6"

URI_aarch64_kapman = "${EPEL_MIRROR}/aarch64/Packages/k/kapman-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kapman;unpack=0"
SRC_URI:append = " ${URI_aarch64_kapman}"
SRC_URI[aarch64_kapman.sha256sum] = "3defc1ea9c85a74a130a7cc7671096b8ea63e148b469deb5efdfbb6dbf69fd85"

RDEPENDS:kapman = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
