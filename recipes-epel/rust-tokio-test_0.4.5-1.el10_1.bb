# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-test"
PV = "0.4.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-tokio-test+default-devel \
 rust-tokio-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-test-0.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e10ec8658b13f948ab2217e992a23e48d04b7f7102c63929d2d5982614573adb"

URI_x86_64_v2_rust-tokio-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-test+default-devel-0.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-test+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-test+default-devel.sha256sum] = "973f8b6776c66ad0f28ccd45fc294366bea28889bdd2bedefe6956cc7a3e0f3d"

URI_x86_64_v2_rust-tokio-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-test-devel-0.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-test-devel}"
SRC_URI[x86_64_v2_rust-tokio-test-devel.sha256sum] = "3c1ddb42524e469db96114ed2409c61e88618a1391b21142244493c7759329c0"

URI_aarch64_rust-tokio-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-test+default-devel-0.4.5-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-test+default-devel}"
SRC_URI[aarch64_rust-tokio-test+default-devel.sha256sum] = "68db0995af25c203f2675daed7cb277a303097af0a5f967042486490c5840e56"

URI_aarch64_rust-tokio-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-test-devel-0.4.5-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-test-devel}"
SRC_URI[aarch64_rust-tokio-test-devel.sha256sum] = "4af5d8dc0aae2e84f30e0c48435f31ffed688be3032984fb36cf08cdca3b9f78"

RDEPENDS:rust-tokio-test+default-devel = " \
 cargo \
 rust-tokio-test-devel \
 "
RDEPENDS:rust-tokio-test-devel = " \
 cargo \
 rust \
 rust-futures-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+test-util-devel \
 rust-tokio+time-devel \
 rust-tokio-stream+default-devel \
 "
