# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unittest-cpp"
PV = "2.0.0"
PR = "22.el10_2"
PACKAGES = " \
 unittest-cpp \
 unittest-cpp-devel \
 unittest-cpp-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unittest-cpp-2.0.0-22.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fd2a8d26c9a8adc0452c30b0f2ca83a1e6c7be152d40309344c0b2e2b9d19e1"

URI_x86_64_v2_unittest-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unittest-cpp-2.0.0-22.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unittest-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unittest-cpp}"
SRC_URI[x86_64_v2_unittest-cpp.sha256sum] = "adbb0ac38127ba29a85919f7a9b88be7d4678843cf0c32aa1aac983503d4a4eb"

URI_x86_64_v2_unittest-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unittest-cpp-devel-2.0.0-22.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unittest-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unittest-cpp-devel}"
SRC_URI[x86_64_v2_unittest-cpp-devel.sha256sum] = "a8cc4c6092ef6b8e30ba06c65a5d228431c3dba66741cdf6d930c7c9101e2e03"

URI_x86_64_v2_unittest-cpp-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unittest-cpp-static-2.0.0-22.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unittest-cpp-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unittest-cpp-static}"
SRC_URI[x86_64_v2_unittest-cpp-static.sha256sum] = "581b4a18a03a37603312b5c4cbcd228293877931141bccea4c162f3b57bf9aa7"

URI_aarch64_unittest-cpp = "${EPEL_MIRROR}/aarch64/Packages/u/unittest-cpp-2.0.0-22.el10_2.aarch64.rpm;name=aarch64_unittest-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_unittest-cpp}"
SRC_URI[aarch64_unittest-cpp.sha256sum] = "9b8913c522db39c5bb4462fedf3d1aa21254275d15b7616544d5db0311018be8"

URI_aarch64_unittest-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/u/unittest-cpp-devel-2.0.0-22.el10_2.aarch64.rpm;name=aarch64_unittest-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_unittest-cpp-devel}"
SRC_URI[aarch64_unittest-cpp-devel.sha256sum] = "c00734924ab5e97ac3895e2b4e4de2e257e91bc2fd967402564d0f17b76691cf"

URI_aarch64_unittest-cpp-static = "${EPEL_MIRROR}/aarch64/Packages/u/unittest-cpp-static-2.0.0-22.el10_2.aarch64.rpm;name=aarch64_unittest-cpp-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_unittest-cpp-static}"
SRC_URI[aarch64_unittest-cpp-static.sha256sum] = "ac3525fc873ad436a362c4c75952f7f05aed28c2ae2566982852f1b68f778f7b"

RDEPENDS:unittest-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:unittest-cpp-devel = " \
 pkgconf-pkg-config \
 unittest-cpp \
 "
RDEPENDS:unittest-cpp-static = " \
 unittest-cpp \
 "
