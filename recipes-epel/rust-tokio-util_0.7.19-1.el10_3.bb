# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-util"
PV = "0.7.19"
PR = "1.el10_3"
PACKAGES = " \
 rust-tokio-util+codec-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+full-devel \
 rust-tokio-util+futures-io-devel \
 rust-tokio-util+futures-util-devel \
 rust-tokio-util+hashbrown-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util+io-util-devel \
 rust-tokio-util+join-map-devel \
 rust-tokio-util+libc-devel \
 rust-tokio-util+net-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util+slab-devel \
 rust-tokio-util+time-devel \
 rust-tokio-util+tracing-devel \
 rust-tokio-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-util-0.7.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edfcb03b55db5ea48473fffb3f80e960fbd97f3e378bf76fa7f4f1ddb540a75b"

URI_x86_64_v2_rust-tokio-util+codec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+codec-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+codec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+codec-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+codec-devel.sha256sum] = "e7d66f010826b434c8f12a2c860e484e68ae7212023c75ba7742f1b3f96d4c53"

URI_x86_64_v2_rust-tokio-util+compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+compat-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+compat-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+compat-devel.sha256sum] = "3be368e212ecc1553cbd801823ba913655c526b9dd29511b0454fd8787f3018e"

URI_x86_64_v2_rust-tokio-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+default-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+default-devel.sha256sum] = "89d4fd73f7675dd68ad513ce9e5435b525ec79c79f8a4c6a80450310c0862887"

URI_x86_64_v2_rust-tokio-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+full-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+full-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+full-devel.sha256sum] = "f0b9eb76af50bd0651d4a1b050ff67606870d816ef44782f08388f86699fbfa1"

URI_x86_64_v2_rust-tokio-util+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+futures-io-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+futures-io-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+futures-io-devel.sha256sum] = "eb5d5b5dfe1736e913eb622fe48ba47a288b856335e54e097e2a112f2deb808c"

URI_x86_64_v2_rust-tokio-util+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+futures-util-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+futures-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+futures-util-devel.sha256sum] = "61ad9fdc0d46df4a867fb1ec775417163e149b3fa23d386b67da80d2b43e733e"

URI_x86_64_v2_rust-tokio-util+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+hashbrown-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+hashbrown-devel.sha256sum] = "0c0661ed3b759a3ac6cd7e880456f2d387fa0b2afedd407793fc9c948e4482fb"

URI_x86_64_v2_rust-tokio-util+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+io-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+io-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+io-devel.sha256sum] = "360a7febfd59a33a68cc591a499a8917ee60c2151fd496a487348471fde708e2"

URI_x86_64_v2_rust-tokio-util+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+io-util-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+io-util-devel.sha256sum] = "34f6fa6b30a3f380a6a54ed802156ccedd72f683ce762fb7d11a28735874a47d"

URI_x86_64_v2_rust-tokio-util+join-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+join-map-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+join-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+join-map-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+join-map-devel.sha256sum] = "97e103081f8017f2934739a1d4f2741546ece67f23b5cbbff47982731d4cba32"

URI_x86_64_v2_rust-tokio-util+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+libc-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+libc-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+libc-devel.sha256sum] = "cc57856fddc6064d8ef8c97e50b64fe3d345a5572d4384b92951b6c37bba784f"

URI_x86_64_v2_rust-tokio-util+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+net-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+net-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+net-devel.sha256sum] = "e6221ef41b20c013dd5c7c08763cbd41cd2c535d084785a477276d58981039ab"

URI_x86_64_v2_rust-tokio-util+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+rt-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+rt-devel.sha256sum] = "eb765627385cbee5a29f127299be019f47095bcf1ad18f16c18d18ad6769bfac"

URI_x86_64_v2_rust-tokio-util+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+slab-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+slab-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+slab-devel.sha256sum] = "f2a1a41f4ee435908c29ebae146e4f6f3a6de22b2dbd323c476a4f31ebe58386"

URI_x86_64_v2_rust-tokio-util+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+time-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+time-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+time-devel.sha256sum] = "55fcb6e8b56f01d2c816b795a670964435054fe652285f0ada0ae547b3ca1fe7"

URI_x86_64_v2_rust-tokio-util+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+tracing-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+tracing-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+tracing-devel.sha256sum] = "6e22023b289644923f140b4e60decd93992ddc46d7b8ee8bb426098355d0861b"

URI_x86_64_v2_rust-tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util-devel-0.7.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util-devel.sha256sum] = "4e3dfa6972d4c7961af1c89b47bdfb4d63ff089b6a93ffa4df002a3020aef6b4"

URI_aarch64_rust-tokio-util+codec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+codec-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+codec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+codec-devel}"
SRC_URI[aarch64_rust-tokio-util+codec-devel.sha256sum] = "8373c8e66f60145c7e46d30d4f3668dcf5f09561c9ac5bc078b976b912573d7d"

URI_aarch64_rust-tokio-util+compat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+compat-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+compat-devel}"
SRC_URI[aarch64_rust-tokio-util+compat-devel.sha256sum] = "4a31bb0720a5dfd62b2f1fcea433e592b307e280cdffdfcfa42d36adb042e8e9"

URI_aarch64_rust-tokio-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+default-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+default-devel}"
SRC_URI[aarch64_rust-tokio-util+default-devel.sha256sum] = "039de4172f04bd3c6d16aca0dedbcaed02362b4165b65fdab3d4e651a07f6cd1"

URI_aarch64_rust-tokio-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+full-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+full-devel}"
SRC_URI[aarch64_rust-tokio-util+full-devel.sha256sum] = "e6db63af886a36060a69b3d9972412a594a8d7257595f8943edbcbae9875f0dd"

URI_aarch64_rust-tokio-util+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+futures-io-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+futures-io-devel}"
SRC_URI[aarch64_rust-tokio-util+futures-io-devel.sha256sum] = "52bd94de4795a5b5ec7f4c06be3eb31c7a86b796ac63a25dfe01e8c7f60d453d"

URI_aarch64_rust-tokio-util+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+futures-util-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+futures-util-devel}"
SRC_URI[aarch64_rust-tokio-util+futures-util-devel.sha256sum] = "10b8c279a6d8012b94ca65f4d9bcc3c7a5dfe98a5333bc69b4ae0d794a3659bd"

URI_aarch64_rust-tokio-util+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+hashbrown-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+hashbrown-devel}"
SRC_URI[aarch64_rust-tokio-util+hashbrown-devel.sha256sum] = "6dffd77557728834c80d4cff86d017c18aa24f0f29a1757f99c7ee5a6296ea0a"

URI_aarch64_rust-tokio-util+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+io-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+io-devel}"
SRC_URI[aarch64_rust-tokio-util+io-devel.sha256sum] = "7858566490ad929c23d6cea60330fb169abb8ee546fe3778f87e4f3f36919814"

URI_aarch64_rust-tokio-util+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+io-util-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+io-util-devel}"
SRC_URI[aarch64_rust-tokio-util+io-util-devel.sha256sum] = "06ffd966f8e16a630fd137c2018ace935f9a7c39ec7481c644f3e955d292e912"

URI_aarch64_rust-tokio-util+join-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+join-map-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+join-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+join-map-devel}"
SRC_URI[aarch64_rust-tokio-util+join-map-devel.sha256sum] = "7335f132b1023e902a3f3cd95155b806feba4f149bef50ccb6db7af3476f9b47"

URI_aarch64_rust-tokio-util+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+libc-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+libc-devel}"
SRC_URI[aarch64_rust-tokio-util+libc-devel.sha256sum] = "b2ae4662a54f6bac72ba934001c243afa120a0c3aaf197cc0fae582a47f3e37e"

URI_aarch64_rust-tokio-util+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+net-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+net-devel}"
SRC_URI[aarch64_rust-tokio-util+net-devel.sha256sum] = "af928d9fdf680675ed84e8e0ecc6998f7f197795a8d5fec7c4a52052ef146c13"

URI_aarch64_rust-tokio-util+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+rt-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+rt-devel}"
SRC_URI[aarch64_rust-tokio-util+rt-devel.sha256sum] = "7760cdef5394d15c0fe5f1ef9fa2c47d4dfb6845675616c556576c2b1e86c8dd"

URI_aarch64_rust-tokio-util+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+slab-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+slab-devel}"
SRC_URI[aarch64_rust-tokio-util+slab-devel.sha256sum] = "d0646a7d8ff102bdb84bda31a65d5204f9a587f5ab544d07720bc65f218ed9cd"

URI_aarch64_rust-tokio-util+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+time-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+time-devel}"
SRC_URI[aarch64_rust-tokio-util+time-devel.sha256sum] = "f27969e4cde0e0a0612ebc203caa47e669865199bc2cfd232fe7574b07c6ecc0"

URI_aarch64_rust-tokio-util+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+tracing-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+tracing-devel}"
SRC_URI[aarch64_rust-tokio-util+tracing-devel.sha256sum] = "e8f2f2607ded4f784fb865daab3116fcb00934084ec13cf5f5f23c2e6e84d109"

URI_aarch64_rust-tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util-devel-0.7.19-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util-devel}"
SRC_URI[aarch64_rust-tokio-util-devel.sha256sum] = "e55f33234d7773e3521ce1f4592a6fddd9285f9bff008a8097cba9153754ec59"

RDEPENDS:rust-tokio-util+codec-devel = " \
 cargo \
 rust-tokio-util+libc-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+compat-devel = " \
 cargo \
 rust-tokio-util+futures-io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+default-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+full-devel = " \
 cargo \
 rust-tokio-util+codec-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+io-util-devel \
 rust-tokio-util+join-map-devel \
 rust-tokio-util+net-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util+time-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+io-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+io-util-devel = " \
 cargo \
 rust-tokio+io-util-devel \
 rust-tokio+rt-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+join-map-devel = " \
 cargo \
 rust-tokio-util+hashbrown-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+net-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+rt-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio-util+futures-util-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+slab-devel = " \
 cargo \
 rust-slab+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+time-devel = " \
 cargo \
 rust-tokio+time-devel \
 rust-tokio-util+slab-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+tracing-devel = " \
 cargo \
 rust-tokio-util-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tokio-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core+default-devel \
 rust-futures-sink+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
