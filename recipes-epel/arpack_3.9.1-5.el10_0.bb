# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arpack"
PV = "3.9.1"
PR = "5.el10_0"
PACKAGES = " \
 arpack \
 arpack-devel \
 arpack-doc \
 arpack-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/arpack-3.9.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e078dd20fb9b9e155f6d2c9fb4d698baaeb205cd25e2b85cf681bb3f50d0fa3"

URI_x86_64_v2_arpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arpack-3.9.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arpack}"
SRC_URI[x86_64_v2_arpack.sha256sum] = "8de6b64a9bd836da35a399b8d6276f8d29d131d3dc1062b5ef1258a7f411d9e6"

URI_x86_64_v2_arpack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arpack-devel-3.9.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arpack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arpack-devel}"
SRC_URI[x86_64_v2_arpack-devel.sha256sum] = "3dc195b858241b6ba99d5cd68c170f7bdc98882dab445306976cdc8791da4a93"

URI_x86_64_v2_arpack-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arpack-doc-3.9.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_arpack-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arpack-doc}"
SRC_URI[x86_64_v2_arpack-doc.sha256sum] = "36c876337352827be9a573522f034a9f64eec9785e274daa28993cf2d1ace629"

URI_x86_64_v2_arpack-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arpack-static-3.9.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arpack-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_arpack-static}"
SRC_URI[x86_64_v2_arpack-static.sha256sum] = "8df4af35afa41d58204eb77bb3cbf95072405d7cab61199ea7a4250bb7084bb0"

URI_aarch64_arpack = "${EPEL_MIRROR}/aarch64/Packages/a/arpack-3.9.1-5.el10_0.aarch64.rpm;name=aarch64_arpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_arpack}"
SRC_URI[aarch64_arpack.sha256sum] = "458763c938e395bff0301758235f0cc4f9a1f37528fc88048fa210d38b3360e3"

URI_aarch64_arpack-devel = "${EPEL_MIRROR}/aarch64/Packages/a/arpack-devel-3.9.1-5.el10_0.aarch64.rpm;name=aarch64_arpack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_arpack-devel}"
SRC_URI[aarch64_arpack-devel.sha256sum] = "1ed3071826b68356d112334c3ce52c62c6dfc38e9a5e003b459cad159f5602fe"

URI_aarch64_arpack-doc = "${EPEL_MIRROR}/aarch64/Packages/a/arpack-doc-3.9.1-5.el10_0.noarch.rpm;name=aarch64_arpack-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_arpack-doc}"
SRC_URI[aarch64_arpack-doc.sha256sum] = "bce00bd67fc2c78f2441b4de117620dd9e4f63a8729b5cc53b7e1ea226721331"

URI_aarch64_arpack-static = "${EPEL_MIRROR}/aarch64/Packages/a/arpack-static-3.9.1-5.el10_0.aarch64.rpm;name=aarch64_arpack-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_arpack-static}"
SRC_URI[aarch64_arpack-static.sha256sum] = "f23b47159878be6d93a35a1632d2962674825a890fd3990ee053295be489c4a9"

RDEPENDS:arpack = " \
 flexiblas-netlib \
 flexiblas-netlib64 \
 glibc \
 libgcc \
 libgfortran \
 "
RDEPENDS:arpack-devel = " \
 arpack \
 arpack-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:arpack-doc = " \
 "
RDEPENDS:arpack-static = " \
 arpack-devel \
 "
