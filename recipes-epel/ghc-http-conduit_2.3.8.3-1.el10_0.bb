# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-http-conduit"
PV = "2.3.8.3"
PR = "1.el10_0"
PACKAGES = " \
 ghc-http-conduit \
 ghc-http-conduit-devel \
 ghc-http-conduit-doc \
 ghc-http-conduit-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-http-conduit-2.3.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b819bb010b2510b284d3bfbbad32ea026f10d0581fba09f205770d0d0de2e354"

URI_x86_64_v2_ghc-http-conduit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-conduit-2.3.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-conduit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-conduit}"
SRC_URI[x86_64_v2_ghc-http-conduit.sha256sum] = "a36e8a6c58202cd0f3c5deab985e8127624804ef50e26ef079f1e7fcd7e73651"

URI_x86_64_v2_ghc-http-conduit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-conduit-devel-2.3.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-conduit-devel}"
SRC_URI[x86_64_v2_ghc-http-conduit-devel.sha256sum] = "78044334c52f5269dee79e5c8cd82cd16fd6b1e72dd15eac1450e9cafb042d9b"

URI_x86_64_v2_ghc-http-conduit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-conduit-doc-2.3.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-http-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-conduit-doc}"
SRC_URI[x86_64_v2_ghc-http-conduit-doc.sha256sum] = "dc3e16556296d55cfe24d412ac912df69249907cc88a6bf158c284d42ce1509a"

URI_x86_64_v2_ghc-http-conduit-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-conduit-prof-2.3.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-conduit-prof}"
SRC_URI[x86_64_v2_ghc-http-conduit-prof.sha256sum] = "d2b8dfd0b744276652a67bf148bc7ba121f6fe8c34be8d54502f7bbb55ffd755"

URI_aarch64_ghc-http-conduit = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-conduit-2.3.8.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-http-conduit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-conduit}"
SRC_URI[aarch64_ghc-http-conduit.sha256sum] = "89e5e3d01beedfc3ac741e479b26475bf53f7c8a53d317f3a4bec4edeb7264a4"

URI_aarch64_ghc-http-conduit-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-conduit-devel-2.3.8.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-http-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-conduit-devel}"
SRC_URI[aarch64_ghc-http-conduit-devel.sha256sum] = "3097fa9a0251c026e4e544c873415c363757b13449e129278750838cab8f1309"

URI_aarch64_ghc-http-conduit-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-conduit-doc-2.3.8.3-1.el10_0.noarch.rpm;name=aarch64_ghc-http-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-conduit-doc}"
SRC_URI[aarch64_ghc-http-conduit-doc.sha256sum] = "ad8d18b176c711cc970ad76107ed554a1aa5f7b53bc594f047a64fcd5290e890"

URI_aarch64_ghc-http-conduit-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-conduit-prof-2.3.8.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-http-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-conduit-prof}"
SRC_URI[aarch64_ghc-http-conduit-prof.sha256sum] = "c888184e35796d5f440d35a4f81aefa29e7bf32ffd71177e16c6f8b0855e7489"

RDEPENDS:ghc-http-conduit = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-http-conduit-devel = " \
 ghc-aeson-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-conduit-extra-devel \
 ghc-http-client-devel \
 ghc-http-client-tls-devel \
 ghc-http-conduit \
 ghc-http-types-devel \
 ghc-mtl-devel \
 ghc-resourcet-devel \
 ghc-transformers-devel \
 ghc-unliftio-core-devel \
 "
RDEPENDS:ghc-http-conduit-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-http-conduit-prof = " \
 ghc-aeson-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-conduit-extra-prof \
 ghc-conduit-prof \
 ghc-http-client-prof \
 ghc-http-client-tls-prof \
 ghc-http-conduit-devel \
 ghc-http-types-prof \
 ghc-mtl-prof \
 ghc-resourcet-prof \
 ghc-transformers-prof \
 ghc-unliftio-core-prof \
 "
