# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-specfile"
PV = "0.37.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-specfile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-specfile-0.37.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3bbbb0336a67bd12e7747f10f494403f6f1d1f78d862517d87ea2e68ae99fcd4"

URI_x86_64_v2_python3-specfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-specfile-0.37.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-specfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-specfile}"
SRC_URI[x86_64_v2_python3-specfile.sha256sum] = "bff9d54f29577fe8d8210f73a708bba2dde4dd28d304d83170ab250eceb60f30"

URI_aarch64_python3-specfile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-specfile-0.37.1-1.el10_0.noarch.rpm;name=aarch64_python3-specfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-specfile}"
SRC_URI[aarch64_python3-specfile.sha256sum] = "04dc625589eab121ba38cde0f9d9c72b360fc1ea41806b6571758ac2246ae8db"

RDEPENDS:python3-specfile = " \
 python3 \
 python3-rpm \
 "
