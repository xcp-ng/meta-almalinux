# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "icedtea-web"
PV = "1.8.8"
PR = "8.el10_0"
PACKAGES = " \
 icedtea-web \
 icedtea-web-devel \
 icedtea-web-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/icedtea-web-1.8.8-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e9599af8514ee147896c370f9f74fee3060062fc77b870968bad5da0123d4f1"

URI_x86_64_v2_icedtea-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icedtea-web-1.8.8-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icedtea-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icedtea-web}"
SRC_URI[x86_64_v2_icedtea-web.sha256sum] = "2d0ca5a2079b71c532443481a3463e3ddf5f56acbfccde8f7ea2ecd20f359883"

URI_x86_64_v2_icedtea-web-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icedtea-web-devel-1.8.8-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_icedtea-web-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icedtea-web-devel}"
SRC_URI[x86_64_v2_icedtea-web-devel.sha256sum] = "21d79d2c0b60a5d27777b4deb0c795eda3f427c1783c897fc944751d9a7270b9"

URI_x86_64_v2_icedtea-web-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icedtea-web-javadoc-1.8.8-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_icedtea-web-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icedtea-web-javadoc}"
SRC_URI[x86_64_v2_icedtea-web-javadoc.sha256sum] = "d064ec8fa7443d94633c80f9854645e56110aca388279c47cb56ef09ad15a4f4"

URI_aarch64_icedtea-web = "${EPEL_MIRROR}/aarch64/Packages/i/icedtea-web-1.8.8-8.el10_0.aarch64.rpm;name=aarch64_icedtea-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_icedtea-web}"
SRC_URI[aarch64_icedtea-web.sha256sum] = "a94535354be31324d1e24694ca443cf8da3a9ce8b73d01ac77eb39fa9fac2f13"

URI_aarch64_icedtea-web-devel = "${EPEL_MIRROR}/aarch64/Packages/i/icedtea-web-devel-1.8.8-8.el10_0.noarch.rpm;name=aarch64_icedtea-web-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_icedtea-web-devel}"
SRC_URI[aarch64_icedtea-web-devel.sha256sum] = "f656286c74a487a545a4ce7f15a8d23a5387f271f7e9cd15704fccae2c6377c1"

URI_aarch64_icedtea-web-javadoc = "${EPEL_MIRROR}/aarch64/Packages/i/icedtea-web-javadoc-1.8.8-8.el10_0.noarch.rpm;name=aarch64_icedtea-web-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_icedtea-web-javadoc}"
SRC_URI[aarch64_icedtea-web-javadoc.sha256sum] = "a71494692fd5f9ad9d1a6996541486adfcc6e642fd3e880360c4eefe7461184e"

RDEPENDS:icedtea-web = " \
 GConf2 \
 alternatives \
 bash \
 glibc \
 java-21-openjdk \
 javapackages-tools \
 libgcc \
 tagsoup \
 "
RDEPENDS:icedtea-web-devel = " \
 icedtea-web \
 "
RDEPENDS:icedtea-web-javadoc = " \
 icedtea-web \
 javapackages-filesystem \
 "
