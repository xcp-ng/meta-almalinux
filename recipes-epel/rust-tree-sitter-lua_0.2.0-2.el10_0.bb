# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-lua"
PV = "0.2.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-lua+default-devel \
 rust-tree-sitter-lua-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-lua-0.2.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c3871f0e51ee7e2950f8cc79e1f5d1e3119b30c215662ac3aa18e6767101322"

URI_x86_64_v2_rust-tree-sitter-lua+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-lua+default-devel-0.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-lua+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-lua+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-lua+default-devel.sha256sum] = "aab72a8936c97854d2213c38ae5e1f84e84c88fdf01742c962f895693c5bfe25"

URI_x86_64_v2_rust-tree-sitter-lua-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-lua-devel-0.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-lua-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-lua-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-lua-devel.sha256sum] = "5d928171290a6cc118705c42dacf6f8dd3f75e255503f2e2b9f0ba7c962ff01c"

URI_aarch64_rust-tree-sitter-lua+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-lua+default-devel-0.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-lua+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-lua+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-lua+default-devel.sha256sum] = "1f770c7e33ad0b80ea4b5ff4e445997ddf487809b761b5c6445727626484fa8f"

URI_aarch64_rust-tree-sitter-lua-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-lua-devel-0.2.0-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-lua-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-lua-devel}"
SRC_URI[aarch64_rust-tree-sitter-lua-devel.sha256sum] = "08c47c2f94e3cf3cbcffa96f5148776195862da0f6719c6bbf9586f47b62511d"

RDEPENDS:rust-tree-sitter-lua+default-devel = " \
 cargo \
 rust-tree-sitter-lua-devel \
 "
RDEPENDS:rust-tree-sitter-lua-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
