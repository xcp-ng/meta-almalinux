# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-siphasher"
PV = "1.0.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-siphasher+default-devel \
 rust-siphasher+serde-devel \
 rust-siphasher+serde_json-devel \
 rust-siphasher+serde_no_std-devel \
 rust-siphasher+serde_std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-siphasher-1.0.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f745fbff49821fcfa04cf92dd93fd6e9d365b09980026693eda9456ff1f5cb39"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+default-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+default-devel.sha256sum] = "d2e9ed6f6840fc28f77196370c21370d3d23bef0b98328cd29756ba7154b5cb6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+serde-devel.sha256sum] = "5a2cd2ffc05fcb44c3952ae064a866c3ddff70c1d080ac0d4f7c824602e81319"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_json-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+serde_json-devel.sha256sum] = "3b0163d1500d1f0a1e9dc06997adcf369304c91fb3b408735ee5385f3820d92a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_no_std-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+serde_no_std-devel.sha256sum] = "1c9eca6232965d8701a96afd4b1f5c05d8abf462b67718a6ca163f5643fb8f8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_std-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+serde_std-devel.sha256sum] = "c1e125b18b56541032bea1b7dab3a0b1d6ae0c4969d194fe41611b7e4311d2d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+std-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher+std-devel.sha256sum] = "5febe884fa1f6cc0da4499f8aa281dec7ec6bd938eca027d3fea71b6ae6c3359"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher-devel;unpack=0"
SRC_URI[x86_64_v2_rust-siphasher-devel.sha256sum] = "8b1779fa49dabaa2bac9170101fcacfc62e4461784f7790fd2e72a31e3f77b50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+default-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+default-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+default-devel.sha256sum] = "99a971a0a385c8faaa96fdc379868879798639b8de41ed169a5b6ee08b75dd27"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+serde-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+serde-devel.sha256sum] = "fb4242de5224bb0771e05ae6caeb38d3b00484da1b2b11f1a51c0183824cb032"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_json-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+serde_json-devel.sha256sum] = "6b26a1798297788946d73814ce7e61b194791d051dcbc8abeda37e4a7d5e80c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_no_std-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+serde_no_std-devel.sha256sum] = "b4e3b96fe17703f136d91037063db8b19595a7136c899343559abd8cdbd51e1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_std-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+serde_std-devel.sha256sum] = "98c00edf3da540092b56ef63c1f52b409fc0c921ed2fc6cbfa7510f9662e850b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+std-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+std-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher+std-devel.sha256sum] = "d017aef7d64d58bc21946894f9c1bffc305b45c2d737e19f669d19da6866d5f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher-devel;unpack=0"
SRC_URI[aarch64_rust-siphasher-devel.sha256sum] = "bc26ee54d6f210c6250cc6b19149457f7e6c08789d9d2ef85fd197ecc34e6a61"

RDEPENDS:rust-siphasher+default-devel = " \
 cargo \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_no_std-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_std-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+std-devel = " \
 cargo \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher-devel = " \
 cargo \
 "
