# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-MimeInfo"
PV = "0.34"
PR = "5.el10"
PACKAGES = " \
 perl-File-MimeInfo \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-File-MimeInfo-0.34-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "822b785a0d486bd253bd3537734a141653c7afa03f2ebb4bf1090065e822acbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-File-MimeInfo-0.34-5.el10.noarch.rpm;name=x86_64_v2_perl-File-MimeInfo;unpack=0"
SRC_URI[x86_64_v2_perl-File-MimeInfo.sha256sum] = "25b06a5cc6124dafcca9a839b2c36f2f71d7be74448aa3113f504834352d0b8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-File-MimeInfo-0.34-5.el10.noarch.rpm;name=aarch64_perl-File-MimeInfo;unpack=0"
SRC_URI[aarch64_perl-File-MimeInfo.sha256sum] = "25b06a5cc6124dafcca9a839b2c36f2f71d7be74448aa3113f504834352d0b8e"

RDEPENDS:perl-File-MimeInfo = " \
 perl-Carp \
 perl-Encode \
 perl-Encode-Locale \
 perl-Exporter \
 perl-Fcntl \
 perl-File-BaseDir \
 perl-File-DesktopEntry \
 perl-File-MimeInfo \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 "
