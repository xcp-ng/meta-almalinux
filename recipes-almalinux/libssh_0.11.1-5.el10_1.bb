# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libssh"
PV = "0.11.1"
PR = "5.el10_1"
PACKAGES = " \
 libssh \
 libssh-config \
 libssh-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libssh-0.11.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f13f129cd2f6ed792a2ec5f9796604b923a3d3d38196977db64a870e027e0f12"

URI_x86_64_v2_libssh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-0.11.1-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_libssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh}"
SRC_URI[x86_64_v2_libssh.sha256sum] = "20c2a600117b01c023fef8b5ab915a3e00f7f6ece6833053e6a6bb105de655ba"

URI_x86_64_v2_libssh-config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libssh-config-0.11.1-5.el10_1.noarch.rpm;name=x86_64_v2_libssh-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh-config}"
SRC_URI[x86_64_v2_libssh-config.sha256sum] = "c7c3e9551fe91b46d03923f21625b20bfec339133dc661a21c183e84450c27e0"

URI_x86_64_v2_libssh-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libssh-devel-0.11.1-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_libssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh-devel}"
SRC_URI[x86_64_v2_libssh-devel.sha256sum] = "e23ae0d22794ff4d1402b0db20415883e5e266e647cedab56a44d362dff4f990"

URI_aarch64_libssh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-0.11.1-5.el10_1.aarch64.rpm;name=aarch64_libssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh}"
SRC_URI[aarch64_libssh.sha256sum] = "a174a9e472fe0503bf80ddc730b967862e2eee601ff61db8833b5aa7daeec152"

URI_aarch64_libssh-config = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libssh-config-0.11.1-5.el10_1.noarch.rpm;name=aarch64_libssh-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh-config}"
SRC_URI[aarch64_libssh-config.sha256sum] = "c7c3e9551fe91b46d03923f21625b20bfec339133dc661a21c183e84450c27e0"

URI_aarch64_libssh-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libssh-devel-0.11.1-5.el10_1.aarch64.rpm;name=aarch64_libssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh-devel}"
SRC_URI[aarch64_libssh-devel.sha256sum] = "dd34383d8b57d5c63e2ec92fce5178f1f34062585bd900f707ba27e009c3ed28"

RDEPENDS:libssh = " \
 glibc \
 krb5-libs \
 libssh-config \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libssh-config = " \
 "
RDEPENDS:libssh-devel = " \
 cmake-filesystem \
 libssh \
 pkgconf-pkg-config \
 "
