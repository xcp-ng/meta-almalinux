# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-insta"
PV = "1.44.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-insta+_cargo_insta_internal-devel \
 rust-insta+clap-devel \
 rust-insta+colors-devel \
 rust-insta+console-devel \
 rust-insta+csv-devel \
 rust-insta+default-devel \
 rust-insta+filters-devel \
 rust-insta+glob-devel \
 rust-insta+globset-devel \
 rust-insta+json-devel \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+redactions-devel \
 rust-insta+regex-devel \
 rust-insta+ron-devel \
 rust-insta+serde-devel \
 rust-insta+toml-devel \
 rust-insta+walkdir-devel \
 rust-insta+yaml-devel \
 rust-insta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-insta-1.44.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb30202cefbaf11d89ed7fd33359fe83f7b465979fd8c8b5306f3b3f2fc6e6b2"

URI_x86_64_v2_rust-insta+_cargo_insta_internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+_cargo_insta_internal-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+_cargo_insta_internal-devel}"
SRC_URI[x86_64_v2_rust-insta+_cargo_insta_internal-devel.sha256sum] = "3e9fdc156765f21c7383c0bd103f35fd447b8c613a3fa5de7935e5eae2c526f5"

URI_x86_64_v2_rust-insta+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+clap-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+clap-devel}"
SRC_URI[x86_64_v2_rust-insta+clap-devel.sha256sum] = "908328b425405040a5ce096349eed04628b8b4713382ab105cd5dd90bd6804f7"

URI_x86_64_v2_rust-insta+colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+colors-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+colors-devel}"
SRC_URI[x86_64_v2_rust-insta+colors-devel.sha256sum] = "77f3e0b5ce3d3a92231f74dc50b5ab73cd1537660940f7512a2b3707b0715a51"

URI_x86_64_v2_rust-insta+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+console-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+console-devel}"
SRC_URI[x86_64_v2_rust-insta+console-devel.sha256sum] = "d6c2dd8c32526824c9ba07806525d91977929dda72eea6d65c061e27e4562581"

URI_x86_64_v2_rust-insta+csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+csv-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+csv-devel}"
SRC_URI[x86_64_v2_rust-insta+csv-devel.sha256sum] = "f6ee196d67b76ce0cfcf8324a0c7068e8e64fc2d989b8ffcc39330bea7185fe8"

URI_x86_64_v2_rust-insta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+default-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+default-devel}"
SRC_URI[x86_64_v2_rust-insta+default-devel.sha256sum] = "ddeaead8f2873c84ee25f06302ed847132650d716851060a43522ed2611ac7f1"

URI_x86_64_v2_rust-insta+filters-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+filters-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+filters-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+filters-devel}"
SRC_URI[x86_64_v2_rust-insta+filters-devel.sha256sum] = "12e8d56fc4f2c5ac557112ef11a935e314aeeac0e2ef9509a445341c0c268d41"

URI_x86_64_v2_rust-insta+glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+glob-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+glob-devel}"
SRC_URI[x86_64_v2_rust-insta+glob-devel.sha256sum] = "dc51f49627a84530d81450d85893b252f544c1fbf10e8a69ed1eab3674272b38"

URI_x86_64_v2_rust-insta+globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+globset-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+globset-devel}"
SRC_URI[x86_64_v2_rust-insta+globset-devel.sha256sum] = "2ad220f274a52afe19360467ae8bad215acaf1029a1436c559146cf4d948e988"

URI_x86_64_v2_rust-insta+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+json-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+json-devel}"
SRC_URI[x86_64_v2_rust-insta+json-devel.sha256sum] = "2194b16c432e6cc3a3e1386500b7f2466ef5fdfda19049f175bc2dc7859db65c"

URI_x86_64_v2_rust-insta+pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+pest-devel}"
SRC_URI[x86_64_v2_rust-insta+pest-devel.sha256sum] = "75294f0d7292b6de421a22a9d4278c4fec52e774863ed470ff448f4f670546b2"

URI_x86_64_v2_rust-insta+pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest_derive-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+pest_derive-devel}"
SRC_URI[x86_64_v2_rust-insta+pest_derive-devel.sha256sum] = "382f2283af5881ccaca04a79989aff07819ed306212485a1837ab967aff23f4f"

URI_x86_64_v2_rust-insta+redactions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+redactions-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+redactions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+redactions-devel}"
SRC_URI[x86_64_v2_rust-insta+redactions-devel.sha256sum] = "b2bea8bde494c57f3512ce9b7ce0ed1880c37736d2a16df5030a93c9c4136802"

URI_x86_64_v2_rust-insta+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+regex-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+regex-devel}"
SRC_URI[x86_64_v2_rust-insta+regex-devel.sha256sum] = "28a029fe1e04763aa0d1e014e6a8c7174ee4bd090f8716a9ad06f1bddb805c81"

URI_x86_64_v2_rust-insta+ron-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+ron-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+ron-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+ron-devel}"
SRC_URI[x86_64_v2_rust-insta+ron-devel.sha256sum] = "c09778f925e140535af15fdb2c84cdd29baac7bf1dc54f1f2c193680c9855575"

URI_x86_64_v2_rust-insta+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+serde-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+serde-devel}"
SRC_URI[x86_64_v2_rust-insta+serde-devel.sha256sum] = "bd70ebd49bf24780bcd79d4420a9f0756cff0da5f2ef87235ed4018814864857"

URI_x86_64_v2_rust-insta+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+toml-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+toml-devel}"
SRC_URI[x86_64_v2_rust-insta+toml-devel.sha256sum] = "3669018caba3e04056e40ed3128708629dc0a9d19873b14519cd80e6b288d9c9"

URI_x86_64_v2_rust-insta+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+walkdir-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+walkdir-devel}"
SRC_URI[x86_64_v2_rust-insta+walkdir-devel.sha256sum] = "3a6eb11c46c5e16bd5044f5206b32233ae944b911eb2e92612bb8a78ddd2a5ce"

URI_x86_64_v2_rust-insta+yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+yaml-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+yaml-devel}"
SRC_URI[x86_64_v2_rust-insta+yaml-devel.sha256sum] = "6e6e65f0834b112f8e8bad91c527ac1a201e19c92aac80fd977c0d12d750b3b6"

URI_x86_64_v2_rust-insta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta-devel-1.44.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta-devel}"
SRC_URI[x86_64_v2_rust-insta-devel.sha256sum] = "27eeb825055ade50d03e9fb42933a56aacf00723a2e27937a37db7ae0df7aa4c"

URI_aarch64_rust-insta+_cargo_insta_internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+_cargo_insta_internal-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+_cargo_insta_internal-devel}"
SRC_URI[aarch64_rust-insta+_cargo_insta_internal-devel.sha256sum] = "93d7b1a5ab74e219c21303b7701e37745d808f88f024a7a1ece2e8af5d3c6b54"

URI_aarch64_rust-insta+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+clap-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+clap-devel}"
SRC_URI[aarch64_rust-insta+clap-devel.sha256sum] = "7f299d8f01ee207fe14222a565df16c23143987570194a435ae04bb6eaf83cac"

URI_aarch64_rust-insta+colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+colors-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+colors-devel}"
SRC_URI[aarch64_rust-insta+colors-devel.sha256sum] = "7e14e0fd665ac3133580cf815af1c0109411d5153f72de759b9a4f95d06adbcf"

URI_aarch64_rust-insta+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+console-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+console-devel}"
SRC_URI[aarch64_rust-insta+console-devel.sha256sum] = "7b32f26e009ed4dd9f5a17ef89c9da79d3526cc5a6268040f3cb0145c8b9e75a"

URI_aarch64_rust-insta+csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+csv-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+csv-devel}"
SRC_URI[aarch64_rust-insta+csv-devel.sha256sum] = "60ff3d0f501815e6432b1b79af23592f5471da40908be0b5a7351803e7fcc67e"

URI_aarch64_rust-insta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+default-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+default-devel}"
SRC_URI[aarch64_rust-insta+default-devel.sha256sum] = "2f390b5c794a3b064d3aa1c64449901f80a4d10e32ecc534f1dbff807a4c3214"

URI_aarch64_rust-insta+filters-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+filters-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+filters-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+filters-devel}"
SRC_URI[aarch64_rust-insta+filters-devel.sha256sum] = "637c855e41166b56706c42b2598e739f8580a820dc46d01efd48c5cdbd40886f"

URI_aarch64_rust-insta+glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+glob-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+glob-devel}"
SRC_URI[aarch64_rust-insta+glob-devel.sha256sum] = "eded3efb73cdbb7637f45b7cd9d5f9fa743fce8e9f6727968e99c0e8cf20836e"

URI_aarch64_rust-insta+globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+globset-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+globset-devel}"
SRC_URI[aarch64_rust-insta+globset-devel.sha256sum] = "9bb45fcd3e40ded7158482a65d94d0e1bba513df58fe25f12e3b715824e680e7"

URI_aarch64_rust-insta+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+json-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+json-devel}"
SRC_URI[aarch64_rust-insta+json-devel.sha256sum] = "fcdd56791553c3f7da4ab31b67ffc8d329de9898c6d5f051029d591a19e9a5f8"

URI_aarch64_rust-insta+pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+pest-devel}"
SRC_URI[aarch64_rust-insta+pest-devel.sha256sum] = "b48b56e1c5e8ca179407c28382a8c75141c311bf9104ea4392718e9f7d13abee"

URI_aarch64_rust-insta+pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest_derive-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+pest_derive-devel}"
SRC_URI[aarch64_rust-insta+pest_derive-devel.sha256sum] = "816d7645052b430412b101180560208f35d190408397b6345f4fcab513e05dc6"

URI_aarch64_rust-insta+redactions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+redactions-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+redactions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+redactions-devel}"
SRC_URI[aarch64_rust-insta+redactions-devel.sha256sum] = "f7b551ba04012ff2055c88b76f81ebc390797f06b9f0b1ac14fa0b5253f8816a"

URI_aarch64_rust-insta+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+regex-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+regex-devel}"
SRC_URI[aarch64_rust-insta+regex-devel.sha256sum] = "e5ed4e81c4bc1e4aa6c610e7dfd7b0844ef25dc2a30c2e1610cbb5c5c574222f"

URI_aarch64_rust-insta+ron-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+ron-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+ron-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+ron-devel}"
SRC_URI[aarch64_rust-insta+ron-devel.sha256sum] = "4f7ad6dec50d470eb0f5a0b2c0d0a22c86f021c9496416d40352a0f2fa84e3d9"

URI_aarch64_rust-insta+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+serde-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+serde-devel}"
SRC_URI[aarch64_rust-insta+serde-devel.sha256sum] = "410aeea26d88f78e4a1da47d4b566263de6fed94a2c6efe9b7a7da79f0d9fe9e"

URI_aarch64_rust-insta+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+toml-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+toml-devel}"
SRC_URI[aarch64_rust-insta+toml-devel.sha256sum] = "ebeece67a5e04965a3c45cece6b1dac54823e6e87bdd8d90351db260188b368b"

URI_aarch64_rust-insta+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+walkdir-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+walkdir-devel}"
SRC_URI[aarch64_rust-insta+walkdir-devel.sha256sum] = "1491a15407fb323d72b453698673c215541bff2d0e830fb6834f1f82016abf9b"

URI_aarch64_rust-insta+yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+yaml-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+yaml-devel}"
SRC_URI[aarch64_rust-insta+yaml-devel.sha256sum] = "8599a6eabcca2ba4eb2c346b72f98653fa842b091c68e4faccf0acd295e7706d"

URI_aarch64_rust-insta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta-devel-1.44.3-1.el10_1.noarch.rpm;name=aarch64_rust-insta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta-devel}"
SRC_URI[aarch64_rust-insta-devel.sha256sum] = "c5b7abfc2d6adb1889898217c34a10b4363fbf3fd9c760e7a190f0cea33779c5"

RDEPENDS:rust-insta+_cargo_insta_internal-devel = " \
 cargo \
 rust-insta+clap-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+clap-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+colors-devel = " \
 cargo \
 rust-insta+console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+console-devel = " \
 cargo \
 rust-console+std-devel \
 rust-console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+default-devel = " \
 cargo \
 rust-insta+colors-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+filters-devel = " \
 cargo \
 rust-insta+regex-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+glob-devel = " \
 cargo \
 rust-insta+globset-devel \
 rust-insta+walkdir-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+globset-devel = " \
 cargo \
 rust-globset+default-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+json-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+pest-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest+default-devel \
 "
RDEPENDS:rust-insta+pest_derive-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest_derive+default-devel \
 "
RDEPENDS:rust-insta+redactions-devel = " \
 cargo \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+regex-devel = " \
 cargo \
 rust-insta-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-insta+ron-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-ron+default-devel \
 "
RDEPENDS:rust-insta+serde-devel = " \
 cargo \
 rust-insta-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-insta+toml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-toml0.5+default-devel \
 "
RDEPENDS:rust-insta+walkdir-devel = " \
 cargo \
 rust-insta-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-insta+yaml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta-devel = " \
 cargo \
 rust \
 rust-once_cell+default-devel \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 "
