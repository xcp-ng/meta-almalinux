# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-freezer"
PV = "0.4.9"
PR = "1.el10_0"
PACKAGES = " \
 python3-pytest-freezer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-freezer-0.4.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0165753db2b7ea803f670abe6ce007f156cd09592dcc4cb39f225084189634ba"

URI_x86_64_v2_python3-pytest-freezer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-freezer-0.4.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-freezer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-freezer}"
SRC_URI[x86_64_v2_python3-pytest-freezer.sha256sum] = "9822e04d7976da55d8adcabdee28da06608be63112b351eca8f1ac04d96a2cb0"

URI_aarch64_python3-pytest-freezer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-freezer-0.4.9-1.el10_0.noarch.rpm;name=aarch64_python3-pytest-freezer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-freezer}"
SRC_URI[aarch64_python3-pytest-freezer.sha256sum] = "72ad9fbcad298e807614a17be46fe5ae682d757f974ec4260d6d979130dee914"

RDEPENDS:python3-pytest-freezer = " \
 python3 \
 python3-freezegun \
 python3-pytest \
 "
