# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_meta"
PV = "2.8.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-pest_meta+default-devel \
 rust-pest_meta+grammar-extras-devel \
 rust-pest_meta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_meta-2.8.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe4b8ce4923ec8d01b0d0b83c896792542292d2e4b038a779963e0849747be00"

URI_x86_64_v2_rust-pest_meta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta+default-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta+default-devel}"
SRC_URI[x86_64_v2_rust-pest_meta+default-devel.sha256sum] = "e26f2183fc53094c31334c40e58ad12465b83fac8a98646f5144db5b2327b040"

URI_x86_64_v2_rust-pest_meta+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta+grammar-extras-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_meta+grammar-extras-devel.sha256sum] = "31c97903ab06fbfe8dba07ab38a96870233fffa2b48a8983c11d324f2c874479"

URI_x86_64_v2_rust-pest_meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta-devel-2.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta-devel}"
SRC_URI[x86_64_v2_rust-pest_meta-devel.sha256sum] = "cf408f3555d9edd36524436d297802993eec780d8b9c6e99228a777284195ed2"

URI_aarch64_rust-pest_meta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta+default-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta+default-devel}"
SRC_URI[aarch64_rust-pest_meta+default-devel.sha256sum] = "ee5b1ae746c99e84ae0ea829e4d2144356d7984182573059c67c54f5f8d67169"

URI_aarch64_rust-pest_meta+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta+grammar-extras-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_meta+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_meta+grammar-extras-devel.sha256sum] = "db5ed77be0022eabbdb93d0dd79f2531a7238e2fde4ae8f27bf9d10c629398af"

URI_aarch64_rust-pest_meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta-devel-2.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-pest_meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta-devel}"
SRC_URI[aarch64_rust-pest_meta-devel.sha256sum] = "4cd512a69beeba1dfda6791ff577f4b7d0717abac468d29530c4c11f2ce8018a"

RDEPENDS:rust-pest_meta+default-devel = " \
 cargo \
 rust-pest_meta-devel \
 "
RDEPENDS:rust-pest_meta+grammar-extras-devel = " \
 cargo \
 rust-pest_meta-devel \
 "
RDEPENDS:rust-pest_meta-devel = " \
 cargo \
 rust \
 rust-pest+default-devel \
 rust-sha2_0.10-devel \
 "
