# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-command-execute-tokio"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-reqsign-command-execute-tokio+default-devel \
 rust-reqsign-command-execute-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-command-execute-tokio-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f395394b5a0bfcf43d33b3efd48699bb132355a66f63adb77572fd925e6e38f"

URI_x86_64_v2_rust-reqsign-command-execute-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-command-execute-tokio+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-command-execute-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-command-execute-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-command-execute-tokio+default-devel.sha256sum] = "9704b012a4bbf3f41b9b05fa1cfe6aedbf371d9b09fa86f6f88b2edc8a0abede"

URI_x86_64_v2_rust-reqsign-command-execute-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-command-execute-tokio-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-command-execute-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-command-execute-tokio-devel}"
SRC_URI[x86_64_v2_rust-reqsign-command-execute-tokio-devel.sha256sum] = "f681a08d956f41121a9104ab808627357787086b30a45c3d89ea4d2ffa6966d6"

URI_aarch64_rust-reqsign-command-execute-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-command-execute-tokio+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-command-execute-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-command-execute-tokio+default-devel}"
SRC_URI[aarch64_rust-reqsign-command-execute-tokio+default-devel.sha256sum] = "b9e10105c52e7dc589b0a15ccecdacba3b60587ed949b0c666ee704dbcda3eee"

URI_aarch64_rust-reqsign-command-execute-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-command-execute-tokio-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-reqsign-command-execute-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-command-execute-tokio-devel}"
SRC_URI[aarch64_rust-reqsign-command-execute-tokio-devel.sha256sum] = "bf1368e3ad413e95d505645cc0510a2201269d9496438e9235fdc53a9a4d8c73"

RDEPENDS:rust-reqsign-command-execute-tokio+default-devel = " \
 cargo \
 rust-reqsign-command-execute-tokio-devel \
 "
RDEPENDS:rust-reqsign-command-execute-tokio-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-reqsign-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+process-devel \
 "
