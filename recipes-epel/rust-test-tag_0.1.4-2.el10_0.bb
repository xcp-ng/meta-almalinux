# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-tag"
PV = "0.1.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-test-tag+default-devel \
 rust-test-tag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-tag-0.1.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af4a43622cab2688d77e40aa332fb7ab3a7384976b431f8c4155bed9a9303c4d"

URI_x86_64_v2_rust-test-tag+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-tag+default-devel-0.1.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-tag+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-tag+default-devel}"
SRC_URI[x86_64_v2_rust-test-tag+default-devel.sha256sum] = "1356be20b2ef370d8939d60dc729d3a1c257028a79603ca9bf0f83ea51ac7c2c"

URI_x86_64_v2_rust-test-tag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-tag-devel-0.1.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-tag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-tag-devel}"
SRC_URI[x86_64_v2_rust-test-tag-devel.sha256sum] = "df97ef666305b72043d67661b9e5c5db1aa6e94e33fce24adc3d9e3f352e490f"

URI_aarch64_rust-test-tag+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-tag+default-devel-0.1.4-2.el10_0.noarch.rpm;name=aarch64_rust-test-tag+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-tag+default-devel}"
SRC_URI[aarch64_rust-test-tag+default-devel.sha256sum] = "8b5bb6e19940bc164d8650ff87aaed349ecfa8288d3e7fb47c8aa5ac904da6de"

URI_aarch64_rust-test-tag-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-tag-devel-0.1.4-2.el10_0.noarch.rpm;name=aarch64_rust-test-tag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-tag-devel}"
SRC_URI[aarch64_rust-test-tag-devel.sha256sum] = "92f5899a2aa09f4fc126f4f12e6c1b5093532067563ae73daa8b93d9681149bc"

RDEPENDS:rust-test-tag+default-devel = " \
 cargo \
 rust-test-tag-devel \
 "
RDEPENDS:rust-test-tag-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
