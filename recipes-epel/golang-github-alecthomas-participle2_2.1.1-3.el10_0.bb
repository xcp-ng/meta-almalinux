# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-alecthomas-participle2"
PV = "2.1.1"
PR = "3.el10_0"
PACKAGES = " \
 golang-github-alecthomas-participle2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-alecthomas-participle2-2.1.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee53b7ac8655f5c3b815a30e95dc0ebe32b124bb9f5cbbf3852a272d9a5762ac"

URI_x86_64_v2_golang-github-alecthomas-participle2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-alecthomas-participle2-devel-2.1.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-alecthomas-participle2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-alecthomas-participle2-devel}"
SRC_URI[x86_64_v2_golang-github-alecthomas-participle2-devel.sha256sum] = "4b38762df123f065450e79241a83892d6df056fc8a33205e6bf43683114ce803"

URI_aarch64_golang-github-alecthomas-participle2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-alecthomas-participle2-devel-2.1.1-3.el10_0.noarch.rpm;name=aarch64_golang-github-alecthomas-participle2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-alecthomas-participle2-devel}"
SRC_URI[aarch64_golang-github-alecthomas-participle2-devel.sha256sum] = "c39ec8ae3ad4c5af606332eefa8bf06f259d75ed5bcd6b93dfd89075341240e3"

RDEPENDS:golang-github-alecthomas-participle2-devel = " \
 go-filesystem \
 golang-github-alecthomas-kong-devel \
 golang-github-alecthomas-repr-devel \
 "
