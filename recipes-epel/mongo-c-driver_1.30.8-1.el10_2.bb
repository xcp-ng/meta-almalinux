# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mongo-c-driver"
PV = "1.30.8"
PR = "1.el10_2"
PACKAGES = " \
 libbson \
 libbson-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mongo-c-driver-1.30.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "895165375b581b923c29331b04bca5c818c13b2489f50957becbe929894ea4f7"

URI_aarch64_libbson = "${EPEL_MIRROR}/aarch64/Packages/l/libbson-1.30.8-1.el10_2.aarch64.rpm;name=aarch64_libbson;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbson}"
SRC_URI[aarch64_libbson.sha256sum] = "6b38acabbf8072fa73412c9b2b79f50dd48edd50a9de50b942e33e33b857b62f"

URI_aarch64_libbson-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbson-devel-1.30.8-1.el10_2.aarch64.rpm;name=aarch64_libbson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbson-devel}"
SRC_URI[aarch64_libbson-devel.sha256sum] = "2f824d50efdf192fecdc93c52e79f7ec40634d8504c10fde347c8d8a27226871"

URI_aarch64_mongo-c-driver = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-1.30.8-1.el10_2.aarch64.rpm;name=aarch64_mongo-c-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver}"
SRC_URI[aarch64_mongo-c-driver.sha256sum] = "5ef515a3614d5673add21c8dee09e57e1752f32c72dfac551f1fcdf052b3fa78"

URI_aarch64_mongo-c-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-devel-1.30.8-1.el10_2.aarch64.rpm;name=aarch64_mongo-c-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver-devel}"
SRC_URI[aarch64_mongo-c-driver-devel.sha256sum] = "68618e41a5b07650b2176dbc0b34f8b448c78540ab531c4848ca9f63e93cff27"

URI_aarch64_mongo-c-driver-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-libs-1.30.8-1.el10_2.aarch64.rpm;name=aarch64_mongo-c-driver-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver-libs}"
SRC_URI[aarch64_mongo-c-driver-libs.sha256sum] = "13040caddc99da2f52e2df537021156c8f16f39a94dbab451f9cc55ad8c6b486"

RDEPENDS:libbson = " \
 glibc \
 "
RDEPENDS:libbson-devel = " \
 cmake-filesystem \
 libbson \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver = " \
 glibc \
 mongo-c-driver-libs \
 "
RDEPENDS:mongo-c-driver-devel = " \
 cmake-filesystem \
 libbson-devel \
 libmongocrypt-devel \
 libzstd-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver-libs = " \
 cyrus-sasl-lib \
 glibc \
 libbson \
 libmongocrypt \
 libzstd \
 openssl-libs \
 snappy \
 utf8proc \
 zlib-ng-compat \
 "
