# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-pa"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-pa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-pa-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c66504e390807cf00caa8da29bc65a36258ee399196c4b3915b11e1026fa3b53"

URI_x86_64_v2_plasma-pa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-pa-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-pa}"
SRC_URI[x86_64_v2_plasma-pa.sha256sum] = "58b9d68c7d1b69bc0499b3b98738f169904d5768833e5332e3dc69dd56e6562d"

URI_aarch64_plasma-pa = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-pa-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-pa}"
SRC_URI[aarch64_plasma-pa.sha256sum] = "ce6ac292dd1b3eb6d64c49dfae578496aa774625acaa0f05c664069188d7b371"

RDEPENDS:plasma-pa = " \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kstatusnotifieritem \
 libcanberra \
 libstdc++ \
 pipewire-pulseaudio \
 pulseaudio-libs \
 pulseaudio-qt-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
