# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbedtls"
PV = "3.6.7"
PR = "1.el10_3"
PACKAGES = " \
 mbedtls \
 mbedtls-devel \
 mbedtls-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbedtls-3.6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9eb46cfc11fbd6bf69b46fa1dd40c3647c1f778d3fbc081379d427933763495"

URI_x86_64_v2_mbedtls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-3.6.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbedtls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls}"
SRC_URI[x86_64_v2_mbedtls.sha256sum] = "1a9280bad34b3e4bb5deb1504cfe96fcd4925f5e381f5a841da02cc719632060"

URI_x86_64_v2_mbedtls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-devel-3.6.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbedtls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls-devel}"
SRC_URI[x86_64_v2_mbedtls-devel.sha256sum] = "fc8d7578866b1b936c26e62015f755a0890d5b8b58b3ef16ca890a7be970a439"

URI_x86_64_v2_mbedtls-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbedtls-doc-3.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mbedtls-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbedtls-doc}"
SRC_URI[x86_64_v2_mbedtls-doc.sha256sum] = "10a2cecf7997ad8ccadacff8f4d61f8f17c64b00a7fb133dcdf93906082f3af3"

URI_aarch64_mbedtls = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-3.6.7-1.el10_3.aarch64.rpm;name=aarch64_mbedtls;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls}"
SRC_URI[aarch64_mbedtls.sha256sum] = "556ad900c002515a29103585b3469ffac721e87eff22d1414ac54741ed43d555"

URI_aarch64_mbedtls-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-devel-3.6.7-1.el10_3.aarch64.rpm;name=aarch64_mbedtls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls-devel}"
SRC_URI[aarch64_mbedtls-devel.sha256sum] = "ba31a957598bc4c6f6f35a4f5f6eff0c94c314d00b740de945dfa47b08eda973"

URI_aarch64_mbedtls-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mbedtls-doc-3.6.7-1.el10_3.noarch.rpm;name=aarch64_mbedtls-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbedtls-doc}"
SRC_URI[aarch64_mbedtls-doc.sha256sum] = "9a0776dabe5589de8e0d5a0c32fbad01061a83a09f81c511bb336eb33ca1f155"

RDEPENDS:mbedtls = " \
 glibc \
 "
RDEPENDS:mbedtls-devel = " \
 cmake-filesystem \
 glibc \
 mbedtls \
 mbedtls-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mbedtls-doc = " \
 "
