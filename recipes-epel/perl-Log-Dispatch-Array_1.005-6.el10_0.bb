# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Log-Dispatch-Array"
PV = "1.005"
PR = "6.el10_0"
PACKAGES = " \
 perl-Log-Dispatch-Array \
 perl-Log-Dispatch-Array-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Log-Dispatch-Array-1.005-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb0f2a95278c894171536026e58f18880c9e93b361997f0781e9b427be3350ff"

URI_x86_64_v2_perl-Log-Dispatch-Array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Dispatch-Array-1.005-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Dispatch-Array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Dispatch-Array}"
SRC_URI[x86_64_v2_perl-Log-Dispatch-Array.sha256sum] = "19e77d3e4ebfca83925546eba6132f9580e05f903706810a85e52678a5b8c277"

URI_x86_64_v2_perl-Log-Dispatch-Array-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Dispatch-Array-tests-1.005-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Dispatch-Array-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Dispatch-Array-tests}"
SRC_URI[x86_64_v2_perl-Log-Dispatch-Array-tests.sha256sum] = "ea9a650b16f6a812cc136e489c17a9edb38d6da70b2d40db278e00c7e92304db"

URI_aarch64_perl-Log-Dispatch-Array = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Dispatch-Array-1.005-6.el10_0.noarch.rpm;name=aarch64_perl-Log-Dispatch-Array;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Dispatch-Array}"
SRC_URI[aarch64_perl-Log-Dispatch-Array.sha256sum] = "64500f2bbaed4877dd8c2fa33e2417166d74281da29da938c80e872e860334f7"

URI_aarch64_perl-Log-Dispatch-Array-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Dispatch-Array-tests-1.005-6.el10_0.noarch.rpm;name=aarch64_perl-Log-Dispatch-Array-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Dispatch-Array-tests}"
SRC_URI[aarch64_perl-Log-Dispatch-Array-tests.sha256sum] = "2860902634f46d6955b547f962a54f5662c52725fda09049d62419294599c0b3"

RDEPENDS:perl-Log-Dispatch-Array = " \
 perl-Log-Dispatch \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Log-Dispatch-Array-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-Log-Dispatch-Array \
 perl-PathTools \
 perl-Test-Deep \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
