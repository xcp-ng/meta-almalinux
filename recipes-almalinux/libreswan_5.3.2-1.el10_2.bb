# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libreswan"
PV = "5.3.2"
PR = "1.el10_2"
PACKAGES = " \
 libreswan \
 libreswan-minimal \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libreswan-5.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7a02465ab98af0af752c586b58e105806adeb7c6f9ea98ce6484cb4157234b8"

URI_x86_64_v2_libreswan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libreswan-5.3.2-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libreswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libreswan}"
SRC_URI[x86_64_v2_libreswan.sha256sum] = "1926f320d81ffefd287a82e8a9cf7ba0a49edaf3ae5dca587b9a11d6792c6513"

URI_x86_64_v2_libreswan-minimal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libreswan-minimal-5.3.2-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libreswan-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libreswan-minimal}"
SRC_URI[x86_64_v2_libreswan-minimal.sha256sum] = "0c321d4d6cbd639f860ff82758b76fa4212b7d0686114f23f13eba7a4db94ce8"

URI_aarch64_libreswan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libreswan-5.3.2-1.el10_2.aarch64.rpm;name=aarch64_libreswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libreswan}"
SRC_URI[aarch64_libreswan.sha256sum] = "e216f1807850b4cee2354d6022423fbcfa3adfe3fd6dd86b6dbb3c9cf2e17ee9"

URI_aarch64_libreswan-minimal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libreswan-minimal-5.3.2-1.el10_2.aarch64.rpm;name=aarch64_libreswan-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_libreswan-minimal}"
SRC_URI[aarch64_libreswan-minimal.sha256sum] = "740f1255f23fd60cbbdaa78877885811f241121e4c0431ce55b0253945c285f0"

RDEPENDS:libreswan = " \
 bash \
 iproute \
 libreswan-minimal \
 logrotate \
 nss \
 nss-softokn \
 procps-ng \
 systemd \
 "
RDEPENDS:libreswan-minimal = " \
 audit-libs \
 bash \
 glibc \
 ldns \
 libcap-ng \
 libevent \
 libgcc \
 libseccomp \
 libselinux \
 libxcrypt \
 nspr \
 nss \
 nss-tools \
 nss-util \
 openldap \
 pam-libs \
 unbound-libs \
 virtual/coreutils \
 virtual/libcurl.so.4___64bit_ \
 "
