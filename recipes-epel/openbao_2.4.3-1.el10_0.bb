# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbao"
PV = "2.4.3"
PR = "1.el10_0"
PACKAGES = " \
 openbao \
 openbao-vault-compat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openbao-2.4.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67fc31cec52793b7d9d3c68299ac094981670d3f517a50e91614d6cad125a11f"

URI_x86_64_v2_openbao = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-2.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbao}"
SRC_URI[x86_64_v2_openbao.sha256sum] = "32b8ea6ffbb3691af7da8e7e10c036a80e246669d781f8d0d8797dfaa665e723"

URI_x86_64_v2_openbao-vault-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-vault-compat-2.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao-vault-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbao-vault-compat}"
SRC_URI[x86_64_v2_openbao-vault-compat.sha256sum] = "b7d87af0f777447f35d00dbf14793cceecd6b8475986345c5d75546819d0e87e"

URI_aarch64_openbao = "${EPEL_MIRROR}/aarch64/Packages/o/openbao-2.4.3-1.el10_0.aarch64.rpm;name=aarch64_openbao;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbao}"
SRC_URI[aarch64_openbao.sha256sum] = "581e698777b82ef2ed82b3b937be56090288724515c5a9bf64a75784685d1faa"

URI_aarch64_openbao-vault-compat = "${EPEL_MIRROR}/aarch64/Packages/o/openbao-vault-compat-2.4.3-1.el10_0.aarch64.rpm;name=aarch64_openbao-vault-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbao-vault-compat}"
SRC_URI[aarch64_openbao-vault-compat.sha256sum] = "f0a9438568571b62ad596b073950583e9ebd6b4b3abb744fcc06abd428df0a6d"

RDEPENDS:openbao = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:openbao-vault-compat = " \
 openbao \
 "
