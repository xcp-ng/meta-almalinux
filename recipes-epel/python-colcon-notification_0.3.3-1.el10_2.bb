# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-notification"
PV = "0.3.3"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-notification \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-notification-0.3.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0f15a0e5f25ba299a688e2611f50e0c6064f118dbe583d036c197650eefef9ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-notification-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-notification;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-notification.sha256sum] = "f8576c059ff70ecca4fd155fa146fda3ae68e23c7918ff64e7075bd049f16386"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-notification-0.3.3-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-notification;unpack=0"
SRC_URI[aarch64_python3-colcon-notification.sha256sum] = "d865edbf3c437ce02ada2bc919b213e6a9dafd93f048ef472100aeb920d9c270"

RDEPENDS:python3-colcon-notification = " \
 python3 \
 python3-colcon-core \
 python3-notify2 \
 "
