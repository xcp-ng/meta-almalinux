# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-error-attr3"
PV = "3.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-proc-macro-error-attr3+default-devel \
 rust-proc-macro-error-attr3-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-error-attr3-3.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4fc4d8ad64977093abedee85bc32e37a13e742f997e2ff5d44e4d051be722463"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error-attr3+default-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error-attr3+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-error-attr3+default-devel.sha256sum] = "d06146784651e873f63f6d07e6f94d3af2b8ba753a0543aa3ec00dd583ecc33c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-error-attr3-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-error-attr3-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro-error-attr3-devel.sha256sum] = "c28ff29289831b342e8e81c4e8d7af585d8e3f00c41a9a8a8ccf311b1d1055de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error-attr3+default-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error-attr3+default-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-error-attr3+default-devel.sha256sum] = "fd25be6af4a6df8705d74b4e81289c4cffc288c4eadf042eb983b7bcec2f6f7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-error-attr3-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro-error-attr3-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro-error-attr3-devel.sha256sum] = "0d89733df09becb0cacd732e55b2c78e45585eec73d6ddd2a65ba44dca80dfa8"

RDEPENDS:rust-proc-macro-error-attr3+default-devel = " \
 cargo \
 rust-proc-macro-error-attr3-devel \
 "
RDEPENDS:rust-proc-macro-error-attr3-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
