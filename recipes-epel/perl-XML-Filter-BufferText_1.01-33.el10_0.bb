# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-Filter-BufferText"
PV = "1.01"
PR = "33.el10_0"
PACKAGES = " \
 perl-XML-Filter-BufferText \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-Filter-BufferText-1.01-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cd51a37f9e846283e8a16af9439bd191f8d3d4cee2e4b65fcbf3b64efac02a9"

URI_x86_64_v2_perl-XML-Filter-BufferText = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-Filter-BufferText-1.01-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-Filter-BufferText;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Filter-BufferText}"
SRC_URI[x86_64_v2_perl-XML-Filter-BufferText.sha256sum] = "73cf36573ba8cdba7c35702ea32df358a071f1636c275f9f0b0cb6397b182536"

URI_aarch64_perl-XML-Filter-BufferText = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-Filter-BufferText-1.01-33.el10_0.noarch.rpm;name=aarch64_perl-XML-Filter-BufferText;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Filter-BufferText}"
SRC_URI[aarch64_perl-XML-Filter-BufferText.sha256sum] = "4cc7365d570575b90a87b0d4ea71e30799a6d7b7eee1837dbf6c9e99ea693829"

RDEPENDS:perl-XML-Filter-BufferText = " \
 perl-XML-SAX-Base \
 perl-base \
 perl-libs \
 perl-vars \
 "
