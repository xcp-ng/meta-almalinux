# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "realmd"
PV = "0.17.1"
PR = "13.el10_1"
PACKAGES = " \
 realmd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/realmd-0.17.1-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd4d1ed9c80a20c0daca24dc6d99a26b03d5d369164792a3f9ff52ccbb59ba21"

URI_x86_64_v2_realmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realmd-0.17.1-13.el10_1.x86_64_v2.rpm;name=x86_64_v2_realmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_realmd}"
SRC_URI[x86_64_v2_realmd.sha256sum] = "0b7247301019dc1303f3a12496ea1ef5594ed2712e7614df3321cafe55f456b4"

URI_aarch64_realmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realmd-0.17.1-13.el10_1.aarch64.rpm;name=aarch64_realmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_realmd}"
SRC_URI[aarch64_realmd.sha256sum] = "eed4ccfcd554304d48da460458fb01054327160a1cc3168aa297ffa1bc953d2b"

RDEPENDS:realmd = " \
 authselect \
 bash \
 glib2 \
 glibc \
 krb5-libs \
 openldap \
 polkit \
 polkit-libs \
 systemd-libs \
 "
