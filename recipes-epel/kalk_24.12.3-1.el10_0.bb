# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kalk"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kalk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kalk-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3936a4e9f173c182ee6de40739b1db9626d50c307b85eda0601d504c7dbf6e16"

URI_x86_64_v2_kalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kalk-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kalk}"
SRC_URI[x86_64_v2_kalk.sha256sum] = "a44fe4e3c083e3558d518fa84d6fc7b0ed08fd62f0075204a1f64d8fa2095a54"

URI_aarch64_kalk = "${EPEL_MIRROR}/aarch64/Packages/k/kalk-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_kalk}"
SRC_URI[aarch64_kalk.sha256sum] = "93fb2247650afc1e1ff16d9e0388525775d2ec7dd092a64b4685147e4f175f16"

RDEPENDS:kalk = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kunitconversion \
 kf6-qqc2-desktop-style \
 kf6-sonnet \
 libqalculate \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
