# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shell-timeout"
PV = "0.3.0"
PR = "2.el10_2"
PACKAGES = " \
 shell-timeout \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/shell-timeout-0.3.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4640a629156fc469b9b1696234ead971e52e369ac1e73837fb0283394de65b66"

URI_x86_64_v2_shell-timeout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shell-timeout-0.3.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_shell-timeout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shell-timeout}"
SRC_URI[x86_64_v2_shell-timeout.sha256sum] = "7775018d415dc18c9e5d1fb07dd4d7f4a670e401f3f42ebc61633c92ec749ec5"

URI_aarch64_shell-timeout = "${EPEL_MIRROR}/aarch64/Packages/s/shell-timeout-0.3.0-2.el10_2.noarch.rpm;name=aarch64_shell-timeout;unpack=0"
SRC_URI:append = " ${URI_aarch64_shell-timeout}"
SRC_URI[aarch64_shell-timeout.sha256sum] = "036891011ff93fed6f7b055a7bc0bdcaa35fae0505537d306f1c627a8735c204"

RDEPENDS:shell-timeout = " \
 filesystem \
 sed \
 virtual/coreutils \
 "
