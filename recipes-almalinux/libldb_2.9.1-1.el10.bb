# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libldb"
PV = "2.9.1"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libldb-2.9.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3aab6f105c0c53374291c6975feab2ecfb98f8f314ea547a829dc620bab950b"

