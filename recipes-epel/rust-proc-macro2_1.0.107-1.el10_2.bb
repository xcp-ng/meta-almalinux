# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro2"
PV = "1.0.107"
PR = "1.el10_2"
PACKAGES = " \
 rust-proc-macro2+default-devel \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro2-1.0.107-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0c15c9a1b7805eee4120c5f3253ec7b7c0e5e89da8c941fd5a01e6038eecb0ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+default-devel-1.0.107-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro2+default-devel.sha256sum] = "08ca1fb3dc2dcdc0c4a2540b40890be7b4d2f4fbd0679936c4a4284554761fbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+proc-macro-devel-1.0.107-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro2+proc-macro-devel.sha256sum] = "0ff928fdf75b43329dc6e4f41b2011f3abaac4b7dd7ee5c4268b8ae14b1f7523"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+span-locations-devel-1.0.107-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro2+span-locations-devel.sha256sum] = "badf8277edf5c8ac369caffd13acddf116405e9a758dc2105c2445bca3ef935e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-devel-1.0.107-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro2-devel.sha256sum] = "a460441e4e07d3447bdc8071576bec1a21f90e713f1e124049c6b8cfac49db92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+default-devel-1.0.107-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro2+default-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro2+default-devel.sha256sum] = "d08cce8d1c053418659593768d446ae18b2f5f9172e0f19605ecc7a46ee64d68"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+proc-macro-devel-1.0.107-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro2+proc-macro-devel.sha256sum] = "718eeac0b4c5c4f01d642cce5f4126d73f749472904dd935c4a22eb77a0854d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+span-locations-devel-1.0.107-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro2+span-locations-devel.sha256sum] = "4de0b579909e84cb505052a090ce1115868b00b3db0721ed4fbfb78dc69df945"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-devel-1.0.107-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro2-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro2-devel.sha256sum] = "a9d74215a212d7c4daef61fc9aeeac111c0e143fd6748bec059d0808c9a983b8"

RDEPENDS:rust-proc-macro2+default-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+proc-macro-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+span-locations-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2-devel = " \
 cargo \
 rust \
 rust-unicode-ident+default-devel \
 "
