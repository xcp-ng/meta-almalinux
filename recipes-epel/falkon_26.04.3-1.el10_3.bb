# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "falkon"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 falkon \
 falkon-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/falkon-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "961741354506ed38a0515d167a26023c2d4c300493afcc0e5b9de5f930567035"

URI_x86_64_v2_falkon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_falkon}"
SRC_URI[x86_64_v2_falkon.sha256sum] = "63fa8539457dba5f0f048f62b3fa52e5d42f4f2dd817c4f3cb37832b250e0a4d"

URI_x86_64_v2_falkon-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-kde-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_falkon-kde}"
SRC_URI[x86_64_v2_falkon-kde.sha256sum] = "507ad11a4eccc201a81b43d4e971a42e0c176e731e951bf0762175dc75773f2d"

URI_aarch64_falkon = "${EPEL_MIRROR}/aarch64/Packages/f/falkon-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_falkon;unpack=0"
SRC_URI:append = " ${URI_aarch64_falkon}"
SRC_URI[aarch64_falkon.sha256sum] = "e0c7c0863e76acad16debdddc6cac9a97d94c5b45fcfff66ce8258b642a67516"

URI_aarch64_falkon-kde = "${EPEL_MIRROR}/aarch64/Packages/f/falkon-kde-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_falkon-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_falkon-kde}"
SRC_URI[aarch64_falkon-kde.sha256sum] = "c3a66f94f6eb9dceb447c0ff1fc8c64d9f17b3f1e5339937ede738ea5609e876"

RDEPENDS:falkon = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 libgcc \
 libstdc++ \
 libxcb \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
RDEPENDS:falkon-kde = " \
 falkon \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kio-core-libs \
 kf6-kjobwidgets \
 kf6-kwallet-libs \
 kf6-purpose \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
