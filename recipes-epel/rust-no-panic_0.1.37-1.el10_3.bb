# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-no-panic"
PV = "0.1.37"
PR = "1.el10_3"
PACKAGES = " \
 rust-no-panic+default-devel \
 rust-no-panic-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-no-panic-0.1.37-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c2c7e7d5a5e211d3e90d9562e8391b543dcea80b77cb945fe807842837491604"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-panic+default-devel-0.1.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-panic+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-no-panic+default-devel.sha256sum] = "3705f5aa6f4927c95e38027f748a05d9ca3a02500534347e6de4b9e9789d86ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-panic-devel-0.1.37-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-panic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-no-panic-devel.sha256sum] = "be603e4200c216adfafb31678027e4b5600c43d2c69cec637b1d27d3bcc846ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-no-panic+default-devel-0.1.37-1.el10_3.noarch.rpm;name=aarch64_rust-no-panic+default-devel;unpack=0"
SRC_URI[aarch64_rust-no-panic+default-devel.sha256sum] = "a580c12aa077018ed04898f1b2adae55d8b86b44c122ac27111f4c0408d7c92b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-no-panic-devel-0.1.37-1.el10_3.noarch.rpm;name=aarch64_rust-no-panic-devel;unpack=0"
SRC_URI[aarch64_rust-no-panic-devel.sha256sum] = "f73bc82e39212f3c780f0f9d50e474ef9c2f6db2bf893e60d4511315de597dad"

RDEPENDS:rust-no-panic+default-devel = " \
 cargo \
 rust-no-panic-devel \
 "
RDEPENDS:rust-no-panic-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
