# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pastel"
PV = "0.12.0"
PR = "1.el10_2"
PACKAGES = " \
 pastel \
 rust-pastel+default-devel \
 rust-pastel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pastel-0.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6aff317ba072698420e90e819b5ea98eb0a7d3412f633efd65a5b519e619de62"

URI_x86_64_v2_pastel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pastel-0.12.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pastel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pastel}"
SRC_URI[x86_64_v2_pastel.sha256sum] = "dae6035b899fb606f9131eb563a116dff3409ff7d88aa50b86addc466ad574c3"

URI_x86_64_v2_rust-pastel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pastel+default-devel-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pastel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pastel+default-devel}"
SRC_URI[x86_64_v2_rust-pastel+default-devel.sha256sum] = "6d06373d55c9c0ced6ddf2360d804f70dc9c8847faea5686d579045fb555889b"

URI_x86_64_v2_rust-pastel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pastel-devel-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pastel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pastel-devel}"
SRC_URI[x86_64_v2_rust-pastel-devel.sha256sum] = "1b235b7ade0ce80babf1db0410f1b52f8c938ecb5bd0147e0b23132d49cf6b4e"

URI_aarch64_pastel = "${EPEL_MIRROR}/aarch64/Packages/p/pastel-0.12.0-1.el10_2.aarch64.rpm;name=aarch64_pastel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pastel}"
SRC_URI[aarch64_pastel.sha256sum] = "dfc969dec4e358e26eca2f20e3b718aff53ddd07a7d5724eacc54c56d73b0514"

URI_aarch64_rust-pastel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pastel+default-devel-0.12.0-1.el10_2.noarch.rpm;name=aarch64_rust-pastel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pastel+default-devel}"
SRC_URI[aarch64_rust-pastel+default-devel.sha256sum] = "7ba63d9febf2541d46132be21b7e235249813d9278ee9c973f88ef26b42ab2b6"

URI_aarch64_rust-pastel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pastel-devel-0.12.0-1.el10_2.noarch.rpm;name=aarch64_rust-pastel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pastel-devel}"
SRC_URI[aarch64_rust-pastel-devel.sha256sum] = "ea510170a52d9be262eeb120aa83dba684346a3eb94ee92111a932832afcba3d"

RDEPENDS:pastel = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-pastel+default-devel = " \
 cargo \
 rust-pastel-devel \
 "
RDEPENDS:rust-pastel-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+suggestions-devel \
 rust-clap+wrap_help-devel \
 rust-clap_complete+default-devel \
 rust-clap_mangen+default-devel \
 rust-nom7+default-devel \
 rust-once_cell+default-devel \
 rust-rand0.9+default-devel \
 rust-regex+default-devel \
 "
