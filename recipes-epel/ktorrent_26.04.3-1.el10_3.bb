# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktorrent"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ktorrent \
 ktorrent-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktorrent-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85f703e15bf92e6f0a4278d859102f69549796fb5c05a4ae04f678ee2df167dd"

URI_x86_64_v2_ktorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktorrent}"
SRC_URI[x86_64_v2_ktorrent.sha256sum] = "0dc44e6c02520248c18830dbf28d698c0a3688a690e9365736ca908a523e258f"

URI_x86_64_v2_ktorrent-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktorrent-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktorrent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktorrent-libs}"
SRC_URI[x86_64_v2_ktorrent-libs.sha256sum] = "dff3fbc9003f10717bb5a21d4d6079f318a339807def50a727e53247d9442b7b"

URI_aarch64_ktorrent = "${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ktorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktorrent}"
SRC_URI[aarch64_ktorrent.sha256sum] = "d4be3013ccf90d5510bb520dcf522a08df746a87c4e89f4b8fbd2b693e51a688"

URI_aarch64_ktorrent-libs = "${EPEL_MIRROR}/aarch64/Packages/k/ktorrent-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ktorrent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktorrent-libs}"
SRC_URI[aarch64_ktorrent-libs.sha256sum] = "b09b812196f51d5c9f03b0d140ae1e3ed8b44f61a20b394361753b94c61e5964"

RDEPENDS:ktorrent = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kplotting \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-syndication \
 ktorrent-libs \
 libgcc \
 libktorrent \
 libmaxminddb \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:ktorrent-libs = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktorrent \
 libgcc \
 libktorrent \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
