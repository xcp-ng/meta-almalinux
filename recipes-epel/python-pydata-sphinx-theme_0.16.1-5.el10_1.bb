# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydata-sphinx-theme"
PV = "0.16.1"
PR = "5.el10_1"
PACKAGES = " \
 python3-pydata-sphinx-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydata-sphinx-theme-0.16.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ce77f9919db324586dad3c80c617eca37c8cc3aa6042d7c7bb4bea4e87c5964"

URI_x86_64_v2_python3-pydata-sphinx-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydata-sphinx-theme-0.16.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydata-sphinx-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydata-sphinx-theme}"
SRC_URI[x86_64_v2_python3-pydata-sphinx-theme.sha256sum] = "d1c864bed154280971c4822ce09612a1a99392b5d4297f0a8987e960b5eb8ffb"

URI_aarch64_python3-pydata-sphinx-theme = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydata-sphinx-theme-0.16.1-5.el10_1.noarch.rpm;name=aarch64_python3-pydata-sphinx-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydata-sphinx-theme}"
SRC_URI[aarch64_python3-pydata-sphinx-theme.sha256sum] = "a8c3879207b95651b0b66e24e0e0ba56dc97c1809b1013bf383f4eb141ba5968"

RDEPENDS:python3-pydata-sphinx-theme = " \
 fontawesome-fonts-all \
 fontawesome-fonts-web \
 python3 \
 python3-accessible-pygments \
 python3-babel \
 python3-beautifulsoup4 \
 python3-docutils \
 python3-pygments \
 python3-sphinx \
 python3-typing-extensions \
 "
