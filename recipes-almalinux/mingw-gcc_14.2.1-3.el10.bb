# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-gcc"
PV = "14.2.1"
PR = "3.el10"
PACKAGES:x86_64_v2 = " \
 mingw32-cpp \
 mingw32-gcc \
 mingw32-gcc-c++ \
 mingw32-libgcc \
 mingw32-libstdc++ \
 mingw64-cpp \
 mingw64-gcc \
 mingw64-gcc-c++ \
 mingw64-libgcc \
 mingw64-libstdc++ \
"
PACKAGES:aarch64 = " \
 mingw32-cpp \
 mingw32-gcc \
 mingw32-gcc-c++ \
 mingw32-libgcc \
 mingw64-cpp \
 mingw64-gcc \
 mingw64-gcc-c++ \
 mingw64-libgcc \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-gcc-14.2.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0bb5854b15b530159c9bd47b017b23d19edf98e6f10537274cade44acd4cc03c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-cpp-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-cpp;unpack=0"
SRC_URI[x86_64_v2_mingw32-cpp.sha256sum] = "4dad7916d626ace9d22d8f98454d73fa52c462d0fa3b26c80e5e0eb804e0d240"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-gcc-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-gcc;unpack=0"
SRC_URI[x86_64_v2_mingw32-gcc.sha256sum] = "53e5cf7a735564e1daff57e55e141ff3aa74ff11ab5bcc95230eaa86832b352b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-gcc-c++-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-gcc-c++;unpack=0"
SRC_URI[x86_64_v2_mingw32-gcc-c++.sha256sum] = "9d89df86f38a839f36888c47a1204ab5c99c4faaeaf96886f196d45daab40cda"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-libgcc-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-libgcc;unpack=0"
SRC_URI[x86_64_v2_mingw32-libgcc.sha256sum] = "74c5cf57baa0669bad46e00afce04480e62106f55176cbd70513fcd27443dc30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-libstdc++-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-libstdc++;unpack=0"
SRC_URI[x86_64_v2_mingw32-libstdc++.sha256sum] = "d0419a667faa9eb68d2afbd93ed87cff159ddd7e0ce421535a78f431c44b724a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-cpp-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-cpp;unpack=0"
SRC_URI[x86_64_v2_mingw64-cpp.sha256sum] = "8dcee9f90578100a46402cde0b9484573705a1043d9d0c4621ff181ee17dbdcf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-gcc-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-gcc;unpack=0"
SRC_URI[x86_64_v2_mingw64-gcc.sha256sum] = "d56ad43be8e5c1342300706df2549309891e5625d64c9293dcae4ffa88d92608"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-gcc-c++-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-gcc-c++;unpack=0"
SRC_URI[x86_64_v2_mingw64-gcc-c++.sha256sum] = "515e848ab55292fdd5604e2107fe1d32f2fc84229ef6efbfd6677285f29bdcc2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-libgcc-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-libgcc;unpack=0"
SRC_URI[x86_64_v2_mingw64-libgcc.sha256sum] = "8f5ca786b60f735ded72dcbedab4b1aa2c147e7ab7c1dbf67d6fabcf3797b7ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-libstdc++-14.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-libstdc++;unpack=0"
SRC_URI[x86_64_v2_mingw64-libstdc++.sha256sum] = "0030ea85b03f4651989c91882a0c344b40b2dac28cb801ec075befc757076d36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-cpp-14.2.1-3.el10.aarch64.rpm;name=aarch64_mingw32-cpp;unpack=0"
SRC_URI[aarch64_mingw32-cpp.sha256sum] = "f794310cf14d3d195b8593add6ac93269865f19e972c1c9043f00017dec09da4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-gcc-14.2.1-3.el10.aarch64.rpm;name=aarch64_mingw32-gcc;unpack=0"
SRC_URI[aarch64_mingw32-gcc.sha256sum] = "d64ace72226e6cd62217abfb3e819821c33b410943a04077aa8739f483005474"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-gcc-c++-14.2.1-3.el10.aarch64.rpm;name=aarch64_mingw32-gcc-c++;unpack=0"
SRC_URI[aarch64_mingw32-gcc-c++.sha256sum] = "3a9db75a47eba4b4e682117d6bc60b76a085fe401e86d38f89fddc0cf09f0c1c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-libgcc-14.2.1-3.el10.aarch64.rpm;name=aarch64_mingw32-libgcc;unpack=0"
SRC_URI[aarch64_mingw32-libgcc.sha256sum] = "3845f9841e4e34a8e2484e5b9f82dcc36f845037a11066c4ebb87f6226ff613b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-cpp-14.2.1-3.el10.aarch64.rpm;name=aarch64_mingw64-cpp;unpack=0"
SRC_URI[aarch64_mingw64-cpp.sha256sum] = "9c796d8c71d0405d18dd7c3c1f5f7998db0b946e02f504c4e06f9b7a206d5233"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-gcc-14.2.1-3.el10.aarch64.rpm;name=aarch64_mingw64-gcc;unpack=0"
SRC_URI[aarch64_mingw64-gcc.sha256sum] = "4400cbafe0ad53edbaee3ae255f0d22b4b623ffdf4ad583f49eae6398f22f8f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-gcc-c++-14.2.1-3.el10.aarch64.rpm;name=aarch64_mingw64-gcc-c++;unpack=0"
SRC_URI[aarch64_mingw64-gcc-c++.sha256sum] = "177223b2bfdacea0360990101dff50b788ee5e254957afb69c9caf63468adc67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-libgcc-14.2.1-3.el10.aarch64.rpm;name=aarch64_mingw64-libgcc;unpack=0"
SRC_URI[aarch64_mingw64-libgcc.sha256sum] = "ebdb201856b18b9a6446aab14c11fa03a09dc08f501a55fc2724c2a931de60a5"

RDEPENDS:mingw32-cpp = " \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-filesystem \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw32-gcc = " \
 bash \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-binutils \
 mingw32-cpp \
 mingw32-crt \
 mingw32-headers \
 mingw32-libgcc \
 mingw32-winpthreads-static \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw32-gcc-c++ = " \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-gcc \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw32-libgcc = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-winpthreads \
 "
RDEPENDS:mingw32-libstdc++ = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 mingw32-winpthreads \
 "
RDEPENDS:mingw64-cpp = " \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw64-filesystem \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw64-gcc = " \
 bash \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw64-binutils \
 mingw64-cpp \
 mingw64-crt \
 mingw64-headers \
 mingw64-libgcc \
 mingw64-winpthreads-static \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw64-gcc-c++ = " \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw64-gcc \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw64-libgcc = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-winpthreads \
 "
RDEPENDS:mingw64-libstdc++ = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libgcc \
 mingw64-winpthreads \
 "
