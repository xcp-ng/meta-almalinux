# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-bignum"
PV = "0.67"
PR = "512.el10"
PACKAGES = " \
 perl-bignum \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-bignum-0.67-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed821cd6d5cd40a6f651d85631bd8bf3df9448f13e14c7ffd4510ce94b451887"

URI_x86_64_v2_perl-bignum = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-bignum-0.67-512.el10.noarch.rpm;name=x86_64_v2_perl-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-bignum}"
SRC_URI[x86_64_v2_perl-bignum.sha256sum] = "93cc32a35c0b74c751bd1351dc9547f34cb5ac6d6b0fe78631b33bb29192a0e1"

URI_aarch64_perl-bignum = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-bignum-0.67-512.el10.noarch.rpm;name=aarch64_perl-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-bignum}"
SRC_URI[aarch64_perl-bignum.sha256sum] = "93cc32a35c0b74c751bd1351dc9547f34cb5ac6d6b0fe78631b33bb29192a0e1"

RDEPENDS:perl-bignum = " \
 perl-Carp \
 perl-Exporter \
 perl-Math-BigInt \
 perl-constant \
 perl-libs \
 perl-overload \
 "
