# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-traverse"
PV = "0.59.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-traverse+default-devel \
 rust-gix-traverse+sha1-devel \
 rust-gix-traverse+sha256-devel \
 rust-gix-traverse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-traverse-0.59.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c2b9fa4da04ab682284893aee157b2fa4d8a9f0ac8feddf0d26f314823b9726"

URI_x86_64_v2_rust-gix-traverse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse+default-devel-0.59.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse+default-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse+default-devel.sha256sum] = "66bcafc0e62161127960eb59cd612d3e276793576f9516a581b8e93c25d78f97"

URI_x86_64_v2_rust-gix-traverse+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse+sha1-devel-0.59.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse+sha1-devel.sha256sum] = "b69ca961a165f967eaab4719c9537965197f0a27ef0561b137593c963d134ad2"

URI_x86_64_v2_rust-gix-traverse+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse+sha256-devel-0.59.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse+sha256-devel.sha256sum] = "7a9d03c61edcfd617b417d1e290c39b7725b4a4afa383cf77a7ca339c3749ff1"

URI_x86_64_v2_rust-gix-traverse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-traverse-devel-0.59.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-traverse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-traverse-devel}"
SRC_URI[x86_64_v2_rust-gix-traverse-devel.sha256sum] = "1827e24306f89f9db53552ffc39f3726689287d9daba1beeec96e002b046881c"

URI_aarch64_rust-gix-traverse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse+default-devel-0.59.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-traverse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse+default-devel}"
SRC_URI[aarch64_rust-gix-traverse+default-devel.sha256sum] = "6fc045b9fd545bbf10acebdad98b038d48521bdc9186a8a18bf8ca8298c93e0d"

URI_aarch64_rust-gix-traverse+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse+sha1-devel-0.59.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-traverse+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse+sha1-devel}"
SRC_URI[aarch64_rust-gix-traverse+sha1-devel.sha256sum] = "61e768794d60136faf1ef417a0c8651a3ca978e866be92ac697cecc7c7e4841d"

URI_aarch64_rust-gix-traverse+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse+sha256-devel-0.59.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-traverse+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse+sha256-devel}"
SRC_URI[aarch64_rust-gix-traverse+sha256-devel.sha256sum] = "9a2d93ed8091428a42124553a3c1caf4b440c8c045ba86e6d83917270cacaaf4"

URI_aarch64_rust-gix-traverse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-traverse-devel-0.59.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-traverse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-traverse-devel}"
SRC_URI[aarch64_rust-gix-traverse-devel.sha256sum] = "1882b6aceb016edb1c3cece7e76cdc09a188650210df0adb44635d3498414e30"

RDEPENDS:rust-gix-traverse+default-devel = " \
 cargo \
 rust-gix-traverse-devel \
 "
RDEPENDS:rust-gix-traverse+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-traverse-devel \
 "
RDEPENDS:rust-gix-traverse+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-traverse-devel \
 "
RDEPENDS:rust-gix-traverse-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
