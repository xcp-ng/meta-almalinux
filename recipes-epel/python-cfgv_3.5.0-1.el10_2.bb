# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cfgv"
PV = "3.5.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-cfgv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cfgv-3.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45c3d6e901cf41764f2adadbd3b912527b7879b246cd74f10069c520d14e45e6"

URI_x86_64_v2_python3-cfgv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cfgv-3.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cfgv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cfgv}"
SRC_URI[x86_64_v2_python3-cfgv.sha256sum] = "d1e9eadce6197e184b90e1ce079e1a9b5f5448c6481f2b1d85abe181fec72149"

URI_aarch64_python3-cfgv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cfgv-3.5.0-1.el10_2.noarch.rpm;name=aarch64_python3-cfgv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cfgv}"
SRC_URI[aarch64_python3-cfgv.sha256sum] = "0e171d169b572395363c0e4e3094ab3a8ca10d632c61b919c02cd6096b899c7b"

RDEPENDS:python3-cfgv = " \
 python3 \
 "
