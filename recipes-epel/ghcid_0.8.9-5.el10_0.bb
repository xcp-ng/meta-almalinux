# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghcid"
PV = "0.8.9"
PR = "5.el10_0"
PACKAGES = " \
 ghc-ghcid \
 ghc-ghcid-devel \
 ghc-ghcid-doc \
 ghc-ghcid-prof \
 ghcid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghcid-0.8.9-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caaea753ba199452660d7ef0d6758a30d6760c3aa17a461f51edc5983a9bea28"

URI_x86_64_v2_ghc-ghcid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghcid-0.8.9-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghcid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghcid}"
SRC_URI[x86_64_v2_ghc-ghcid.sha256sum] = "69798e288b44e042615ddfbc5a374294f8e301b7f9353a8838454266696366e9"

URI_x86_64_v2_ghc-ghcid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghcid-devel-0.8.9-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghcid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghcid-devel}"
SRC_URI[x86_64_v2_ghc-ghcid-devel.sha256sum] = "e1abae68af3aeb16c4b3c7bfc97dcf46c5c3b1fe4289741dc44ab3fbf2375cf2"

URI_x86_64_v2_ghc-ghcid-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghcid-doc-0.8.9-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ghcid-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghcid-doc}"
SRC_URI[x86_64_v2_ghc-ghcid-doc.sha256sum] = "5b5f8fe4fdb25bca120ea13686046f6d02c2c940df361c0dc2acc9e38798e351"

URI_x86_64_v2_ghc-ghcid-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ghcid-prof-0.8.9-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ghcid-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ghcid-prof}"
SRC_URI[x86_64_v2_ghc-ghcid-prof.sha256sum] = "00ff23022bef90d4d7afe0c136c44dece82ba26ada47834e78bc5d58dbd215c9"

URI_x86_64_v2_ghcid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghcid-0.8.9-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghcid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghcid}"
SRC_URI[x86_64_v2_ghcid.sha256sum] = "3a29a6150ff775103ccde249c9c67eb2d0196d41e1fe2da0b4b40ea01300f089"

URI_aarch64_ghc-ghcid = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghcid-0.8.9-5.el10_0.aarch64.rpm;name=aarch64_ghc-ghcid;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghcid}"
SRC_URI[aarch64_ghc-ghcid.sha256sum] = "5f928db8df4c9560184e9acc50bfac1349b6e0228bac4bf785f7444a26c04bdb"

URI_aarch64_ghc-ghcid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghcid-devel-0.8.9-5.el10_0.aarch64.rpm;name=aarch64_ghc-ghcid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghcid-devel}"
SRC_URI[aarch64_ghc-ghcid-devel.sha256sum] = "ea17402ae98141aa1d93f61e3deb8c0725eb816609af0676d99bbabe9c298bd9"

URI_aarch64_ghc-ghcid-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghcid-doc-0.8.9-5.el10_0.noarch.rpm;name=aarch64_ghc-ghcid-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghcid-doc}"
SRC_URI[aarch64_ghc-ghcid-doc.sha256sum] = "43e100364236a94c44ed287667c9e8baca84a117ef94c0060023edb7ee7acb1d"

URI_aarch64_ghc-ghcid-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ghcid-prof-0.8.9-5.el10_0.aarch64.rpm;name=aarch64_ghc-ghcid-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ghcid-prof}"
SRC_URI[aarch64_ghc-ghcid-prof.sha256sum] = "0cbb72f33b974e334b5b72e2ad90425c8ffa38f67f233078a1ecdea0bb6f0b48"

URI_aarch64_ghcid = "${EPEL_MIRROR}/aarch64/Packages/g/ghcid-0.8.9-5.el10_0.aarch64.rpm;name=aarch64_ghcid;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghcid}"
SRC_URI[aarch64_ghcid.sha256sum] = "9e75a100e0a78308b53711f4c23aff89a9ca9c0d0c0b77366e846b240cbef2a7"

RDEPENDS:ghc-ghcid = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-clock \
 ghc-cmdargs \
 ghc-colour \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-extra \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ghcid-devel = " \
 ghc-ansi-terminal-devel \
 ghc-base-devel \
 ghc-cmdargs-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-extra-devel \
 ghc-filepath-devel \
 ghc-ghcid \
 ghc-process-devel \
 ghc-time-devel \
 "
RDEPENDS:ghc-ghcid-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ghcid-prof = " \
 ghc-ansi-terminal-prof \
 ghc-base-prof \
 ghc-cmdargs-prof \
 ghc-directory-prof \
 ghc-extra-prof \
 ghc-filepath-prof \
 ghc-ghcid-devel \
 ghc-process-prof \
 ghc-time-prof \
 "
RDEPENDS:ghcid = " \
 cabal-install \
 ghc-compiler \
 glibc \
 gmp \
 libffi \
 "
