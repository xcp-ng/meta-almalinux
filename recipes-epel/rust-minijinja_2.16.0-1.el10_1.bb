# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-minijinja"
PV = "2.16.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+custom_syntax-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+default-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+fuel-devel \
 rust-minijinja+indexmap-devel \
 rust-minijinja+internal_debug-devel \
 rust-minijinja+internal_safe_search-devel \
 rust-minijinja+json-devel \
 rust-minijinja+key_interning-devel \
 rust-minijinja+loop_controls-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja+preserve_order-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+serde_json-devel \
 rust-minijinja+speedups-devel \
 rust-minijinja+stacker-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja+unstable_machinery_serde-devel \
 rust-minijinja+urlencode-devel \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-minijinja-2.16.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72f9ea18ab60aecd60b69515a32126cfed9e121a47f2d0554ede594e6a670c2a"

URI_x86_64_v2_rust-minijinja+adjacent_loop_items-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+adjacent_loop_items-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+adjacent_loop_items-devel}"
SRC_URI[x86_64_v2_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "2b2c8ccabf5e1f0546edafcdf689a7d0506015108237f37d2f870023e8384b69"

URI_x86_64_v2_rust-minijinja+builtins-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+builtins-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+builtins-devel}"
SRC_URI[x86_64_v2_rust-minijinja+builtins-devel.sha256sum] = "a5f93c86a4b6f2b078329c4558fc9351faad2db85f50c80dc368565cc448b1e9"

URI_x86_64_v2_rust-minijinja+custom_syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+custom_syntax-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+custom_syntax-devel}"
SRC_URI[x86_64_v2_rust-minijinja+custom_syntax-devel.sha256sum] = "25ea4ff7bcbbe1a4da9d34f7ba0163d86f6567f173f87edd1156271e91c7e895"

URI_x86_64_v2_rust-minijinja+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+debug-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+debug-devel}"
SRC_URI[x86_64_v2_rust-minijinja+debug-devel.sha256sum] = "ded3a829cf6bb369be56d68c2cd19ffc4630189cf7e73b512bdcd92b94eb64a6"

URI_x86_64_v2_rust-minijinja+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+default-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+default-devel}"
SRC_URI[x86_64_v2_rust-minijinja+default-devel.sha256sum] = "c094ed7b812244cb870766b1d2e5dec3c2ba334c7ddff15212059a3b83523ae4"

URI_x86_64_v2_rust-minijinja+deserialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+deserialization-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+deserialization-devel}"
SRC_URI[x86_64_v2_rust-minijinja+deserialization-devel.sha256sum] = "69fa48bc698a67ab0db2240e4c071e8dd899dbc2062d15f21a8eed7e92954992"

URI_x86_64_v2_rust-minijinja+fuel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+fuel-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+fuel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+fuel-devel}"
SRC_URI[x86_64_v2_rust-minijinja+fuel-devel.sha256sum] = "8a06b973c8a5913612b2f14fcd42855f8e68f51bf2af27b7081cac1c7116afb9"

URI_x86_64_v2_rust-minijinja+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+indexmap-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+indexmap-devel}"
SRC_URI[x86_64_v2_rust-minijinja+indexmap-devel.sha256sum] = "74159ec949c86dca4b75207f3fbf0fd504bb2b3e28bd627992f0fd34dd642cf0"

URI_x86_64_v2_rust-minijinja+internal_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_debug-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+internal_debug-devel}"
SRC_URI[x86_64_v2_rust-minijinja+internal_debug-devel.sha256sum] = "a2f0d42dd0fb967244a87ed61830a42cf538253f646e0a18c8e7def193246a1c"

URI_x86_64_v2_rust-minijinja+internal_safe_search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_safe_search-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+internal_safe_search-devel}"
SRC_URI[x86_64_v2_rust-minijinja+internal_safe_search-devel.sha256sum] = "b0039b46c145a2f0470089a4e62bb6ab432ad59125725d330ff6f3a812c10e72"

URI_x86_64_v2_rust-minijinja+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+json-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+json-devel}"
SRC_URI[x86_64_v2_rust-minijinja+json-devel.sha256sum] = "25d89318d1ec5470f044d15ef7a06d7974fb050ae7305e4d1e11dba7ba73d25f"

URI_x86_64_v2_rust-minijinja+key_interning-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+key_interning-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+key_interning-devel}"
SRC_URI[x86_64_v2_rust-minijinja+key_interning-devel.sha256sum] = "2c0c72b34f3aaffbfe856a3d50e5e96eea2f2c77f6ec12800e2e59d4f106f25f"

URI_x86_64_v2_rust-minijinja+loop_controls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loop_controls-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+loop_controls-devel}"
SRC_URI[x86_64_v2_rust-minijinja+loop_controls-devel.sha256sum] = "bcbc4f21802e3239e5e13a0243654112101440af0b73d71b82a3de7177a12c53"

URI_x86_64_v2_rust-minijinja+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+macros-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+macros-devel}"
SRC_URI[x86_64_v2_rust-minijinja+macros-devel.sha256sum] = "b75bcc194034888857aec786fcda7c8b1e2f0afdae2cfad03422f53a870a6e57"

URI_x86_64_v2_rust-minijinja+multi_template-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+multi_template-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+multi_template-devel}"
SRC_URI[x86_64_v2_rust-minijinja+multi_template-devel.sha256sum] = "6f253c018c8f5b8683be6fb3195dbf21648d71c2a3f54f3aa331118a70601c9a"

URI_x86_64_v2_rust-minijinja+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+percent-encoding-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-minijinja+percent-encoding-devel.sha256sum] = "6e2b4334b237a28650c84ebab73bb3f4ed18fac91e33e61ec9343d78c89d034d"

URI_x86_64_v2_rust-minijinja+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+preserve_order-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-minijinja+preserve_order-devel.sha256sum] = "201ba57401a7683cd9abb93989efc3953407a4fce3f12f0df95b5871afe36f74"

URI_x86_64_v2_rust-minijinja+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+serde-devel}"
SRC_URI[x86_64_v2_rust-minijinja+serde-devel.sha256sum] = "0e2ab7b2e9743ee2d5cfe5acd7ba9e4a7249b1bde192369c24e88d85bfa13313"

URI_x86_64_v2_rust-minijinja+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde_json-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+serde_json-devel}"
SRC_URI[x86_64_v2_rust-minijinja+serde_json-devel.sha256sum] = "22c5e68377c82b831b244a0f47cd7ff1bba77d2a9dc2265884415db910d94edd"

URI_x86_64_v2_rust-minijinja+speedups-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+speedups-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+speedups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+speedups-devel}"
SRC_URI[x86_64_v2_rust-minijinja+speedups-devel.sha256sum] = "0a4351209a6a969513d982ef7838787d1a973aa0e78d1b24aa4a6c83d455a561"

URI_x86_64_v2_rust-minijinja+stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+stacker-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+stacker-devel}"
SRC_URI[x86_64_v2_rust-minijinja+stacker-devel.sha256sum] = "25dc830991271207136be7eb350f796ca765be9d3c43b923ba2c5c2eea186d5f"

URI_x86_64_v2_rust-minijinja+std_collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+std_collections-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+std_collections-devel}"
SRC_URI[x86_64_v2_rust-minijinja+std_collections-devel.sha256sum] = "2b793e83b90e3978bd823d609a11d687bbb5324af3737ec7f04e3a4085f8e365"

URI_x86_64_v2_rust-minijinja+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicase-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicase-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicase-devel.sha256sum] = "35541a785990d73c93723d3bb42a356c79f385a72143ee022a29a9565f581f47"

URI_x86_64_v2_rust-minijinja+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicode-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicode-devel.sha256sum] = "cbeaf734778c64731d8de9982650c456c98cd4f66c50896a936dc50c8b6f18c1"

URI_x86_64_v2_rust-minijinja+unicode-ident-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-ident-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicode-ident-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicode-ident-devel.sha256sum] = "3e21dff658c572363649a39828ab270878d6d1d74fe0660555dee3c19651d648"

URI_x86_64_v2_rust-minijinja+unstable_machinery-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unstable_machinery-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery-devel.sha256sum] = "376bcf82f0828e88adf144a25ff9f5be8e0897b65ab6b90ff3ce0ab3c4ad666a"

URI_x86_64_v2_rust-minijinja+unstable_machinery_serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery_serde-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unstable_machinery_serde-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "3f4f39131e2caabb617dca8d7f62aa193f44607ef8cf895106be06535f7f9fe0"

URI_x86_64_v2_rust-minijinja+urlencode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+urlencode-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+urlencode-devel}"
SRC_URI[x86_64_v2_rust-minijinja+urlencode-devel.sha256sum] = "5ba81c7bfeadb7a134860a519ac59f04610d8bbee00241e325c033bd075ba09d"

URI_x86_64_v2_rust-minijinja+v_htmlescape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+v_htmlescape-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+v_htmlescape-devel}"
SRC_URI[x86_64_v2_rust-minijinja+v_htmlescape-devel.sha256sum] = "e9806be6ccef355ed95f704ce775f719f487f9a5101bbd76e61eeaac1fcefdec"

URI_x86_64_v2_rust-minijinja-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja-devel-2.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja-devel}"
SRC_URI[x86_64_v2_rust-minijinja-devel.sha256sum] = "322c8196b7a95b7997babbc55cd2b535a012cceb76c2efe8c9f6011adb53f52f"

URI_aarch64_rust-minijinja+adjacent_loop_items-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+adjacent_loop_items-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+adjacent_loop_items-devel}"
SRC_URI[aarch64_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "d51bf6e5e1c2e4111027550b056377e516593e8e34ce1cac257258aed8ab8aa5"

URI_aarch64_rust-minijinja+builtins-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+builtins-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+builtins-devel}"
SRC_URI[aarch64_rust-minijinja+builtins-devel.sha256sum] = "65754c59835c76d8f77d4e9c6b0118bfa84ada74c9bdd85412dbb97e5de2d423"

URI_aarch64_rust-minijinja+custom_syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+custom_syntax-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+custom_syntax-devel}"
SRC_URI[aarch64_rust-minijinja+custom_syntax-devel.sha256sum] = "355a10f5a9ab038956af324b89e728ad812ee55518bd41f5e2ca09d82dc2befd"

URI_aarch64_rust-minijinja+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+debug-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+debug-devel}"
SRC_URI[aarch64_rust-minijinja+debug-devel.sha256sum] = "49befdaad80f0777580721539a536a254a1a84296bf2cac21d6ca2054275d941"

URI_aarch64_rust-minijinja+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+default-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+default-devel}"
SRC_URI[aarch64_rust-minijinja+default-devel.sha256sum] = "2278315951c17fef433a27fb979076a9dd2bf91c7ded8c51d5143400ceaf281f"

URI_aarch64_rust-minijinja+deserialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+deserialization-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+deserialization-devel}"
SRC_URI[aarch64_rust-minijinja+deserialization-devel.sha256sum] = "e945101137308a69464ed80838b300141a9a69b4599906faad600de25b653a10"

URI_aarch64_rust-minijinja+fuel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+fuel-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+fuel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+fuel-devel}"
SRC_URI[aarch64_rust-minijinja+fuel-devel.sha256sum] = "005cf0ac840c93ededa3bfd7745128cb39d511c2bd06a666b59d24effd0ae221"

URI_aarch64_rust-minijinja+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+indexmap-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+indexmap-devel}"
SRC_URI[aarch64_rust-minijinja+indexmap-devel.sha256sum] = "37d0f550a9cbb9fa3149e74eeb7bf07c2584ee251494d63719c73a776fe62737"

URI_aarch64_rust-minijinja+internal_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_debug-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+internal_debug-devel}"
SRC_URI[aarch64_rust-minijinja+internal_debug-devel.sha256sum] = "fd7c49ccc7cf7aa8072ab531a8ab2653cfeab847920049a6a0606649e86e2d26"

URI_aarch64_rust-minijinja+internal_safe_search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_safe_search-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+internal_safe_search-devel}"
SRC_URI[aarch64_rust-minijinja+internal_safe_search-devel.sha256sum] = "fc26046745c12fa8a3e6a95e7cca09797d5825407b4f841ecece833676043c96"

URI_aarch64_rust-minijinja+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+json-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+json-devel}"
SRC_URI[aarch64_rust-minijinja+json-devel.sha256sum] = "3a8ccbc368db1d333071f2a29d187ec18b8d210c463b10d31db4d84ceb299886"

URI_aarch64_rust-minijinja+key_interning-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+key_interning-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+key_interning-devel}"
SRC_URI[aarch64_rust-minijinja+key_interning-devel.sha256sum] = "30fe481c4012c5613aa37df019b5573166c2ca632eb2df34a4ccbc2d523e5037"

URI_aarch64_rust-minijinja+loop_controls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loop_controls-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+loop_controls-devel}"
SRC_URI[aarch64_rust-minijinja+loop_controls-devel.sha256sum] = "2929c2a52442663cb9b14ad1053ff212fe8172b2556c56136e4baf462f73e428"

URI_aarch64_rust-minijinja+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+macros-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+macros-devel}"
SRC_URI[aarch64_rust-minijinja+macros-devel.sha256sum] = "a88cac2715ce02a148642c4f5b6a294f2a40548940ae7cff48da4a41190ea5a2"

URI_aarch64_rust-minijinja+multi_template-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+multi_template-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+multi_template-devel}"
SRC_URI[aarch64_rust-minijinja+multi_template-devel.sha256sum] = "1d089e90927d4814c4e5f5f421fed91713e18e123b3a962133cc9cbc0abecfe0"

URI_aarch64_rust-minijinja+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+percent-encoding-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+percent-encoding-devel}"
SRC_URI[aarch64_rust-minijinja+percent-encoding-devel.sha256sum] = "1a9af56196c6dbc833accdd87dc880056da4c1a71a1bb9e636dba13910ce03db"

URI_aarch64_rust-minijinja+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+preserve_order-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+preserve_order-devel}"
SRC_URI[aarch64_rust-minijinja+preserve_order-devel.sha256sum] = "43c678b7b3a8c6f671647a1d15ef93af988a8f1dc4601e3774b8e3590e4328bb"

URI_aarch64_rust-minijinja+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+serde-devel}"
SRC_URI[aarch64_rust-minijinja+serde-devel.sha256sum] = "356d7af597942698eda11c7654c7b62eda822c667fa0795e669504eca0b8dfcb"

URI_aarch64_rust-minijinja+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde_json-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+serde_json-devel}"
SRC_URI[aarch64_rust-minijinja+serde_json-devel.sha256sum] = "99f2f2e0d28fccd6cfaf8854806ade84b7c8d2d2c2ada8a9561bca2776af6747"

URI_aarch64_rust-minijinja+speedups-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+speedups-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+speedups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+speedups-devel}"
SRC_URI[aarch64_rust-minijinja+speedups-devel.sha256sum] = "4fb7bd16b6b482d0583f324a9ae2bb523830128e98b1ee5f625c31f06d88fd19"

URI_aarch64_rust-minijinja+stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+stacker-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+stacker-devel}"
SRC_URI[aarch64_rust-minijinja+stacker-devel.sha256sum] = "f97e8332bf6784f73dd652b37de973b72a29d049e60a78cecedcb9a1205ae712"

URI_aarch64_rust-minijinja+std_collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+std_collections-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+std_collections-devel}"
SRC_URI[aarch64_rust-minijinja+std_collections-devel.sha256sum] = "0aea88502602c4ab60101efe015a73db5c3f51e72561d4adc23ea5e8663b5472"

URI_aarch64_rust-minijinja+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicase-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicase-devel}"
SRC_URI[aarch64_rust-minijinja+unicase-devel.sha256sum] = "2bbd01c394758ddb797c33c88fa19b0a9bf94f0fa3074ffdaec4b39fa4440d33"

URI_aarch64_rust-minijinja+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicode-devel}"
SRC_URI[aarch64_rust-minijinja+unicode-devel.sha256sum] = "ca0c63de7e2d93ff8d634400fad85c8b23ad3ade782eaacc2c9376d43aaafe77"

URI_aarch64_rust-minijinja+unicode-ident-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-ident-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicode-ident-devel}"
SRC_URI[aarch64_rust-minijinja+unicode-ident-devel.sha256sum] = "e578d97b1f0261040645ec687e2acc3eea4797002b955f68e889e6bd2d25072a"

URI_aarch64_rust-minijinja+unstable_machinery-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unstable_machinery-devel}"
SRC_URI[aarch64_rust-minijinja+unstable_machinery-devel.sha256sum] = "aaf7f92546b377d2469e313c7aa8e2892a2212cc574b4f9f51829312ec161230"

URI_aarch64_rust-minijinja+unstable_machinery_serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery_serde-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unstable_machinery_serde-devel}"
SRC_URI[aarch64_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "ffb9ed7f43bee4bde6be1f362ae16fde63b9c6a48b998f8f946220fdf7ac1222"

URI_aarch64_rust-minijinja+urlencode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+urlencode-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+urlencode-devel}"
SRC_URI[aarch64_rust-minijinja+urlencode-devel.sha256sum] = "7514280606d9ee2fdf0893e87edae663f8195bd946f2d751813bb43c75df6dc1"

URI_aarch64_rust-minijinja+v_htmlescape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+v_htmlescape-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+v_htmlescape-devel}"
SRC_URI[aarch64_rust-minijinja+v_htmlescape-devel.sha256sum] = "97acc289a6a6b684ca811cc5a2cc35c5b8b69a4b8375029f3aec314debcf47b2"

URI_aarch64_rust-minijinja-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja-devel-2.16.0-1.el10_1.noarch.rpm;name=aarch64_rust-minijinja-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja-devel}"
SRC_URI[aarch64_rust-minijinja-devel.sha256sum] = "b651d3701792afeb8168b0708cf50763be990251c48feae14217569aa794c91f"

RDEPENDS:rust-minijinja+adjacent_loop_items-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+builtins-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+custom_syntax-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+default-devel = " \
 cargo \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+deserialization-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+fuel-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_safe_search-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+json-devel = " \
 cargo \
 rust-minijinja+serde_json-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+key_interning-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loop_controls-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+macros-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+multi_template-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+percent-encoding-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-minijinja+preserve_order-devel = " \
 cargo \
 rust-minijinja+indexmap-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde_json-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-minijinja+speedups-devel = " \
 cargo \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+stacker-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-stacker+default-devel \
 "
RDEPENDS:rust-minijinja+std_collections-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicase-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-minijinja+unicode-devel = " \
 cargo \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicode-ident-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicode-ident+default-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery-devel = " \
 cargo \
 rust-minijinja+internal_debug-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery_serde-devel = " \
 cargo \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-minijinja+urlencode-devel = " \
 cargo \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+v_htmlescape-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-v_htmlescape+default-devel \
 "
RDEPENDS:rust-minijinja-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 "
