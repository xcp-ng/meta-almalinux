# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-tinytest"
PV = "1.4.3"
PR = "1.el10_2"
PACKAGES = " \
 R-tinytest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-tinytest-1.4.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0d8b106a656c56ab4dae57d945dc98b946352749ff85c2759fd94a55ac15f32"

URI_x86_64_v2_R-tinytest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-tinytest-1.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_R-tinytest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-tinytest}"
SRC_URI[x86_64_v2_R-tinytest.sha256sum] = "a196a1d21065d6d76ceb38806c3532c8dbee7bdbc321e97e19fb6c9e3726dee2"

URI_aarch64_R-tinytest = "${EPEL_MIRROR}/aarch64/Packages/r/R-tinytest-1.4.3-1.el10_2.noarch.rpm;name=aarch64_R-tinytest;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-tinytest}"
SRC_URI[aarch64_R-tinytest.sha256sum] = "3008e35a1eeef6820cf962017a5eef6494b4ebe4210297011a1db138a34967af"

RDEPENDS:R-tinytest = " \
 R-core \
 "
