# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-lite"
PV = "0.1.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-regex-lite+default-devel \
 rust-regex-lite+std-devel \
 rust-regex-lite+string-devel \
 rust-regex-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-lite-0.1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0dc0d62959538c01dddab837dba891ff4625d7694a89fcc3667a5797d2b2cdd"

URI_x86_64_v2_rust-regex-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite+default-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite+default-devel}"
SRC_URI[x86_64_v2_rust-regex-lite+default-devel.sha256sum] = "e3f7b70c727da69c8afe6d249cd224c1a5524c1397e4a082ed7af153fa2a9a04"

URI_x86_64_v2_rust-regex-lite+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite+std-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite+std-devel}"
SRC_URI[x86_64_v2_rust-regex-lite+std-devel.sha256sum] = "20b93cf4ce634e4e68a75f1ab0f90ac6d4bd127e97e947d68a61b604d63eeaf2"

URI_x86_64_v2_rust-regex-lite+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite+string-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite+string-devel}"
SRC_URI[x86_64_v2_rust-regex-lite+string-devel.sha256sum] = "6240617c1109ee0b5a6246ae62f2d7a19b9bd4b4ba880d43938dd022147ae20e"

URI_x86_64_v2_rust-regex-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-lite-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-lite-devel}"
SRC_URI[x86_64_v2_rust-regex-lite-devel.sha256sum] = "37e77a0291a1e4efa698e10769b1d1eb7a521597eae16ed139750faefd4dedca"

URI_aarch64_rust-regex-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite+default-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite+default-devel}"
SRC_URI[aarch64_rust-regex-lite+default-devel.sha256sum] = "c96a4ef9b9bbb880dc3f1d35bc0fb25a17d45035c2f718a2f29c67a05684dd0a"

URI_aarch64_rust-regex-lite+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite+std-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-lite+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite+std-devel}"
SRC_URI[aarch64_rust-regex-lite+std-devel.sha256sum] = "09d5b33d7748667c835c02de39b0e98c3f99bdb729f960648c1b73cb4348d5b7"

URI_aarch64_rust-regex-lite+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite+string-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-lite+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite+string-devel}"
SRC_URI[aarch64_rust-regex-lite+string-devel.sha256sum] = "e2297f4493c03a70960578626b454dec1bee396ddf5a27b2006463702aa2c2d4"

URI_aarch64_rust-regex-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-lite-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-regex-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-lite-devel}"
SRC_URI[aarch64_rust-regex-lite-devel.sha256sum] = "2b984282b68e29fcee035a6297d997470469e4bbdf039832a74ea004034488f6"

RDEPENDS:rust-regex-lite+default-devel = " \
 cargo \
 rust-regex-lite+std-devel \
 rust-regex-lite+string-devel \
 rust-regex-lite-devel \
 "
RDEPENDS:rust-regex-lite+std-devel = " \
 cargo \
 rust-regex-lite-devel \
 "
RDEPENDS:rust-regex-lite+string-devel = " \
 cargo \
 rust-regex-lite-devel \
 "
RDEPENDS:rust-regex-lite-devel = " \
 cargo \
 rust \
 "
