# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-version"
PE = "8"
PV = "0.99.32"
PR = "4.el10"
PACKAGES = " \
 perl-version \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-version-0.99.32-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69296532df793ff85c443f06cfe9dba66f08b55a195cd1656b0b2a8fc51c68c9"

URI_x86_64_v2_perl-version = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-version-0.99.32-4.el10.x86_64_v2.rpm;name=x86_64_v2_perl-version;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-version}"
SRC_URI[x86_64_v2_perl-version.sha256sum] = "997f8e8f5f7ed372da5849d1a66f3341fc66dc3c6a72affb086b2235820a0928"

URI_aarch64_perl-version = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-version-0.99.32-4.el10.aarch64.rpm;name=aarch64_perl-version;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-version}"
SRC_URI[aarch64_perl-version.sha256sum] = "60be5e5b2fe3dc9c3c28a838301e8f868578ba31d627d445a2f7f149b69463d5"

RDEPENDS:perl-version = " \
 glibc \
 perl-B \
 perl-Carp \
 perl-POSIX \
 perl-constant \
 perl-if \
 perl-libs \
 perl-locale \
 perl-overload \
 perl-version \
 "
