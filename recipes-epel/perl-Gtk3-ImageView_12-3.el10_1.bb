# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Gtk3-ImageView"
PV = "12"
PR = "3.el10_1"
PACKAGES = " \
 perl-Gtk3-ImageView \
 perl-Gtk3-ImageView-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Gtk3-ImageView-12-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "434b5de81c4ce89abfad0e3a8f3f263f0327d8c0ea8533c979c4f2d3be5eae2f"

URI_x86_64_v2_perl-Gtk3-ImageView = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-ImageView-12-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-ImageView;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-ImageView}"
SRC_URI[x86_64_v2_perl-Gtk3-ImageView.sha256sum] = "80da56d33a75df1d23abdef489944955736a913fc64b021dae1b453b6a2fadf0"

URI_x86_64_v2_perl-Gtk3-ImageView-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-ImageView-tests-12-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-ImageView-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-ImageView-tests}"
SRC_URI[x86_64_v2_perl-Gtk3-ImageView-tests.sha256sum] = "18359ed8045ff9e1a134809be73c1ca680c07fb8f62260114d38b5c76dec9034"

URI_aarch64_perl-Gtk3-ImageView = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-ImageView-12-3.el10_1.noarch.rpm;name=aarch64_perl-Gtk3-ImageView;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-ImageView}"
SRC_URI[aarch64_perl-Gtk3-ImageView.sha256sum] = "63fbef0c9db7ccf229366694e26acce17902869e476e08273a6d3b738c496edb"

URI_aarch64_perl-Gtk3-ImageView-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-ImageView-tests-12-3.el10_1.noarch.rpm;name=aarch64_perl-Gtk3-ImageView-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-ImageView-tests}"
SRC_URI[aarch64_perl-Gtk3-ImageView-tests.sha256sum] = "79e93d6b9cc0a2515ac1d374bdb340a06ace7d06a33e36f4504fd27e90d7f15f"

RDEPENDS:perl-Gtk3-ImageView = " \
 perl-Cairo \
 perl-Carp \
 perl-Glib \
 perl-Gtk3 \
 perl-Gtk3-ImageView \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-base \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-Gtk3-ImageView-tests = " \
 ImageMagick-perl \
 bash \
 mutter \
 perl-Carp-Always \
 perl-ExtUtils-MakeMaker \
 perl-File-Temp \
 perl-Glib \
 perl-Gtk3 \
 perl-Gtk3-ImageView \
 perl-MIME-Base64 \
 perl-PathTools \
 perl-Test-Deep \
 perl-Test-Harness \
 perl-Test-MockObject \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 virtual/coreutils \
 xwayland-run \
 "
