# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kr-fs"
PV = "0.1.0"
PR = "19.el10_0"
PACKAGES = " \
 golang-github-kr-fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kr-fs-0.1.0-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b34e14769b87f4668d07b47dff7189ad8fb302e5d01159bc8f2936b2651e4092"

URI_x86_64_v2_golang-github-kr-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-kr-fs-devel-0.1.0-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-kr-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-kr-fs-devel}"
SRC_URI[x86_64_v2_golang-github-kr-fs-devel.sha256sum] = "f80c86ce4ccea0c52bf998c46c18c0b0b068b38d6f96ce638012afc853dbd641"

URI_aarch64_golang-github-kr-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kr-fs-devel-0.1.0-19.el10_0.noarch.rpm;name=aarch64_golang-github-kr-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kr-fs-devel}"
SRC_URI[aarch64_golang-github-kr-fs-devel.sha256sum] = "e4acb7e8bb1478e42f624e0970cf0cd5d514873ace182356bebfa4a232b509d0"

RDEPENDS:golang-github-kr-fs-devel = " \
 go-filesystem \
 "
