# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata"
PV = "0.23.1"
PR = "3.el10_2"
PACKAGES = " \
 rust-cargo_metadata+builder-devel \
 rust-cargo_metadata+default-devel \
 rust-cargo_metadata+derive_builder-devel \
 rust-cargo_metadata-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata-0.23.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14565574036e7296c73ab17b6b553c1e040364328f2f1e5257a4f921f801aee2"

URI_x86_64_v2_rust-cargo_metadata+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+builder-devel-0.23.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+builder-devel.sha256sum] = "b355d1801eb90fe40c99f7885883370fc78a357c19d74834e09c66a6f24f183e"

URI_x86_64_v2_rust-cargo_metadata+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+default-devel-0.23.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+default-devel.sha256sum] = "4a779bf7f24e97e7556ea1518ad33deca3fc211e7a53dadd2c9b8523a9d010dd"

URI_x86_64_v2_rust-cargo_metadata+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata+derive_builder-devel-0.23.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata+derive_builder-devel.sha256sum] = "96f8f22becee467107b46d9c32657a9059d5b1835ac6b3e8f6275cdbd674a603"

URI_x86_64_v2_rust-cargo_metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata-devel-0.23.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata-devel.sha256sum] = "690f0950c8158cd9dc80f73f1a17ef1ddf20fbf816771d4698ed6a4a885bd944"

URI_aarch64_rust-cargo_metadata+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+builder-devel-0.23.1-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata+builder-devel.sha256sum] = "9802ae24b8c774d129ff16bc7081d593c049fc932aefca3ba40ed9188853d1be"

URI_aarch64_rust-cargo_metadata+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+default-devel-0.23.1-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata+default-devel.sha256sum] = "37a75a4d6ed43ecf097c4239f36a3d8da571f50af3e77aaabe56d575c3f9669a"

URI_aarch64_rust-cargo_metadata+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata+derive_builder-devel-0.23.1-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata+derive_builder-devel.sha256sum] = "9dfbed9466e7923bb2ad4991bcfcb13e65b956a725fdbe044c9fc6963e9b2f06"

URI_aarch64_rust-cargo_metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata-devel-0.23.1-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata-devel}"
SRC_URI[aarch64_rust-cargo_metadata-devel.sha256sum] = "3010b869bdd713984623e2bf2998bd7ebec01138b3059f1c3138c806c0acc0cf"

RDEPENDS:rust-cargo_metadata+builder-devel = " \
 cargo \
 rust-cargo_metadata+derive_builder-devel \
 rust-cargo_metadata-devel \
 "
RDEPENDS:rust-cargo_metadata+default-devel = " \
 cargo \
 rust-cargo_metadata-devel \
 "
RDEPENDS:rust-cargo_metadata+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror+default-devel \
 "
