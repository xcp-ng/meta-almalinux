# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordered-float4"
PV = "4.6.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-ordered-float4+arbitrary-devel \
 rust-ordered-float4+bytemuck-devel \
 rust-ordered-float4+default-devel \
 rust-ordered-float4+libm-devel \
 rust-ordered-float4+proptest-devel \
 rust-ordered-float4+rand-devel \
 rust-ordered-float4+randtest-devel \
 rust-ordered-float4+rkyv-devel \
 rust-ordered-float4+rkyv_16-devel \
 rust-ordered-float4+rkyv_32-devel \
 rust-ordered-float4+rkyv_64-devel \
 rust-ordered-float4+rkyv_ck-devel \
 rust-ordered-float4+serde-devel \
 rust-ordered-float4+std-devel \
 rust-ordered-float4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordered-float4-4.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5115d8cca8e4c4203d544a9ed16525ee7054f7fad4b4d9ec376e4be14ea3f940"

URI_x86_64_v2_rust-ordered-float4+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+arbitrary-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+arbitrary-devel.sha256sum] = "0706b2b5e3655a2a034fd3e3e9939c93bc90c9c833179d4454a56ef0739067e1"

URI_x86_64_v2_rust-ordered-float4+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+bytemuck-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+bytemuck-devel.sha256sum] = "bf6510d2d7a7ef8ac1e02a034534002cafa33d9df9f0a1c540589f90d63eb833"

URI_x86_64_v2_rust-ordered-float4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+default-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+default-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+default-devel.sha256sum] = "f1becf7bf4f8d7c8ab03fe354d194c5379f795bb62b4023f1d3c201585eaee74"

URI_x86_64_v2_rust-ordered-float4+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+libm-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+libm-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+libm-devel.sha256sum] = "56b73db03bc14b351c7ae1ff33d67032b691cf7c139ae8cd86125e0894006e6c"

URI_x86_64_v2_rust-ordered-float4+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+proptest-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+proptest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+proptest-devel.sha256sum] = "b4dd521ae1c58586a73fac3be788ba2b1aab00b6c989c70b908b2cec55741390"

URI_x86_64_v2_rust-ordered-float4+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+rand-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+rand-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+rand-devel.sha256sum] = "d5df14475fca3a501bcec8c8d09d7ece115fcae07a12576970380fd0ed7b4416"

URI_x86_64_v2_rust-ordered-float4+randtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+randtest-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+randtest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+randtest-devel.sha256sum] = "6ad008d203197ea3a4e38b1492eedf2f1c6c843a2073e24433b0ae7c86b9c359"

URI_x86_64_v2_rust-ordered-float4+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+rkyv-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+rkyv-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+rkyv-devel.sha256sum] = "6f0fc31377fbf7f1570734a1034f2ea15bb5a1b44f1b12f1cb6b7a15169a54a2"

URI_x86_64_v2_rust-ordered-float4+rkyv_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+rkyv_16-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+rkyv_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+rkyv_16-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+rkyv_16-devel.sha256sum] = "09659e6494f4ad30ad7d509524f64b4dd5f1f38ee2ba4af4fbb6e335c190ad94"

URI_x86_64_v2_rust-ordered-float4+rkyv_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+rkyv_32-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+rkyv_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+rkyv_32-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+rkyv_32-devel.sha256sum] = "32fe7976e9840b32555d473ff6949ca72dbeb05e1ca47e78084730280e5e6acd"

URI_x86_64_v2_rust-ordered-float4+rkyv_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+rkyv_64-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+rkyv_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+rkyv_64-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+rkyv_64-devel.sha256sum] = "3db05d36698e376bca9e928bba332ca0eb70a5c53532a95366bee4f67198f396"

URI_x86_64_v2_rust-ordered-float4+rkyv_ck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+rkyv_ck-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+rkyv_ck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+rkyv_ck-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+rkyv_ck-devel.sha256sum] = "bf7b59ac7801c7c6510cc8f5058181ca6dc9993df1de4e7fa2fdadaa6de021dd"

URI_x86_64_v2_rust-ordered-float4+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+serde-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+serde-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+serde-devel.sha256sum] = "a0c29f1ec64ce02dece7b01c319f41d9d5daeacf5e25f3fd6173870b98147eb5"

URI_x86_64_v2_rust-ordered-float4+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4+std-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4+std-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4+std-devel.sha256sum] = "7820403dd4a347444af726fee017bb9c71ae5708e4da86422e41f9a7ccb8e6db"

URI_x86_64_v2_rust-ordered-float4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float4-devel-4.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float4-devel}"
SRC_URI[x86_64_v2_rust-ordered-float4-devel.sha256sum] = "5c606e9aba5e662e21fb62c4b31909dcf899acd8aac8de8fd756a662b54e311c"

URI_aarch64_rust-ordered-float4+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+arbitrary-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+arbitrary-devel}"
SRC_URI[aarch64_rust-ordered-float4+arbitrary-devel.sha256sum] = "aadb65e978df3b6db85281c37b54fd2f67400da36ce20a5b2d1f79e3f84dde09"

URI_aarch64_rust-ordered-float4+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+bytemuck-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+bytemuck-devel}"
SRC_URI[aarch64_rust-ordered-float4+bytemuck-devel.sha256sum] = "e57040aa7a0a473f441fd5e7f6fec0b41240bf75f29e45104560051de3f36624"

URI_aarch64_rust-ordered-float4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+default-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+default-devel}"
SRC_URI[aarch64_rust-ordered-float4+default-devel.sha256sum] = "4d690f0a2eb6e9672838732a8d7a78f09e0f5d0772cea2d8c101a186791bb7c3"

URI_aarch64_rust-ordered-float4+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+libm-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+libm-devel}"
SRC_URI[aarch64_rust-ordered-float4+libm-devel.sha256sum] = "1885a6d55a6981053a8d9d159abcfff7e9f0b0ddf301c8e209316dc97f411f7d"

URI_aarch64_rust-ordered-float4+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+proptest-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+proptest-devel}"
SRC_URI[aarch64_rust-ordered-float4+proptest-devel.sha256sum] = "d80ee34ce0d169d51c2df5aa4764f724e6863e035fed4bad9b853bb508af99a0"

URI_aarch64_rust-ordered-float4+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+rand-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+rand-devel}"
SRC_URI[aarch64_rust-ordered-float4+rand-devel.sha256sum] = "6d0c97da65cc64aee3df4b0e2ac9884d4aeca57342e9a6c6c350e4d99380df30"

URI_aarch64_rust-ordered-float4+randtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+randtest-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+randtest-devel}"
SRC_URI[aarch64_rust-ordered-float4+randtest-devel.sha256sum] = "7e588e11b4b1fd45ad91076083dc8171b8c26b90bc69b9a14f88ffc8285ed358"

URI_aarch64_rust-ordered-float4+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+rkyv-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+rkyv-devel}"
SRC_URI[aarch64_rust-ordered-float4+rkyv-devel.sha256sum] = "375bc9cf2886e444c1a9957624136cef1c28ac9a905b275e24b0fd246f9907dc"

URI_aarch64_rust-ordered-float4+rkyv_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+rkyv_16-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+rkyv_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+rkyv_16-devel}"
SRC_URI[aarch64_rust-ordered-float4+rkyv_16-devel.sha256sum] = "5c36ee9f06b7cbe8475b52566c34c188610f2fe0eef4b942d9155d904acc7a2d"

URI_aarch64_rust-ordered-float4+rkyv_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+rkyv_32-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+rkyv_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+rkyv_32-devel}"
SRC_URI[aarch64_rust-ordered-float4+rkyv_32-devel.sha256sum] = "084d7a737c2b78ee4c0042ebce587f205f82be4328a756b5951a38701f7a09ec"

URI_aarch64_rust-ordered-float4+rkyv_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+rkyv_64-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+rkyv_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+rkyv_64-devel}"
SRC_URI[aarch64_rust-ordered-float4+rkyv_64-devel.sha256sum] = "3ce318396924979ba1be2cf48c5b219895c5d9399e5d56bcf853151a3ab024d0"

URI_aarch64_rust-ordered-float4+rkyv_ck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+rkyv_ck-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+rkyv_ck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+rkyv_ck-devel}"
SRC_URI[aarch64_rust-ordered-float4+rkyv_ck-devel.sha256sum] = "ba4ccfdb9750721e2be6881b7282cccfea107b45964a2f44e244701558467227"

URI_aarch64_rust-ordered-float4+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+serde-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+serde-devel}"
SRC_URI[aarch64_rust-ordered-float4+serde-devel.sha256sum] = "969a16e04543c37cc4598ce13eb11bc86304bfb91e01482b724d2bc512ad3535"

URI_aarch64_rust-ordered-float4+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4+std-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4+std-devel}"
SRC_URI[aarch64_rust-ordered-float4+std-devel.sha256sum] = "e2291c2075d6b4645bd5c7152148f4d32f2e6a2fd870511392d75c83ad7ca1ba"

URI_aarch64_rust-ordered-float4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float4-devel-4.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-ordered-float4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float4-devel}"
SRC_URI[aarch64_rust-ordered-float4-devel.sha256sum] = "19a16302bdbc2e02c20c110518f91a9b7e8008fcc1d88149530d4ed6939ec3ad"

RDEPENDS:rust-ordered-float4+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-ordered-float4-devel \
 "
RDEPENDS:rust-ordered-float4+bytemuck-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-ordered-float4-devel \
 "
RDEPENDS:rust-ordered-float4+default-devel = " \
 cargo \
 rust-ordered-float4+std-devel \
 rust-ordered-float4-devel \
 "
RDEPENDS:rust-ordered-float4+libm-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-ordered-float4-devel \
 "
RDEPENDS:rust-ordered-float4+proptest-devel = " \
 cargo \
 rust-ordered-float4-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-ordered-float4+rand-devel = " \
 cargo \
 rust-ordered-float4-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float4+randtest-devel = " \
 cargo \
 rust-ordered-float4-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float4+rkyv-devel = " \
 cargo \
 rust-ordered-float4+rkyv_32-devel \
 rust-ordered-float4-devel \
 "
RDEPENDS:rust-ordered-float4+rkyv_16-devel = " \
 cargo \
 rust-ordered-float4-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+size_16-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-ordered-float4+rkyv_32-devel = " \
 cargo \
 rust-ordered-float4-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-ordered-float4+rkyv_64-devel = " \
 cargo \
 rust-ordered-float4-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+size_64-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-ordered-float4+rkyv_ck-devel = " \
 cargo \
 rust-ordered-float4-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-ordered-float4+serde-devel = " \
 cargo \
 rust-ordered-float4-devel \
 rust-rand0.8+serde1-devel \
 rust-rand0.8-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ordered-float4+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-ordered-float4-devel \
 "
RDEPENDS:rust-ordered-float4-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
