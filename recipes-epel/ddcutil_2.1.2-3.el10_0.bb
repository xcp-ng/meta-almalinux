# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ddcutil"
PV = "2.1.2"
PR = "3.el10_0"
PACKAGES = " \
 ddcutil \
 libddcutil \
 libddcutil-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/ddcutil-2.1.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe40d3812c74b2e78ad39575f2ad9be8995a643f826e499de69e7c09dd64f2df"

URI_x86_64_v2_ddcutil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ddcutil-2.1.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ddcutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ddcutil}"
SRC_URI[x86_64_v2_ddcutil.sha256sum] = "80fe3da58fe0ad577cf2d62be632d01b387dcc432d07d37c9948eca65da53ade"

URI_x86_64_v2_libddcutil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libddcutil-2.1.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libddcutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libddcutil}"
SRC_URI[x86_64_v2_libddcutil.sha256sum] = "d36b771be8d98aff03dc653568e8d489cf28d26c785a40f43363f1be762f5620"

URI_x86_64_v2_libddcutil-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libddcutil-devel-2.1.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libddcutil-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libddcutil-devel}"
SRC_URI[x86_64_v2_libddcutil-devel.sha256sum] = "92272d7656f739e45b2b676b8a109bf3fd72340a468fe5364e7805db71c4af64"

URI_aarch64_ddcutil = "${EPEL_MIRROR}/aarch64/Packages/d/ddcutil-2.1.2-3.el10_0.aarch64.rpm;name=aarch64_ddcutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_ddcutil}"
SRC_URI[aarch64_ddcutil.sha256sum] = "4b3e745e1a8c5d1c50ee4f4bbd19f530fb270bdf85b65e38b2f00a922412c143"

URI_aarch64_libddcutil = "${EPEL_MIRROR}/aarch64/Packages/l/libddcutil-2.1.2-3.el10_0.aarch64.rpm;name=aarch64_libddcutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_libddcutil}"
SRC_URI[aarch64_libddcutil.sha256sum] = "5b012bf28bcc25275053b1484fcc2eb6d88545e7b14165d2577e535fe01f7c93"

URI_aarch64_libddcutil-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libddcutil-devel-2.1.2-3.el10_0.aarch64.rpm;name=aarch64_libddcutil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libddcutil-devel}"
SRC_URI[aarch64_libddcutil-devel.sha256sum] = "727bc403637fca4cf354568ef9de4c43b021fb5d82dbbf430a0e83a2328185e9"

RDEPENDS:ddcutil = " \
 glib2 \
 glibc \
 hwdata \
 i2c-tools \
 jansson \
 libdrm \
 libgcc \
 systemd-libs \
 "
RDEPENDS:libddcutil = " \
 glib2 \
 glibc \
 jansson \
 libdrm \
 libgcc \
 libusb1 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:libddcutil-devel = " \
 cmake-filesystem \
 libddcutil \
 pkgconf-pkg-config \
 "
