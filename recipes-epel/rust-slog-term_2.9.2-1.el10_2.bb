# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slog-term"
PV = "2.9.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-slog-term+default-devel \
 rust-slog-term+erased-serde-devel \
 rust-slog-term+nested-values-devel \
 rust-slog-term+serde-devel \
 rust-slog-term+serde_json-devel \
 rust-slog-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slog-term-2.9.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "436400ffc1b6e975e31198fd9a5b04e73a986edcb1e7e4c9a52bd0016dfdcd1e"

URI_x86_64_v2_rust-slog-term+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+default-devel-2.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+default-devel}"
SRC_URI[x86_64_v2_rust-slog-term+default-devel.sha256sum] = "c85c4d1c45fff180a2c775972c8afd1c21235fa977303cb66c249d61264198cf"

URI_x86_64_v2_rust-slog-term+erased-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+erased-serde-devel-2.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+erased-serde-devel}"
SRC_URI[x86_64_v2_rust-slog-term+erased-serde-devel.sha256sum] = "262b6449d3e8299a54d0b36cc9bae64578537bfd615cad929cb0ac626d43523e"

URI_x86_64_v2_rust-slog-term+nested-values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+nested-values-devel-2.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+nested-values-devel}"
SRC_URI[x86_64_v2_rust-slog-term+nested-values-devel.sha256sum] = "51eb342a3f74716190790a7a37d37a8e1e76efb7e4fa3fed5cd200c28cb4ca07"

URI_x86_64_v2_rust-slog-term+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+serde-devel-2.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+serde-devel}"
SRC_URI[x86_64_v2_rust-slog-term+serde-devel.sha256sum] = "aa06a774c6abc2e864cad4db8f69c3472c097ac5af2f51baf8f35dd8f2b3f3d7"

URI_x86_64_v2_rust-slog-term+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term+serde_json-devel-2.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term+serde_json-devel}"
SRC_URI[x86_64_v2_rust-slog-term+serde_json-devel.sha256sum] = "288671ebf6938dbf40e9d054eea31fb9019f1de7278fc47bc7dcdd1a3c695f09"

URI_x86_64_v2_rust-slog-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slog-term-devel-2.9.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slog-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slog-term-devel}"
SRC_URI[x86_64_v2_rust-slog-term-devel.sha256sum] = "107622f98f411efccd93a5a55da760b6ad993917c2530a62d616f3b631489b08"

URI_aarch64_rust-slog-term+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+default-devel-2.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-slog-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+default-devel}"
SRC_URI[aarch64_rust-slog-term+default-devel.sha256sum] = "1bf17931625262bd328cd3d5ed2f7ec03d8d75dd2cd89074fc6a9d2ea643094f"

URI_aarch64_rust-slog-term+erased-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+erased-serde-devel-2.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-slog-term+erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+erased-serde-devel}"
SRC_URI[aarch64_rust-slog-term+erased-serde-devel.sha256sum] = "93e7adcf3139ea4fcd2e04f5b0835e6b08c73c78ab31dd9732810fdc4b7bd079"

URI_aarch64_rust-slog-term+nested-values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+nested-values-devel-2.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-slog-term+nested-values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+nested-values-devel}"
SRC_URI[aarch64_rust-slog-term+nested-values-devel.sha256sum] = "3825514e62f3cbef6dd240f223da51758984cf0b1b051f9340893513dc044f57"

URI_aarch64_rust-slog-term+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+serde-devel-2.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-slog-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+serde-devel}"
SRC_URI[aarch64_rust-slog-term+serde-devel.sha256sum] = "e8e6478180492aaae033f064dec2b7c43c334ee31a1e1e63ac4a8cecc87c6ad1"

URI_aarch64_rust-slog-term+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term+serde_json-devel-2.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-slog-term+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term+serde_json-devel}"
SRC_URI[aarch64_rust-slog-term+serde_json-devel.sha256sum] = "d16b5faff7c4961bc7fd7749dc253044b4f9f69663f778b3d25797cb1e1ee991"

URI_aarch64_rust-slog-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slog-term-devel-2.9.2-1.el10_2.noarch.rpm;name=aarch64_rust-slog-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slog-term-devel}"
SRC_URI[aarch64_rust-slog-term-devel.sha256sum] = "b387decee18403a80b268ccc0bcb6eda6ddd15a0bdc0542269b5552d4cedd65b"

RDEPENDS:rust-slog-term+default-devel = " \
 cargo \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+erased-serde-devel = " \
 cargo \
 rust-erased-serde0.3+default-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+nested-values-devel = " \
 cargo \
 rust-slog+nested-values-devel \
 rust-slog-term+erased-serde-devel \
 rust-slog-term+serde-devel \
 rust-slog-term+serde_json-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-slog-term-devel \
 "
RDEPENDS:rust-slog-term-devel = " \
 cargo \
 rust \
 rust-chrono+default-devel \
 rust-is-terminal+default-devel \
 rust-slog+default-devel \
 rust-term+default-devel \
 rust-thread_local+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time-devel \
 "
