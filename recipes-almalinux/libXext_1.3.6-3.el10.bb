# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXext"
PV = "1.3.6"
PR = "3.el10"
PACKAGES = " \
 libXext \
 libXext-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXext-1.3.6-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c34a2dfe42ae5cc17b4f550029a8f2bca06d51e07796470c82ed34882c52f5e"

URI_x86_64_v2_libXext = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXext-1.3.6-3.el10.x86_64_v2.rpm;name=x86_64_v2_libXext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXext}"
SRC_URI[x86_64_v2_libXext.sha256sum] = "304b9904a670f759834d13a67e5aa92e8db3d5649a36a04d1a8530a6c6a2a645"

URI_x86_64_v2_libXext-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXext-devel-1.3.6-3.el10.x86_64_v2.rpm;name=x86_64_v2_libXext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXext-devel}"
SRC_URI[x86_64_v2_libXext-devel.sha256sum] = "10fc6e150be7faff5e33d4dd804bcec6b9b0b0f951d598b56800e87d71bf9753"

URI_aarch64_libXext = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXext-1.3.6-3.el10.aarch64.rpm;name=aarch64_libXext;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXext}"
SRC_URI[aarch64_libXext.sha256sum] = "a6faeb524d1acd75570b54dd3b66ff8fb0328d3383a819f7679e6780c1689dc3"

URI_aarch64_libXext-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXext-devel-1.3.6-3.el10.aarch64.rpm;name=aarch64_libXext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXext-devel}"
SRC_URI[aarch64_libXext-devel.sha256sum] = "0f78fdcf8925ff3e702ca408c05227ad3e3d29a162b4debf25d2144bd0dd693b"

RDEPENDS:libXext = " \
 glibc \
 libX11 \
 "
RDEPENDS:libXext-devel = " \
 libX11-devel \
 libXext \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
