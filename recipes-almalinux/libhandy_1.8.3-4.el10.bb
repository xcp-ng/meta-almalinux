# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libhandy"
PV = "1.8.3"
PR = "4.el10"
PACKAGES = " \
 libhandy \
 libhandy-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libhandy-1.8.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af09d0b9c8cd4c7462fd5780016957c72311e0f442e2eae46614e5345a41b340"

URI_x86_64_v2_libhandy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libhandy-1.8.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_libhandy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libhandy}"
SRC_URI[x86_64_v2_libhandy.sha256sum] = "6d94b5cbb1313195b7f88d3d731cb97af1c2316ddfcc94b89d9911fc3d2de745"

URI_x86_64_v2_libhandy-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libhandy-devel-1.8.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_libhandy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libhandy-devel}"
SRC_URI[x86_64_v2_libhandy-devel.sha256sum] = "5d5194f123cc2b6ad1844eeada2e1d52fa5f07b8d1ab353fef522a6129970cfa"

URI_aarch64_libhandy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libhandy-1.8.3-4.el10.aarch64.rpm;name=aarch64_libhandy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libhandy}"
SRC_URI[aarch64_libhandy.sha256sum] = "984b9d4cf9367123985da73d10e445af6b631626a90dc40facf16986deba4216"

URI_aarch64_libhandy-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libhandy-devel-1.8.3-4.el10.aarch64.rpm;name=aarch64_libhandy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libhandy-devel}"
SRC_URI[aarch64_libhandy-devel.sha256sum] = "b280711cdbdbb9de6b21cb2be38b8c2ebc53770b383ab8ad9b7c99000c0d24c0"

RDEPENDS:libhandy = " \
 atk \
 cairo \
 fribidi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libgcc \
 pango \
 "
RDEPENDS:libhandy-devel = " \
 gtk3-devel \
 libhandy \
 pkgconf-pkg-config \
 "
