# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyasynchat"
PV = "1.0.4"
PR = "1.el10_1"
PACKAGES = " \
 python3-pyasynchat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyasynchat-1.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d925fe44714c8fca2ede5263d6b3c5c7bdcfdf3424d957c59bc085e3d99c282f"

URI_x86_64_v2_python3-pyasynchat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyasynchat-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyasynchat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyasynchat}"
SRC_URI[x86_64_v2_python3-pyasynchat.sha256sum] = "7cdc17e2c926fcbafaabe37def9d2bd4395de7726e3cd947bd29311c84fdb496"

URI_aarch64_python3-pyasynchat = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyasynchat-1.0.4-1.el10_1.noarch.rpm;name=aarch64_python3-pyasynchat;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyasynchat}"
SRC_URI[aarch64_python3-pyasynchat.sha256sum] = "a4f76d5d4a34616ec6fd3763aeef5317ed452df23df956bc68641a96a58f20cb"

RDEPENDS:python3-pyasynchat = " \
 python3 \
 python3-pyasyncore \
 "
