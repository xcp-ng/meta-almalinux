# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-solid"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-solid \
 kf6-solid-devel \
 kf6-solid-doc \
 kf6-solid-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-solid-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0c883c17ac7b1773eb5030c85abd81717bb0a2ab51840f8cfde76e06056df2b"

URI_x86_64_v2_kf6-solid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid}"
SRC_URI[x86_64_v2_kf6-solid.sha256sum] = "bd1e6db073662c562bf01d241984c9885c3332896a607cdfaff0918ffd37e25a"

URI_x86_64_v2_kf6-solid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-devel}"
SRC_URI[x86_64_v2_kf6-solid-devel.sha256sum] = "29df922f03a834a5b3e9e1c8c8641b846e5942f777831b76f793d77dfaca35ce"

URI_x86_64_v2_kf6-solid-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-solid-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-doc}"
SRC_URI[x86_64_v2_kf6-solid-doc.sha256sum] = "2670c790132cdd85036f47baebc3d8267e2c8522db7faa49eaa39aae49095970"

URI_x86_64_v2_kf6-solid-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-solid-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-html}"
SRC_URI[x86_64_v2_kf6-solid-html.sha256sum] = "6cc838646624af57108718419d433eadda7ade4219b14347737136915778f7b4"

URI_aarch64_kf6-solid = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-solid;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid}"
SRC_URI[aarch64_kf6-solid.sha256sum] = "baab6ceb3ca79c29350841c5c7599e22b3c535db8e21c94ea6f6963afc9fe2e1"

URI_aarch64_kf6-solid-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-solid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-devel}"
SRC_URI[aarch64_kf6-solid-devel.sha256sum] = "64fa1d56a5235b3c76672c6e45df4887f2e14ac8b2cff8485e78ec5128bc300c"

URI_aarch64_kf6-solid-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-solid-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-doc}"
SRC_URI[aarch64_kf6-solid-doc.sha256sum] = "52f1a709baa08c2418f893cda9f3081b1a27b3cc7ad40ac4b047cbce98af3df7"

URI_aarch64_kf6-solid-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-solid-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-html}"
SRC_URI[aarch64_kf6-solid-html.sha256sum] = "b1ac33207c82a72cc33a8a3d66852cd9ca2a8b598613804dc827bdc5c8c48380"

RDEPENDS:kf6-solid = " \
 glibc \
 kf6-filesystem \
 libimobiledevice \
 libmount \
 libplist \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
RDEPENDS:kf6-solid-devel = " \
 cmake-filesystem \
 kf6-solid \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-solid-doc = " \
 "
RDEPENDS:kf6-solid-html = " \
 "
