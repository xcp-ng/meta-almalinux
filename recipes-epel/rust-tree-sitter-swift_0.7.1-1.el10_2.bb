# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-swift"
PV = "0.7.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-swift+default-devel \
 rust-tree-sitter-swift-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-swift-0.7.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "233843758f4348c45b3b258b91571eb2e1c18f206d7e00e00f0194c93b7e362a"

URI_x86_64_v2_rust-tree-sitter-swift+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-swift+default-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-swift+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-swift+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-swift+default-devel.sha256sum] = "d24cacd5021ebc1f7c78de306e8f21ba29cafa4027ae41c7acf681c38fba5e29"

URI_x86_64_v2_rust-tree-sitter-swift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-swift-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-swift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-swift-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-swift-devel.sha256sum] = "3d5cabc13e6c5be0ee4400251115d9aa6078bcc560899503207dd9468ca2e0e1"

URI_aarch64_rust-tree-sitter-swift+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-swift+default-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-swift+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-swift+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-swift+default-devel.sha256sum] = "f5f07c524079bd91a34cb06d39b24878271019a30b74b6a8fd2ef50ee3fc5e16"

URI_aarch64_rust-tree-sitter-swift-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-swift-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-swift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-swift-devel}"
SRC_URI[aarch64_rust-tree-sitter-swift-devel.sha256sum] = "865444d241be77fc5105d899649bd4ccdb37d218bbd7bf883d2f4389543a1bff"

RDEPENDS:rust-tree-sitter-swift+default-devel = " \
 cargo \
 rust-tree-sitter-swift-devel \
 "
RDEPENDS:rust-tree-sitter-swift-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
