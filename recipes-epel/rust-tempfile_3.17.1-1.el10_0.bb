# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tempfile"
PV = "3.17.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-tempfile+default-devel \
 rust-tempfile+getrandom-devel \
 rust-tempfile+nightly-devel \
 rust-tempfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tempfile-3.17.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9224bfb1f9eb8929dfad80334c9fe8ffb3c4c487a8579f07da49ba004b57101a"

URI_x86_64_v2_rust-tempfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+default-devel-3.17.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+default-devel}"
SRC_URI[x86_64_v2_rust-tempfile+default-devel.sha256sum] = "a44b3e5c33f45537746133083dc00a9e578a37ecb5181f8ab0a9e53512babccd"

URI_x86_64_v2_rust-tempfile+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+getrandom-devel-3.17.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+getrandom-devel}"
SRC_URI[x86_64_v2_rust-tempfile+getrandom-devel.sha256sum] = "b8cd776b6f9761844b2fca0d581fac7b7724411bd31f689a6bd306afc4f34db0"

URI_x86_64_v2_rust-tempfile+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+nightly-devel-3.17.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+nightly-devel}"
SRC_URI[x86_64_v2_rust-tempfile+nightly-devel.sha256sum] = "e021fa030b6dd6103eea40b3eb0704396e2da3328544ac3bc9604039c6176666"

URI_x86_64_v2_rust-tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile-devel-3.17.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile-devel}"
SRC_URI[x86_64_v2_rust-tempfile-devel.sha256sum] = "a704377bf5c34e4b6c3a74a7390db3d3de5805a07de6e97c715ab3cd63adc654"

URI_aarch64_rust-tempfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+default-devel-3.17.1-1.el10_0.noarch.rpm;name=aarch64_rust-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+default-devel}"
SRC_URI[aarch64_rust-tempfile+default-devel.sha256sum] = "9adbda200e722349312e31e2028a1950ccf91f1cbd26bd036280260f5b3c68b8"

URI_aarch64_rust-tempfile+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+getrandom-devel-3.17.1-1.el10_0.noarch.rpm;name=aarch64_rust-tempfile+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+getrandom-devel}"
SRC_URI[aarch64_rust-tempfile+getrandom-devel.sha256sum] = "c3e81321840b205bff122205538c04b59d57687534880cef445010f700d50b99"

URI_aarch64_rust-tempfile+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+nightly-devel-3.17.1-1.el10_0.noarch.rpm;name=aarch64_rust-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+nightly-devel}"
SRC_URI[aarch64_rust-tempfile+nightly-devel.sha256sum] = "2f773b79a898e877cc22f0712be688c7ca722a43d6a1aa16a05ea525e080360d"

URI_aarch64_rust-tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile-devel-3.17.1-1.el10_0.noarch.rpm;name=aarch64_rust-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile-devel}"
SRC_URI[aarch64_rust-tempfile-devel.sha256sum] = "b0da156b233df968c50badbc983c6d9bcb14e9fbfde11e78505289a59ccc8ea1"

RDEPENDS:rust-tempfile+default-devel = " \
 cargo \
 rust-tempfile+getrandom-devel \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile+getrandom-devel = " \
 cargo \
 rust-getrandom-devel \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile+nightly-devel = " \
 cargo \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-fastrand+default-devel \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 "
