# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeedu-data"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdeedu-data \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdeedu-data-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "77ffcdf89bf3901fd7a038d7efc8c1e877c609b4073484df2e4523f6c462737c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeedu-data-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kdeedu-data;unpack=0"
SRC_URI[x86_64_v2_kdeedu-data.sha256sum] = "8b21d521d9b79c0f1537e39bccb2b9ef9e3fd19f542a332e0993cee3a6fd0eee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdeedu-data-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kdeedu-data;unpack=0"
SRC_URI[aarch64_kdeedu-data.sha256sum] = "16ee516e348d45f6b28c7daea330c4f55173d9b808b9738fa365a8ec49fe4ac9"

RDEPENDS:kdeedu-data = " \
 hicolor-icon-theme \
 "
