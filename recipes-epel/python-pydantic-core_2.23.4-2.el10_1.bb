# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic-core"
PV = "2.23.4"
PR = "2.el10_1"
PACKAGES = " \
 python3-pydantic-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-core-2.23.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6fb55f65c6d70c61ad8e9472076cb95e18496edd6ae240360d1bcf09cdc7c78"

URI_x86_64_v2_python3-pydantic-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-core-2.23.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pydantic-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-core}"
SRC_URI[x86_64_v2_python3-pydantic-core.sha256sum] = "fc88ecda0bc381aca236618e6e3ea6719a1915b421520507d5e2a7a0d220d77c"

URI_aarch64_python3-pydantic-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-core-2.23.4-2.el10_1.aarch64.rpm;name=aarch64_python3-pydantic-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-core}"
SRC_URI[aarch64_python3-pydantic-core.sha256sum] = "de48b40c55992da14875a2d91326f18176799e19b5e84d6246fe38ff39ed7ba0"

RDEPENDS:python3-pydantic-core = " \
 glibc \
 libgcc \
 python3 \
 python3-typing-extensions \
 "
