# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libx86"
PV = "1.1"
PR = "44.el10_0"
PACKAGES:x86_64_v2 = " \
 libx86 \
 libx86-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libx86-1.1-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5be915f9d957d73c785da50992088e7b300671a598b701bf41249ae73dee57d2"

URI_x86_64_v2_libx86 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libx86-1.1-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libx86;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libx86}"
SRC_URI[x86_64_v2_libx86.sha256sum] = "8618051182dfba7e9233d5df5a63829727c4c648a68322510fe587ceb84d15c3"

URI_x86_64_v2_libx86-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libx86-devel-1.1-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libx86-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libx86-devel}"
SRC_URI[x86_64_v2_libx86-devel.sha256sum] = "fc20f67ebd3109b582096f395d8b76441fd33b823eb18e0f34caa11f0a1bd1e6"

RDEPENDS:libx86 = " \
 glibc \
 "
RDEPENDS:libx86-devel = " \
 libx86 \
 pkgconf-pkg-config \
 "
