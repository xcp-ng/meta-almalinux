# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hardinfo2"
PV = "2.2.16"
PR = "1.el10_2"
PACKAGES = " \
 hardinfo2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hardinfo2-2.2.16-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66632d620339ad3695ea2420d5f06585e3394ce4a67acfcaf4c2665d043e33c9"

URI_x86_64_v2_hardinfo2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hardinfo2-2.2.16-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hardinfo2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hardinfo2}"
SRC_URI[x86_64_v2_hardinfo2.sha256sum] = "2bc75c266967f16f985afce723460785266af3748e23ba1fef6967c6dd0c77a0"

URI_aarch64_hardinfo2 = "${EPEL_MIRROR}/aarch64/Packages/h/hardinfo2-2.2.16-1.el10_2.aarch64.rpm;name=aarch64_hardinfo2;unpack=0"
SRC_URI:append = " ${URI_aarch64_hardinfo2}"
SRC_URI[aarch64_hardinfo2.sha256sum] = "01a6c1617921dccab4f826c748b0063eb8c6bcacdbe9b3a6d1ad6ea3618a3909"

RDEPENDS:hardinfo2 = " \
 bash \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 json-glib \
 libX11 \
 libdecor \
 libgcc \
 libsoup3 \
 libstdc++ \
 libwayland-client \
 libxcb \
 pango \
 qt5-qtbase \
 qt5-qtbase-gui \
 vulkan-loader \
 "
