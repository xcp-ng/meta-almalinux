# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmenuedit"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kmenuedit \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmenuedit-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ba184fe3bc352356a0739901b3a01f39a83dfe31da998747bb3b53e8fd238c8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmenuedit-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmenuedit;unpack=0"
SRC_URI[x86_64_v2_kmenuedit.sha256sum] = "06291537f861f9fc7dc4e3e9adc74725ce221d40acf6300f08e4a07edd7a7296"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmenuedit-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kmenuedit;unpack=0"
SRC_URI[aarch64_kmenuedit.sha256sum] = "b1aa1bae5653939c025f2e437e9f5e6b6d5784f56efadf850ecbe89767f207a1"

RDEPENDS:kmenuedit = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
