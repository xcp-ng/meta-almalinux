# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Load"
PE = "1"
PV = "0.36"
PR = "511.el10"
PACKAGES = " \
 perl-Module-Load \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Module-Load-0.36-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c594d490f9dfc34513516d4e020bd6bbc8970ead4770f7c1894e334873e638f1"

URI_x86_64_v2_perl-Module-Load = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Module-Load-0.36-511.el10.noarch.rpm;name=x86_64_v2_perl-Module-Load;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Load}"
SRC_URI[x86_64_v2_perl-Module-Load.sha256sum] = "04b36e1069ef8dee690a71ae89c7c9c900d61ed5a26a15329effede65cb8b680"

URI_aarch64_perl-Module-Load = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Module-Load-0.36-511.el10.noarch.rpm;name=aarch64_perl-Module-Load;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Load}"
SRC_URI[aarch64_perl-Module-Load.sha256sum] = "04b36e1069ef8dee690a71ae89c7c9c900d61ed5a26a15329effede65cb8b680"

RDEPENDS:perl-Module-Load = " \
 perl-PathTools \
 perl-libs \
 "
