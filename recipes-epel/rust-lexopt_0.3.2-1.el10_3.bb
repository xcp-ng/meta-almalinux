# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexopt"
PV = "0.3.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-lexopt+default-devel \
 rust-lexopt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexopt-0.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a520a3c234eaf1f3f41b7acf4c222789e640334a92e0b78b5fe204d6bb4a85f6"

URI_x86_64_v2_rust-lexopt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexopt+default-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexopt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexopt+default-devel}"
SRC_URI[x86_64_v2_rust-lexopt+default-devel.sha256sum] = "f918cb565c556095ef91a05f1f3ec79fde6ffcb652ebc2b1311d222eccf4e9ef"

URI_x86_64_v2_rust-lexopt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexopt-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexopt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexopt-devel}"
SRC_URI[x86_64_v2_rust-lexopt-devel.sha256sum] = "e74b4c0036c20aae92f04244e37f6024fe28cba450bf66eb63641826b530e8f4"

URI_aarch64_rust-lexopt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexopt+default-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-lexopt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexopt+default-devel}"
SRC_URI[aarch64_rust-lexopt+default-devel.sha256sum] = "53a6d112466c5f66dd05362a4754f711c56d28943b49bd278f7e6ec9dcfc7957"

URI_aarch64_rust-lexopt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexopt-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-lexopt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexopt-devel}"
SRC_URI[aarch64_rust-lexopt-devel.sha256sum] = "3a3e673a7bdcc9f5d8b38b3a85ed4ebb8d5448296a0483e84af56df63704ebfb"

RDEPENDS:rust-lexopt+default-devel = " \
 cargo \
 rust-lexopt-devel \
 "
RDEPENDS:rust-lexopt-devel = " \
 cargo \
 "
