# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Perl-OSType"
PV = "1.010"
PR = "512.el10"
PACKAGES = " \
 perl-Perl-OSType \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Perl-OSType-1.010-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "683725397bbc65ad1587d1db30b489274153cbe2dad7c5791014d6aeda6967c0"

URI_x86_64_v2_perl-Perl-OSType = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Perl-OSType-1.010-512.el10.noarch.rpm;name=x86_64_v2_perl-Perl-OSType;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl-OSType}"
SRC_URI[x86_64_v2_perl-Perl-OSType.sha256sum] = "046d05fcff956d8c1a27e330da854acc6f53c3813ae884b4213140f8d0e9d610"

URI_aarch64_perl-Perl-OSType = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Perl-OSType-1.010-512.el10.noarch.rpm;name=aarch64_perl-Perl-OSType;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl-OSType}"
SRC_URI[aarch64_perl-Perl-OSType.sha256sum] = "046d05fcff956d8c1a27e330da854acc6f53c3813ae884b4213140f8d0e9d610"

RDEPENDS:perl-Perl-OSType = " \
 perl-Exporter \
 perl-libs \
 "
