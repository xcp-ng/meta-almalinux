# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "copr-cli"
PV = "2.7"
PR = "1.el10_3"
PACKAGES = " \
 copr-cli \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/copr-cli-2.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a5373c33a65b30bc61039ccf079c2d7f88712496908190dd57372bf2c8b238d6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/copr-cli-2.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_copr-cli;unpack=0"
SRC_URI[x86_64_v2_copr-cli.sha256sum] = "2dcbb8fdf5a57586dd9efa5fc9a70e3a70aea4895d3f2d213f80c845ac94b645"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/copr-cli-2.7-1.el10_3.noarch.rpm;name=aarch64_copr-cli;unpack=0"
SRC_URI[aarch64_copr-cli.sha256sum] = "42f08ffe2e81de7d11cf88919fe0f008234e5704a77f16868b2944239b4742c4"

RDEPENDS:copr-cli = " \
 python3 \
 python3-copr \
 python3-humanize \
 python3-jinja2 \
 python3-koji \
 python3-rich \
 python3-setuptools \
 python3-typing-extensions \
 wget \
 "
