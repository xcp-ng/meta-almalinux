# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dl-fedora"
PV = "2.1"
PR = "1.el10_0"
PACKAGES = " \
 dl-fedora \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dl-fedora-2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5a3ab2cde9e07940e8d1bc6282362d0c42c31b3915f04cc417e43ee9ca62b679"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dl-fedora-2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dl-fedora;unpack=0"
SRC_URI[x86_64_v2_dl-fedora.sha256sum] = "70aa21544881d752a1e34bb0609c8dfe4cfeb17447c94f433be8837a07958f3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dl-fedora-2.1-1.el10_0.aarch64.rpm;name=aarch64_dl-fedora;unpack=0"
SRC_URI[aarch64_dl-fedora.sha256sum] = "1eb5f543345bbb644bce7a912bbeafe000e8e6cce77234099098c4e3c689c17f"

RDEPENDS:dl-fedora = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 zlib-ng-compat \
 "
