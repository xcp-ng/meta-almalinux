# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unty"
PV = "0.0.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-unty+default-devel \
 rust-unty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unty-0.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cefe83d95d0e500d0adf5307490f43ec4f0ff0ee1476c095e2d8ac10d0741b8"

URI_x86_64_v2_rust-unty+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unty+default-devel-0.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unty+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unty+default-devel}"
SRC_URI[x86_64_v2_rust-unty+default-devel.sha256sum] = "53399258cfc765ad7d98e5c2874882a47d95b81480f1c371fc2f7ab7278a5360"

URI_x86_64_v2_rust-unty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unty-devel-0.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unty-devel}"
SRC_URI[x86_64_v2_rust-unty-devel.sha256sum] = "15113e1c4d1af58d913b7f758bb544557a9c8dabaeccf15f3158560365bbbf9b"

URI_aarch64_rust-unty+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unty+default-devel-0.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-unty+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unty+default-devel}"
SRC_URI[aarch64_rust-unty+default-devel.sha256sum] = "4b612fb97d986c98ff65469e1358b98e0ca8c0b2fa6c24a8b3978e065096ac2b"

URI_aarch64_rust-unty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unty-devel-0.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-unty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unty-devel}"
SRC_URI[aarch64_rust-unty-devel.sha256sum] = "ef51692de4445867a65682d44e45df8a96467d770fd471589f373cae500d03e3"

RDEPENDS:rust-unty+default-devel = " \
 cargo \
 rust-unty-devel \
 "
RDEPENDS:rust-unty-devel = " \
 cargo \
 rust \
 "
