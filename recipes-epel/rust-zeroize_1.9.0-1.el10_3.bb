# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zeroize"
PV = "1.9.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-zeroize+aarch64-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize+default-devel \
 rust-zeroize+derive-devel \
 rust-zeroize+serde-devel \
 rust-zeroize+simd-devel \
 rust-zeroize+std-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zeroize-1.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "482d4057bd4170b17e153a189b28558a794ea1292409c619e470531fad40698c"

URI_x86_64_v2_rust-zeroize+aarch64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+aarch64-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+aarch64-devel}"
SRC_URI[x86_64_v2_rust-zeroize+aarch64-devel.sha256sum] = "a54bf7148fc9753f68016053673be666c3d34b20c3bf0e6dc1163291dab4d9a9"

URI_x86_64_v2_rust-zeroize+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+alloc-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+alloc-devel}"
SRC_URI[x86_64_v2_rust-zeroize+alloc-devel.sha256sum] = "90f45c7b8af62192e63160fa2acf0cd9cd1ad8d412d4e4e288929bce21ce4277"

URI_x86_64_v2_rust-zeroize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+default-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+default-devel}"
SRC_URI[x86_64_v2_rust-zeroize+default-devel.sha256sum] = "017798302eec77bd56629bd7d4d44b070d309273d2184e5642c50ab5635ade73"

URI_x86_64_v2_rust-zeroize+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+derive-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize+derive-devel.sha256sum] = "b0387fe7367e5de3cd02db8ac1af00464be9f569daaef6cb8ba22de47b669c55"

URI_x86_64_v2_rust-zeroize+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+serde-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+serde-devel}"
SRC_URI[x86_64_v2_rust-zeroize+serde-devel.sha256sum] = "1d14183961c3129f3737df8be823379892fa61898d16a134b6d673f0a5f643eb"

URI_x86_64_v2_rust-zeroize+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+simd-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+simd-devel}"
SRC_URI[x86_64_v2_rust-zeroize+simd-devel.sha256sum] = "5cc026a74a0aa9f61ca38bebe6c7f6c35c35b37e40a7791261fceeb49273f337"

URI_x86_64_v2_rust-zeroize+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+std-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+std-devel}"
SRC_URI[x86_64_v2_rust-zeroize+std-devel.sha256sum] = "3baeab6da58f9fcace62dfa0db8b11472e6b094dca1f16b6d623f89d53a24f4e"

URI_x86_64_v2_rust-zeroize+zeroize_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize+zeroize_derive-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize+zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize+zeroize_derive-devel}"
SRC_URI[x86_64_v2_rust-zeroize+zeroize_derive-devel.sha256sum] = "b1bb6efbca398b54eaf92dd85c03f798eb3511669030cc4a0034746c2d3caabc"

URI_x86_64_v2_rust-zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zeroize-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zeroize-devel}"
SRC_URI[x86_64_v2_rust-zeroize-devel.sha256sum] = "543b6fb0835ea3acbc71ba7dfde1cd0d225e1e1565811f259ccefd76d9c6e976"

URI_aarch64_rust-zeroize+aarch64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+aarch64-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize+aarch64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+aarch64-devel}"
SRC_URI[aarch64_rust-zeroize+aarch64-devel.sha256sum] = "99f562e3412015c6ec2494c39995d9e19a7e38c995c92bcac748a923daf4b633"

URI_aarch64_rust-zeroize+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+alloc-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+alloc-devel}"
SRC_URI[aarch64_rust-zeroize+alloc-devel.sha256sum] = "730f16ec3fe01ae18ef90d6feec836a06fa51514304a50cf91bffe29e5c984e6"

URI_aarch64_rust-zeroize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+default-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+default-devel}"
SRC_URI[aarch64_rust-zeroize+default-devel.sha256sum] = "8f6fbc77f7ef330cadad5ad3dd75b7a55fdbd92a175c54cde45c0bf42a5fdf16"

URI_aarch64_rust-zeroize+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+derive-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+derive-devel}"
SRC_URI[aarch64_rust-zeroize+derive-devel.sha256sum] = "de906a3bccb250e862c7f877835e3c2356200984f3e369bc2848d5ec2991337d"

URI_aarch64_rust-zeroize+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+serde-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+serde-devel}"
SRC_URI[aarch64_rust-zeroize+serde-devel.sha256sum] = "2b56be69280c8fd7415b05c75250c8e17d9ce27aad73e60155b3bac6b848b33b"

URI_aarch64_rust-zeroize+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+simd-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+simd-devel}"
SRC_URI[aarch64_rust-zeroize+simd-devel.sha256sum] = "5ad935facf855c56cb2d84b7ae0da1e2844e8b036909ae59dbfab0d8c2c5fd32"

URI_aarch64_rust-zeroize+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+std-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+std-devel}"
SRC_URI[aarch64_rust-zeroize+std-devel.sha256sum] = "474b496eb7ebf18ecb522a3bb15bb3b955619f3c6756f4b3130804f4e988f4ec"

URI_aarch64_rust-zeroize+zeroize_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize+zeroize_derive-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize+zeroize_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize+zeroize_derive-devel}"
SRC_URI[aarch64_rust-zeroize+zeroize_derive-devel.sha256sum] = "cb6e5086770eb07e56c7bb5bcd41d66d90a375fe2a67e6d24e8151714c599c09"

URI_aarch64_rust-zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zeroize-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zeroize-devel}"
SRC_URI[aarch64_rust-zeroize-devel.sha256sum] = "412d8c8d0398e609612eb89698294aa869ee0530aed69c423984ab9a02bae825"

RDEPENDS:rust-zeroize+aarch64-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+alloc-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+default-devel = " \
 cargo \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+derive-devel = " \
 cargo \
 rust-zeroize+zeroize_derive-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+simd-devel = " \
 cargo \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+std-devel = " \
 cargo \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-zeroize+zeroize_derive-devel = " \
 cargo \
 rust-zeroize-devel \
 rust-zeroize_derive+default-devel \
 "
RDEPENDS:rust-zeroize-devel = " \
 cargo \
 rust \
 "
