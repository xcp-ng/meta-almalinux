# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shim-unsigned-aarch64"
PV = "16.1"
PR = "2.el10.alma.1"
PACKAGES:x86_64_v2 = " \
  \
"
PACKAGES:aarch64 = " \
 shim-unsigned-aarch64 \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/shim-unsigned-aarch64-16.1-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f070da884bada36247972cc887694f95a6f725fee6f880f27b0df230bfe165bc"

URI_aarch64_shim-unsigned-aarch64 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/shim-unsigned-aarch64-16.1-2.el10.alma.1.aarch64.rpm;name=aarch64_shim-unsigned-aarch64;unpack=0"
SRC_URI:append = " ${URI_aarch64_shim-unsigned-aarch64}"
SRC_URI[aarch64_shim-unsigned-aarch64.sha256sum] = "ba443694d0735dedb955cdb6caba520f04f41de1bc9183819eb9d8f0011f88a9"

RDEPENDS:shim-unsigned-aarch64 = " \
 "
