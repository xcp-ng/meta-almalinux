# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-util"
PV = "1.0.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-lexical-util+compact-devel \
 rust-lexical-util+default-devel \
 rust-lexical-util+f128-devel \
 rust-lexical-util+f16-devel \
 rust-lexical-util+float16-devel \
 rust-lexical-util+format-devel \
 rust-lexical-util+lint-devel \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util+parse-integers-devel \
 rust-lexical-util+power-of-two-devel \
 rust-lexical-util+radix-devel \
 rust-lexical-util+std-devel \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util+write-integers-devel \
 rust-lexical-util-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-util-1.0.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d8eb3143b9f44732d7bf27e9cb42563841742ca4c4d16ede572a8bba23f55062"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+compact-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+compact-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+compact-devel.sha256sum] = "54eea55feda5f67d2825b04354d8252edc5aa8cd2a2ebec52decb40cc2d0dc4b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+default-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+default-devel.sha256sum] = "80e1d4615684220fba8d9fd60cbfb3c5f787f0c5f3f14604ec55f9e3b5a4dddf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+f128-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+f128-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+f128-devel.sha256sum] = "e6f25189da0da562d044cda248663e930d4dabd3caa7fe5b5334b8c16f6ea519"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+f16-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+f16-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+f16-devel.sha256sum] = "1ab57866af5d5dfb565156e0e68be4b9f653bcbbfacf1e52e67403442770b895"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+float16-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+float16-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+float16-devel.sha256sum] = "33f60bb38bf0b4c40696266b26c1e9641a267eab0acf2cb79fc7d13e887b98a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+format-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+format-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+format-devel.sha256sum] = "a5b32961e156714f009c0b2cfca2fd7589ef3f814aa439d81e1dbebaafcdb0b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+lint-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+lint-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+lint-devel.sha256sum] = "79031fe82c3108e4d501e1d1d00683a96d8b49b2e8f951f610a6380e41f16cd1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+parse-floats-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+parse-floats-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+parse-floats-devel.sha256sum] = "99fad54a55b0a1714c34951816d9ad72410f89464294c6fab5516189d6446a54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+parse-integers-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+parse-integers-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+parse-integers-devel.sha256sum] = "33690cea74e83d2944f7e309ddd8b74243ae7f53f6add13b2a12a324f0078e54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+power-of-two-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+power-of-two-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+power-of-two-devel.sha256sum] = "3a0022500da383c7c9f78fcaf63da7fbbd3e5c4f1be069ed6ae2b0e406200ce0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+radix-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+radix-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+radix-devel.sha256sum] = "f70c7f84a62be45f52034b7a6638d8441eaf25ce44bbf9193c74911eafa40447"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+std-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+std-devel.sha256sum] = "d3f3c2c559bc6d0fdcfb8f4d41f116721cdb7e22f6bda188d2dc12a268cfb807"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+write-floats-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+write-floats-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+write-floats-devel.sha256sum] = "80d1f5b14a8e9b84ad770e35fc0a0f15a5c59e5f1ecaed59aa5d74dbf9ccdd45"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util+write-integers-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util+write-integers-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util+write-integers-devel.sha256sum] = "5f5bde28406588187b7af759d51b026aff77ee4f266d578b0abfc74325dcc1e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-util-devel-1.0.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lexical-util-devel.sha256sum] = "d03d4e3f1377d826ce053a0620ed6b56457cab173654b9d494d8a6865a5abe59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+compact-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+compact-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+compact-devel.sha256sum] = "6c9e793e3cf23523602b836c45d58f4636d0eddaf9e079677e46474a834048e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+default-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+default-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+default-devel.sha256sum] = "6a96db746b14d0df60819f4a80ffb1018e9834ae81a06d493ce8af35f2d2e347"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+f128-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+f128-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+f128-devel.sha256sum] = "662af41956179f0bd44ab16027d45f7047aea892bc9407dbf110cf0baf2740b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+f16-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+f16-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+f16-devel.sha256sum] = "7ba227b2eb9a16ab874bb200791b854605d137760ba0eedb27e74951ca206d48"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+float16-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+float16-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+float16-devel.sha256sum] = "477eba9c658d9eb398fad8afd74b4ad91473614bed6b293ed97702bd3197cc97"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+format-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+format-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+format-devel.sha256sum] = "dc3ad3ed250a88cda19e6d61b5e7af8fc5d3a6134d5c23dd6582e9d2eff60d98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+lint-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+lint-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+lint-devel.sha256sum] = "f4a5c30f7e838031d9f311467d6482a3d8b5d0ebf1b6574f521da04f26de0857"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+parse-floats-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+parse-floats-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+parse-floats-devel.sha256sum] = "16dd3a0a3b792d62a23a7eb1e3d3bb9655b633b116431627834e1a2bbaebc78e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+parse-integers-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+parse-integers-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+parse-integers-devel.sha256sum] = "7902d423e1f24c70262f618f12cb0e42c20f99aef06c2c7ea711c0a76a28194b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+power-of-two-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+power-of-two-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+power-of-two-devel.sha256sum] = "052711b2d84d134141bd3cd6fcab12a681820b679c720fe73fc5a5fedbb482fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+radix-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+radix-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+radix-devel.sha256sum] = "5c0717c2195b99eadc909ce1fb945aa706dbaa1617702819fcffbf6c2f0a2abb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+std-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+std-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+std-devel.sha256sum] = "fb2c913ce765a0631b671264a1c7439a6f6048d37aafb1758b0f9d35525091c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+write-floats-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+write-floats-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+write-floats-devel.sha256sum] = "e93f66c1b0ede674bd731edd801ad5c5ff107e7d2a4fdd05c026ae522c016f3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util+write-integers-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util+write-integers-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util+write-integers-devel.sha256sum] = "c38a75cc60623be05c16788be4f510e6d542bdcb511f558176cf79eaf64e272f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-util-devel-1.0.7-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-util-devel;unpack=0"
SRC_URI[aarch64_rust-lexical-util-devel.sha256sum] = "3d243194310aa7943bea0cfe0f858f7b708bb0a5f952897d015e6f7765d15a51"

RDEPENDS:rust-lexical-util+compact-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+default-devel = " \
 cargo \
 rust-lexical-util+std-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+f128-devel = " \
 cargo \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+f16-devel = " \
 cargo \
 rust-lexical-util+float16-devel \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util+write-floats-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+float16-devel = " \
 cargo \
 rust-float16+default-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+format-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+lint-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+parse-floats-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+parse-integers-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+power-of-two-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+radix-devel = " \
 cargo \
 rust-lexical-util+power-of-two-devel \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+std-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+write-floats-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util+write-integers-devel = " \
 cargo \
 rust-lexical-util-devel \
 "
RDEPENDS:rust-lexical-util-devel = " \
 cargo \
 rust \
 "
