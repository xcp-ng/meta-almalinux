# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fastrand"
PV = "2.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-fastrand+alloc-devel \
 rust-fastrand+default-devel \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fastrand-2.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39d7cf0aa85424688ce522915077b45d702055c7cba67f0e5822034d78199471"

URI_x86_64_v2_rust-fastrand+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand+alloc-devel-2.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fastrand+alloc-devel}"
SRC_URI[x86_64_v2_rust-fastrand+alloc-devel.sha256sum] = "339c12657656690997207ff330e6b949a1e3354670ffd956ee8b27d1aa010962"

URI_x86_64_v2_rust-fastrand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand+default-devel-2.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fastrand+default-devel}"
SRC_URI[x86_64_v2_rust-fastrand+default-devel.sha256sum] = "ffcec7899a839d54936b450e3db4b038aaf14608f6df7f98c3cca35485fbf538"

URI_x86_64_v2_rust-fastrand+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand+std-devel-2.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fastrand+std-devel}"
SRC_URI[x86_64_v2_rust-fastrand+std-devel.sha256sum] = "8ec60b18cd7d0ec332cd8a6c5242aabc22eda05309774da2f2da25e2cca59fa1"

URI_x86_64_v2_rust-fastrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand-devel-2.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fastrand-devel}"
SRC_URI[x86_64_v2_rust-fastrand-devel.sha256sum] = "9aeffec817bd0331d2db516c49888acf635c99cfe64d15e144646d2839d7293e"

URI_aarch64_rust-fastrand+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand+alloc-devel-2.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-fastrand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fastrand+alloc-devel}"
SRC_URI[aarch64_rust-fastrand+alloc-devel.sha256sum] = "40a64f21e73c37a615e9b11774193bd0e0183b73652013aa6ff7fe932dd50f44"

URI_aarch64_rust-fastrand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand+default-devel-2.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-fastrand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fastrand+default-devel}"
SRC_URI[aarch64_rust-fastrand+default-devel.sha256sum] = "202a936fc79628fdcec4ad49dbb54636d9adcd03431c9880f48ed6b6cde28975"

URI_aarch64_rust-fastrand+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand+std-devel-2.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-fastrand+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fastrand+std-devel}"
SRC_URI[aarch64_rust-fastrand+std-devel.sha256sum] = "acbf75c96e45be0cb10c5616eb8f2ffa0209ab4b5cb4153c2f6f3ec2857f2389"

URI_aarch64_rust-fastrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand-devel-2.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-fastrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fastrand-devel}"
SRC_URI[aarch64_rust-fastrand-devel.sha256sum] = "9591b7916d8add8fd23106b3650bd89aa536aa2d28b7eda4694c304098f3504d"

RDEPENDS:rust-fastrand+alloc-devel = " \
 cargo \
 rust-fastrand-devel \
 "
RDEPENDS:rust-fastrand+default-devel = " \
 cargo \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 "
RDEPENDS:rust-fastrand+std-devel = " \
 cargo \
 rust-fastrand+alloc-devel \
 rust-fastrand-devel \
 "
RDEPENDS:rust-fastrand-devel = " \
 cargo \
 rust \
 "
