# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdkimpp"
PV = "2.0.0"
PR = "19.el10_0"
PACKAGES = " \
 libdkimpp \
 libdkimpp-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libdkimpp-2.0.0-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "14cfe9f02d1f0e4a0f0375fbf7d5f595feca85b6642f8674b4850273ad51c21d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdkimpp-2.0.0-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdkimpp;unpack=0"
SRC_URI[x86_64_v2_libdkimpp.sha256sum] = "93966c67c19b67e4718efb4c58fcb519776020582228fbcc16eb4372d7e4b872"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdkimpp-devel-2.0.0-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdkimpp-devel;unpack=0"
SRC_URI[x86_64_v2_libdkimpp-devel.sha256sum] = "d80fc3df62710bc8439cd3422366e148903d6bb4893a17d6698abea402639cb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdkimpp-2.0.0-19.el10_0.aarch64.rpm;name=aarch64_libdkimpp;unpack=0"
SRC_URI[aarch64_libdkimpp.sha256sum] = "49d26e4721f3dc71a77f889dab4c9e237427fbd833e724c29094065af6a4103e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdkimpp-devel-2.0.0-19.el10_0.aarch64.rpm;name=aarch64_libdkimpp-devel;unpack=0"
SRC_URI[aarch64_libdkimpp-devel.sha256sum] = "13ee19aa963ec68349a22b5bd905c22b51138445b50baa60ffed8354449d0812"

RDEPENDS:libdkimpp = " \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:libdkimpp-devel = " \
 libdkimpp \
 pkgconf-pkg-config \
 "
