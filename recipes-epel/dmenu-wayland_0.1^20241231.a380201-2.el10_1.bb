# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dmenu-wayland"
PV = "0.1^20241231.a380201"
PR = "2.el10_1"
PACKAGES = " \
 dmenu-wayland \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dmenu-wayland-0.1^20241231.a380201-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1e38f063537a0e2de0023bae3e191f1157c952086591e154dc17f8e3bbf5dcf7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dmenu-wayland-0.1^20241231.a380201-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dmenu-wayland;unpack=0"
SRC_URI[x86_64_v2_dmenu-wayland.sha256sum] = "e1a1e8c09ffe18c79694c974b2f1a3dba8a439e8b46b0bcc28bf07a6dacbae0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dmenu-wayland-0.1^20241231.a380201-2.el10_1.aarch64.rpm;name=aarch64_dmenu-wayland;unpack=0"
SRC_URI[aarch64_dmenu-wayland.sha256sum] = "7806ad986810120856395090c7fc8230ce53475b1d7ab8a75a11d564c680389c"

RDEPENDS:dmenu-wayland = " \
 bash \
 cairo \
 glib2 \
 glibc \
 libwayland-client \
 libxkbcommon \
 pango \
 "
