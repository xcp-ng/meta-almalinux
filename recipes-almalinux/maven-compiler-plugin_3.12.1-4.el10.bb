# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-compiler-plugin"
PV = "3.12.1"
PR = "4.el10"
PACKAGES = " \
 maven-compiler-plugin \
 maven-compiler-plugin-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-compiler-plugin-3.12.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f13406565c39e9bc699d852ee66f4e8bb3fe107820f0a7898f2b26193a406631"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-compiler-plugin-3.12.1-4.el10.noarch.rpm;name=x86_64_v2_maven-compiler-plugin;unpack=0"
SRC_URI[x86_64_v2_maven-compiler-plugin.sha256sum] = "93501f1183d5dac172ad892c0eb71603e5ca15527dcf630591b15983018435a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-compiler-plugin-javadoc-3.12.1-4.el10.noarch.rpm;name=x86_64_v2_maven-compiler-plugin-javadoc;unpack=0"
SRC_URI[x86_64_v2_maven-compiler-plugin-javadoc.sha256sum] = "2a6152d99e793a6123d43f7a01e70ddd6d0e766a3ba92768b00e489530ccdd73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-compiler-plugin-3.12.1-4.el10.noarch.rpm;name=aarch64_maven-compiler-plugin;unpack=0"
SRC_URI[aarch64_maven-compiler-plugin.sha256sum] = "93501f1183d5dac172ad892c0eb71603e5ca15527dcf630591b15983018435a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-compiler-plugin-javadoc-3.12.1-4.el10.noarch.rpm;name=aarch64_maven-compiler-plugin-javadoc;unpack=0"
SRC_URI[aarch64_maven-compiler-plugin-javadoc.sha256sum] = "2a6152d99e793a6123d43f7a01e70ddd6d0e766a3ba92768b00e489530ccdd73"

RDEPENDS:maven-compiler-plugin = " \
 javapackages-filesystem \
 maven-shared-incremental \
 maven-shared-utils \
 plexus-compiler \
 plexus-languages \
 plexus-utils \
 "
RDEPENDS:maven-compiler-plugin-javadoc = " \
 javapackages-filesystem \
 "
