# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-mobile"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-lookandfeel-fedora-mobile \
 plasma-mobile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-mobile-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22a65c7e43b8071a6fa07ab7304ea667431f957f30520546d1f77ebaf7927c2f"

URI_x86_64_v2_plasma-lookandfeel-fedora-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-lookandfeel-fedora-mobile-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-lookandfeel-fedora-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-lookandfeel-fedora-mobile}"
SRC_URI[x86_64_v2_plasma-lookandfeel-fedora-mobile.sha256sum] = "ec1aec4ec2073548d4cbefd26b1f373ddebbef21d84e2c6a8b36279bc6a5a791"

URI_x86_64_v2_plasma-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-mobile-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-mobile}"
SRC_URI[x86_64_v2_plasma-mobile.sha256sum] = "5533f9859e3657463ef1a5968d6c0f9f7233964548c2295757728e440af5cae2"

URI_aarch64_plasma-lookandfeel-fedora-mobile = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-lookandfeel-fedora-mobile-6.6.4-1.el10_2.noarch.rpm;name=aarch64_plasma-lookandfeel-fedora-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-lookandfeel-fedora-mobile}"
SRC_URI[aarch64_plasma-lookandfeel-fedora-mobile.sha256sum] = "cbea95e3d155ac02154c21b35fc6dcc75fb56427f37c4b404b373d8bf581d5b9"

URI_aarch64_plasma-mobile = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-mobile-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-mobile}"
SRC_URI[aarch64_plasma-mobile.sha256sum] = "5c494ec2669bf52c8709786020aecd90ae677b04f03d44480100ad53a195ff31"

RDEPENDS:plasma-lookandfeel-fedora-mobile = " \
 plasma-mobile \
 "
RDEPENDS:plasma-mobile = " \
 bash \
 glibc \
 kf6-bluez-qt \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-solid \
 kpipewire \
 kscreen \
 kwayland \
 kwin \
 kwin-libs \
 layer-shell-qt \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 plasma-activities \
 plasma-lookandfeel-fedora-mobile \
 plasma-milou \
 plasma-nano \
 plasma-nm \
 plasma-pa \
 plasma-workspace \
 qcoro-qt6 \
 qqc2-breeze-style \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 qt6-qtwayland \
 systemd-libs \
 virtual/system-backgrounds-kde \
 "
