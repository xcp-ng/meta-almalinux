# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksh"
PE = "3"
PV = "1.0.10"
PR = "5.el10_0.1"
PACKAGES = " \
 ksh \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ksh-1.0.10-5.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "965d4f68c98d91f2f49378393ff679c1a475e61def3a519c4e5936ee41d74c0b"

URI_x86_64_v2_ksh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ksh-1.0.10-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ksh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksh}"
SRC_URI[x86_64_v2_ksh.sha256sum] = "31bf4893eb436201d433bcd99b6927bcffbd88d9533750c87dc322ccf5d1f3f2"

URI_aarch64_ksh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ksh-1.0.10-5.el10_0.1.aarch64.rpm;name=aarch64_ksh;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksh}"
SRC_URI[aarch64_ksh.sha256sum] = "f173c4a25667d766c695c33d490bbec787a2fcd06d476bc38875392f3c40d4a5"

RDEPENDS:ksh = " \
 bash \
 diffutils \
 glibc \
 grep \
 sed \
 systemd \
 virtual/coreutils \
 "
