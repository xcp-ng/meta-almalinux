# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-macros"
PV = "2.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-tokio-macros+default-devel \
 rust-tokio-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-macros-2.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93743cf9b7935fe847d1f96cf0d4705b84263a27a3cefa43270c7a677f2e3a37"

URI_x86_64_v2_rust-tokio-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-macros+default-devel-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-macros+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-macros+default-devel.sha256sum] = "36d098a271c5d38dffb7cdc87b32b97e2383ac53970df2d7defda4f7e8743211"

URI_x86_64_v2_rust-tokio-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-macros-devel-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-macros-devel}"
SRC_URI[x86_64_v2_rust-tokio-macros-devel.sha256sum] = "db781e9724c2f25a347b67a6fe7df5d606418f83c5fb6e000224bbf35dee593d"

URI_aarch64_rust-tokio-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-macros+default-devel-2.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-macros+default-devel}"
SRC_URI[aarch64_rust-tokio-macros+default-devel.sha256sum] = "cfa90c8e2af24299e35134efcd5070d7da5edda5d036c43d85a00ba53d5fe66b"

URI_aarch64_rust-tokio-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-macros-devel-2.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-macros-devel}"
SRC_URI[aarch64_rust-tokio-macros-devel.sha256sum] = "f8f08d9adfc8aca31e1ace538ff688852fd8165baf2a4d455593f9f661e6dde6"

RDEPENDS:rust-tokio-macros+default-devel = " \
 cargo \
 rust-tokio-macros-devel \
 "
RDEPENDS:rust-tokio-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
