# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-rust"
PV = "0.23.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-rust+default-devel \
 rust-tree-sitter-rust-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-rust-0.23.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34c758a4fe3e59c78114f9b6bc9dfcce3057f117a50f923ff844915bfee17c59"

URI_x86_64_v2_rust-tree-sitter-rust+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-rust+default-devel-0.23.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-rust+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-rust+default-devel.sha256sum] = "8d7f81dc96a1dd643725a169126e455fde3915d9c56150bab30ecc1abfed85d9"

URI_x86_64_v2_rust-tree-sitter-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-rust-devel-0.23.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-rust-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-rust-devel.sha256sum] = "779682810aeae485bf881728b90f261ac066f2fdff2ac94d3b2f7a8c716ac274"

URI_aarch64_rust-tree-sitter-rust+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-rust+default-devel-0.23.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-rust+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-rust+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-rust+default-devel.sha256sum] = "63e484605ddca46bcd13c9e9e85f8d46226982f4914be2a0dbba5d9cfd512eaf"

URI_aarch64_rust-tree-sitter-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-rust-devel-0.23.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-rust-devel}"
SRC_URI[aarch64_rust-tree-sitter-rust-devel.sha256sum] = "96e6c3d53cead8ac2ac7929864b976c22468f3e18120c72d7dc5e696005364cd"

RDEPENDS:rust-tree-sitter-rust+default-devel = " \
 cargo \
 rust-tree-sitter-rust-devel \
 "
RDEPENDS:rust-tree-sitter-rust-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
