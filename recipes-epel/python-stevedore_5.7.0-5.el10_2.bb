# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-stevedore"
PV = "5.7.0"
PR = "5.el10_2"
PACKAGES = " \
 python3-stevedore \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-stevedore-5.7.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "812e14b4be735789e8fcfe9e7b4eeff66a2d461ee4f0c8364916b20f1e00cecc"

URI_x86_64_v2_python3-stevedore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-stevedore-5.7.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-stevedore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-stevedore}"
SRC_URI[x86_64_v2_python3-stevedore.sha256sum] = "03bc8947bbc234235ca5c484e90f1a5eb5c2a058d496ce9af7ef0cb96cfb6518"

URI_aarch64_python3-stevedore = "${EPEL_MIRROR}/aarch64/Packages/p/python3-stevedore-5.7.0-5.el10_2.noarch.rpm;name=aarch64_python3-stevedore;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-stevedore}"
SRC_URI[aarch64_python3-stevedore.sha256sum] = "453f9d00197877ce11a825842ff1197c056340081025bba8642514d523ed419c"

RDEPENDS:python3-stevedore = " \
 python3 \
 "
