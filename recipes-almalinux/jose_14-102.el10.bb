# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jose"
PV = "14"
PR = "102.el10"
PACKAGES = " \
 jose \
 libjose \
 libjose-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jose-14-102.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3907042f4d5937a564226e1408ff04be22cee7d7201b084e682921a15edd4f3b"

URI_x86_64_v2_jose = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jose-14-102.el10.x86_64_v2.rpm;name=x86_64_v2_jose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jose}"
SRC_URI[x86_64_v2_jose.sha256sum] = "ca722fad8600ed9096442658089a49cc551e22400a237eb1156782a61fb52dbd"

URI_x86_64_v2_libjose = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libjose-14-102.el10.x86_64_v2.rpm;name=x86_64_v2_libjose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjose}"
SRC_URI[x86_64_v2_libjose.sha256sum] = "39e7e9ae150e66bc9933c128f119cc822a994eb32aff18e6ca6dc5fd65bf0971"

URI_x86_64_v2_libjose-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libjose-devel-14-102.el10.x86_64_v2.rpm;name=x86_64_v2_libjose-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjose-devel}"
SRC_URI[x86_64_v2_libjose-devel.sha256sum] = "f9b8c00e0c74f7b8e0272cfee724cd76e52981970d6df84c487f62d11a6fc511"

URI_aarch64_jose = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jose-14-102.el10.aarch64.rpm;name=aarch64_jose;unpack=0"
SRC_URI:append = " ${URI_aarch64_jose}"
SRC_URI[aarch64_jose.sha256sum] = "9f2e30c3582ecd683d486a5f82fe22fd53c0ff90094abcea5ab94986a10e11db"

URI_aarch64_libjose = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libjose-14-102.el10.aarch64.rpm;name=aarch64_libjose;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjose}"
SRC_URI[aarch64_libjose.sha256sum] = "4d09d8768aff36081a391c88a38deb18cb5f434526a3a0c0c83812d9007d9988"

URI_aarch64_libjose-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libjose-devel-14-102.el10.aarch64.rpm;name=aarch64_libjose-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjose-devel}"
SRC_URI[aarch64_libjose-devel.sha256sum] = "03bde79fc752e53f3d2a9d67a47bf0e88c884592a80297ce7a9cf2750da5b86b"

RDEPENDS:jose = " \
 glibc \
 jansson \
 libgcc \
 libjose \
 "
RDEPENDS:libjose = " \
 glibc \
 jansson \
 libgcc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libjose-devel = " \
 jansson-devel \
 libjose \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
