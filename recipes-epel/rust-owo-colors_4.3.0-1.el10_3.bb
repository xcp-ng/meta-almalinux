# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-owo-colors"
PV = "4.3.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-owo-colors+alloc-devel \
 rust-owo-colors+default-devel \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors+supports-colors-devel \
 rust-owo-colors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-owo-colors-4.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b164fcb017a292692645b74c43fa306711dbe1616b2ce2771bc5e5dbc81b926"

URI_x86_64_v2_rust-owo-colors+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+alloc-devel-4.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+alloc-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+alloc-devel.sha256sum] = "d58276ae24d4d033cbd8b878006c9f260db4bc2c94389bd1ac7b07f34654fade"

URI_x86_64_v2_rust-owo-colors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+default-devel-4.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+default-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+default-devel.sha256sum] = "944821a89a5260ff73c76fa5578c6daa4d87740280a0eae2ca42f029198b2d3c"

URI_x86_64_v2_rust-owo-colors+supports-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-color-devel-4.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+supports-color-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+supports-color-devel.sha256sum] = "fca057016875f9988c381a1630c08cc6da87a55784ffebb05f1c4601af2aae77"

URI_x86_64_v2_rust-owo-colors+supports-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-colors-devel-4.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors+supports-colors-devel}"
SRC_URI[x86_64_v2_rust-owo-colors+supports-colors-devel.sha256sum] = "19750d171bb378bfaf1999db2b3940e3018db798b0c861570473e03d34b7b43f"

URI_x86_64_v2_rust-owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors-devel-4.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors-devel}"
SRC_URI[x86_64_v2_rust-owo-colors-devel.sha256sum] = "a50e8633038f5d9a5b8c3b59f09cc10e24767e619f84cbc1739db69bba299df6"
RPROVIDES:rust-owo-colors-devel:x86_64_v2 = "virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

URI_aarch64_rust-owo-colors+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+alloc-devel-4.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+alloc-devel}"
SRC_URI[aarch64_rust-owo-colors+alloc-devel.sha256sum] = "b1ac2eb8828af5cf16c24e8928652d42665ba46f34e2e9790667b597d0d4ec5c"

URI_aarch64_rust-owo-colors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+default-devel-4.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+default-devel}"
SRC_URI[aarch64_rust-owo-colors+default-devel.sha256sum] = "3c815c6c327dffd255a9e5c5f96a282bd8658c8ebfffc4df59b5262ce94c55f7"

URI_aarch64_rust-owo-colors+supports-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-color-devel-4.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+supports-color-devel}"
SRC_URI[aarch64_rust-owo-colors+supports-color-devel.sha256sum] = "70db02841dc456980b95f44181d1091b0669249328c20d569ce8047a4b7b1e11"

URI_aarch64_rust-owo-colors+supports-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-colors-devel-4.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors+supports-colors-devel}"
SRC_URI[aarch64_rust-owo-colors+supports-colors-devel.sha256sum] = "2af57b17583dabb219bd67a90e4ce3d697ab75c85513c7b6e38dcee12073f7c8"

URI_aarch64_rust-owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors-devel-4.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors-devel}"
SRC_URI[aarch64_rust-owo-colors-devel.sha256sum] = "279078caebef421cb0f0ebb9d7138ca388c94249012e397e45fe76469718cd3f"
RPROVIDES:rust-owo-colors-devel:aarch64 = "virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

RDEPENDS:rust-owo-colors+alloc-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+default-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+supports-color-devel = " \
 cargo \
 rust-owo-colors-devel \
 rust-supports-color+default-devel \
 "
RDEPENDS:rust-owo-colors+supports-colors-devel = " \
 cargo \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors-devel \
 rust-supports-color2+default-devel \
 "
RDEPENDS:rust-owo-colors-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"
