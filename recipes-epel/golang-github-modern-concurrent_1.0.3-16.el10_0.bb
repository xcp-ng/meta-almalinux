# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-modern-concurrent"
PV = "1.0.3"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-modern-concurrent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-modern-concurrent-1.0.3-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a9193c653d3e0a812b7499682c5d51c84750db49b3f620243d2c0dd798dcf9d"

URI_x86_64_v2_golang-github-modern-concurrent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-modern-concurrent-devel-1.0.3-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-modern-concurrent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-modern-concurrent-devel}"
SRC_URI[x86_64_v2_golang-github-modern-concurrent-devel.sha256sum] = "2bf4285a05af8e43d5a919c6b227c6af6cfc2008b7ccc6ae6dd86ad95c2e773a"

URI_aarch64_golang-github-modern-concurrent-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-modern-concurrent-devel-1.0.3-16.el10_0.noarch.rpm;name=aarch64_golang-github-modern-concurrent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-modern-concurrent-devel}"
SRC_URI[aarch64_golang-github-modern-concurrent-devel.sha256sum] = "4146898e2d6a7f810732f4a8b8eb19059267de42b7158b726ff3983b2940bd99"

RDEPENDS:golang-github-modern-concurrent-devel = " \
 go-filesystem \
 "
