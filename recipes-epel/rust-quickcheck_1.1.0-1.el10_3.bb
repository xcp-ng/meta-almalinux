# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quickcheck"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-quickcheck+default-devel \
 rust-quickcheck+env_logger-devel \
 rust-quickcheck+log-devel \
 rust-quickcheck+regex-devel \
 rust-quickcheck+use_logging-devel \
 rust-quickcheck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quickcheck-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c155fade31069e36ed3e469de8e749b724b8be8347d2d884fff46d337c899f82"

URI_x86_64_v2_rust-quickcheck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+default-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+default-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+default-devel.sha256sum] = "ba404d369b869648ae167114b5adcd0d08bef50687a904dee8661b6ad482d863"

URI_x86_64_v2_rust-quickcheck+env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+env_logger-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+env_logger-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+env_logger-devel.sha256sum] = "0ab59daf77cbf0486b3fa4c9d8e1a8d689646dd57170abb08cf536e718b2ad97"

URI_x86_64_v2_rust-quickcheck+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+log-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+log-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+log-devel.sha256sum] = "0ef163a40aca404d2ce8e73ffebe29af44510a8a04b2df5ad99b9185c4fbc25e"

URI_x86_64_v2_rust-quickcheck+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+regex-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+regex-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+regex-devel.sha256sum] = "77724be3ccc8675d6c9b3d06d57cea408126ac6eaeaaed4c8b25d43e540ef937"

URI_x86_64_v2_rust-quickcheck+use_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck+use_logging-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck+use_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck+use_logging-devel}"
SRC_URI[x86_64_v2_rust-quickcheck+use_logging-devel.sha256sum] = "7a7f4ce74082237914e67f0b1d855d6cbcdeed23d2a76162c01ad97edea239c9"

URI_x86_64_v2_rust-quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quickcheck-devel}"
SRC_URI[x86_64_v2_rust-quickcheck-devel.sha256sum] = "951755dd8e606952d6af0f15f56883d72ac4d20d1a42b3eafbf166dab94235e3"

URI_aarch64_rust-quickcheck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+default-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-quickcheck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+default-devel}"
SRC_URI[aarch64_rust-quickcheck+default-devel.sha256sum] = "1f78a2fc86031d15e114b956d37c908c02706a1f1048a3a08bc829781ebc2987"

URI_aarch64_rust-quickcheck+env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+env_logger-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-quickcheck+env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+env_logger-devel}"
SRC_URI[aarch64_rust-quickcheck+env_logger-devel.sha256sum] = "0108b8d0a63c8069f679aef66c5bb6d8fd60f7c27930ce1a535c08baf4e3ce8a"

URI_aarch64_rust-quickcheck+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+log-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-quickcheck+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+log-devel}"
SRC_URI[aarch64_rust-quickcheck+log-devel.sha256sum] = "7359e6a9be86787cc9c4f4280ee58441ba6cf3e6b53c640a7c323b4838bc48c4"

URI_aarch64_rust-quickcheck+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+regex-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-quickcheck+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+regex-devel}"
SRC_URI[aarch64_rust-quickcheck+regex-devel.sha256sum] = "09e68a2c3ffe64cd47a57e6bc27cb510335fa8c794c0912b3a706f5f7b1d77a2"

URI_aarch64_rust-quickcheck+use_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck+use_logging-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-quickcheck+use_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck+use_logging-devel}"
SRC_URI[aarch64_rust-quickcheck+use_logging-devel.sha256sum] = "c8cefe4901321e61e225e7d793e639004869774a9dd45fc049e516eccb12c385"

URI_aarch64_rust-quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quickcheck-devel}"
SRC_URI[aarch64_rust-quickcheck-devel.sha256sum] = "47710a3f873e9ea95334e2ea8848318be78b836d39620bced2a258f5ef1808d1"

RDEPENDS:rust-quickcheck+default-devel = " \
 cargo \
 rust-quickcheck+regex-devel \
 rust-quickcheck+use_logging-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+env_logger-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+regex-devel = " \
 cargo \
 rust-env_logger+regex-devel \
 rust-env_logger-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck+use_logging-devel = " \
 cargo \
 rust-quickcheck+env_logger-devel \
 rust-quickcheck+log-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-quickcheck-devel = " \
 cargo \
 rust \
 rust-rand+sys_rng-devel \
 rust-rand-devel \
 "
