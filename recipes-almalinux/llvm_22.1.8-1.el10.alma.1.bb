# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm"
PV = "22.1.8"
PR = "1.el10.alma.1"
PACKAGES = " \
 clang \
 clang-analyzer \
 clang-devel \
 clang-libs \
 clang-resource-filesystem \
 clang-tools-extra \
 compiler-rt \
 git-clang-format \
 libomp \
 libomp-devel \
 lld \
 lld-devel \
 lld-libs \
 lldb \
 lldb-devel \
 llvm \
 llvm-devel \
 llvm-doc \
 llvm-filesystem \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 llvm-toolset \
 python3-clang \
 python3-lit \
 python3-lldb \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/llvm-22.1.8-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "00e378552d975fc40eb1d64337bce8548d25c6980f808708cf577420ac120742"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang;unpack=0"
SRC_URI[x86_64_v2_clang.sha256sum] = "1c1913a220c831cfbd47b295159633657ec98f018846d47a7dbd082871c3bdc4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-analyzer-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-analyzer;unpack=0"
SRC_URI[x86_64_v2_clang-analyzer.sha256sum] = "66935fa3df778b815a6fddafdcc47884a7e6f559ab8f6ddd5fd9595c2e41cc7f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-devel-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-devel;unpack=0"
SRC_URI[x86_64_v2_clang-devel.sha256sum] = "93720a751e228d7d52944f3ab5beed933854b5a91ec4521cfdc9b083a4d5bd56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-libs-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-libs;unpack=0"
SRC_URI[x86_64_v2_clang-libs.sha256sum] = "1301851d1d876a8903651b77c6e627d6f18754c0576802a5fa1cefd90ce0589e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-resource-filesystem-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-resource-filesystem;unpack=0"
SRC_URI[x86_64_v2_clang-resource-filesystem.sha256sum] = "885e49dd45d2f74dcf875f840e233d67e79489f21f065b5fac7c9ade353af706"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clang-tools-extra-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_clang-tools-extra;unpack=0"
SRC_URI[x86_64_v2_clang-tools-extra.sha256sum] = "f36d7429d5e9fe40131dde76bd8f0213fda88e6a09f94f752948ee54f57a36d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/compiler-rt-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_compiler-rt;unpack=0"
SRC_URI[x86_64_v2_compiler-rt.sha256sum] = "6cc9711d97ca558d5c44feb8c11d1e279d1194dc9eccdc5953bb28e371dacec1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-clang-format-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_git-clang-format;unpack=0"
SRC_URI[x86_64_v2_git-clang-format.sha256sum] = "8a7269b112cd0c05595161a6f9b0e993cf7b71a330acac24d0ba5a47d5239789"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp;unpack=0"
SRC_URI[x86_64_v2_libomp.sha256sum] = "066e7cba1615b5d809775deef964a19ead29ded3342688c64e465e5fbee36a14"
RPROVIDES:libomp:append:x86_64_v2 = " virtual/libomp.so_VERSION__64bit_ virtual/libomp.so___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libomp-devel-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libomp-devel;unpack=0"
SRC_URI[x86_64_v2_libomp-devel.sha256sum] = "3abab3f0f9469d8bae7310b2742aecee105c1944da259b16aa6a80bd9d9ff6bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld;unpack=0"
SRC_URI[x86_64_v2_lld.sha256sum] = "0774354ef9f9d8eca3b799d68b3b87d2221e300209c8d01f739e6759cc04c764"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-devel-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-devel;unpack=0"
SRC_URI[x86_64_v2_lld-devel.sha256sum] = "491531a46b8a09d703d0640a25848cd5b6446af64c2ba53660498e0eb6f3699d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lld-libs-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lld-libs;unpack=0"
SRC_URI[x86_64_v2_lld-libs.sha256sum] = "22448675b0b378a446c0ecba9b27793eb5f90b9f5513eae1f522ab075a15cb7c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb;unpack=0"
SRC_URI[x86_64_v2_lldb.sha256sum] = "3c37de4753e5123f2567fc900d97ed0c6521ccd26fbbc585c30c1b4662e77d04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lldb-devel-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lldb-devel;unpack=0"
SRC_URI[x86_64_v2_lldb-devel.sha256sum] = "074f54f589da93e62f87bc280ba5f44c736cdc0ee1b19f6470f3e18ba422cf88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm;unpack=0"
SRC_URI[x86_64_v2_llvm.sha256sum] = "016a45788ce2872c33a7a51da37b034e7915578af81b32bbf1505f105f42b655"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-devel-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-devel;unpack=0"
SRC_URI[x86_64_v2_llvm-devel.sha256sum] = "bee2e92f0fe9123503f3364e6bdd697e65fdc2df2b0c25b5df37f2d96d7867d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-doc-22.1.8-1.el10.alma.1.noarch.rpm;name=x86_64_v2_llvm-doc;unpack=0"
SRC_URI[x86_64_v2_llvm-doc.sha256sum] = "f9198d12adf64c44dc54ef668ba147038086271af28770062c6082a2c182bfc5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-filesystem-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-filesystem;unpack=0"
SRC_URI[x86_64_v2_llvm-filesystem.sha256sum] = "7e54bbc25c20d29e0b16678d0a4e702f8e1254d23dd83453bcd78e19e173cc6a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-googletest-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-googletest;unpack=0"
SRC_URI[x86_64_v2_llvm-googletest.sha256sum] = "1ac3327dc91eef473c1441fb83346a0d16402e55a7021251060bc2bb893aff7a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-libs-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-libs;unpack=0"
SRC_URI[x86_64_v2_llvm-libs.sha256sum] = "5ff8e8a4a326d47cd82d02dc60c93c6a500a7f46b17d49e6ec2e1320954a840c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-static-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-static;unpack=0"
SRC_URI[x86_64_v2_llvm-static.sha256sum] = "2fca8dd01087b9647b4c69f66b20ceaafb831343bc4d9a8cb9de9913fd9037ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-test-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-test;unpack=0"
SRC_URI[x86_64_v2_llvm-test.sha256sum] = "fd3ddc82ecb659034c81837a4d4f5eb359abcea88bddcdfea11d92bc36ef2b92"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/llvm-toolset-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_llvm-toolset;unpack=0"
SRC_URI[x86_64_v2_llvm-toolset.sha256sum] = "16724e35c1750365191e4a9c19019d9faea2c4d58a4dfdd4e598d815238c9ba8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-clang-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-clang;unpack=0"
SRC_URI[x86_64_v2_python3-clang.sha256sum] = "827b0db100cd999c62344fbaac381eabe66a4fa474cdfc66336dbd1bc1748589"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lit-22.1.8-1.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-lit;unpack=0"
SRC_URI[x86_64_v2_python3-lit.sha256sum] = "3ab52b78f6f74f8aa63a7b826c454e8fb09a19fdb74c950d68e0689a46b0b1b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lldb-22.1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-lldb;unpack=0"
SRC_URI[x86_64_v2_python3-lldb.sha256sum] = "4cb79af993ab0eca5efd1b6bd9d610d5080b67278244878c6a112aaf2157ca12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang;unpack=0"
SRC_URI[aarch64_clang.sha256sum] = "7f3b0e04c02d2833f533fbb9a6e106599331e015ff9f7097dfbf7bad766e098a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-analyzer-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-analyzer;unpack=0"
SRC_URI[aarch64_clang-analyzer.sha256sum] = "893d0ddce63b33576f0ca65e6068f5cbc00c8aa6e49a556f44cc9ab35e9b5041"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-devel-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-devel;unpack=0"
SRC_URI[aarch64_clang-devel.sha256sum] = "7fe8e9b533dcb39d6c035cd36d9ab8b543554def27cdaabbdab215d2c7e99afd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-libs-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-libs;unpack=0"
SRC_URI[aarch64_clang-libs.sha256sum] = "4c1fc8e12aa5586569d1c7692302b14f40f5880f41a19d07d9b5fe23cde38f15"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-resource-filesystem-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-resource-filesystem;unpack=0"
SRC_URI[aarch64_clang-resource-filesystem.sha256sum] = "d1c7e49050c598b2600f39ee85edd52c70187f7417e17ed479cfe48506abec25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clang-tools-extra-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_clang-tools-extra;unpack=0"
SRC_URI[aarch64_clang-tools-extra.sha256sum] = "eddc8c7efe59a6f8e23b009c12b0dfbd1c2a7059b2adcc865f63dac275a824bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/compiler-rt-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_compiler-rt;unpack=0"
SRC_URI[aarch64_compiler-rt.sha256sum] = "ea4872b5738e5b47187088eda7601c521c507c87bee00cb48f35f573a01b04e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-clang-format-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_git-clang-format;unpack=0"
SRC_URI[aarch64_git-clang-format.sha256sum] = "8878f8abb7f3f5f777b61e2e070d9918bd35dbd67fd758f20f0dd3c15822f539"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_libomp;unpack=0"
SRC_URI[aarch64_libomp.sha256sum] = "e9149ae71ec392b6dd598ff725e95122b274090c46e48773610bc356c8e611ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libomp-devel-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_libomp-devel;unpack=0"
SRC_URI[aarch64_libomp-devel.sha256sum] = "1317f1598da2bf19d8bacf3efdd70b071c2e4d2671317a5704e31ad9c352df83"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lld;unpack=0"
SRC_URI[aarch64_lld.sha256sum] = "08922ddae76f547a928a045504d67c97961d6c346615c8e82004bbdf3c701c65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-devel-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lld-devel;unpack=0"
SRC_URI[aarch64_lld-devel.sha256sum] = "e8b22338b3aa9bfb3417532a468c88d4d80e1a30b61cdd8c2746f1bab18fba78"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lld-libs-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lld-libs;unpack=0"
SRC_URI[aarch64_lld-libs.sha256sum] = "5a56b8a19bebd5317a7cf554a2ec72ce7239f26b32436480c8260ccf634826d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lldb;unpack=0"
SRC_URI[aarch64_lldb.sha256sum] = "b70dbf2a4f6e1a9d3f139cf6001faea83fc4254d4377a2e14ec1a41ce62c7d94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lldb-devel-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_lldb-devel;unpack=0"
SRC_URI[aarch64_lldb-devel.sha256sum] = "5680e7fa77188766f4c2f381e5bf73d2c40e0e83d9caabe703412ee2ac73e70e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm;unpack=0"
SRC_URI[aarch64_llvm.sha256sum] = "4d64d8028740ed3c7251980a95a96d63e8eee6d270054460351d1a64b74c99b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-devel-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-devel;unpack=0"
SRC_URI[aarch64_llvm-devel.sha256sum] = "efd7a65929d96c542e55b64313c7a3ff8d80b787b04c6731a3c06c6e8a6634bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-doc-22.1.8-1.el10.alma.1.noarch.rpm;name=aarch64_llvm-doc;unpack=0"
SRC_URI[aarch64_llvm-doc.sha256sum] = "f9198d12adf64c44dc54ef668ba147038086271af28770062c6082a2c182bfc5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-filesystem-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-filesystem;unpack=0"
SRC_URI[aarch64_llvm-filesystem.sha256sum] = "6e8922e30531d3917bb64c4d701596d03aaa50f0f98537e6937e2c562fd1df99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-googletest-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-googletest;unpack=0"
SRC_URI[aarch64_llvm-googletest.sha256sum] = "4b863d74f84021a523fd368bf47106672e0d707d6af7e787534081af6669847a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-libs-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-libs;unpack=0"
SRC_URI[aarch64_llvm-libs.sha256sum] = "a294333b818f47c97adbc807a4e3f9c81b24b9fc45ddb8e03353a077fa584a4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-static-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-static;unpack=0"
SRC_URI[aarch64_llvm-static.sha256sum] = "739295341a59b0dde8899d79e2a740def3a71a1c2916dc13b861052cf10be52e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-test-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-test;unpack=0"
SRC_URI[aarch64_llvm-test.sha256sum] = "0416f686498e466e4ba52e5a9c373f576ea575dc6adf5f834fdbe2e0aeed8c17"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/llvm-toolset-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_llvm-toolset;unpack=0"
SRC_URI[aarch64_llvm-toolset.sha256sum] = "0d2edfd501e1cfe0d96b3be43a7bc7460b2bc50805745a724ce5c01cd125beac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-clang-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-clang;unpack=0"
SRC_URI[aarch64_python3-clang.sha256sum] = "568255d216eba51ab6c16df33d4b592ef3d2d1ed8a48309b6eab8bbba1b4eb02"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lit-22.1.8-1.el10.alma.1.noarch.rpm;name=aarch64_python3-lit;unpack=0"
SRC_URI[aarch64_python3-lit.sha256sum] = "3ab52b78f6f74f8aa63a7b826c454e8fb09a19fdb74c950d68e0689a46b0b1b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lldb-22.1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-lldb;unpack=0"
SRC_URI[aarch64_python3-lldb.sha256sum] = "2f34d9d68cb75b82e9311c37967907e6d2ab7e81840155d32d3fbaff87776424"

RDEPENDS:clang = " \
 clang-libs \
 gcc-c++ \
 glibc \
 libstdc++ \
 libstdc++-devel \
 llvm-libs \
 "
RDEPENDS:clang-analyzer = " \
 clang \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang-devel = " \
 clang \
 clang-libs \
 clang-tools-extra \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm-devel \
 "
RDEPENDS:clang-libs:x86_64_v2 = " \
 clang-resource-filesystem \
 gcc-toolset-15-gcc-c++ \
 glibc \
 libstdc++ \
 llvm-libs \
"
RDEPENDS:clang-libs:aarch64 = " \
 clang-resource-filesystem \
 gcc-toolset-15-gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
"
RDEPENDS:clang-resource-filesystem = " \
 "
RDEPENDS:clang-tools-extra = " \
 clang-libs \
 emacs-filesystem \
 glibc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 python3 \
 "
RDEPENDS:compiler-rt = " \
 clang-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:git-clang-format = " \
 clang-tools-extra \
 git-core \
 python3 \
 "
RDEPENDS:libomp = " \
 elfutils-libelf \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:libomp-devel = " \
 clang-resource-filesystem \
 libomp \
 "
RDEPENDS:lld = " \
 alternatives \
 bash \
 glibc \
 libstdc++ \
 lld-libs \
 llvm-libs \
 "
RDEPENDS:lld-devel = " \
 cmake-filesystem \
 lld \
 lld-libs \
 "
RDEPENDS:lld-libs = " \
 glibc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb:x86_64_v2 = " \
 clang-libs \
 glibc \
 libedit \
 libstdc++ \
 libxml2 \
 llvm-libs \
 ncurses-libs \
 python3-libs \
 python3-lldb \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:lldb:aarch64 = " \
 clang-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm-libs \
 ncurses-libs \
 python3-libs \
 python3-lldb \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:lldb-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 lldb \
 llvm-libs \
 "
RDEPENDS:llvm = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm-devel = " \
 alternatives \
 bash \
 cmake-filesystem \
 glibc \
 libedit-devel \
 libstdc++ \
 libzstd-devel \
 llvm \
 llvm-googletest \
 llvm-libs \
 llvm-static \
 llvm-test \
 "
RDEPENDS:llvm-doc = " \
 llvm \
 "
RDEPENDS:llvm-filesystem = " \
 "
RDEPENDS:llvm-googletest = " \
 llvm-filesystem \
 "
RDEPENDS:llvm-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 libxml2 \
 libzstd \
 llvm-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:llvm-static = " \
 llvm-filesystem \
 "
RDEPENDS:llvm-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm \
 llvm-libs \
 "
RDEPENDS:llvm-toolset = " \
 clang \
 lld \
 llvm \
 "
RDEPENDS:python3-clang = " \
 clang-devel \
 python3 \
 "
RDEPENDS:python3-lit = " \
 python3 \
 "
RDEPENDS:python3-lldb = " \
 lldb \
 python3 \
 "
