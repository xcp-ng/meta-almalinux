# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordered-float"
PV = "5.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-ordered-float+arbitrary-devel \
 rust-ordered-float+bytemuck-devel \
 rust-ordered-float+default-devel \
 rust-ordered-float+libm-devel \
 rust-ordered-float+proptest-devel \
 rust-ordered-float+rand-devel \
 rust-ordered-float+randtest-devel \
 rust-ordered-float+rkyv_08-devel \
 rust-ordered-float+rkyv_08_16-devel \
 rust-ordered-float+rkyv_08_32-devel \
 rust-ordered-float+rkyv_08_64-devel \
 rust-ordered-float+rkyv_08_ck-devel \
 rust-ordered-float+serde-devel \
 rust-ordered-float+std-devel \
 rust-ordered-float-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordered-float-5.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "200cd1c426e8bf06f3a4d04b841051b05eca2d10e21815284b3897945bf31645"

URI_x86_64_v2_rust-ordered-float+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+arbitrary-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+arbitrary-devel.sha256sum] = "a12acf3fbeaddba87f2e4e4b8d3944ffaaa1cb75a1dad855c4798c0e002f45cd"

URI_x86_64_v2_rust-ordered-float+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+bytemuck-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+bytemuck-devel.sha256sum] = "6cfb53cad0c7a88e13ff447448f12def7c1264d26406bf38530ece2b8f305c8e"

URI_x86_64_v2_rust-ordered-float+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+default-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+default-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+default-devel.sha256sum] = "6857d2176a1299028f6ebcac19770da1dcbef59bf75de338405d6b6d89823448"

URI_x86_64_v2_rust-ordered-float+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+libm-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+libm-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+libm-devel.sha256sum] = "272285abf3febeebffaf832572489aba904e4b5c75d753b580da664dfc053e0a"

URI_x86_64_v2_rust-ordered-float+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+proptest-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+proptest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+proptest-devel.sha256sum] = "7b1f511e5b19f2872ce7f92e85ad138d2beb887cff7fdd53040ddfbfd0309d37"

URI_x86_64_v2_rust-ordered-float+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rand-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rand-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rand-devel.sha256sum] = "4ea31bba8ba358a23400bd4732683b091a35e8d28024efcc6952102bb4da4ab5"

URI_x86_64_v2_rust-ordered-float+randtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+randtest-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+randtest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+randtest-devel.sha256sum] = "aa5ca9206cf86abcd7c359694dbdce71e72b12b39053b64abc3de4ded83d9888"

URI_x86_64_v2_rust-ordered-float+rkyv_08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08-devel.sha256sum] = "f903767bfeab79ad458529507e25ade1475f7e525331834462dd09d06c49ebfe"

URI_x86_64_v2_rust-ordered-float+rkyv_08_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08_16-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08_16-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08_16-devel.sha256sum] = "ae56b48fa02f416090be23f958a5c9b39ce125213ac4b7f6094a4de01d24ae1c"

URI_x86_64_v2_rust-ordered-float+rkyv_08_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08_32-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08_32-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08_32-devel.sha256sum] = "1a458cfb10adf734824fcbe152a64dc0ffa30aa276f12724744549318c59d4b9"

URI_x86_64_v2_rust-ordered-float+rkyv_08_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08_64-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08_64-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08_64-devel.sha256sum] = "b625e6c3ed341f2bf21e8d32eac1282988d1f1d93c3798f9b61d086e2aff10b6"

URI_x86_64_v2_rust-ordered-float+rkyv_08_ck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+rkyv_08_ck-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+rkyv_08_ck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+rkyv_08_ck-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+rkyv_08_ck-devel.sha256sum] = "14cdd7cd21713e84eea5d2144e622e7bbca9e451a23d111f914f353d40081af4"

URI_x86_64_v2_rust-ordered-float+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+serde-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+serde-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+serde-devel.sha256sum] = "b1d2db5e84a8ffbec4f7cfa39b3f10bb74832246de80d38f6752b7b311d8d1fd"

URI_x86_64_v2_rust-ordered-float+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float+std-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float+std-devel}"
SRC_URI[x86_64_v2_rust-ordered-float+std-devel.sha256sum] = "3ce855c13f8cbb42b6762e03aa2fda40af00cf4e0530d278af3fcd71e222e156"

URI_x86_64_v2_rust-ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float-devel-5.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float-devel}"
SRC_URI[x86_64_v2_rust-ordered-float-devel.sha256sum] = "5a4bf8e7d80319a521bd7295af685ebe31af502e304f178028636e5982d2858d"

URI_aarch64_rust-ordered-float+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+arbitrary-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+arbitrary-devel}"
SRC_URI[aarch64_rust-ordered-float+arbitrary-devel.sha256sum] = "52bc2a7b2c30319bc0db00eede28f7e993914cffa36163204f2304578a19e75c"

URI_aarch64_rust-ordered-float+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+bytemuck-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+bytemuck-devel}"
SRC_URI[aarch64_rust-ordered-float+bytemuck-devel.sha256sum] = "c48a0e3c04b4a6b0f06af524e366ddee7e2dfd064557be196c585e55fdf8d411"

URI_aarch64_rust-ordered-float+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+default-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+default-devel}"
SRC_URI[aarch64_rust-ordered-float+default-devel.sha256sum] = "bd8ae24944c6a8cb477a45a4b7f26775869fa8279d8ae274c5b7d851cbff44e6"

URI_aarch64_rust-ordered-float+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+libm-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+libm-devel}"
SRC_URI[aarch64_rust-ordered-float+libm-devel.sha256sum] = "2aa7b773c5938cccc11d3fd284d77db85cfc4850a140c108c5ab839fae569c42"

URI_aarch64_rust-ordered-float+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+proptest-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+proptest-devel}"
SRC_URI[aarch64_rust-ordered-float+proptest-devel.sha256sum] = "46ba55f1622591bfdb62295aa743d23de4f94f193ce519fb959ec6b8123a3a70"

URI_aarch64_rust-ordered-float+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rand-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rand-devel}"
SRC_URI[aarch64_rust-ordered-float+rand-devel.sha256sum] = "ec54328f1a8cc6c604ff64ccc59f85c21aaae34ed3b6c562176403146b0e47d1"

URI_aarch64_rust-ordered-float+randtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+randtest-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+randtest-devel}"
SRC_URI[aarch64_rust-ordered-float+randtest-devel.sha256sum] = "4cf3e891c7063db05af59400078332231446b11dda15a634871120255ff56a7f"

URI_aarch64_rust-ordered-float+rkyv_08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08-devel.sha256sum] = "0941c55020b3b60cf413b18f0f4a35c981227c82b96319f3c401d9ee7ff579f9"

URI_aarch64_rust-ordered-float+rkyv_08_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08_16-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08_16-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08_16-devel.sha256sum] = "29d76509fd2a862733495dc968149315e7b8cb1debe9ae463ab5dec31fc95d54"

URI_aarch64_rust-ordered-float+rkyv_08_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08_32-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08_32-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08_32-devel.sha256sum] = "c1cfb131b2973be12ebd7c4786b6bf2eccc99fd4d4c140561cf943dd50d3eb13"

URI_aarch64_rust-ordered-float+rkyv_08_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08_64-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08_64-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08_64-devel.sha256sum] = "5f78adf52afda3c5c0207d112dfc844494f9ccf48f46e4f96ec2f4c7843ae6fe"

URI_aarch64_rust-ordered-float+rkyv_08_ck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+rkyv_08_ck-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+rkyv_08_ck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+rkyv_08_ck-devel}"
SRC_URI[aarch64_rust-ordered-float+rkyv_08_ck-devel.sha256sum] = "89406cfb971eb4578466e940ea7e15ca643a59f20362cae292c52fb0fc0118c1"

URI_aarch64_rust-ordered-float+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+serde-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+serde-devel}"
SRC_URI[aarch64_rust-ordered-float+serde-devel.sha256sum] = "ad88522d5d2209b1a34653ee45219f459de721d33cb93ab932474dce3a49acd7"

URI_aarch64_rust-ordered-float+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float+std-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float+std-devel}"
SRC_URI[aarch64_rust-ordered-float+std-devel.sha256sum] = "3cae27e7664bd689a8faeea0f7c1b7c483e8c5f1262001c0da30af09cb449686"

URI_aarch64_rust-ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float-devel-5.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float-devel}"
SRC_URI[aarch64_rust-ordered-float-devel.sha256sum] = "c469971872d6cfa4f56197e59f514c4c3f8aa79e53feb706b8ea48007b0f88ca"

RDEPENDS:rust-ordered-float+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+bytemuck-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+default-devel = " \
 cargo \
 rust-ordered-float+std-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+libm-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+proptest-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-ordered-float+rand-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float+randtest-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08-devel = " \
 cargo \
 rust-ordered-float+rkyv_08_32-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08_16-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv+pointer_width_16-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08_32-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv+pointer_width_32-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08_64-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv+pointer_width_64-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-ordered-float+rkyv_08_ck-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rkyv+bytecheck-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-ordered-float+serde-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-rand0.8+serde1-devel \
 rust-rand0.8-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ordered-float+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-ordered-float-devel \
 "
RDEPENDS:rust-ordered-float-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
