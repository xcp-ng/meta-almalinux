# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling_macro"
PV = "0.20.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-darling_macro+default-devel \
 rust-darling_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling_macro-0.20.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "841e1ce2fbe2ae400753d9516920de7f278da992c9fb398311a3ff18e4779616"

URI_x86_64_v2_rust-darling_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_macro+default-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_macro+default-devel}"
SRC_URI[x86_64_v2_rust-darling_macro+default-devel.sha256sum] = "35fd21eb46430f9b8e4aa02898981f7aa1f277cf7385ec89db3eb160f3caccdb"

URI_x86_64_v2_rust-darling_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_macro-devel-0.20.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_macro-devel}"
SRC_URI[x86_64_v2_rust-darling_macro-devel.sha256sum] = "1f4c7c717e1dee1a327818fc302b0bde47a39beff0d56ff5f665eea394ac2afe"

URI_aarch64_rust-darling_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_macro+default-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_macro+default-devel}"
SRC_URI[aarch64_rust-darling_macro+default-devel.sha256sum] = "a1ec367fcf2194a50b09e079ffb0966f00d516c1acfd00558f51d787fb4ddc1b"

URI_aarch64_rust-darling_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_macro-devel-0.20.11-1.el10_0.noarch.rpm;name=aarch64_rust-darling_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_macro-devel}"
SRC_URI[aarch64_rust-darling_macro-devel.sha256sum] = "434e698409196fb2f09cd5454c59b1a8581602881ec794785a018e6134c86b00"

RDEPENDS:rust-darling_macro+default-devel = " \
 cargo \
 rust-darling_macro-devel \
 "
RDEPENDS:rust-darling_macro-devel = " \
 cargo \
 rust \
 rust-darling_core+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
