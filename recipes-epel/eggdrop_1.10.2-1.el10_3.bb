# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eggdrop"
PV = "1.10.2"
PR = "1.el10_3"
PACKAGES = " \
 eggdrop \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/eggdrop-1.10.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ba6bd0b105f5ad1afc767f28e3bd19888a3221f49fa744a70d63b299f0dd2587"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eggdrop-1.10.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_eggdrop;unpack=0"
SRC_URI[x86_64_v2_eggdrop.sha256sum] = "2d63e5dd03ce4ef070019e7960fe0f017b488da37712505dbe3d4022ec1ad156"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eggdrop-1.10.2-1.el10_3.aarch64.rpm;name=aarch64_eggdrop;unpack=0"
SRC_URI[aarch64_eggdrop.sha256sum] = "f0aa17430223ebf437603031581477fb577aa03c313a20c9f28ca5af93a039d1"

RDEPENDS:eggdrop = " \
 bash \
 glibc \
 openssl-libs \
 python3-libs \
 tcl \
 zlib-ng-compat \
 "
