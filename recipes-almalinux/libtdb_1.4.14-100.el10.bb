# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtdb"
PV = "1.4.14"
PR = "100.el10"
PACKAGES = " \
 libtdb \
 libtdb-devel \
 python3-tdb \
 tdb-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtdb-1.4.14-100.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e1967cb44bb1fb27e9b0efdf272960e6f0b8ebcd4e9803a95c8783731b5cdef"

URI_x86_64_v2_libtdb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtdb-1.4.14-100.el10.x86_64_v2.rpm;name=x86_64_v2_libtdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtdb}"
SRC_URI[x86_64_v2_libtdb.sha256sum] = "dde535d3c5fa6c4a21eb58ce4ff1a99b9646f092809d97a7a50de273634f6b5a"

URI_x86_64_v2_libtdb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtdb-devel-1.4.14-100.el10.x86_64_v2.rpm;name=x86_64_v2_libtdb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtdb-devel}"
SRC_URI[x86_64_v2_libtdb-devel.sha256sum] = "68e0bb2f32c0f3616c1783993bb48e3a28cfdeed286187e9684f6629cea1bb26"

URI_x86_64_v2_python3-tdb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-tdb-1.4.14-100.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tdb}"
SRC_URI[x86_64_v2_python3-tdb.sha256sum] = "4e327ca7fa42ebb9d824faecabafa39161e3344e5bedb291286a0f5bb87b893a"

URI_x86_64_v2_tdb-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tdb-tools-1.4.14-100.el10.x86_64_v2.rpm;name=x86_64_v2_tdb-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tdb-tools}"
SRC_URI[x86_64_v2_tdb-tools.sha256sum] = "ae82d46ea4026d3a55dd8ed30f0b3450b0784fda6b2bfcf1293df63c473ffa04"

URI_aarch64_libtdb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtdb-1.4.14-100.el10.aarch64.rpm;name=aarch64_libtdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtdb}"
SRC_URI[aarch64_libtdb.sha256sum] = "e1b17e21091e3d981004699fb47c16d64a6fb883c900ccd89dcf9a8394b38882"

URI_aarch64_libtdb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtdb-devel-1.4.14-100.el10.aarch64.rpm;name=aarch64_libtdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtdb-devel}"
SRC_URI[aarch64_libtdb-devel.sha256sum] = "5cdd22af2212e4e635483e44340251e6c98373bbe28862815518eeac2d278960"

URI_aarch64_python3-tdb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-tdb-1.4.14-100.el10.aarch64.rpm;name=aarch64_python3-tdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tdb}"
SRC_URI[aarch64_python3-tdb.sha256sum] = "d238d0b8f87fd0882438b8ae4357d83bbfdf39ce06776555a3f42bb34a142fa8"

URI_aarch64_tdb-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tdb-tools-1.4.14-100.el10.aarch64.rpm;name=aarch64_tdb-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_tdb-tools}"
SRC_URI[aarch64_tdb-tools.sha256sum] = "ee01357776432026939a1273981537239c29cf847c7df762eeb9937b3ed6d107"

RDEPENDS:libtdb = " \
 glibc \
 "
RDEPENDS:libtdb-devel = " \
 libtdb \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-tdb = " \
 glibc \
 libtdb \
 python3 \
 "
RDEPENDS:tdb-tools = " \
 glibc \
 libtdb \
 "
