# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksh"
PE = "3"
PV = "1.0.10"
PR = "12.el10"
PACKAGES = " \
 ksh \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ksh-1.0.10-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d9d03f4d28b3f4b4907a6a1aec381f982e450a4d39d2cab39705755d792dc562"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ksh-1.0.10-12.el10.x86_64_v2.rpm;name=x86_64_v2_ksh;unpack=0"
SRC_URI[x86_64_v2_ksh.sha256sum] = "c8bee29e7bc4dd79b03449d28a4813447f6919abbf98f3aebc468c372f7add1f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ksh-1.0.10-12.el10.aarch64.rpm;name=aarch64_ksh;unpack=0"
SRC_URI[aarch64_ksh.sha256sum] = "3cf071fd0d02de4a48d65d8393c3a4fad38847a2f055b0135ac9825f730b92ec"

RDEPENDS:ksh = " \
 bash \
 diffutils \
 glibc \
 grep \
 sed \
 systemd \
 virtual/coreutils \
 "
