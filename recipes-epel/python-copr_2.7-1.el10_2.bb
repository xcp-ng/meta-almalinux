# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-copr"
PV = "2.7"
PR = "1.el10_2"
PACKAGES = " \
 python-copr-doc \
 python3-copr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-copr-2.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5d8f33505426da084d09b3203bc28817cd20d22d32eb01c7f7416f41115dd66"

URI_x86_64_v2_python-copr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-copr-doc-2.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-copr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-copr-doc}"
SRC_URI[x86_64_v2_python-copr-doc.sha256sum] = "074aa6c230e337106361db5ab178a3a4b38a0caa059f8f5d6f5a725f79dc04ca"

URI_x86_64_v2_python3-copr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-copr-2.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-copr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-copr}"
SRC_URI[x86_64_v2_python3-copr.sha256sum] = "ea7ec5de0dcd75e21cabffef4445e1443463d33f128c9b4e87a387af0fda23ff"

URI_aarch64_python-copr-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-copr-doc-2.7-1.el10_2.noarch.rpm;name=aarch64_python-copr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-copr-doc}"
SRC_URI[aarch64_python-copr-doc.sha256sum] = "198798515be0f5e92afaca4b403af3aa4875653a4ab70cd415e47e03fe59cdd4"

URI_aarch64_python3-copr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-copr-2.7-1.el10_2.noarch.rpm;name=aarch64_python3-copr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-copr}"
SRC_URI[aarch64_python3-copr.sha256sum] = "111aef297ad2bf7ba2e638adc61e3101270ae9ff8b54a2a9069c1d985489168d"

RDEPENDS:python-copr-doc = " \
 "
RDEPENDS:python3-copr = " \
 python3 \
 python3-filelock \
 python3-munch \
 python3-requests \
 python3-requests-gssapi \
 python3-requests-toolbelt \
 python3-setuptools \
 "
