# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ds2"
PV = "2.0.0"
PR = "2.el10_2"
PACKAGES = " \
 php-pecl-ds2 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ds2-2.0.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cade5d19dabb95f0c01cf8401a5122b5bcf76ae902c68a3d35260a6d6fcb6e00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ds2-2.0.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ds2;unpack=0"
SRC_URI[x86_64_v2_php-pecl-ds2.sha256sum] = "0f946c7fb0c80caac77b8f74b7662629715e46c88618009413aef89ed749656e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ds2-2.0.0-2.el10_2.aarch64.rpm;name=aarch64_php-pecl-ds2;unpack=0"
SRC_URI[aarch64_php-pecl-ds2.sha256sum] = "ebc7e87068381e05bdd9b4daa67d824f79e4810cf9d32265b0cc44273233c6fc"

RDEPENDS:php-pecl-ds2 = " \
 glibc \
 php-common \
 "
