# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snafu"
PV = "0.8.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-snafu+alloc-devel \
 rust-snafu+backtrace-devel \
 rust-snafu+backtraces-impl-backtrace-crate-devel \
 rust-snafu+default-devel \
 rust-snafu+futures-core-crate-devel \
 rust-snafu+futures-crate-devel \
 rust-snafu+futures-devel \
 rust-snafu+guide-devel \
 rust-snafu+internal-dev-dependencies-devel \
 rust-snafu+pin-project-devel \
 rust-snafu+rust_1_61-devel \
 rust-snafu+rust_1_65-devel \
 rust-snafu+rust_1_81-devel \
 rust-snafu+std-devel \
 rust-snafu+unstable-core-error-devel \
 rust-snafu+unstable-provider-api-devel \
 rust-snafu+unstable-try-trait-devel \
 rust-snafu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snafu-0.8.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6908b3a2af6e1c82b6bd716da831ea249f74058a9812624cb7fb14ce55fab34"

URI_x86_64_v2_rust-snafu+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+alloc-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+alloc-devel}"
SRC_URI[x86_64_v2_rust-snafu+alloc-devel.sha256sum] = "af7aa680681895dae5a657c143160fde1fbd66b10827a7cd189920efe0cd7eca"

URI_x86_64_v2_rust-snafu+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+backtrace-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+backtrace-devel}"
SRC_URI[x86_64_v2_rust-snafu+backtrace-devel.sha256sum] = "cc5371a3c13c0151812a2bcecb3dd3edeaee3a98d4d58be1632784970e0b8216"

URI_x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+backtraces-impl-backtrace-crate-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel}"
SRC_URI[x86_64_v2_rust-snafu+backtraces-impl-backtrace-crate-devel.sha256sum] = "3460e22f258ce3aeeb6bafa73c97e7099c73b2bbc03be67ea5f667c2fcbf9a77"

URI_x86_64_v2_rust-snafu+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+default-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+default-devel}"
SRC_URI[x86_64_v2_rust-snafu+default-devel.sha256sum] = "5b800ea9c2844e02312e7ad5f26ffb6c7ecab84a5dfc8074f12244995f45a026"

URI_x86_64_v2_rust-snafu+futures-core-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+futures-core-crate-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+futures-core-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+futures-core-crate-devel}"
SRC_URI[x86_64_v2_rust-snafu+futures-core-crate-devel.sha256sum] = "1fe0cce804b1b3dc34861044b649cb7d8fbd7aef2f8a8e5a31e028ade13ad191"

URI_x86_64_v2_rust-snafu+futures-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+futures-crate-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+futures-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+futures-crate-devel}"
SRC_URI[x86_64_v2_rust-snafu+futures-crate-devel.sha256sum] = "49c199cec2b19090e2a45d0c1b39b91c4b80ef3479022f58973a94b86615d707"

URI_x86_64_v2_rust-snafu+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+futures-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+futures-devel}"
SRC_URI[x86_64_v2_rust-snafu+futures-devel.sha256sum] = "86628273c40f8bf5cf547ccf6bb9c9b0c9335f60f1d0294b285b178f7493a175"

URI_x86_64_v2_rust-snafu+guide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+guide-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+guide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+guide-devel}"
SRC_URI[x86_64_v2_rust-snafu+guide-devel.sha256sum] = "67663e4dca41bb3217cc724a756be02d452934da24406f708ee04edb0ed76ae4"

URI_x86_64_v2_rust-snafu+internal-dev-dependencies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+internal-dev-dependencies-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+internal-dev-dependencies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+internal-dev-dependencies-devel}"
SRC_URI[x86_64_v2_rust-snafu+internal-dev-dependencies-devel.sha256sum] = "8a9fd2e3d5f51ea039443243604b0ca89753e1412ae7634f375da47b3919e0de"

URI_x86_64_v2_rust-snafu+pin-project-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+pin-project-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+pin-project-devel}"
SRC_URI[x86_64_v2_rust-snafu+pin-project-devel.sha256sum] = "e7a6e41cf28bc2dfe96912c9cdfbd8dd5f1ad858996d550dd137997f6aaf538f"

URI_x86_64_v2_rust-snafu+rust_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+rust_1_61-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+rust_1_61-devel}"
SRC_URI[x86_64_v2_rust-snafu+rust_1_61-devel.sha256sum] = "f8d7377b564d973cc3ec424c8f385b696028897f4db7992a3436211583fb9992"

URI_x86_64_v2_rust-snafu+rust_1_65-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+rust_1_65-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+rust_1_65-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+rust_1_65-devel}"
SRC_URI[x86_64_v2_rust-snafu+rust_1_65-devel.sha256sum] = "946d31ea95d7925134becea711b298617bb60e9752fdffb995a51ad7f8813792"

URI_x86_64_v2_rust-snafu+rust_1_81-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+rust_1_81-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+rust_1_81-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+rust_1_81-devel}"
SRC_URI[x86_64_v2_rust-snafu+rust_1_81-devel.sha256sum] = "0762f60ff701ca789e7b37c31f5a248970dba1a4f94951b86bdebac7e04430fd"

URI_x86_64_v2_rust-snafu+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+std-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+std-devel}"
SRC_URI[x86_64_v2_rust-snafu+std-devel.sha256sum] = "ae8c03184241c1fb582ddb7f6b8a63e6af9b99b4c752cc4c48a8d60d3651b770"

URI_x86_64_v2_rust-snafu+unstable-core-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+unstable-core-error-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+unstable-core-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+unstable-core-error-devel}"
SRC_URI[x86_64_v2_rust-snafu+unstable-core-error-devel.sha256sum] = "d25e48bf0f778c9901686c271a5c761bea14b19e9a9c02883fe4429b4f8138e8"

URI_x86_64_v2_rust-snafu+unstable-provider-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+unstable-provider-api-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+unstable-provider-api-devel}"
SRC_URI[x86_64_v2_rust-snafu+unstable-provider-api-devel.sha256sum] = "39091fff570bfbadd21ad6009a4364001d80a03d4b12228e8d8e456a8ebd6de0"

URI_x86_64_v2_rust-snafu+unstable-try-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu+unstable-try-trait-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu+unstable-try-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu+unstable-try-trait-devel}"
SRC_URI[x86_64_v2_rust-snafu+unstable-try-trait-devel.sha256sum] = "3a06c0beb44724cfac20824834e3d47da65acc7e9fadcc20bc34298a7aaa1035"

URI_x86_64_v2_rust-snafu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-devel}"
SRC_URI[x86_64_v2_rust-snafu-devel.sha256sum] = "ae4fe2d5c827baca537b2eaedb96c64195c1d4d8c074ede14c097756a3776f66"

URI_aarch64_rust-snafu+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+alloc-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+alloc-devel}"
SRC_URI[aarch64_rust-snafu+alloc-devel.sha256sum] = "259c3400d73569a26febb80bdcff0c480193a3c216e0df96c701461d5d2e8b6a"

URI_aarch64_rust-snafu+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+backtrace-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+backtrace-devel}"
SRC_URI[aarch64_rust-snafu+backtrace-devel.sha256sum] = "0c7e7034dc350830b2d057f05d89f6bc31b6c2192debe97e3562593360820fa3"

URI_aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+backtraces-impl-backtrace-crate-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel}"
SRC_URI[aarch64_rust-snafu+backtraces-impl-backtrace-crate-devel.sha256sum] = "d4081e5618775a33551e5c04dc96e980f356f9e695fc3760c2482c541bbeea07"

URI_aarch64_rust-snafu+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+default-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+default-devel}"
SRC_URI[aarch64_rust-snafu+default-devel.sha256sum] = "ccaff41cdceb0568fc84b593d7d5ddbd73317db276f018136a08fbda2ffc35e2"

URI_aarch64_rust-snafu+futures-core-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+futures-core-crate-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+futures-core-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+futures-core-crate-devel}"
SRC_URI[aarch64_rust-snafu+futures-core-crate-devel.sha256sum] = "d07e05b0cb87da51aa42fe33e7aebcf150039702b4f177d54ebe1550541bd78f"

URI_aarch64_rust-snafu+futures-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+futures-crate-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+futures-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+futures-crate-devel}"
SRC_URI[aarch64_rust-snafu+futures-crate-devel.sha256sum] = "7a539cea3be4e75beab0b52fe6baed885c7e14f3a9fb74911d5f1cb5e5bbccd4"

URI_aarch64_rust-snafu+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+futures-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+futures-devel}"
SRC_URI[aarch64_rust-snafu+futures-devel.sha256sum] = "54863187184b2700d9d374db0926d8e985c18d57bdf43c617b8c86cba0fa96ec"

URI_aarch64_rust-snafu+guide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+guide-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+guide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+guide-devel}"
SRC_URI[aarch64_rust-snafu+guide-devel.sha256sum] = "6c5bec58e97a4ef1e4fcbe8342316c84d30d728ffde5bb07969bf7635ffa6827"

URI_aarch64_rust-snafu+internal-dev-dependencies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+internal-dev-dependencies-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+internal-dev-dependencies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+internal-dev-dependencies-devel}"
SRC_URI[aarch64_rust-snafu+internal-dev-dependencies-devel.sha256sum] = "c1c0bf9cb8dd3b67ea100f58177ac109de6aeb2ffff7e65a0efffb6dae1fee23"

URI_aarch64_rust-snafu+pin-project-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+pin-project-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+pin-project-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+pin-project-devel}"
SRC_URI[aarch64_rust-snafu+pin-project-devel.sha256sum] = "7decd7f0867f4a91e7d220e59ddd95bc4bbe0c6e73cdae41494379dfc84a347d"

URI_aarch64_rust-snafu+rust_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+rust_1_61-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+rust_1_61-devel}"
SRC_URI[aarch64_rust-snafu+rust_1_61-devel.sha256sum] = "be622d97a798c5af34e8e87bcd0f471cbf702c036af745a36bce22b4042e8069"

URI_aarch64_rust-snafu+rust_1_65-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+rust_1_65-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+rust_1_65-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+rust_1_65-devel}"
SRC_URI[aarch64_rust-snafu+rust_1_65-devel.sha256sum] = "60b5bf2d5c4786fef6ab89526fb4d0af7561a98699c56edbff4e6da76c7e14ff"

URI_aarch64_rust-snafu+rust_1_81-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+rust_1_81-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+rust_1_81-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+rust_1_81-devel}"
SRC_URI[aarch64_rust-snafu+rust_1_81-devel.sha256sum] = "66ae9205a5fbd71a8215d7b607522ec1716ae03a9efe5d3c9a16a7c9ae78c60e"

URI_aarch64_rust-snafu+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+std-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+std-devel}"
SRC_URI[aarch64_rust-snafu+std-devel.sha256sum] = "9b39429d668f35f25560b516b30760a654d4db3e48022f429ec0a8456c7654c1"

URI_aarch64_rust-snafu+unstable-core-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+unstable-core-error-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+unstable-core-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+unstable-core-error-devel}"
SRC_URI[aarch64_rust-snafu+unstable-core-error-devel.sha256sum] = "6d0fde47d3ea82672a4396a7a494a333b17131c6c4555917d13ac59d381c52f5"

URI_aarch64_rust-snafu+unstable-provider-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+unstable-provider-api-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+unstable-provider-api-devel}"
SRC_URI[aarch64_rust-snafu+unstable-provider-api-devel.sha256sum] = "1bd5f79bb0c42a7c43d54db6cb37f1bd53c5f1bc251ccdc23c75209f0c4a239d"

URI_aarch64_rust-snafu+unstable-try-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu+unstable-try-trait-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu+unstable-try-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu+unstable-try-trait-devel}"
SRC_URI[aarch64_rust-snafu+unstable-try-trait-devel.sha256sum] = "2a6121a807c42ffad06fa3ad4d2eef154fce2e102b073c02f34b23008ffde0fb"

URI_aarch64_rust-snafu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-snafu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-devel}"
SRC_URI[aarch64_rust-snafu-devel.sha256sum] = "3e1f61b081fa8ab120e250a45d92f815817bcdd9c3126e6845a1a75a8e841549"

RDEPENDS:rust-snafu+alloc-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+backtraces-impl-backtrace-crate-devel = " \
 cargo \
 rust-snafu+backtrace-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+default-devel = " \
 cargo \
 rust-snafu+rust_1_65-devel \
 rust-snafu+std-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+futures-core-crate-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+futures-crate-devel = " \
 cargo \
 rust-futures-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+futures-devel = " \
 cargo \
 rust-snafu+futures-core-crate-devel \
 rust-snafu+pin-project-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+guide-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+internal-dev-dependencies-devel = " \
 cargo \
 rust-snafu+futures-crate-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+pin-project-devel = " \
 cargo \
 rust-pin-project-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+rust_1_61-devel = " \
 cargo \
 rust-snafu-derive+rust_1_61-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+rust_1_65-devel = " \
 cargo \
 rust-snafu+rust_1_61-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+rust_1_81-devel = " \
 cargo \
 rust-snafu+rust_1_65-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+std-devel = " \
 cargo \
 rust-snafu+alloc-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+unstable-core-error-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+unstable-provider-api-devel = " \
 cargo \
 rust-snafu-derive+unstable-provider-api-devel \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu+unstable-try-trait-devel = " \
 cargo \
 rust-snafu-devel \
 "
RDEPENDS:rust-snafu-devel = " \
 bash \
 cargo \
 rust \
 rust-snafu-derive+default-devel \
 "
