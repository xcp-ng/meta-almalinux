# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syslinux"
PV = "6.04"
PR = "0.35.el10.alma.2"
PACKAGES:x86_64_v2 = " \
 syslinux \
 syslinux-extlinux \
 syslinux-extlinux-nonlinux \
 syslinux-nonlinux \
 syslinux-tftpboot \
"
PACKAGES:aarch64 = " \
 syslinux-extlinux-nonlinux \
 syslinux-nonlinux \
 syslinux-tftpboot \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/syslinux-6.04-0.35.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "02cb78dc665696cb2c3904b995c24198429f6357b4390653659ed297921cff39"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - syslinux-extlinux-nonlinux: syslinux
# - syslinux-nonlinux: syslinux

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-6.04-0.35.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_syslinux;unpack=0"
SRC_URI[x86_64_v2_syslinux.sha256sum] = "a616924972649ed6a5c5d71cb49064edaa6b449c3776200bd8163193648e3e36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-extlinux-6.04-0.35.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_syslinux-extlinux;unpack=0"
SRC_URI[x86_64_v2_syslinux-extlinux.sha256sum] = "556831cbf58ef35e96cb86eb719f1ea1fbb15e4f7d91a21d45f33f78f9cf81e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-extlinux-nonlinux-6.04-0.35.el10.alma.2.noarch.rpm;name=x86_64_v2_syslinux-extlinux-nonlinux;unpack=0"
SRC_URI[x86_64_v2_syslinux-extlinux-nonlinux.sha256sum] = "189f67da4515b0cbe476d7f689eac30243bea35408e30e16c15d87f5acfa472e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-nonlinux-6.04-0.35.el10.alma.2.noarch.rpm;name=x86_64_v2_syslinux-nonlinux;unpack=0"
SRC_URI[x86_64_v2_syslinux-nonlinux.sha256sum] = "a836cf13c29f4a83fa68d86a78ac1e9d0598ac1d835ddc215b551a4c649d5830"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/syslinux-tftpboot-6.04-0.35.el10.alma.2.noarch.rpm;name=x86_64_v2_syslinux-tftpboot;unpack=0"
SRC_URI[x86_64_v2_syslinux-tftpboot.sha256sum] = "4033b4afbfebfdc9c10ea17d7fd0897af119bd2c12a6e8558c82e29973017418"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/syslinux-extlinux-nonlinux-6.04-0.35.el10.alma.2.noarch.rpm;name=aarch64_syslinux-extlinux-nonlinux;unpack=0"
SRC_URI[aarch64_syslinux-extlinux-nonlinux.sha256sum] = "189f67da4515b0cbe476d7f689eac30243bea35408e30e16c15d87f5acfa472e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/syslinux-nonlinux-6.04-0.35.el10.alma.2.noarch.rpm;name=aarch64_syslinux-nonlinux;unpack=0"
SRC_URI[aarch64_syslinux-nonlinux.sha256sum] = "a836cf13c29f4a83fa68d86a78ac1e9d0598ac1d835ddc215b551a4c649d5830"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/syslinux-tftpboot-6.04-0.35.el10.alma.2.noarch.rpm;name=aarch64_syslinux-tftpboot;unpack=0"
SRC_URI[aarch64_syslinux-tftpboot.sha256sum] = "4033b4afbfebfdc9c10ea17d7fd0897af119bd2c12a6e8558c82e29973017418"

RDEPENDS:syslinux = " \
 glibc \
 libuuid \
 mtools \
 syslinux-nonlinux \
 "
RDEPENDS:syslinux-extlinux = " \
 bash \
 glibc \
 syslinux \
 syslinux-extlinux-nonlinux \
 "
RDEPENDS:syslinux-extlinux-nonlinux:x86_64_v2 = " \
 glibc \
 syslinux \
"
RDEPENDS:syslinux-extlinux-nonlinux:aarch64 = " \
 glibc \
"
RDEPENDS:syslinux-nonlinux:x86_64_v2 = " \
 glibc \
 syslinux \
"
RDEPENDS:syslinux-nonlinux:aarch64 = " \
 glibc \
"
RDEPENDS:syslinux-tftpboot = " \
 glibc \
 "
