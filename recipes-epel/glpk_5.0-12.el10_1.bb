# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glpk"
PV = "5.0"
PR = "12.el10_1"
PACKAGES = " \
 glpk \
 glpk-devel \
 glpk-doc \
 glpk-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glpk-5.0-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6812386754a6b3af2d5f68692f9cf697867305215c437052f3e6a18bd52204d"

URI_x86_64_v2_glpk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-5.0-12.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk}"
SRC_URI[x86_64_v2_glpk.sha256sum] = "ade5cc174fc851dd74663a480e8394798a4b6ed9c15ca1ba177abefe77c6cda4"

URI_x86_64_v2_glpk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-devel-5.0-12.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk-devel}"
SRC_URI[x86_64_v2_glpk-devel.sha256sum] = "e2b8bb4eadb5ef340cb1b8dd09c856f526c216d99b8cc42283d0948e7da223e2"

URI_x86_64_v2_glpk-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-doc-5.0-12.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk-doc}"
SRC_URI[x86_64_v2_glpk-doc.sha256sum] = "fc80db686830d70a5cd1867c3f79939b80fb23ef3a1a29aa5d8bd309515eecfc"

URI_x86_64_v2_glpk-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-utils-5.0-12.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk-utils}"
SRC_URI[x86_64_v2_glpk-utils.sha256sum] = "54f495a5ddb9245f9d6fee6b4a3e194cfe3cffb2bf1b55b78ccb59042c9c1f66"

URI_aarch64_glpk = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-5.0-12.el10_1.aarch64.rpm;name=aarch64_glpk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk}"
SRC_URI[aarch64_glpk.sha256sum] = "d22d36856ca8a20da98c5340acf5f3b725873d62294adb5616f6c63d2412aeca"

URI_aarch64_glpk-devel = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-devel-5.0-12.el10_1.aarch64.rpm;name=aarch64_glpk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk-devel}"
SRC_URI[aarch64_glpk-devel.sha256sum] = "50b7b0bf59d00c3547094ebc511b91a03bf27caf6d57333a868ed5bea5fcc00e"

URI_aarch64_glpk-doc = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-doc-5.0-12.el10_1.aarch64.rpm;name=aarch64_glpk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk-doc}"
SRC_URI[aarch64_glpk-doc.sha256sum] = "a40d984d122f1ff48745d6a6b6a85db5b8c34af1755247a1e91a0f8dea660273"

URI_aarch64_glpk-utils = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-utils-5.0-12.el10_1.aarch64.rpm;name=aarch64_glpk-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk-utils}"
SRC_URI[aarch64_glpk-utils.sha256sum] = "0e88034d48e99c5b065bd38e4c9cc0d0c6a705fb05ef6f7962520fe5861f8d73"

RDEPENDS:glpk = " \
 glibc \
 gmp \
 suitesparse \
 zlib-ng-compat \
 "
RDEPENDS:glpk-devel = " \
 glpk \
 "
RDEPENDS:glpk-doc = " \
 "
RDEPENDS:glpk-utils = " \
 glibc \
 glpk \
 "
