# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dovecot"
PE = "1"
PV = "2.3.21"
PR = "21.el10"
PACKAGES = " \
 dovecot \
 dovecot-devel \
 dovecot-mysql \
 dovecot-pgsql \
 dovecot-pigeonhole \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dovecot-2.3.21-21.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c0924491c5db43e3f30b8014c6ff9e9a537b6d7ff0d7c24a3c4db6de3e00cb51"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dovecot: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-2.3.21-21.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot;unpack=0"
SRC_URI[x86_64_v2_dovecot.sha256sum] = "945dba54108fd56820dcdb0af0a8a8580ab04ee7736fd425abdda1ac6bd5fefa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dovecot-devel-2.3.21-21.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-devel;unpack=0"
SRC_URI[x86_64_v2_dovecot-devel.sha256sum] = "6a2aa11b1011018c09fe723aa5618a1347f3ca6ad9ca1b200fa4c93815598070"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-mysql-2.3.21-21.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-mysql;unpack=0"
SRC_URI[x86_64_v2_dovecot-mysql.sha256sum] = "46d915830266129112af4761e65f7aa5ea75fc9faa02849d83bee812543fc5ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pgsql-2.3.21-21.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-pgsql;unpack=0"
SRC_URI[x86_64_v2_dovecot-pgsql.sha256sum] = "7a958ca5124294d8ca521f566b24f2622f1ce7496aa1ec060c93de58d5e58211"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pigeonhole-2.3.21-21.el10.x86_64_v2.rpm;name=x86_64_v2_dovecot-pigeonhole;unpack=0"
SRC_URI[x86_64_v2_dovecot-pigeonhole.sha256sum] = "bc4599c4bbc87ea64747b735ce9feaa9bfb3b2b20a708d69fa5cf30f625fb931"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-2.3.21-21.el10.aarch64.rpm;name=aarch64_dovecot;unpack=0"
SRC_URI[aarch64_dovecot.sha256sum] = "9c11f1918961ab788a7b04b66aa4ec35ccf193c46ab01e90ad2e6dd18e46ea2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dovecot-devel-2.3.21-21.el10.aarch64.rpm;name=aarch64_dovecot-devel;unpack=0"
SRC_URI[aarch64_dovecot-devel.sha256sum] = "48812ba602d6eca82c8855de6564c739687a86f07550a22af7dba23849531148"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-mysql-2.3.21-21.el10.aarch64.rpm;name=aarch64_dovecot-mysql;unpack=0"
SRC_URI[aarch64_dovecot-mysql.sha256sum] = "097f83e041597c742d5105522fb90b31692b60f8bf81c4c2c899f9c7aed60332"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pgsql-2.3.21-21.el10.aarch64.rpm;name=aarch64_dovecot-pgsql;unpack=0"
SRC_URI[aarch64_dovecot-pgsql.sha256sum] = "1a6146d4f8ba0470b1e48d2797a0a43a998b4a5cd443e145e0fe1542dd93600e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pigeonhole-2.3.21-21.el10.aarch64.rpm;name=aarch64_dovecot-pigeonhole;unpack=0"
SRC_URI[aarch64_dovecot-pigeonhole.sha256sum] = "128a75c0379cbd52561d6c1d97818d7b0ca80818cb6e7865dfc594b2d90487cd"

RDEPENDS:dovecot:x86_64_v2 = " \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libcap \
 libcom_err \
 libicu \
 libxcrypt \
 libzstd \
 lz4-libs \
 openldap \
 openssl \
 openssl-libs \
 pam-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:dovecot:aarch64 = " \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libcom_err \
 libicu \
 libxcrypt \
 libzstd \
 lz4-libs \
 openldap \
 openssl \
 openssl-libs \
 pam-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:dovecot-devel = " \
 dovecot \
 "
RDEPENDS:dovecot-mysql = " \
 dovecot \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:dovecot-pgsql = " \
 dovecot \
 glibc \
 libpq \
 "
RDEPENDS:dovecot-pigeonhole = " \
 dovecot \
 glibc \
 "
