# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_normalizer"
PV = "2.2.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_normalizer+datagen-devel \
 rust-icu_normalizer+default-devel \
 rust-icu_normalizer+harfbuzz_traits-devel \
 rust-icu_normalizer+icu_properties-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_normalizer+utf16_iter-devel \
 rust-icu_normalizer+utf8_iter-devel \
 rust-icu_normalizer+write16-devel \
 rust-icu_normalizer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_normalizer-2.2.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20ca92770d476ddbec8a11ec54c897ef3c0a621b9f355718576eefe266649a3e"

URI_x86_64_v2_rust-icu_normalizer+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+compiled_data-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+compiled_data-devel.sha256sum] = "03417a862b6c26bbbb11c73cf6e3bc0180c50e8a9fb1aca7f03d998b08f32012"

URI_x86_64_v2_rust-icu_normalizer+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+datagen-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+datagen-devel.sha256sum] = "470362c690161274e2a4adad231e5e2d61118075d148beeb46407e243ecac381"

URI_x86_64_v2_rust-icu_normalizer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+default-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+default-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+default-devel.sha256sum] = "b5f79e98a3218ff9bb3777b8768434f605d10e785b6926e47c0dd0a2ed2327dc"

URI_x86_64_v2_rust-icu_normalizer+harfbuzz_traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+harfbuzz_traits-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+harfbuzz_traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+harfbuzz_traits-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+harfbuzz_traits-devel.sha256sum] = "bb1db830c4561fea26469886409791441bb812a6ce5a23fe480006de4cb81b9a"

URI_x86_64_v2_rust-icu_normalizer+icu_properties-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+icu_properties-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+icu_properties-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+icu_properties-devel.sha256sum] = "86405468a2f6de7f7d60bd385a4c33c40a94ca3961f94b22b3b7b768b12a88b2"

URI_x86_64_v2_rust-icu_normalizer+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+serde-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+serde-devel.sha256sum] = "5214f98acf563912aa73445e460aa69ef35264ac7c3c201f606a3f96616e2d28"

URI_x86_64_v2_rust-icu_normalizer+utf16_iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+utf16_iter-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+utf16_iter-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+utf16_iter-devel.sha256sum] = "c614b2ac63ed3b2c2b9dd8f75933d1a09ad6778cc58a7627288d99917fb2d2d3"

URI_x86_64_v2_rust-icu_normalizer+utf8_iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+utf8_iter-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+utf8_iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+utf8_iter-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+utf8_iter-devel.sha256sum] = "20f3916a1e7bc7786dff71c608fdd47b04c8753bd139332983334908cc550c28"

URI_x86_64_v2_rust-icu_normalizer+write16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+write16-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+write16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+write16-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+write16-devel.sha256sum] = "ae71391fe3111b53c6e454a3bafb63d6e4e8b4b2a2bab861ebfe9a91a730ac6f"

URI_x86_64_v2_rust-icu_normalizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer-devel-2.2.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer-devel.sha256sum] = "2c1dc72cf0859d855475c5a57c731d9a5d03c6bd10471ba81b2c4498677ed1eb"

URI_aarch64_rust-icu_normalizer+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+compiled_data-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_normalizer+compiled_data-devel.sha256sum] = "7c217cb861e83d52dcf7f93c452dc6a1df743a798fed9fa23e99512a65170500"

URI_aarch64_rust-icu_normalizer+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+datagen-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+datagen-devel}"
SRC_URI[aarch64_rust-icu_normalizer+datagen-devel.sha256sum] = "31d37b7cb742c17b7c84c5b53a3468f29c49a5518e1fabf14c4572c280308212"

URI_aarch64_rust-icu_normalizer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+default-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+default-devel}"
SRC_URI[aarch64_rust-icu_normalizer+default-devel.sha256sum] = "241b955eb0b6313d556ae46f8339ea3ed2d3dd4bd1c0ced037a4356910d0b65f"

URI_aarch64_rust-icu_normalizer+harfbuzz_traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+harfbuzz_traits-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer+harfbuzz_traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+harfbuzz_traits-devel}"
SRC_URI[aarch64_rust-icu_normalizer+harfbuzz_traits-devel.sha256sum] = "4f60073c10d69203b3a526f1e5a972122ef91fd5a20b4238c58a2ca113e7e0ee"

URI_aarch64_rust-icu_normalizer+icu_properties-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+icu_properties-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer+icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+icu_properties-devel}"
SRC_URI[aarch64_rust-icu_normalizer+icu_properties-devel.sha256sum] = "8c728a17856493130bb074d78bc20f4e91ca6a449bd2053fe8b7ad534493a662"

URI_aarch64_rust-icu_normalizer+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+serde-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+serde-devel}"
SRC_URI[aarch64_rust-icu_normalizer+serde-devel.sha256sum] = "83402562de179cb8666b0c99e32d7e9ac94977db78af2a23969c884658dd598f"

URI_aarch64_rust-icu_normalizer+utf16_iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+utf16_iter-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer+utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+utf16_iter-devel}"
SRC_URI[aarch64_rust-icu_normalizer+utf16_iter-devel.sha256sum] = "f92d7d3800d968eee2e0ae34ebcff92c1ceee7a252fdf065bec173c547d35dd0"

URI_aarch64_rust-icu_normalizer+utf8_iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+utf8_iter-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer+utf8_iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+utf8_iter-devel}"
SRC_URI[aarch64_rust-icu_normalizer+utf8_iter-devel.sha256sum] = "1f041f238f86d3e52c9c669842210b9eec2fbc879133db5a055d4ed7d64b07cd"

URI_aarch64_rust-icu_normalizer+write16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+write16-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer+write16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+write16-devel}"
SRC_URI[aarch64_rust-icu_normalizer+write16-devel.sha256sum] = "aa4b0a96740160ad4f17d0c0c5f4f154a220e654ef2085bc6be29c3aa4c301b0"

URI_aarch64_rust-icu_normalizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer-devel-2.2.0-2.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer-devel}"
SRC_URI[aarch64_rust-icu_normalizer-devel.sha256sum] = "33035d1690a5d0b6d265e2dee5c0b859db259bb31992a0bfd07dac3b85ac5877"

RDEPENDS:rust-icu_normalizer+compiled_data-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-icu_normalizer_data-devel \
 rust-icu_properties+compiled_data-devel \
 rust-icu_properties-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_normalizer+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_normalizer+icu_properties-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties+datagen-devel \
 rust-icu_properties-devel \
 rust-icu_provider+export-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_normalizer+default-devel = " \
 cargo \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_normalizer+utf16_iter-devel \
 rust-icu_normalizer+utf8_iter-devel \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer+harfbuzz_traits-devel = " \
 cargo \
 rust-harfbuzz-traits-devel \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer+icu_properties-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-icu_properties-devel \
 "
RDEPENDS:rust-icu_normalizer+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties+serde-devel \
 rust-icu_properties-devel \
 rust-icu_provider+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_normalizer+utf16_iter-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-utf16_iter-devel \
 rust-write16+alloc-devel \
 rust-write16-devel \
 "
RDEPENDS:rust-icu_normalizer+utf8_iter-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-utf8_iter-devel \
 "
RDEPENDS:rust-icu_normalizer+write16-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_provider-devel \
 rust-smallvec-devel \
 rust-zerovec-devel \
 "
