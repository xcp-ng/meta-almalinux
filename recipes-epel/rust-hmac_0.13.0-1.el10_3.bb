# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hmac"
PV = "0.13.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-hmac+default-devel \
 rust-hmac+zeroize-devel \
 rust-hmac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hmac-0.13.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfb05a6373f25e8d3e4f69c77b56457b50039c9b402d0eac304eca65a8905e7c"

URI_x86_64_v2_rust-hmac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac+default-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hmac+default-devel}"
SRC_URI[x86_64_v2_rust-hmac+default-devel.sha256sum] = "bf63d18e7563620abf317b1436571294881c95a401a68e8fad78fd0f59566279"

URI_x86_64_v2_rust-hmac+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac+zeroize-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hmac+zeroize-devel}"
SRC_URI[x86_64_v2_rust-hmac+zeroize-devel.sha256sum] = "53e0bebd442687c8713452de129c6b6d81f36c105d2f53cd87a133eaeb00c8d2"

URI_x86_64_v2_rust-hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hmac-devel}"
SRC_URI[x86_64_v2_rust-hmac-devel.sha256sum] = "660f55c695a321599a26ec9060c5b7368671d7cc59a4018e7c091ba2eb365db6"

URI_aarch64_rust-hmac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac+default-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-hmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hmac+default-devel}"
SRC_URI[aarch64_rust-hmac+default-devel.sha256sum] = "a8a2f967f73d84aeefeb87bc2c1b7d3efddfeaba584c7c0d212e368fde791c23"

URI_aarch64_rust-hmac+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac+zeroize-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-hmac+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hmac+zeroize-devel}"
SRC_URI[aarch64_rust-hmac+zeroize-devel.sha256sum] = "ca22a1f49b36d2ddbd76676bafaf855ec844ece77f97c139b8487a1ef0341b38"

URI_aarch64_rust-hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hmac-devel}"
SRC_URI[aarch64_rust-hmac-devel.sha256sum] = "53dccc35d9c6664bbba500f1f6d01945098cab176f3b721c68aa79ba0db4ec32"

RDEPENDS:rust-hmac+default-devel = " \
 cargo \
 rust-hmac-devel \
 "
RDEPENDS:rust-hmac+zeroize-devel = " \
 cargo \
 rust-digest+zeroize-devel \
 rust-hmac-devel \
 "
RDEPENDS:rust-hmac-devel = " \
 cargo \
 rust \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
