# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c-ares"
PV = "1.25.0"
PR = "6.el10"
PACKAGES = " \
 c-ares \
 c-ares-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/c-ares-1.25.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa54666e3155ce6b83b018470ad79427dbf317ae86e929c9e5cf32b027611ab5"

URI_x86_64_v2_c-ares = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/c-ares-1.25.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_c-ares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-ares}"
SRC_URI[x86_64_v2_c-ares.sha256sum] = "b2180b0a38cf6dcf73c333bfdcb0994bf9a86fb22739cab5f97a0aa4cd543c00"

URI_x86_64_v2_c-ares-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/c-ares-devel-1.25.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_c-ares-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c-ares-devel}"
SRC_URI[x86_64_v2_c-ares-devel.sha256sum] = "10a9d7c51cf213b02e22f0faf24f6d1db73919c24d652986f97333d7da7edc26"

URI_aarch64_c-ares = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/c-ares-1.25.0-6.el10.aarch64.rpm;name=aarch64_c-ares;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-ares}"
SRC_URI[aarch64_c-ares.sha256sum] = "7c1d179b2c58425794a65e04dc37a8799c2bb65b94ceacc39705adc1cf4ee565"

URI_aarch64_c-ares-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/c-ares-devel-1.25.0-6.el10.aarch64.rpm;name=aarch64_c-ares-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c-ares-devel}"
SRC_URI[aarch64_c-ares-devel.sha256sum] = "7fe2bf271577a06b314f794f5f209ab1de6ea89519867d7c7754d69e58a50560"

RDEPENDS:c-ares = " \
 glibc \
 "
RDEPENDS:c-ares-devel = " \
 c-ares \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
