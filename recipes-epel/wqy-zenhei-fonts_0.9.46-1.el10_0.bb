# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wqy-zenhei-fonts"
PV = "0.9.46"
PR = "1.el10_0"
PACKAGES = " \
 wqy-zenhei-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wqy-zenhei-fonts-0.9.46-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20672dc5020660aa1e656a059acd03d5403ec9d660ce1cf9f0c2497cc3353b6d"

URI_x86_64_v2_wqy-zenhei-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wqy-zenhei-fonts-0.9.46-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_wqy-zenhei-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wqy-zenhei-fonts}"
SRC_URI[x86_64_v2_wqy-zenhei-fonts.sha256sum] = "1d94f9a210580cffb563563dab2feb4ee81e1a1367b0261b2149f314f6cce5d1"

URI_aarch64_wqy-zenhei-fonts = "${EPEL_MIRROR}/aarch64/Packages/w/wqy-zenhei-fonts-0.9.46-1.el10_0.noarch.rpm;name=aarch64_wqy-zenhei-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_wqy-zenhei-fonts}"
SRC_URI[aarch64_wqy-zenhei-fonts.sha256sum] = "dd7e1cf089f4b9ff380e288a282dff2e4bd4d60eeedb3039737a707c3e714591"

RDEPENDS:wqy-zenhei-fonts = " \
 fonts-filesystem \
 "
