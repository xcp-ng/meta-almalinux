# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netplan"
PV = "1.2.1"
PR = "2.el10_1"
PACKAGES = " \
 netplan \
 netplan-default-backend-NetworkManager \
 netplan-default-backend-networkd \
 netplan-devel \
 netplan-libs \
 python3-netplan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netplan-1.2.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e0f2e14f180617ad7fa20c36f06681de0534acbe7efce33f599f3d3d916a8e7"

URI_x86_64_v2_netplan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-1.2.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netplan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan}"
SRC_URI[x86_64_v2_netplan.sha256sum] = "22240a688d2bd94e7577240ffce31e5b722fb3c76039d9ce394a24836738608b"

URI_x86_64_v2_netplan-default-backend-NetworkManager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-default-backend-NetworkManager-1.2.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_netplan-default-backend-NetworkManager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan-default-backend-NetworkManager}"
SRC_URI[x86_64_v2_netplan-default-backend-NetworkManager.sha256sum] = "80eb3b7f8122e7935defa326cac71c8ce8bced811213b6240c0e4ec77dcbdcf9"
RPROVIDES:netplan-default-backend-NetworkManager:append:x86_64_v2 = " virtual/netplan-default-backend"

URI_x86_64_v2_netplan-default-backend-networkd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-default-backend-networkd-1.2.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_netplan-default-backend-networkd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan-default-backend-networkd}"
SRC_URI[x86_64_v2_netplan-default-backend-networkd.sha256sum] = "c12a21795aa4356d7637a63f51e5a043897fdc0f130669dad3b8cead87d4b550"
RPROVIDES:netplan-default-backend-networkd:append:x86_64_v2 = " virtual/netplan-default-backend"

URI_x86_64_v2_netplan-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-devel-1.2.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netplan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan-devel}"
SRC_URI[x86_64_v2_netplan-devel.sha256sum] = "9fd3722932ac68847a50152cced964dd89740992309cd098ded38ee649147d02"

URI_x86_64_v2_netplan-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-libs-1.2.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netplan-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netplan-libs}"
SRC_URI[x86_64_v2_netplan-libs.sha256sum] = "4ac30c2071bf27ced591aa9a46617f6199e8b2794366b8cd5244915743a7d9a9"

URI_x86_64_v2_python3-netplan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-netplan-1.2.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-netplan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-netplan}"
SRC_URI[x86_64_v2_python3-netplan.sha256sum] = "80c064e22d164739e152548f1602193e3316b47fa9f78055f3ba4d4c23dffb89"

URI_aarch64_netplan = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-1.2.1-2.el10_1.aarch64.rpm;name=aarch64_netplan;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan}"
SRC_URI[aarch64_netplan.sha256sum] = "1245d334ee8cb19ca939f372e1dff1612d19f970fb9f19433b753f9aaeaf34bf"

URI_aarch64_netplan-default-backend-NetworkManager = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-default-backend-NetworkManager-1.2.1-2.el10_1.noarch.rpm;name=aarch64_netplan-default-backend-NetworkManager;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan-default-backend-NetworkManager}"
SRC_URI[aarch64_netplan-default-backend-NetworkManager.sha256sum] = "ad1049fbcc03fd4b48a7c0e4394569b5633b7a73c2264654fc166bb37aeaf8a9"
RPROVIDES:netplan-default-backend-NetworkManager:append:aarch64 = " virtual/netplan-default-backend"

URI_aarch64_netplan-default-backend-networkd = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-default-backend-networkd-1.2.1-2.el10_1.noarch.rpm;name=aarch64_netplan-default-backend-networkd;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan-default-backend-networkd}"
SRC_URI[aarch64_netplan-default-backend-networkd.sha256sum] = "1e6fe98cc03adaed7ce16c88003d1d7a897d5f3d4f3d3a72df4236447f46a0b9"
RPROVIDES:netplan-default-backend-networkd:append:aarch64 = " virtual/netplan-default-backend"

URI_aarch64_netplan-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-devel-1.2.1-2.el10_1.aarch64.rpm;name=aarch64_netplan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan-devel}"
SRC_URI[aarch64_netplan-devel.sha256sum] = "c3f6416dba9d54317d41419c1870cdac3e56b833c55045920ebafec0fb8a5850"

URI_aarch64_netplan-libs = "${EPEL_MIRROR}/aarch64/Packages/n/netplan-libs-1.2.1-2.el10_1.aarch64.rpm;name=aarch64_netplan-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_netplan-libs}"
SRC_URI[aarch64_netplan-libs.sha256sum] = "8404773fa169806cb28fdb8752e07bdea10657e2cf6026aff18a4b86497d09d2"

URI_aarch64_python3-netplan = "${EPEL_MIRROR}/aarch64/Packages/p/python3-netplan-1.2.1-2.el10_1.aarch64.rpm;name=aarch64_python3-netplan;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-netplan}"
SRC_URI[aarch64_python3-netplan.sha256sum] = "abcd8819da7c5e88e4abd61bf6d7af2f5a0182a7487b3c816c143316520f41f3"

RDEPENDS:netplan = " \
 dbus-common \
 glib2 \
 glibc \
 iproute \
 libgcc \
 netplan-libs \
 python3 \
 python3-netifaces \
 python3-netplan \
 python3-pyyaml \
 systemd-libs \
 virtual/netplan-default-backend \
 "
RDEPENDS:netplan-default-backend-NetworkManager = " \
 NetworkManager \
 NetworkManager-config-server \
 netplan \
 "
RDEPENDS:netplan-default-backend-networkd = " \
 netplan \
 systemd-networkd \
 "
RDEPENDS:netplan-devel = " \
 glib2-devel \
 libuuid-devel \
 libyaml-devel \
 netplan-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:netplan-libs = " \
 glib2 \
 glibc \
 libgcc \
 libuuid \
 libyaml \
 "
RDEPENDS:python3-netplan = " \
 glibc \
 netplan-libs \
 python3 \
 python3-cffi \
 "
