# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libspelling"
PV = "0.4.6"
PR = "1.el10"
PACKAGES = " \
 libspelling \
 libspelling-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libspelling-0.4.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbc80ae1d938fb3fc7486a3c56539e2b7a2612fb359eabddd2847acc1c5e2b9d"

URI_x86_64_v2_libspelling = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libspelling-0.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_libspelling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspelling}"
SRC_URI[x86_64_v2_libspelling.sha256sum] = "39575479577906f33f51cea8ce5dc0f798c6c5176410a607ad4c6f0bfaabfa26"

URI_x86_64_v2_libspelling-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libspelling-devel-0.4.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_libspelling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspelling-devel}"
SRC_URI[x86_64_v2_libspelling-devel.sha256sum] = "1f8d6030d097954544594f148a2d85947a328aa80f9118afb42eb375903eb501"

URI_aarch64_libspelling = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libspelling-0.4.6-1.el10.aarch64.rpm;name=aarch64_libspelling;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspelling}"
SRC_URI[aarch64_libspelling.sha256sum] = "3bc3352358581e47ceb13c60d29bfe9499a1b30b128535c84286b5d6f883da5e"

URI_aarch64_libspelling-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libspelling-devel-0.4.6-1.el10.aarch64.rpm;name=aarch64_libspelling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspelling-devel}"
SRC_URI[aarch64_libspelling-devel.sha256sum] = "2cdb6fde1aa963a8bde8a3e17963a070a9adda3a01f914afb4fb6b54e3201034"

RDEPENDS:libspelling = " \
 enchant2 \
 glib2 \
 glibc \
 gtk4 \
 gtksourceview5 \
 libgcc \
 libicu \
 pango \
 "
RDEPENDS:libspelling-devel = " \
 glib2-devel \
 gtk4-devel \
 gtksourceview5-devel \
 libspelling \
 pkgconf-pkg-config \
 "
