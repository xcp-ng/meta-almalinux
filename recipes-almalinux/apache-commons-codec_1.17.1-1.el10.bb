# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-codec"
PV = "1.17.1"
PR = "1.el10"
PACKAGES = " \
 apache-commons-codec \
 apache-commons-codec-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apache-commons-codec-1.17.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "390d350d1771cba0c55931f1cbd4e2aa866a0b38b16caf58a51c81852231b214"

URI_x86_64_v2_apache-commons-codec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apache-commons-codec-1.17.1-1.el10.noarch.rpm;name=x86_64_v2_apache-commons-codec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-codec}"
SRC_URI[x86_64_v2_apache-commons-codec.sha256sum] = "0035212dcd86c29c3c2b03bb563f9d90529b0d21db3fcbb6376e8a23a35d1570"

URI_x86_64_v2_apache-commons-codec-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-codec-javadoc-1.17.1-1.el10.noarch.rpm;name=x86_64_v2_apache-commons-codec-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-codec-javadoc}"
SRC_URI[x86_64_v2_apache-commons-codec-javadoc.sha256sum] = "197b4c06f63ff89e65332d110d1b69203836c92b4b4daffd2bf64c376ddebc7d"

URI_aarch64_apache-commons-codec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apache-commons-codec-1.17.1-1.el10.noarch.rpm;name=aarch64_apache-commons-codec;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-codec}"
SRC_URI[aarch64_apache-commons-codec.sha256sum] = "0035212dcd86c29c3c2b03bb563f9d90529b0d21db3fcbb6376e8a23a35d1570"

URI_aarch64_apache-commons-codec-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-codec-javadoc-1.17.1-1.el10.noarch.rpm;name=aarch64_apache-commons-codec-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-codec-javadoc}"
SRC_URI[aarch64_apache-commons-codec-javadoc.sha256sum] = "197b4c06f63ff89e65332d110d1b69203836c92b4b4daffd2bf64c376ddebc7d"

RDEPENDS:apache-commons-codec = " \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-codec-javadoc = " \
 javapackages-filesystem \
 "
