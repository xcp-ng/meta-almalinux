# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinyvec_macros"
PV = "0.1.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-tinyvec_macros+default-devel \
 rust-tinyvec_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tinyvec_macros-0.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62f72457f6dec6da19f0ef4021619502a38b6ca9aab17f655e89bf2f4b8152bb"

URI_x86_64_v2_rust-tinyvec_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec_macros+default-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec_macros+default-devel}"
SRC_URI[x86_64_v2_rust-tinyvec_macros+default-devel.sha256sum] = "fe71bf10eee8d93d05dae47ac5e8dd8e9cea97d708b06fcc43bd3fba1f06105c"

URI_x86_64_v2_rust-tinyvec_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec_macros-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec_macros-devel}"
SRC_URI[x86_64_v2_rust-tinyvec_macros-devel.sha256sum] = "a4718fc6aa563070cc6d92c4a5944bf12662d7058f5e49f19ce5c5bfb318a997"

URI_aarch64_rust-tinyvec_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec_macros+default-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-tinyvec_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec_macros+default-devel}"
SRC_URI[aarch64_rust-tinyvec_macros+default-devel.sha256sum] = "d0a50ae391c7059c08f394cd78893041fa6b1027fde4e96a8b1789f2d0b99d00"

URI_aarch64_rust-tinyvec_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec_macros-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec_macros-devel}"
SRC_URI[aarch64_rust-tinyvec_macros-devel.sha256sum] = "b96fa38f189d69d0eb77f7912198172fec90d8f87fced1601d8a541ff8df906d"

RDEPENDS:rust-tinyvec_macros+default-devel = " \
 cargo \
 rust-tinyvec_macros-devel \
 "
RDEPENDS:rust-tinyvec_macros-devel = " \
 cargo \
 "
