# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Package-Stash-XS"
PV = "0.30"
PR = "3.el10_0"
PACKAGES = " \
 perl-Package-Stash-XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Package-Stash-XS-0.30-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "488ee34fe975652a2dfc7279a49fc02915d4a3d848aca771c7da3cd77b3dd8e6"

URI_x86_64_v2_perl-Package-Stash-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Package-Stash-XS-0.30-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Package-Stash-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Package-Stash-XS}"
SRC_URI[x86_64_v2_perl-Package-Stash-XS.sha256sum] = "78af51a3a7772890d84de521705439792e4f173a7d711b8d6fdd8cefc7c8dad2"

URI_aarch64_perl-Package-Stash-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Package-Stash-XS-0.30-3.el10_0.aarch64.rpm;name=aarch64_perl-Package-Stash-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Package-Stash-XS}"
SRC_URI[aarch64_perl-Package-Stash-XS.sha256sum] = "672e093843bf371be5a6ec9d6ec088ba92ed71be2bf20d07bd4d8b7afd37f82c"

RDEPENDS:perl-Package-Stash-XS = " \
 glibc \
 perl-libs \
 "
