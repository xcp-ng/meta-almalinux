# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kunitconversion"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kunitconversion \
 kf6-kunitconversion-devel \
 kf6-kunitconversion-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kunitconversion-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef828f756371fffc29bf10b238fd8ea26bdce4c02066045e8620d1296dcca57e"

URI_x86_64_v2_kf6-kunitconversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion}"
SRC_URI[x86_64_v2_kf6-kunitconversion.sha256sum] = "84fab9e900acd8c9746a74c4cca6b0a1a6a20432433db9f9d3e6856249b24405"

URI_x86_64_v2_kf6-kunitconversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-devel}"
SRC_URI[x86_64_v2_kf6-kunitconversion-devel.sha256sum] = "147bca6d61aa1ea0dab1eeb1c793b651bca014f82ba4b462d9e85c62fb54c660"

URI_x86_64_v2_kf6-kunitconversion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kunitconversion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-doc}"
SRC_URI[x86_64_v2_kf6-kunitconversion-doc.sha256sum] = "f001ea4571670efb91bd4c57da60d6942c54d875af75b665fa88fe3dcaaa6000"

URI_aarch64_kf6-kunitconversion = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion}"
SRC_URI[aarch64_kf6-kunitconversion.sha256sum] = "79033b68823abe7928624e01f110bd03d526154019c43081654afa1a0e9aaf35"

URI_aarch64_kf6-kunitconversion-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kunitconversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-devel}"
SRC_URI[aarch64_kf6-kunitconversion-devel.sha256sum] = "2decc4dfa27424468ca3ddba99045643613badbd109b947555d26bece45b2fb6"

URI_aarch64_kf6-kunitconversion-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kunitconversion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-doc}"
SRC_URI[aarch64_kf6-kunitconversion-doc.sha256sum] = "0d1d097487f80fda40ce77be4bc29658da451962f1e72649019edddcecd32c69"

RDEPENDS:kf6-kunitconversion = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kunitconversion-devel = " \
 cmake-filesystem \
 kf6-kunitconversion \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kunitconversion-doc = " \
 "
