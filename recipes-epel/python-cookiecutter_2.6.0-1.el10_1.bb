# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cookiecutter"
PV = "2.6.0"
PR = "1.el10_1"
PACKAGES = " \
 python-cookiecutter-doc \
 python3-cookiecutter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cookiecutter-2.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9eec31bb620b4277fa3eeffeb9e9f76ddf9ff7d7d4ad22ce47a282e11e1304bc"

URI_x86_64_v2_python-cookiecutter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-cookiecutter-doc-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-cookiecutter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-cookiecutter-doc}"
SRC_URI[x86_64_v2_python-cookiecutter-doc.sha256sum] = "e798bc352d218fb8ae3c2ac34e25f659900c0246e298d70b42bb07d3d470caeb"

URI_x86_64_v2_python3-cookiecutter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cookiecutter-2.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cookiecutter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cookiecutter}"
SRC_URI[x86_64_v2_python3-cookiecutter.sha256sum] = "17d42239858f3047f9f0610e77388feb1f931a557942b1d01950e814f2a180c7"

URI_aarch64_python-cookiecutter-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-cookiecutter-doc-2.6.0-1.el10_1.noarch.rpm;name=aarch64_python-cookiecutter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-cookiecutter-doc}"
SRC_URI[aarch64_python-cookiecutter-doc.sha256sum] = "6166e0881dcd2bf064a04ac03783f4acd4bf72661aaef6769935dd61464adf46"

URI_aarch64_python3-cookiecutter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cookiecutter-2.6.0-1.el10_1.noarch.rpm;name=aarch64_python3-cookiecutter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cookiecutter}"
SRC_URI[aarch64_python3-cookiecutter.sha256sum] = "47a82b80f8d6e348a5c742751b5363ef0d60a70f315fa9f3dcd092bc3e5c8a9f"

RDEPENDS:python-cookiecutter-doc = " \
 "
RDEPENDS:python3-cookiecutter = " \
 python3 \
 python3-arrow \
 python3-binaryornot \
 python3-click \
 python3-jinja2 \
 python3-pyyaml \
 python3-requests \
 python3-rich \
 python3-slugify \
 "
