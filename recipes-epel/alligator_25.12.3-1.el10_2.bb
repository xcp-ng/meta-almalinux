# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alligator"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 alligator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alligator-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c881b14eb2f00c2bcc89b5c575b7ae1a02adebf598c9ed6223db45dd328eeae8"

URI_x86_64_v2_alligator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alligator-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alligator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alligator}"
SRC_URI[x86_64_v2_alligator.sha256sum] = "6c22ee1a9ebe7ce19a2345a973395f971be5b37650f9c037f11c4b1dcaa64454"

URI_aarch64_alligator = "${EPEL_MIRROR}/aarch64/Packages/a/alligator-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_alligator;unpack=0"
SRC_URI:append = " ${URI_aarch64_alligator}"
SRC_URI[aarch64_alligator.sha256sum] = "cd784dbd593091a0a561210598a6bcabfcf3f09ac167630bcac8c2d808f42538"

RDEPENDS:alligator = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
