# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-rs-sys"
PV = "0.5.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-libz-rs-sys+c-allocator-devel \
 rust-libz-rs-sys+custom-prefix-devel \
 rust-libz-rs-sys+default-devel \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+semver-prefix-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys+testing-prefix-devel \
 rust-libz-rs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-rs-sys-0.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af50bc89a783e89084ccfb1498f6525f053f7053af2f357345f7ae7f8cafb7fc"

URI_x86_64_v2_rust-libz-rs-sys+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+c-allocator-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "3ca57e1278803e5bf677d1c73233519e39ff8459ffdd84fbe135ed99dc4d2cff"

URI_x86_64_v2_rust-libz-rs-sys+custom-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+custom-prefix-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+custom-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "0f03799f510ef3eb21dc53a7fe78e7209c25b0385f30610edd74a223352de67a"

URI_x86_64_v2_rust-libz-rs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+default-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+default-devel.sha256sum] = "547e8890fe8bfd4fa12f759d854433e890b5d804b492f610781c6984c1558fa6"

URI_x86_64_v2_rust-libz-rs-sys+export-symbols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+export-symbols-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+export-symbols-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "7344be1bd165de29a8d790f6676295e49ef2221d6453dee2be96982daaad7f5e"

URI_x86_64_v2_rust-libz-rs-sys+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+rust-allocator-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "d51eb4e6854eada6d66ab9bba5a6b3c306f9cfa57872071d45c71ce48120868b"

URI_x86_64_v2_rust-libz-rs-sys+semver-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+semver-prefix-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+semver-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "7635fbfcc15a73db91f263729a7302da6cfb546bde054629ed828d2d57e4238a"

URI_x86_64_v2_rust-libz-rs-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+std-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+std-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+std-devel.sha256sum] = "0ec87f0125e330cd7dc89118c0672ccd6262175fecfa9eaedfcd678abd0dea3e"

URI_x86_64_v2_rust-libz-rs-sys+testing-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+testing-prefix-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+testing-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "064aba5a27cf21bf34fa629142493163f835da1cb0e83b2c885f4a9dc3003e38"

URI_x86_64_v2_rust-libz-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys-devel.sha256sum] = "50fac5495580ee504d89544beea4647ede5754626b1d46f5109387aa6706f95b"

URI_aarch64_rust-libz-rs-sys+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+c-allocator-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+c-allocator-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "5b8a67bbc79679dbde5a778b9ac51638cdb0f6998bdf60c053fff4574fc71eab"

URI_aarch64_rust-libz-rs-sys+custom-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+custom-prefix-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+custom-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "dc25790debac85805287f2f4446f3adde392efb9d12099844cd12d9be1b367be"

URI_aarch64_rust-libz-rs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+default-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+default-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+default-devel.sha256sum] = "3b89c50ca7f1697a6e08fa46cea24c40b6c98c1bebc2a1ddfdda36783254baa0"

URI_aarch64_rust-libz-rs-sys+export-symbols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+export-symbols-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+export-symbols-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "77b5fb9406c043608aee7818731d35852e7aaf6d0af0f98f4ad572b814698990"

URI_aarch64_rust-libz-rs-sys+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+rust-allocator-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+rust-allocator-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "1837d6f0f415dc861d84c582787906db856b32a726198363ff9e1d39e1607d0a"

URI_aarch64_rust-libz-rs-sys+semver-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+semver-prefix-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+semver-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "83d2b1f90107127122f79da4b6d206208486c8535a6d354cf6634309c88df239"

URI_aarch64_rust-libz-rs-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+std-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+std-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+std-devel.sha256sum] = "e4adb5a54f4bad312b20dbd519e5b195a2e3f93bac72617849fee34ff59996d0"

URI_aarch64_rust-libz-rs-sys+testing-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+testing-prefix-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+testing-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "890759718099b0c18fae2d275651a666e67a45b04dc479cb2d002d2f6a138dfd"

URI_aarch64_rust-libz-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys-devel}"
SRC_URI[aarch64_rust-libz-rs-sys-devel.sha256sum] = "06a339ed0e2525256344e19c0a5baa0d5adf3e7d7a30097f938fe644156d85d5"

RDEPENDS:rust-libz-rs-sys+c-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+c-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+custom-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+default-devel = " \
 cargo \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+export-symbols-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+rust-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+rust-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+semver-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+std-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+std-devel \
 "
RDEPENDS:rust-libz-rs-sys+testing-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys-devel = " \
 cargo \
 rust \
 rust-zlib-rs-devel \
 "
