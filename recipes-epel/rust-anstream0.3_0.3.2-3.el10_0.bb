# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstream0.3"
PV = "0.3.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-anstream0.3+auto-devel \
 rust-anstream0.3+default-devel \
 rust-anstream0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstream0.3-0.3.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b240feedb893b72adb0b363c8940a2406a0d86936d53e122b809ce226d8f0fa1"

URI_x86_64_v2_rust-anstream0.3+auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream0.3+auto-devel-0.3.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream0.3+auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream0.3+auto-devel}"
SRC_URI[x86_64_v2_rust-anstream0.3+auto-devel.sha256sum] = "8597b8124794307fba7b96e6cd8814c9ec5062a621f4ea1ed409ec46a77ce487"

URI_x86_64_v2_rust-anstream0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream0.3+default-devel-0.3.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream0.3+default-devel}"
SRC_URI[x86_64_v2_rust-anstream0.3+default-devel.sha256sum] = "e4b3ef56167378f93739a99fdd1a04b7d60f20d7bd60379c1f7c74f123a99e4b"

URI_x86_64_v2_rust-anstream0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream0.3-devel-0.3.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream0.3-devel}"
SRC_URI[x86_64_v2_rust-anstream0.3-devel.sha256sum] = "e333f2b4c241b9f030052fff1698d6e8031758be7c8ba249f9c0052a5fbb7201"

URI_aarch64_rust-anstream0.3+auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream0.3+auto-devel-0.3.2-3.el10_0.noarch.rpm;name=aarch64_rust-anstream0.3+auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream0.3+auto-devel}"
SRC_URI[aarch64_rust-anstream0.3+auto-devel.sha256sum] = "6d68ab302b605784b7de0adf73004532330aa02d1d0067c681c88dccb50a7c52"

URI_aarch64_rust-anstream0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream0.3+default-devel-0.3.2-3.el10_0.noarch.rpm;name=aarch64_rust-anstream0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream0.3+default-devel}"
SRC_URI[aarch64_rust-anstream0.3+default-devel.sha256sum] = "d144e80c21a662d9c5026bbf705b6cabb6ff6b05c52b3d010b05e8fa9104d646"

URI_aarch64_rust-anstream0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream0.3-devel-0.3.2-3.el10_0.noarch.rpm;name=aarch64_rust-anstream0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream0.3-devel}"
SRC_URI[aarch64_rust-anstream0.3-devel.sha256sum] = "bd2779f58eeb3307e8e7adc26b08bc4e3bf8b1fe2caf0418c3119de2027df5c0"

RDEPENDS:rust-anstream0.3+auto-devel = " \
 cargo \
 rust-anstream0.3-devel \
 rust-anstyle-query+default-devel \
 rust-colorchoice+default-devel \
 rust-is-terminal+default-devel \
 "
RDEPENDS:rust-anstream0.3+default-devel = " \
 cargo \
 rust-anstream0.3+auto-devel \
 rust-anstream0.3-devel \
 "
RDEPENDS:rust-anstream0.3-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-parse+default-devel \
 rust-utf8parse+default-devel \
 "
