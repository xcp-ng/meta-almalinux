# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-harfbuzz-traits"
PV = "0.6.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-harfbuzz-traits+default-devel \
 rust-harfbuzz-traits-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-harfbuzz-traits-0.6.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a22c3b3b7a57088513b9e47fbeb10dce650b79c1bba22ff3e36cdd8c2f92c97"

URI_x86_64_v2_rust-harfbuzz-traits+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-harfbuzz-traits+default-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-harfbuzz-traits+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-harfbuzz-traits+default-devel}"
SRC_URI[x86_64_v2_rust-harfbuzz-traits+default-devel.sha256sum] = "db221939fa8ce2ee18f2b4f1bf53293f3e0bf8e8133f35cba71641a15b86843c"

URI_x86_64_v2_rust-harfbuzz-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-harfbuzz-traits-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-harfbuzz-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-harfbuzz-traits-devel}"
SRC_URI[x86_64_v2_rust-harfbuzz-traits-devel.sha256sum] = "7c0df26f3d8f3e704863493e47573193f0ee900440ad1e9fc3e6b3a4b7e982c3"

URI_aarch64_rust-harfbuzz-traits+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-harfbuzz-traits+default-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-harfbuzz-traits+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-harfbuzz-traits+default-devel}"
SRC_URI[aarch64_rust-harfbuzz-traits+default-devel.sha256sum] = "7cd6846484a7eeb42f06adef16b44ab2b9c04e472644c653dd596bbf95320753"

URI_aarch64_rust-harfbuzz-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-harfbuzz-traits-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-harfbuzz-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-harfbuzz-traits-devel}"
SRC_URI[aarch64_rust-harfbuzz-traits-devel.sha256sum] = "d02aed4b19fffda9c6a2a809b1f058b83057a2fe3c3fe1a5db7c91c632adc138"

RDEPENDS:rust-harfbuzz-traits+default-devel = " \
 cargo \
 rust-harfbuzz-traits-devel \
 "
RDEPENDS:rust-harfbuzz-traits-devel = " \
 cargo \
 "
