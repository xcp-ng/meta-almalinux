# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cipher"
PV = "0.5.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-cipher+alloc-devel \
 rust-cipher+blobby-devel \
 rust-cipher+block-buffer-devel \
 rust-cipher+block-padding-devel \
 rust-cipher+default-devel \
 rust-cipher+dev-devel \
 rust-cipher+getrandom-devel \
 rust-cipher+rand_core-devel \
 rust-cipher+stream-wrapper-devel \
 rust-cipher+zeroize-devel \
 rust-cipher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cipher-0.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fe73587c7ecb7569252c32f237b55b6bd164c4f316189e9881fdf2084ea1310"

URI_x86_64_v2_rust-cipher+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+alloc-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+alloc-devel}"
SRC_URI[x86_64_v2_rust-cipher+alloc-devel.sha256sum] = "136e47a8b79574e55195736575a1c73dc7d8849343fd000c53b9b4681b5a637f"

URI_x86_64_v2_rust-cipher+blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+blobby-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+blobby-devel}"
SRC_URI[x86_64_v2_rust-cipher+blobby-devel.sha256sum] = "db157f992aae2f2b6fa3b396d8b0cdcb8616ae6d79b4e5c85e66434c0a71c74f"

URI_x86_64_v2_rust-cipher+block-buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+block-buffer-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+block-buffer-devel}"
SRC_URI[x86_64_v2_rust-cipher+block-buffer-devel.sha256sum] = "aa2cf9680c811a97dd9212dfe046e260180cf0df32a5edb3edeb5115e2018def"

URI_x86_64_v2_rust-cipher+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+block-padding-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+block-padding-devel}"
SRC_URI[x86_64_v2_rust-cipher+block-padding-devel.sha256sum] = "45f8cd68c705a5637553c49fcd3741f835a63301c85cf527a47dc51d7287a1df"

URI_x86_64_v2_rust-cipher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+default-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+default-devel}"
SRC_URI[x86_64_v2_rust-cipher+default-devel.sha256sum] = "7229e24a37a022f541772c6ed546c6cba60bf71ba9baee6b1b62093acc726098"

URI_x86_64_v2_rust-cipher+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+dev-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+dev-devel}"
SRC_URI[x86_64_v2_rust-cipher+dev-devel.sha256sum] = "fff87a6033813856b4685cffe7becc0bac2d9bcbe2376faaaae13dfa38c67d5a"

URI_x86_64_v2_rust-cipher+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+getrandom-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+getrandom-devel}"
SRC_URI[x86_64_v2_rust-cipher+getrandom-devel.sha256sum] = "6594d1a91660f3a4d3bf313cf7de6b228cbe9a7e02d7bd28ce9018ea39437512"

URI_x86_64_v2_rust-cipher+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+rand_core-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+rand_core-devel}"
SRC_URI[x86_64_v2_rust-cipher+rand_core-devel.sha256sum] = "db2473cd248612429b0dd87706fc0485c7e54f7ebd10d8c11754a093ca9954a7"

URI_x86_64_v2_rust-cipher+stream-wrapper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+stream-wrapper-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+stream-wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+stream-wrapper-devel}"
SRC_URI[x86_64_v2_rust-cipher+stream-wrapper-devel.sha256sum] = "dddbf230b3f93462f78d67ab983dac7cb8cacc1d5ab00d0980459332d989bcd0"

URI_x86_64_v2_rust-cipher+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+zeroize-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cipher+zeroize-devel.sha256sum] = "b52717d1e0bd1318bb2019e385a4ba15d705672c8273a36fce1b50c3c50e3bec"

URI_x86_64_v2_rust-cipher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher-devel-0.5.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher-devel}"
SRC_URI[x86_64_v2_rust-cipher-devel.sha256sum] = "e329b0b4001508334bab7e47e175e2349df01f1177e102b7ae9228c31a5be86f"

URI_aarch64_rust-cipher+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+alloc-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+alloc-devel}"
SRC_URI[aarch64_rust-cipher+alloc-devel.sha256sum] = "c4359e04b3c97aa3d1be2604f2e4cfe20ee87f6aa9a312ef64c4a545829a365e"

URI_aarch64_rust-cipher+blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+blobby-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+blobby-devel}"
SRC_URI[aarch64_rust-cipher+blobby-devel.sha256sum] = "26f57245aa588f00d98322685cd28c1ef6afe25504168d0d0f7e6821fc3bc84f"

URI_aarch64_rust-cipher+block-buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+block-buffer-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+block-buffer-devel}"
SRC_URI[aarch64_rust-cipher+block-buffer-devel.sha256sum] = "5dc29cfa28a18c1396ed89242d01334ca9eec5f6e7dfce994c972dd3724e386f"

URI_aarch64_rust-cipher+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+block-padding-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+block-padding-devel}"
SRC_URI[aarch64_rust-cipher+block-padding-devel.sha256sum] = "817e890feeb2b34d62b87cad684e1efbaf35c3ac6fba86e9a049bb1875959dcc"

URI_aarch64_rust-cipher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+default-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+default-devel}"
SRC_URI[aarch64_rust-cipher+default-devel.sha256sum] = "6b5b77fbe6c3bb14062792c9d736674d1799372f87669d648a7f2515e6c425bf"

URI_aarch64_rust-cipher+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+dev-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+dev-devel}"
SRC_URI[aarch64_rust-cipher+dev-devel.sha256sum] = "f865f172967569d5a339785a78b4650ca3ebda0a03d05c0981d1640e196d3f83"

URI_aarch64_rust-cipher+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+getrandom-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+getrandom-devel}"
SRC_URI[aarch64_rust-cipher+getrandom-devel.sha256sum] = "31f50b13495e6311772422d08c82868814d774bdd4ba40d631f529cc2429db42"

URI_aarch64_rust-cipher+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+rand_core-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+rand_core-devel}"
SRC_URI[aarch64_rust-cipher+rand_core-devel.sha256sum] = "51a1801b066dd09d5756c4fece11a80b713b1c1180c16aad35720fb9e2617efd"

URI_aarch64_rust-cipher+stream-wrapper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+stream-wrapper-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+stream-wrapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+stream-wrapper-devel}"
SRC_URI[aarch64_rust-cipher+stream-wrapper-devel.sha256sum] = "605ebc2a4b9076e427ca84485e92235cbf5031d494c629a123b3fe19bd6faaed"

URI_aarch64_rust-cipher+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+zeroize-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+zeroize-devel}"
SRC_URI[aarch64_rust-cipher+zeroize-devel.sha256sum] = "f632b591037b1658398df90d3eb65e85703af75589aaf94e88d858cdd29fcddd"

URI_aarch64_rust-cipher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher-devel-0.5.2-1.el10_3.noarch.rpm;name=aarch64_rust-cipher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher-devel}"
SRC_URI[aarch64_rust-cipher-devel.sha256sum] = "ba470b6d4a51f40c002e777954da8ec1a0a427f6954a578c83e13999c9870d8f"

RDEPENDS:rust-cipher+alloc-devel = " \
 cargo \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+blobby-devel = " \
 cargo \
 rust-blobby+default-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+block-buffer-devel = " \
 cargo \
 rust-block-buffer+default-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+block-padding-devel = " \
 cargo \
 rust-cipher-devel \
 rust-inout+block-padding-devel \
 "
RDEPENDS:rust-cipher+default-devel = " \
 cargo \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+dev-devel = " \
 cargo \
 rust-cipher+blobby-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+getrandom-devel = " \
 cargo \
 rust-cipher-devel \
 rust-crypto-common+getrandom-devel \
 "
RDEPENDS:rust-cipher+rand_core-devel = " \
 cargo \
 rust-cipher-devel \
 rust-crypto-common+rand_core-devel \
 "
RDEPENDS:rust-cipher+stream-wrapper-devel = " \
 cargo \
 rust-cipher+block-buffer-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+zeroize-devel = " \
 cargo \
 rust-block-buffer+default-devel \
 rust-block-buffer+zeroize-devel \
 rust-cipher-devel \
 rust-crypto-common+zeroize-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-cipher-devel = " \
 cargo \
 rust \
 rust-crypto-common+default-devel \
 rust-inout+default-devel \
 "
