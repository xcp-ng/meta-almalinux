# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pmezard-difflib"
PV = "1.0.0"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-pmezard-difflib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pmezard-difflib-1.0.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5674621f90b086848a4c7248a8aa4fe77d6fd4afbefb373e122dfe898856b13"

URI_x86_64_v2_golang-github-pmezard-difflib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pmezard-difflib-devel-1.0.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pmezard-difflib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pmezard-difflib-devel}"
SRC_URI[x86_64_v2_golang-github-pmezard-difflib-devel.sha256sum] = "4a75c9147e9ebdd478f4130907bb955c7188d0069783f5589cedbb2aa2c2ed39"

URI_aarch64_golang-github-pmezard-difflib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pmezard-difflib-devel-1.0.0-17.el10_0.noarch.rpm;name=aarch64_golang-github-pmezard-difflib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pmezard-difflib-devel}"
SRC_URI[aarch64_golang-github-pmezard-difflib-devel.sha256sum] = "3bda4b253fa2e7919a19e00c461272b2db7321a97d3aa995ced6c577b85f0c2f"

RDEPENDS:golang-github-pmezard-difflib-devel = " \
 go-filesystem \
 "
