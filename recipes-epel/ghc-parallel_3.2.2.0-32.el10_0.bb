# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-parallel"
PV = "3.2.2.0"
PR = "32.el10_0"
PACKAGES = " \
 ghc-parallel \
 ghc-parallel-devel \
 ghc-parallel-doc \
 ghc-parallel-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-parallel-3.2.2.0-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d18e0162f386cd09416f8afdabaac431fcd72ea684c277bad87bca74aff617e6"

URI_x86_64_v2_ghc-parallel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parallel-3.2.2.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parallel}"
SRC_URI[x86_64_v2_ghc-parallel.sha256sum] = "14050a18c0f6786e01b0a679267f604a900655620a0ca510b6d7a1649678ebb9"

URI_x86_64_v2_ghc-parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parallel-devel-3.2.2.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parallel-devel}"
SRC_URI[x86_64_v2_ghc-parallel-devel.sha256sum] = "dcecfd47003409471d4037766ff55910d3bc8dc504de6bc89284097803ed98ef"

URI_x86_64_v2_ghc-parallel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parallel-doc-3.2.2.0-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-parallel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parallel-doc}"
SRC_URI[x86_64_v2_ghc-parallel-doc.sha256sum] = "8f50942313d7534a9288f5759676c60cafc810a59d5196c89e3fca21c80b4b34"

URI_x86_64_v2_ghc-parallel-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-parallel-prof-3.2.2.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-parallel-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-parallel-prof}"
SRC_URI[x86_64_v2_ghc-parallel-prof.sha256sum] = "c93342d6d642cdb1e79c338378cbfe6e274d2f0ed2f22f0020411b918a657a8a"

URI_aarch64_ghc-parallel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parallel-3.2.2.0-32.el10_0.aarch64.rpm;name=aarch64_ghc-parallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parallel}"
SRC_URI[aarch64_ghc-parallel.sha256sum] = "25f76bda0ec8405c3137b3376cb620479081c0ae4f5d3d1e0b6d7e52c01fc303"

URI_aarch64_ghc-parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parallel-devel-3.2.2.0-32.el10_0.aarch64.rpm;name=aarch64_ghc-parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parallel-devel}"
SRC_URI[aarch64_ghc-parallel-devel.sha256sum] = "81d938ee1dc70d5d7c02d437aea3fb96303c78bafb2c21b7759d046b7410dd58"

URI_aarch64_ghc-parallel-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parallel-doc-3.2.2.0-32.el10_0.noarch.rpm;name=aarch64_ghc-parallel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parallel-doc}"
SRC_URI[aarch64_ghc-parallel-doc.sha256sum] = "d7c9b3c543fd24800c4ec657d55c0a6b43e6551a5c3cddc2da918e8513a67d1e"

URI_aarch64_ghc-parallel-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-parallel-prof-3.2.2.0-32.el10_0.aarch64.rpm;name=aarch64_ghc-parallel-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-parallel-prof}"
SRC_URI[aarch64_ghc-parallel-prof.sha256sum] = "ef644efeda06425839127558401a2943cf3b547ccc2fc329953aab8f2432228c"

RDEPENDS:ghc-parallel = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-parallel-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-parallel \
 "
RDEPENDS:ghc-parallel-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-parallel-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-parallel-devel \
 "
