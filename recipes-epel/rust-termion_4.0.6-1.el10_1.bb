# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-termion"
PV = "4.0.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-termion+default-devel \
 rust-termion+serde-devel \
 rust-termion-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-termion-4.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec76e83f2c4dd61af7a8ea974af69a8dcd6e1c0fce0ab4356539a91fcf019b36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termion+default-devel-4.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termion+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-termion+default-devel.sha256sum] = "80c287719b0e8da53a7efae215ccb95cd9f9cd155e5d55068cce85694cd2066b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termion+serde-devel-4.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termion+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-termion+serde-devel.sha256sum] = "2423c7e1780fd93246d965fc46e37aa5b4d684e20bf7db2d69e7a2a2c574900f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termion-devel-4.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termion-devel;unpack=0"
SRC_URI[x86_64_v2_rust-termion-devel.sha256sum] = "494cff00236b964eda4d681671ee2689065d8246b4472bb0ee37cf385db64aac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-termion+default-devel-4.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-termion+default-devel;unpack=0"
SRC_URI[aarch64_rust-termion+default-devel.sha256sum] = "459f26f0a5f5c04cebe133f3fa8a88452787df2ae42008b6ed35c43c950c4113"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-termion+serde-devel-4.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-termion+serde-devel;unpack=0"
SRC_URI[aarch64_rust-termion+serde-devel.sha256sum] = "a0c3e3ff49252b92a000bc248fe38621f1081576f77af4527d649c1074814492"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-termion-devel-4.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-termion-devel;unpack=0"
SRC_URI[aarch64_rust-termion-devel.sha256sum] = "d67a918cdf680f18ce59b510dc57072179796ee0e366ccc52fab546f66ffde11"

RDEPENDS:rust-termion+default-devel = " \
 cargo \
 rust-termion-devel \
 "
RDEPENDS:rust-termion+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-termion-devel \
 "
RDEPENDS:rust-termion-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-numtoa+default-devel \
 "
