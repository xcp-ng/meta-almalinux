# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic-settings"
PV = "2.8.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-pydantic-settings \
 python3-pydantic-settings+toml \
 python3-pydantic-settings+yaml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-settings-2.8.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e847175443e0960e337206b8ceb7eb67cdc80a5485f712f498ca223a91aac248"

URI_x86_64_v2_python3-pydantic-settings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-settings-2.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-settings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-settings}"
SRC_URI[x86_64_v2_python3-pydantic-settings.sha256sum] = "11a31cfd637080bfabdc821b627edf36af92881267cf7b91511da0ad78c50f91"

URI_x86_64_v2_python3-pydantic-settings+toml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-settings+toml-2.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-settings+toml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-settings+toml}"
SRC_URI[x86_64_v2_python3-pydantic-settings+toml.sha256sum] = "e0f3523017d7a4f6f9b6a6acdb082dc744210468f8ae3c92c5edce1efb63a695"

URI_x86_64_v2_python3-pydantic-settings+yaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-settings+yaml-2.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pydantic-settings+yaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-settings+yaml}"
SRC_URI[x86_64_v2_python3-pydantic-settings+yaml.sha256sum] = "0b881fdc220a44af5b010040628382cf8852df1f31cb8aecfc78e616399735c9"

URI_aarch64_python3-pydantic-settings = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-settings-2.8.1-1.el10_1.noarch.rpm;name=aarch64_python3-pydantic-settings;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-settings}"
SRC_URI[aarch64_python3-pydantic-settings.sha256sum] = "dc3cc95957394c04f0b17f678fc386f55ac83c72fd621e6f65f722185e32cdb3"

URI_aarch64_python3-pydantic-settings+toml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-settings+toml-2.8.1-1.el10_1.noarch.rpm;name=aarch64_python3-pydantic-settings+toml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-settings+toml}"
SRC_URI[aarch64_python3-pydantic-settings+toml.sha256sum] = "f6eaf4f33dbfa5a974457a2e1ccc5ca610269e78a5e2b7cf8e3c02fec82f2355"

URI_aarch64_python3-pydantic-settings+yaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-settings+yaml-2.8.1-1.el10_1.noarch.rpm;name=aarch64_python3-pydantic-settings+yaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-settings+yaml}"
SRC_URI[aarch64_python3-pydantic-settings+yaml.sha256sum] = "cbb6e6eb87af29391fc58622d6553a64fb9d99a34619496201184a586c40550a"

RDEPENDS:python3-pydantic-settings = " \
 python3 \
 python3-dotenv \
 python3-pydantic \
 "
RDEPENDS:python3-pydantic-settings+toml = " \
 python3 \
 python3-pydantic-settings \
 python3-tomli \
 "
RDEPENDS:python3-pydantic-settings+yaml = " \
 python3 \
 python3-pydantic-settings \
 python3-pyyaml \
 "
