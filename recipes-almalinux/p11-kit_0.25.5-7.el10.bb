# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "p11-kit"
PV = "0.25.5"
PR = "7.el10"
PACKAGES = " \
 p11-kit \
 p11-kit-devel \
 p11-kit-server \
 p11-kit-trust \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/p11-kit-0.25.5-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcd72ae43cb1ad0eaa95a2f1cb83a27f241f68557c8001c291e0089593a09606"

URI_x86_64_v2_p11-kit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/p11-kit-0.25.5-7.el10.x86_64_v2.rpm;name=x86_64_v2_p11-kit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_p11-kit}"
SRC_URI[x86_64_v2_p11-kit.sha256sum] = "1d207c2783aa66eaa969ef45f676081a042d1c703c19be9897066f6be2557bba"

URI_x86_64_v2_p11-kit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/p11-kit-devel-0.25.5-7.el10.x86_64_v2.rpm;name=x86_64_v2_p11-kit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_p11-kit-devel}"
SRC_URI[x86_64_v2_p11-kit-devel.sha256sum] = "f1430ef1c5a123acc9192c4b4589cd8a978c0affa94dac51f587796100a1b269"

URI_x86_64_v2_p11-kit-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/p11-kit-server-0.25.5-7.el10.x86_64_v2.rpm;name=x86_64_v2_p11-kit-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_p11-kit-server}"
SRC_URI[x86_64_v2_p11-kit-server.sha256sum] = "7c499f22ba4526648cac129795177790ca66163fbe7d86fdd9b185f00837c20b"

URI_x86_64_v2_p11-kit-trust = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/p11-kit-trust-0.25.5-7.el10.x86_64_v2.rpm;name=x86_64_v2_p11-kit-trust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_p11-kit-trust}"
SRC_URI[x86_64_v2_p11-kit-trust.sha256sum] = "c5a466416970a6e240fb69851d6bf7e0f6519b587f6d5bd708a23878e4eb857c"

URI_aarch64_p11-kit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/p11-kit-0.25.5-7.el10.aarch64.rpm;name=aarch64_p11-kit;unpack=0"
SRC_URI:append = " ${URI_aarch64_p11-kit}"
SRC_URI[aarch64_p11-kit.sha256sum] = "4a0ee02cbf6018d3d1eb650164f713b727b48665fe647d713a34a4202fcf6444"

URI_aarch64_p11-kit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/p11-kit-devel-0.25.5-7.el10.aarch64.rpm;name=aarch64_p11-kit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_p11-kit-devel}"
SRC_URI[aarch64_p11-kit-devel.sha256sum] = "3c3fa7cba40ec41f67a4cbd7f05863d7b1d8c3525522065a3c0bec7fb1c6903a"

URI_aarch64_p11-kit-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/p11-kit-server-0.25.5-7.el10.aarch64.rpm;name=aarch64_p11-kit-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_p11-kit-server}"
SRC_URI[aarch64_p11-kit-server.sha256sum] = "073bdd06fe1a837f8cbca7ec201162c6c55c81d8740d13fba905aa1792ec2254"

URI_aarch64_p11-kit-trust = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/p11-kit-trust-0.25.5-7.el10.aarch64.rpm;name=aarch64_p11-kit-trust;unpack=0"
SRC_URI:append = " ${URI_aarch64_p11-kit-trust}"
SRC_URI[aarch64_p11-kit-trust.sha256sum] = "e12e8f78f5b5b1025588d3ea7deb358800bec0de08c15f2c8c6cd0e24948b3af"

RDEPENDS:p11-kit = " \
 glibc \
 libffi \
 libtasn1 \
 "
RDEPENDS:p11-kit-devel = " \
 p11-kit \
 pkgconf-pkg-config \
 "
RDEPENDS:p11-kit-server = " \
 glibc \
 libffi \
 p11-kit \
 systemd-libs \
 "
RDEPENDS:p11-kit-trust = " \
 alternatives \
 bash \
 glibc \
 libtasn1 \
 p11-kit \
 "
