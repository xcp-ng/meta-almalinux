# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysql8.4"
PV = "8.4.11"
PR = "1.el10.alma.1"
PACKAGES = " \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-devel \
 mysql8.4-errmsg \
 mysql8.4-libs \
 mysql8.4-server \
 mysql8.4-test \
 mysql8.4-test-data \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mysql8.4-8.4.11-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c118f05f8908cff549e09f49e5df15c6ec515f82a4b325dcd47ba821d65c5d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-8.4.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4;unpack=0"
SRC_URI[x86_64_v2_mysql8.4.sha256sum] = "fb8ab2f21cfbbafd785276c5353b703d944b65a78e9a9ef2cbee6fb5e5276717"
RPROVIDES:mysql8.4:append:x86_64_v2 = " virtual//usr/bin/mysqldump virtual/mysql-any_or_mariadb-any"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-common-8.4.11-1.el10.alma.1.noarch.rpm;name=x86_64_v2_mysql8.4-common;unpack=0"
SRC_URI[x86_64_v2_mysql8.4-common.sha256sum] = "a83c1481a89af77af81950f8e9dbe7686e0965841abb899723172f9e65223383"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-devel-8.4.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-devel;unpack=0"
SRC_URI[x86_64_v2_mysql8.4-devel.sha256sum] = "fdd66a1d1d87bcd8a7fcf5ef49996adf429c72bf484d0d70ca7e404575463086"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-errmsg-8.4.11-1.el10.alma.1.noarch.rpm;name=x86_64_v2_mysql8.4-errmsg;unpack=0"
SRC_URI[x86_64_v2_mysql8.4-errmsg.sha256sum] = "1558ee7c0354fd257e4f60afcec2d8a7d0245eab203dfbe9de5554112e5d8356"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-libs-8.4.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-libs;unpack=0"
SRC_URI[x86_64_v2_mysql8.4-libs.sha256sum] = "222fbb77e57a7bfbdcda09af7b82e0e3f132621bbaa8fcb8638e954c243f7921"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mysql8.4-server-8.4.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-server;unpack=0"
SRC_URI[x86_64_v2_mysql8.4-server.sha256sum] = "a84c0e900de6e84a90b16dee933064b55c0c9b292cec4d2b788d8ec0d87a7403"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-test-8.4.11-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_mysql8.4-test;unpack=0"
SRC_URI[x86_64_v2_mysql8.4-test.sha256sum] = "ea779af8ca59886daa9da2319d28c07b58b4b6f256642aea73c7e357c0d6c5c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mysql8.4-test-data-8.4.11-1.el10.alma.1.noarch.rpm;name=x86_64_v2_mysql8.4-test-data;unpack=0"
SRC_URI[x86_64_v2_mysql8.4-test-data.sha256sum] = "3da839556f6064ed61f8bf626039a79dbacfe08e15b79bb26332e9ff2e574c7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-8.4.11-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4;unpack=0"
SRC_URI[aarch64_mysql8.4.sha256sum] = "fe122d529075a0c4e37ea74fb99fb6bfa49d92fe5b345da55317d0fd075ae2b2"
RPROVIDES:mysql8.4:append:aarch64 = " virtual//usr/bin/mysqldump virtual/mysql-any_or_mariadb-any"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-common-8.4.11-1.el10.alma.1.noarch.rpm;name=aarch64_mysql8.4-common;unpack=0"
SRC_URI[aarch64_mysql8.4-common.sha256sum] = "a83c1481a89af77af81950f8e9dbe7686e0965841abb899723172f9e65223383"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-devel-8.4.11-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4-devel;unpack=0"
SRC_URI[aarch64_mysql8.4-devel.sha256sum] = "ac7f5198eac93a208970c1a0049683e52997829ddb189cdd4c1371a770093ae4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-errmsg-8.4.11-1.el10.alma.1.noarch.rpm;name=aarch64_mysql8.4-errmsg;unpack=0"
SRC_URI[aarch64_mysql8.4-errmsg.sha256sum] = "1558ee7c0354fd257e4f60afcec2d8a7d0245eab203dfbe9de5554112e5d8356"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-libs-8.4.11-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4-libs;unpack=0"
SRC_URI[aarch64_mysql8.4-libs.sha256sum] = "3810df80f204fe4593b805837278e4e9384ed3ef532a0be89d1623ff6b280aed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mysql8.4-server-8.4.11-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4-server;unpack=0"
SRC_URI[aarch64_mysql8.4-server.sha256sum] = "7445a839f122aa8592375403b8ffcb4bc47f1095d7c70fa721995549a551f0a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-test-8.4.11-1.el10.alma.1.aarch64.rpm;name=aarch64_mysql8.4-test;unpack=0"
SRC_URI[aarch64_mysql8.4-test.sha256sum] = "5f6f2ec666efa8f0b42ad4fd51f2b98f91d8c74874b0a41e63eac43a48f86b69"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mysql8.4-test-data-8.4.11-1.el10.alma.1.noarch.rpm;name=aarch64_mysql8.4-test-data;unpack=0"
SRC_URI[aarch64_mysql8.4-test-data.sha256sum] = "3da839556f6064ed61f8bf626039a79dbacfe08e15b79bb26332e9ff2e574c7d"

RDEPENDS:mysql8.4 = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 libzstd \
 mysql8.4-common \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mysql8.4-devel = " \
 bash \
 libzstd-devel \
 mysql8.4-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:mysql8.4-errmsg = " \
 mysql8.4-common \
 "
RDEPENDS:mysql8.4-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 mysql8.4-common \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-server:x86_64_v2 = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libicu \
 libstdc++ \
 libtirpc \
 libzstd \
 lz4-libs \
 mariadb-connector-c-config \
 mecab \
 mysql-selinux \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-errmsg \
 numactl-libs \
 openssl-libs \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 policycoreutils-python-utils \
 protobuf-lite \
 shadow-utils \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:mysql8.4-server:aarch64 = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libicu \
 libstdc++ \
 libtirpc \
 libzstd \
 lz4-libs \
 mariadb-connector-c-config \
 mecab \
 mysql-selinux \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-errmsg \
 openssl-libs \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 policycoreutils-python-utils \
 protobuf-lite \
 shadow-utils \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:mysql8.4-test = " \
 bash \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 libzstd \
 lz4 \
 lz4-libs \
 mysql8.4 \
 mysql8.4-common \
 mysql8.4-server \
 mysql8.4-test-data \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Compare \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-JSON \
 perl-Memoize \
 perl-Socket \
 perl-Sys-Hostname \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-libwww-perl \
 protobuf \
 zlib-ng-compat \
 "
RDEPENDS:mysql8.4-test-data = " \
 bash \
 mysql8.4-test \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IO \
 perl-JSON \
 perl-Memoize \
 perl-POSIX \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Test-Simple \
 perl-Time \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 "
