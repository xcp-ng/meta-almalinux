# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libretls"
PV = "3.8.1"
PR = "4.el10_0"
PACKAGES = " \
 libretls \
 libretls-devel \
 libretls-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libretls-3.8.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0970b77537906fc822f3cebe3c87ccc0f3b3c4fcd81ae39a10ca0e82c1d28758"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libretls-3.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libretls;unpack=0"
SRC_URI[x86_64_v2_libretls.sha256sum] = "2c4bc18d2bce24f2fe5f36f1ff0c9def3e50984122983f30e4f0f28bd8e9c823"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libretls-devel-3.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libretls-devel;unpack=0"
SRC_URI[x86_64_v2_libretls-devel.sha256sum] = "277d2ebb2cbe2f8cbaf91a0694298577eb33b2d43cf442f9af8f67bb2efc63ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libretls-static-3.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libretls-static;unpack=0"
SRC_URI[x86_64_v2_libretls-static.sha256sum] = "126efda90b14e4790c29e8d243191e71b5f860d4735a309c236e7b74b237fde0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libretls-3.8.1-4.el10_0.aarch64.rpm;name=aarch64_libretls;unpack=0"
SRC_URI[aarch64_libretls.sha256sum] = "47d8d43a6a4a0eef6906f696e47c847021dc3482b64fa3346874835c9f5a6c80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libretls-devel-3.8.1-4.el10_0.aarch64.rpm;name=aarch64_libretls-devel;unpack=0"
SRC_URI[aarch64_libretls-devel.sha256sum] = "d8bb4bbe4067df822c43d391c2eff1957358eee3b735db069b4df745f32725cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libretls-static-3.8.1-4.el10_0.aarch64.rpm;name=aarch64_libretls-static;unpack=0"
SRC_URI[aarch64_libretls-static.sha256sum] = "c029ef088bc9a4a7583180cbd6fa867556f3da4bf26c9b6c9e716d506588c510"

RDEPENDS:libretls = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:libretls-devel = " \
 libretls \
 pkgconf-pkg-config \
 "
RDEPENDS:libretls-static = " \
 libretls-devel \
 "
