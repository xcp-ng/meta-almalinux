# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtksourceview3"
PV = "3.24.11"
PR = "8.el10_1"
PACKAGES = " \
 gtksourceview3 \
 gtksourceview3-devel \
 gtksourceview3-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtksourceview3-3.24.11-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7bb74760f9b36bc42a3590af98e1f00de1ff124f8b582892b67ffda19a0b95d"

URI_x86_64_v2_gtksourceview3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtksourceview3-3.24.11-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtksourceview3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtksourceview3}"
SRC_URI[x86_64_v2_gtksourceview3.sha256sum] = "9315b32329b0a3460330aed37e2765f270bdb90d676e9b76aceaebb0a5c5be29"

URI_x86_64_v2_gtksourceview3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtksourceview3-devel-3.24.11-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtksourceview3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtksourceview3-devel}"
SRC_URI[x86_64_v2_gtksourceview3-devel.sha256sum] = "e70aa711fbe59e0bdb7df26f764d6e5c2c03fae95529fd4d2bec2988a00f11f9"

URI_x86_64_v2_gtksourceview3-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtksourceview3-tests-3.24.11-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtksourceview3-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtksourceview3-tests}"
SRC_URI[x86_64_v2_gtksourceview3-tests.sha256sum] = "38d6a7bcf52922a6e0a78ce2de6f4d30839c1f6f5d8133f06429eef34a3ff36f"

URI_aarch64_gtksourceview3 = "${EPEL_MIRROR}/aarch64/Packages/g/gtksourceview3-3.24.11-8.el10_1.aarch64.rpm;name=aarch64_gtksourceview3;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtksourceview3}"
SRC_URI[aarch64_gtksourceview3.sha256sum] = "4756cd1ed116c915945bd2eec1bc8fad689c42b35f70d8db280252207b2ed6f0"

URI_aarch64_gtksourceview3-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gtksourceview3-devel-3.24.11-8.el10_1.aarch64.rpm;name=aarch64_gtksourceview3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtksourceview3-devel}"
SRC_URI[aarch64_gtksourceview3-devel.sha256sum] = "d0423d62a33f8054fe5ff78bfcdb4dcd83474d61749a456c500ab9d086bf2466"

URI_aarch64_gtksourceview3-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gtksourceview3-tests-3.24.11-8.el10_1.aarch64.rpm;name=aarch64_gtksourceview3-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtksourceview3-tests}"
SRC_URI[aarch64_gtksourceview3-tests.sha256sum] = "8c93c4efd61bbf62b2300b2b45bb74ba382a58266fabc34c74f8ef0a25ed0e3f"

RDEPENDS:gtksourceview3 = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libxml2 \
 pango \
 "
RDEPENDS:gtksourceview3-devel = " \
 glib2-devel \
 gtk3-devel \
 gtksourceview3 \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gtksourceview3-tests = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 gtksourceview3 \
 libxml2 \
 pango \
 "
