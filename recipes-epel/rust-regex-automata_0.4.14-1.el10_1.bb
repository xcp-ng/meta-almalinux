# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-automata"
PV = "0.4.14"
PR = "1.el10_1"
PACKAGES = " \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+default-devel \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+internal-instrument-devel \
 rust-regex-automata+internal-instrument-pikevm-devel \
 rust-regex-automata+logging-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-automata+perf-literal-multisubstring-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata+unicode-age-devel \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-automata+unicode-case-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-script-devel \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-automata-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-automata-0.4.14-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fbbf83aa34c20d00d282cbe474d7b38dd6f7e2d1e65c3f64589789caa2d4bde"

URI_x86_64_v2_rust-regex-automata+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+alloc-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+alloc-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+alloc-devel.sha256sum] = "b8b698002f3cb3da88ca0c1d0c8bd242444df79f849790cd673a0066cc2811ad"

URI_x86_64_v2_rust-regex-automata+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+default-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+default-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+default-devel.sha256sum] = "966f3ed37e7e0fb2446a9f65be6808b91ccade8eb9b727c0ed7b30ea929617dc"

URI_x86_64_v2_rust-regex-automata+dfa-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-build-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-build-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-build-devel.sha256sum] = "75fb810101509d48e4027ce91b31b22dc9864ef934a500af0c8bb2a11ae12377"

URI_x86_64_v2_rust-regex-automata+dfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-devel.sha256sum] = "be206ffb38e6a948c7ff3dea818d570a37d94d63e52f3658aa06056b5fe0f726"

URI_x86_64_v2_rust-regex-automata+dfa-onepass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-onepass-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-onepass-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-onepass-devel.sha256sum] = "2e401762ca0ea212f861b724988cc6d3be8fb130a7d33653e045f6ff3fba5678"

URI_x86_64_v2_rust-regex-automata+dfa-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-search-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-search-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-search-devel.sha256sum] = "7a6723bc3aa141772de869141510c7467edf729441798aaec484285cd40fa9c8"

URI_x86_64_v2_rust-regex-automata+hybrid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+hybrid-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+hybrid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+hybrid-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+hybrid-devel.sha256sum] = "c9b12b658e85ec45e715c652f343e02afe6d23c0e35f57866ab6f9f618f2f027"

URI_x86_64_v2_rust-regex-automata+internal-instrument-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+internal-instrument-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+internal-instrument-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+internal-instrument-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+internal-instrument-devel.sha256sum] = "f3db681aaec54a20e443e0bd232f38e4a74d1f1cb4402ad155b0c219eb252156"

URI_x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+internal-instrument-pikevm-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel.sha256sum] = "c45357917079c73ae702c152403b0dd1c89d890efb75744f9ed06c0cdcbab792"

URI_x86_64_v2_rust-regex-automata+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+logging-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+logging-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+logging-devel.sha256sum] = "805a363d78807431393c29fcfeb4437e8fd5529fc83e8025b06b890da783bac5"

URI_x86_64_v2_rust-regex-automata+meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+meta-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+meta-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+meta-devel.sha256sum] = "fba1c9bf4c9ecda56f3cdbcc52981f4dae9c8f78826dfc408619fa37948ac21b"

URI_x86_64_v2_rust-regex-automata+nfa-backtrack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-backtrack-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-backtrack-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-backtrack-devel.sha256sum] = "179fbf7778932b089f8d802d5faefd20e87ac947cfcd8fcf4a4b605e5db8f644"

URI_x86_64_v2_rust-regex-automata+nfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-devel.sha256sum] = "e00e4be368a21dadd3e65b9ef9ba05663c3d5b2c7951a039fa9af0ebf7222484"

URI_x86_64_v2_rust-regex-automata+nfa-pikevm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-pikevm-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-pikevm-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-pikevm-devel.sha256sum] = "a335552efcbf3679395af816802f832bb541082fbfaa0b8199a263fa8b3de9e2"

URI_x86_64_v2_rust-regex-automata+nfa-thompson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-thompson-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-thompson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-thompson-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-thompson-devel.sha256sum] = "3fe8becb916703cc0fc07da95a55d98ffcb027f97107d78842e64585e49dbabe"

URI_x86_64_v2_rust-regex-automata+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-devel.sha256sum] = "4bb7331d23e39ffc9a77cf0250ecabb97fe5664b5d137a8fd2ce6cc633d0b4f7"

URI_x86_64_v2_rust-regex-automata+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-inline-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-inline-devel.sha256sum] = "dceb85ec8bb2b38f5ca27e9c198cb1613bd46cadbe958ceda01c060d65341109"

URI_x86_64_v2_rust-regex-automata+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-devel.sha256sum] = "90aebef7999b296fb62c14c59f98dcae6fbd161838fa2e5bb9fa2965c0a066c7"

URI_x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-multisubstring-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel.sha256sum] = "f2c856249ceed4ed7fc2feca1dcc40bc02ac1a641c113a40ee9d1ee7603a92ee"

URI_x86_64_v2_rust-regex-automata+perf-literal-substring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-substring-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-substring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-substring-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-substring-devel.sha256sum] = "4037057896b64c620dcb3b01f3c78d22a837ef3022226a45384f0f14c7ba0cbe"

URI_x86_64_v2_rust-regex-automata+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+std-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+std-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+std-devel.sha256sum] = "b3db8620f94b6caa9e023988873e66311ba9476423ddd79d863f87487cf13940"

URI_x86_64_v2_rust-regex-automata+syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+syntax-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+syntax-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+syntax-devel.sha256sum] = "2ff6d716f4f44edb4cec58cdb03bc9ba54b4e9d9816688dc4c25dc9428b1f36b"

URI_x86_64_v2_rust-regex-automata+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-age-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-age-devel.sha256sum] = "a417a54238ece7f32dfb95ba534e840750ee73afda0f7d5962000a3657686f2a"

URI_x86_64_v2_rust-regex-automata+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-bool-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-bool-devel.sha256sum] = "6d3c3210d3e540022f3d3b39ae30a2ee030611739cfbb00e58de01b04a7eb79c"

URI_x86_64_v2_rust-regex-automata+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-case-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-case-devel.sha256sum] = "5928c1479a47cb4249bac3a9641aaa50a0c50f366a91cd3e25914bfccf716ee5"

URI_x86_64_v2_rust-regex-automata+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-devel.sha256sum] = "59933dda90f920ba0b34aaa42bbeedafc5521602aee5f9d9d41133e6fe23ee33"

URI_x86_64_v2_rust-regex-automata+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-gencat-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-gencat-devel.sha256sum] = "2f1f588e06684bd694a3cefa994ba24ae3595b706dc0707a8a72f7b6982e8a6b"

URI_x86_64_v2_rust-regex-automata+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-perl-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-perl-devel.sha256sum] = "f4c49c25bb330092b8d2d47af1fd3a3be62ebc92ad3055c72dd8e3924fdb9570"

URI_x86_64_v2_rust-regex-automata+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-script-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-script-devel.sha256sum] = "8a55b0c50316eea8babd82eae3572413bfbf3194e00dca0a080b558a85924331"

URI_x86_64_v2_rust-regex-automata+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-segment-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-segment-devel.sha256sum] = "63e818d3056bb00b85a0ae5d82c8129b4147207d5b3b2df24d9c491fa2fdc7ce"

URI_x86_64_v2_rust-regex-automata+unicode-word-boundary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-word-boundary-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-word-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-word-boundary-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-word-boundary-devel.sha256sum] = "e4b19127decff263312c1067655288fcbff6a1d1e71377cff980a01742fe6798"

URI_x86_64_v2_rust-regex-automata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata-devel-0.4.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata-devel}"
SRC_URI[x86_64_v2_rust-regex-automata-devel.sha256sum] = "cc68564bf93ff516d6205af4213410a568863c18c498b8370380a8b8bfc9ad92"

URI_aarch64_rust-regex-automata+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+alloc-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+alloc-devel}"
SRC_URI[aarch64_rust-regex-automata+alloc-devel.sha256sum] = "26adb7e6ce6f60f2103f4951ec1dc7a126aa6cc4ccc56aa85fd20072726a4a93"

URI_aarch64_rust-regex-automata+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+default-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+default-devel}"
SRC_URI[aarch64_rust-regex-automata+default-devel.sha256sum] = "41151178cd75b7d685562e31f4cf3db52a864d43f8c878159faf006482c20cf1"

URI_aarch64_rust-regex-automata+dfa-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-build-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+dfa-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-build-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-build-devel.sha256sum] = "6c8b2f345c131aa41e7597adc79ced81278cfbbdff9d28e0a8a7cf729b09fcf0"

URI_aarch64_rust-regex-automata+dfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+dfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-devel.sha256sum] = "78d32f955396cc1fa1813d46bba927d7b3e6c16694a04928b3426a9af9d4c278"

URI_aarch64_rust-regex-automata+dfa-onepass-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-onepass-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+dfa-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-onepass-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-onepass-devel.sha256sum] = "6808a97cb6e73083f825715c47a5d2a7838a45d6abee5ae560b76273748a4d97"

URI_aarch64_rust-regex-automata+dfa-search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-search-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+dfa-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-search-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-search-devel.sha256sum] = "bed2871a396ab35313ed436b63b2057ddf278edf9feed78451189d3f3a0b9333"

URI_aarch64_rust-regex-automata+hybrid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+hybrid-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+hybrid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+hybrid-devel}"
SRC_URI[aarch64_rust-regex-automata+hybrid-devel.sha256sum] = "19824c68b9e9be8d07fbbe0517cba43ecf9fa0689083c568f9facd95dbcb988f"

URI_aarch64_rust-regex-automata+internal-instrument-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+internal-instrument-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+internal-instrument-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+internal-instrument-devel}"
SRC_URI[aarch64_rust-regex-automata+internal-instrument-devel.sha256sum] = "d396ee84ed65f6e71bedfe362535e24aaea9d09892773f260bf00d895b6dcc6e"

URI_aarch64_rust-regex-automata+internal-instrument-pikevm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+internal-instrument-pikevm-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+internal-instrument-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+internal-instrument-pikevm-devel}"
SRC_URI[aarch64_rust-regex-automata+internal-instrument-pikevm-devel.sha256sum] = "3aa19da3915276dc78b1566dfe043bd077bf6029701f1281c00563baa7fd63b4"

URI_aarch64_rust-regex-automata+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+logging-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+logging-devel}"
SRC_URI[aarch64_rust-regex-automata+logging-devel.sha256sum] = "3fbabd1123dd308a0dfb2f52b1cd39c202d813f8b0eb6f6bf0b4109a872ce1a4"

URI_aarch64_rust-regex-automata+meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+meta-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+meta-devel}"
SRC_URI[aarch64_rust-regex-automata+meta-devel.sha256sum] = "0ec6bb3b9dafb7717e239715cfa5ee71cd7b6c9d3a402de6d80fd66834cebcc2"

URI_aarch64_rust-regex-automata+nfa-backtrack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-backtrack-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+nfa-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-backtrack-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-backtrack-devel.sha256sum] = "a3f6fa8cd33bff0c02b64fb136ffbb4924c2c7acb38ad7599091c17f79d97b6d"

URI_aarch64_rust-regex-automata+nfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+nfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-devel.sha256sum] = "b5066227718b6d2559ff825eeaa169747a0f63b9623775d66a0279998617dc2a"

URI_aarch64_rust-regex-automata+nfa-pikevm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-pikevm-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+nfa-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-pikevm-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-pikevm-devel.sha256sum] = "10392cfcbdca377981ebd5879d179dee4ebb6f869ecc84b985c70a371809058b"

URI_aarch64_rust-regex-automata+nfa-thompson-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-thompson-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+nfa-thompson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-thompson-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-thompson-devel.sha256sum] = "8dab83dc2df830e75d58740404d39fce6ddb2dc0bb69fec06ab5e6e73449a80f"

URI_aarch64_rust-regex-automata+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-devel.sha256sum] = "4bed648359daef987705f03acbd55a81aa52ab2fd97b0193b15948459d11806a"

URI_aarch64_rust-regex-automata+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-inline-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-inline-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-inline-devel.sha256sum] = "95533e3fc560e549472c1af6147ba875008f39656675d680c6e7883240f219a1"

URI_aarch64_rust-regex-automata+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-devel.sha256sum] = "6201b5e404c4c65941d725211d3b0292fd802b652fbb3d04bd4ba9a4001bf0d6"

URI_aarch64_rust-regex-automata+perf-literal-multisubstring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-multisubstring-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-multisubstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-multisubstring-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-multisubstring-devel.sha256sum] = "e1368da08888a258e00d5be38887791c8bfa4babc373e8d14d5d058ea24a0e08"

URI_aarch64_rust-regex-automata+perf-literal-substring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-substring-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-substring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-substring-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-substring-devel.sha256sum] = "6a66365730434d59a9eb314785c986dd2c428f7343232ac2b38cb8aec571b3b6"

URI_aarch64_rust-regex-automata+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+std-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+std-devel}"
SRC_URI[aarch64_rust-regex-automata+std-devel.sha256sum] = "972a9758bb6ff1c80d6993206bb6177e13b8ed2725a86e2e232b12ee886a113c"

URI_aarch64_rust-regex-automata+syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+syntax-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+syntax-devel}"
SRC_URI[aarch64_rust-regex-automata+syntax-devel.sha256sum] = "ecc86fa730d0940ecf2c3b76b67b298c265764966cb889dcef8dba3ed75b8232"

URI_aarch64_rust-regex-automata+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-age-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-age-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-age-devel.sha256sum] = "ce86a8793d1d16855733705edf7339e5fad54d2270a82f1a25aafaac3a113e18"

URI_aarch64_rust-regex-automata+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-bool-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-bool-devel.sha256sum] = "4ccd7485663a6c5bd98c914430c5c82073cfcd22be850ff09ab5c69b9fc65528"

URI_aarch64_rust-regex-automata+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-case-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-case-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-case-devel.sha256sum] = "68e222c3de24d638933b2964f3dd7875b346a7d00125c463c64242bbf11b7a67"

URI_aarch64_rust-regex-automata+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-devel.sha256sum] = "02424ddd8c139909912c235f5f60ceb3d5fd19936ca14a0d20f00fe6c7ab86ab"

URI_aarch64_rust-regex-automata+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-gencat-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-gencat-devel.sha256sum] = "7c871663ca03acec31d9ba20038a9b90b78afe5ee638a001f68e3b7555de0cf8"

URI_aarch64_rust-regex-automata+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-perl-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-perl-devel.sha256sum] = "2a7d2cc67d8c2ff706f935e54f751df0e97ccfd04ae01f02a5ffb132c12e9662"

URI_aarch64_rust-regex-automata+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-script-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-script-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-script-devel.sha256sum] = "0e64ec96b99633520584ae14357491a066c5a40af72cacd98c151708e15eb405"

URI_aarch64_rust-regex-automata+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-segment-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-segment-devel.sha256sum] = "ff36e23551d79ff22182315475abae35ade0d67617d50ebfbeb3e750ce06a103"

URI_aarch64_rust-regex-automata+unicode-word-boundary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-word-boundary-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata+unicode-word-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-word-boundary-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-word-boundary-devel.sha256sum] = "279a612f218c0f85f66b4d7c40f92537243ac35a35926406814f988ac71a0f98"

URI_aarch64_rust-regex-automata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata-devel-0.4.14-1.el10_1.noarch.rpm;name=aarch64_rust-regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata-devel}"
SRC_URI[aarch64_rust-regex-automata-devel.sha256sum] = "ef204d18f48e38541cbef629d9ff3b5b6545c51e365fe183d335af6b00a38183"

RDEPENDS:rust-regex-automata+alloc-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+default-devel = " \
 cargo \
 rust-regex-automata+dfa-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-build-devel = " \
 cargo \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-devel = " \
 cargo \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-onepass-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-search-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+hybrid-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+internal-instrument-devel = " \
 cargo \
 rust-regex-automata+internal-instrument-pikevm-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+internal-instrument-pikevm-devel = " \
 cargo \
 rust-regex-automata+logging-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+logging-devel = " \
 cargo \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick-devel \
 rust-log+default-devel \
 rust-memchr+logging-devel \
 rust-memchr-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+meta-devel = " \
 cargo \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-backtrack-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-devel = " \
 cargo \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-pikevm-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-thompson-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-devel = " \
 cargo \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-inline-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-devel = " \
 cargo \
 rust-regex-automata+perf-literal-multisubstring-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-multisubstring-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-substring-devel = " \
 cargo \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+std-devel = " \
 cargo \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+syntax-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-age-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-bool-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-case-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-devel = " \
 cargo \
 rust-regex-automata+unicode-age-devel \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-automata+unicode-case-devel \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-script-devel \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-gencat-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-perl-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-script-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-segment-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-word-boundary-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata-devel = " \
 cargo \
 rust \
 "
