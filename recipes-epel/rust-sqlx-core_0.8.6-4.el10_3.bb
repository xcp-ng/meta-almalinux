# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx-core"
PV = "0.8.6"
PR = "4.el10_3"
PACKAGES = " \
 rust-sqlx-core+_rt-tokio-devel \
 rust-sqlx-core+_tls-native-tls-devel \
 rust-sqlx-core+_tls-none-devel \
 rust-sqlx-core+_tls-rustls-devel \
 rust-sqlx-core+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-core+_tls-rustls-ring-webpki-devel \
 rust-sqlx-core+any-devel \
 rust-sqlx-core+bigdecimal-devel \
 rust-sqlx-core+bit-vec-devel \
 rust-sqlx-core+bstr-devel \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-core+crc-devel \
 rust-sqlx-core+default-devel \
 rust-sqlx-core+ipnet-devel \
 rust-sqlx-core+ipnetwork-devel \
 rust-sqlx-core+json-devel \
 rust-sqlx-core+mac_address-devel \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-core+native-tls-devel \
 rust-sqlx-core+offline-devel \
 rust-sqlx-core+regex-devel \
 rust-sqlx-core+rust_decimal-devel \
 rust-sqlx-core+rustls-devel \
 rust-sqlx-core+rustls-native-certs-devel \
 rust-sqlx-core+serde-devel \
 rust-sqlx-core+serde_json-devel \
 rust-sqlx-core+sha2-devel \
 rust-sqlx-core+time-devel \
 rust-sqlx-core+tokio-devel \
 rust-sqlx-core+tokio-stream-devel \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-core+webpki-roots-devel \
 rust-sqlx-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-core-0.8.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a3fb4304a24fa690afb61b2bffb6f587664f70a703e1c3d4da78fa5cd246dcf"

URI_x86_64_v2_rust-sqlx-core+_rt-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_rt-tokio-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_rt-tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_rt-tokio-devel.sha256sum] = "23acd91d61e76be7400437d0c94556ccdf16fd5dd6b9a2dbb512a844d209493c"

URI_x86_64_v2_rust-sqlx-core+_tls-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-native-tls-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-native-tls-devel.sha256sum] = "b15330329cf864cb8cc70d9753f765c3f6622f60d4e4a5b234a7b145d223b590"

URI_x86_64_v2_rust-sqlx-core+_tls-none-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-none-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-none-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-none-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-none-devel.sha256sum] = "3a86a993b9c6c7237526fdbdf633bc52d03a0bb55016b187ad470358609104bd"

URI_x86_64_v2_rust-sqlx-core+_tls-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-rustls-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-rustls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-rustls-devel.sha256sum] = "66bc1548b24142bfdc49160ee8aa6fecf0f5d73960be45ef6371eb137034be31"

URI_x86_64_v2_rust-sqlx-core+_tls-rustls-ring-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-rustls-ring-native-roots-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-rustls-ring-native-roots-devel.sha256sum] = "e4fa79a926a33989c4c3db822a5f5166f42ae7459450dd40e2d939ac2687208e"

URI_x86_64_v2_rust-sqlx-core+_tls-rustls-ring-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+_tls-rustls-ring-webpki-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+_tls-rustls-ring-webpki-devel.sha256sum] = "8ed59efab2dc4f4f59972c841b0012cf397fdeb85580e0ece8794d8c44f5b86a"

URI_x86_64_v2_rust-sqlx-core+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+any-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+any-devel.sha256sum] = "d4101198f7db1836988d4f4b516c853dffbdbf2da49f5e69ed09810455b0de8f"

URI_x86_64_v2_rust-sqlx-core+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+bigdecimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+bigdecimal-devel.sha256sum] = "51707adbb0221538477bd0823582730a1e4726461f26ad41783c9d2bcd1f2e98"

URI_x86_64_v2_rust-sqlx-core+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+bit-vec-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+bit-vec-devel.sha256sum] = "46cd114e661335a8765f0be66fcb9848edd719af35dbc82487126dd6b8b1a633"

URI_x86_64_v2_rust-sqlx-core+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+bstr-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+bstr-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+bstr-devel.sha256sum] = "19b54143995c976b49c704cba39e01c181c154642311ac22741262f72e0f4ac5"

URI_x86_64_v2_rust-sqlx-core+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+chrono-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+chrono-devel.sha256sum] = "59e1c8292432c2e776dda2b5ad5f9296c85a8633b1293169c7d58237697a70f9"

URI_x86_64_v2_rust-sqlx-core+crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+crc-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+crc-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+crc-devel.sha256sum] = "0c3e4ea5ef42b60a9f802f3b64eb16deab0eda8f75ac4ad1f11fec0befc5cf99"

URI_x86_64_v2_rust-sqlx-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+default-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+default-devel.sha256sum] = "a7f56e56c56da1818eee0ec609e8804b8254d5277084a58c3cef570f65f15bc9"

URI_x86_64_v2_rust-sqlx-core+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+ipnet-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+ipnet-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+ipnet-devel.sha256sum] = "abffbe8d9959fad24844e438c2cf47a1d80cbee6e3e6d566217d61deebb56d34"

URI_x86_64_v2_rust-sqlx-core+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+ipnetwork-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+ipnetwork-devel.sha256sum] = "ab869154f314e3e06ce9f6beb73ae435cbf5856683c121462038e0b58a1b7300"

URI_x86_64_v2_rust-sqlx-core+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+json-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+json-devel.sha256sum] = "8c2e89bd1fccccd3277ec46fca5511534a92e2310656701340168ce9689c86df"

URI_x86_64_v2_rust-sqlx-core+mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+mac_address-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+mac_address-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+mac_address-devel.sha256sum] = "39f80441e75fc8ec8cdc46232797fe5ec0936813da0c56b9b0dcb73aebc2074b"

URI_x86_64_v2_rust-sqlx-core+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+migrate-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+migrate-devel.sha256sum] = "6fa0f1a537cf01108f2e4093317db36742711c3a38472455c900619b8726db45"

URI_x86_64_v2_rust-sqlx-core+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+native-tls-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+native-tls-devel.sha256sum] = "8e1043e8fc1446afe09820ac84445656616b3ae35eafefaf241ff00689f9c110"

URI_x86_64_v2_rust-sqlx-core+offline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+offline-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+offline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+offline-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+offline-devel.sha256sum] = "0a1e24d165214df8900f6bfce55acf4087ca2d843536eb799bee0d15a3125e79"

URI_x86_64_v2_rust-sqlx-core+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+regex-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+regex-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+regex-devel.sha256sum] = "68c94b05cf3a7fe206ba95ec5fff98db056e1a3076e9fd1c5f538ece7b69c300"

URI_x86_64_v2_rust-sqlx-core+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+rust_decimal-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+rust_decimal-devel.sha256sum] = "29a05ad01b02724ca5ad70326ee80ce7b591ea4550fdaed5ee9617f133c40357"

URI_x86_64_v2_rust-sqlx-core+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+rustls-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+rustls-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+rustls-devel.sha256sum] = "3f62355dc81e93919b0abadf41c237d8809a16ad097f42f67d41714dc11e9092"

URI_x86_64_v2_rust-sqlx-core+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+rustls-native-certs-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+rustls-native-certs-devel.sha256sum] = "37bd221b122583ab765d631313ffdecb7fb781bc68a1eaa7fe5a8ee503540507"

URI_x86_64_v2_rust-sqlx-core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+serde-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+serde-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+serde-devel.sha256sum] = "86d2aa02803664fb11a352f068425da9dcb0df74ede4ab38cad88585131d5e84"

URI_x86_64_v2_rust-sqlx-core+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+serde_json-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+serde_json-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+serde_json-devel.sha256sum] = "3aeabbcc5f26733b66fc429ea68e302c995d7f43c2153db4349d1540f263b275"

URI_x86_64_v2_rust-sqlx-core+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+sha2-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+sha2-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+sha2-devel.sha256sum] = "b879b5a96ecaf70fc3fc7e37c10b89bd6ab8ccae51fe5a78c3a460090284028d"

URI_x86_64_v2_rust-sqlx-core+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+time-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+time-devel.sha256sum] = "67b1542c6b4099a32169390e9c2b30e411231ce72a69512ac1eb82bca70368c2"

URI_x86_64_v2_rust-sqlx-core+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+tokio-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+tokio-devel.sha256sum] = "5d4513a7cf93d397e85ef92ace683920fdfe0763faadfc68b5962310ff63d3f8"

URI_x86_64_v2_rust-sqlx-core+tokio-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+tokio-stream-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+tokio-stream-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+tokio-stream-devel.sha256sum] = "a2875847a72e17f683fae428484f72fa7bf780e77d352f0da8e28a283d1356ab"

URI_x86_64_v2_rust-sqlx-core+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+uuid-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+uuid-devel.sha256sum] = "9db63b3d377e77c8a37642d70fe2be2228d4118b4b2b3eb55891cc358bbf5267"

URI_x86_64_v2_rust-sqlx-core+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core+webpki-roots-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core+webpki-roots-devel.sha256sum] = "d37b0f622a4b2049f115ec4144f51c6b5c153502a416c7a4a8f49ea854d67741"

URI_x86_64_v2_rust-sqlx-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-core-devel-0.8.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-core-devel}"
SRC_URI[x86_64_v2_rust-sqlx-core-devel.sha256sum] = "c65f12e30a775d6f3947bd91e157511ec456e2870ec1957be697d4a5d89910cd"

URI_aarch64_rust-sqlx-core+_rt-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_rt-tokio-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_rt-tokio-devel}"
SRC_URI[aarch64_rust-sqlx-core+_rt-tokio-devel.sha256sum] = "d011fbc5b5aabe10f5fb61a6857ae467da69fd0215406aa68b609eceeff07aaf"

URI_aarch64_rust-sqlx-core+_tls-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-native-tls-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-native-tls-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-native-tls-devel.sha256sum] = "bba6ba0fe502a5959f8d48715e2303b354635c56290f2e034fd55a1d277051fe"

URI_aarch64_rust-sqlx-core+_tls-none-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-none-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-none-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-none-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-none-devel.sha256sum] = "34b353225facf64033b47f881a34eee15f05760fc4a7744b2082998db21f67a3"

URI_aarch64_rust-sqlx-core+_tls-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-rustls-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-rustls-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-rustls-devel.sha256sum] = "14b7a920cc2848319bf6f69bc62823849e637b0ea77ae559a020b2c21121716f"

URI_aarch64_rust-sqlx-core+_tls-rustls-ring-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-rustls-ring-native-roots-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-rustls-ring-native-roots-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-rustls-ring-native-roots-devel.sha256sum] = "fbbaeadeb367eb8a80bb838fa3bcb6686f257a812740916ad460bf011cc99404"

URI_aarch64_rust-sqlx-core+_tls-rustls-ring-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+_tls-rustls-ring-webpki-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+_tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+_tls-rustls-ring-webpki-devel}"
SRC_URI[aarch64_rust-sqlx-core+_tls-rustls-ring-webpki-devel.sha256sum] = "02dbea26089bb1e27951037903c729e601253d6e589e1e4e0cc3cb841db8e992"

URI_aarch64_rust-sqlx-core+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+any-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+any-devel}"
SRC_URI[aarch64_rust-sqlx-core+any-devel.sha256sum] = "732f5d203fe7fecc31a4374cd47699fcfa7dd56797771a4b1af155ee5b66634a"

URI_aarch64_rust-sqlx-core+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+bigdecimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx-core+bigdecimal-devel.sha256sum] = "612144bfbf85dae27f586b5cef3dc4c4828894adab4ad4df9c6727a93a6b808b"

URI_aarch64_rust-sqlx-core+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+bit-vec-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+bit-vec-devel}"
SRC_URI[aarch64_rust-sqlx-core+bit-vec-devel.sha256sum] = "7d7798120c92d0e2dba2444f9119d087153dc661a91fe3952fa7474bee2f859e"

URI_aarch64_rust-sqlx-core+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+bstr-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+bstr-devel}"
SRC_URI[aarch64_rust-sqlx-core+bstr-devel.sha256sum] = "1f6f6af51d6f662530ec353f6cffd4c96394589d371b6119697ed5bcd23ea7b4"

URI_aarch64_rust-sqlx-core+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+chrono-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+chrono-devel}"
SRC_URI[aarch64_rust-sqlx-core+chrono-devel.sha256sum] = "c0107edb5a485a9e887b8b540e11dca50c54f8d4587235ede34e328c57a42ae9"

URI_aarch64_rust-sqlx-core+crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+crc-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+crc-devel}"
SRC_URI[aarch64_rust-sqlx-core+crc-devel.sha256sum] = "0a0f2e19b9e99d8cb3de634bf6cff919ffb7760237432abd12c063681fd0514c"

URI_aarch64_rust-sqlx-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+default-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+default-devel}"
SRC_URI[aarch64_rust-sqlx-core+default-devel.sha256sum] = "053bd03963378bcc86a958c3fd8257ee2ec0a330c372c853c5ce45c97b66b569"

URI_aarch64_rust-sqlx-core+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+ipnet-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+ipnet-devel}"
SRC_URI[aarch64_rust-sqlx-core+ipnet-devel.sha256sum] = "c5da2563440e936db230847f0e1bb7509d97635e7987a72dfee3ea8716d851b7"

URI_aarch64_rust-sqlx-core+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+ipnetwork-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+ipnetwork-devel}"
SRC_URI[aarch64_rust-sqlx-core+ipnetwork-devel.sha256sum] = "bb992e1407b1176aa5cff24292e261f171023e9e71f4dff1bcf285e21670c7c0"

URI_aarch64_rust-sqlx-core+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+json-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+json-devel}"
SRC_URI[aarch64_rust-sqlx-core+json-devel.sha256sum] = "bbead8aba166cbaa622020dcf896398ffd66a9165ad0de039dcf8488fb1a99ee"

URI_aarch64_rust-sqlx-core+mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+mac_address-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+mac_address-devel}"
SRC_URI[aarch64_rust-sqlx-core+mac_address-devel.sha256sum] = "f7348a4c0dded5b9c2582db7505f1f16e55839673c6d97ee0777d255d4a43c3c"

URI_aarch64_rust-sqlx-core+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+migrate-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+migrate-devel}"
SRC_URI[aarch64_rust-sqlx-core+migrate-devel.sha256sum] = "f77481a2b6f53354d71ae5b81efa0d73261fc62aaf1e3aa9ff4c6a77bd9bde35"

URI_aarch64_rust-sqlx-core+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+native-tls-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+native-tls-devel}"
SRC_URI[aarch64_rust-sqlx-core+native-tls-devel.sha256sum] = "14832519a80a63adcb91ee1d2a53bccc41700262242a42b28aefa8131d457aef"

URI_aarch64_rust-sqlx-core+offline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+offline-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+offline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+offline-devel}"
SRC_URI[aarch64_rust-sqlx-core+offline-devel.sha256sum] = "c33dadd36e5d75846a07a0be9dee1f30826f317303663b61ef943c05a71bccba"

URI_aarch64_rust-sqlx-core+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+regex-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+regex-devel}"
SRC_URI[aarch64_rust-sqlx-core+regex-devel.sha256sum] = "9090107029c6613c529bf044eef5d93aff497e96944e4b9bd215e265527e5026"

URI_aarch64_rust-sqlx-core+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+rust_decimal-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx-core+rust_decimal-devel.sha256sum] = "480170af8a63e8295f21d2ad15b68f45e0320d5f9ac1ac01b24d4c7758269b71"

URI_aarch64_rust-sqlx-core+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+rustls-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+rustls-devel}"
SRC_URI[aarch64_rust-sqlx-core+rustls-devel.sha256sum] = "e94cb2bae6d76d25fc148b08579360bb5fee573ee2176cbe9f4a2833ba9c1e43"

URI_aarch64_rust-sqlx-core+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+rustls-native-certs-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-sqlx-core+rustls-native-certs-devel.sha256sum] = "b1dd71cdf9b0160a904df81413a54c3d8ffb3fda09b1825a604efb5e0389ffd3"

URI_aarch64_rust-sqlx-core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+serde-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+serde-devel}"
SRC_URI[aarch64_rust-sqlx-core+serde-devel.sha256sum] = "5f56e8511caccbb396129e742474576d51fd083162ee638b070e3709553d859d"

URI_aarch64_rust-sqlx-core+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+serde_json-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+serde_json-devel}"
SRC_URI[aarch64_rust-sqlx-core+serde_json-devel.sha256sum] = "2b670477ad28b4b41d8387bc232dc3e0c2f18a6142afb3addeeaabf3e5312a3d"

URI_aarch64_rust-sqlx-core+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+sha2-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+sha2-devel}"
SRC_URI[aarch64_rust-sqlx-core+sha2-devel.sha256sum] = "342195518dbff64415cb36ffaab51d82dc02bcaa591f6ca41c19dc4040405d70"

URI_aarch64_rust-sqlx-core+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+time-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+time-devel}"
SRC_URI[aarch64_rust-sqlx-core+time-devel.sha256sum] = "2e0482bdb5a5721e0921cc72fc2ea0da01ac379f0cea60adf8b47b81abd60f18"

URI_aarch64_rust-sqlx-core+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+tokio-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+tokio-devel}"
SRC_URI[aarch64_rust-sqlx-core+tokio-devel.sha256sum] = "871a5592c9ce1b0f07fb3d035d4ed248c38cebf2e68378cf6a4f94d4e4a60a0f"

URI_aarch64_rust-sqlx-core+tokio-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+tokio-stream-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+tokio-stream-devel}"
SRC_URI[aarch64_rust-sqlx-core+tokio-stream-devel.sha256sum] = "b0fc37d0f73a6479a10f03b0454bd2de04c225ed686b15634a8bb7954971b2f9"

URI_aarch64_rust-sqlx-core+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+uuid-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+uuid-devel}"
SRC_URI[aarch64_rust-sqlx-core+uuid-devel.sha256sum] = "bdba928b1bbe3daf55828bc541c2306f27226e907432e7a7e51594840d4fc65d"

URI_aarch64_rust-sqlx-core+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core+webpki-roots-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core+webpki-roots-devel}"
SRC_URI[aarch64_rust-sqlx-core+webpki-roots-devel.sha256sum] = "3de83a36f498e11d912954eab49d3d2a944752afe9bf40cfc5f346524a436b98"

URI_aarch64_rust-sqlx-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-core-devel-0.8.6-4.el10_3.noarch.rpm;name=aarch64_rust-sqlx-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-core-devel}"
SRC_URI[aarch64_rust-sqlx-core-devel.sha256sum] = "0c890a734d8373b2c7d1af11c4bd3e0a3102a6984c8de802ee22e807559edb41"

RDEPENDS:rust-sqlx-core+_rt-tokio-devel = " \
 cargo \
 rust-sqlx-core+tokio-devel \
 rust-sqlx-core+tokio-stream-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-native-tls-devel = " \
 cargo \
 rust-sqlx-core+native-tls-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-none-devel = " \
 cargo \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-rustls-devel = " \
 cargo \
 rust-sqlx-core+rustls-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-rustls-ring-native-roots-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-sqlx-core+_tls-rustls-devel \
 rust-sqlx-core+rustls-native-certs-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+_tls-rustls-ring-webpki-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-sqlx-core+_tls-rustls-devel \
 rust-sqlx-core+webpki-roots-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+any-devel = " \
 cargo \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+bit-vec-devel = " \
 cargo \
 rust-bit-vec0.6+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+bstr-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+crc-devel = " \
 cargo \
 rust-crc+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+default-devel = " \
 cargo \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+ipnet-devel = " \
 cargo \
 rust-ipnet+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+ipnetwork-devel = " \
 cargo \
 rust-ipnetwork+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+json-devel = " \
 cargo \
 rust-sqlx-core+serde-devel \
 rust-sqlx-core+serde_json-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+mac_address-devel = " \
 cargo \
 rust-mac_address+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+migrate-devel = " \
 cargo \
 rust-sqlx-core+crc-devel \
 rust-sqlx-core+sha2-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+native-tls-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+offline-devel = " \
 cargo \
 rust-either+serde-devel \
 rust-sqlx-core+serde-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+rust_decimal-devel = " \
 cargo \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+rustls-devel = " \
 cargo \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs+default-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+sha2-devel = " \
 cargo \
 rust-sha2_0.10-devel \
 rust-sqlx-core-devel \
 "
RDEPENDS:rust-sqlx-core+time-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-sqlx-core+tokio-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-sqlx-core+tokio-stream-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+fs-devel \
 "
RDEPENDS:rust-sqlx-core+uuid-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-sqlx-core+webpki-roots-devel = " \
 cargo \
 rust-sqlx-core-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-sqlx-core-devel = " \
 cargo \
 rust-base64_0.22+std-devel \
 rust-base64_0.22-devel \
 rust-bytes+default-devel \
 rust-crossbeam-queue+default-devel \
 rust-either+default-devel \
 rust-event-listener+default-devel \
 rust-futures-core-devel \
 rust-futures-intrusive+default-devel \
 rust-futures-io+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-hashbrown0.15+default-devel \
 rust-hashlink0.10+default-devel \
 rust-indexmap+default-devel \
 rust-log-devel \
 rust-memchr-devel \
 rust-once_cell+default-devel \
 rust-percent-encoding+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+default-devel \
 rust-tracing+log-devel \
 rust-url+default-devel \
 "
