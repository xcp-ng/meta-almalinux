# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-copr"
PV = "2.8"
PR = "1.el10_3"
PACKAGES = " \
 python-copr-doc \
 python3-copr \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-copr-2.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "65b5e5d6993bf3d72c1cfa3a63a5ab536d036f2a2587d116e3872364b332068c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-copr-doc-2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-copr-doc;unpack=0"
SRC_URI[x86_64_v2_python-copr-doc.sha256sum] = "d8ca8173350d9005111cb5b4fe7e2042f7041c62614eb1bd996a7a62c06ddaab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-copr-2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-copr;unpack=0"
SRC_URI[x86_64_v2_python3-copr.sha256sum] = "209a90d421c023abca1c6e6f06f9ae1d55ae0887b118dbe4409b5eb73fdc4dc3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-copr-doc-2.8-1.el10_3.noarch.rpm;name=aarch64_python-copr-doc;unpack=0"
SRC_URI[aarch64_python-copr-doc.sha256sum] = "74911d55929beb7ca69b3d98fe0ca44e0fafc6adb5c2ce037fd86867ceb22ade"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-copr-2.8-1.el10_3.noarch.rpm;name=aarch64_python3-copr;unpack=0"
SRC_URI[aarch64_python3-copr.sha256sum] = "59da882d8498b263f05fa0cb3e98e54b8d415cb1d4e72b26c61b48d1a735fc35"

RDEPENDS:python-copr-doc = " \
 "
RDEPENDS:python3-copr = " \
 python3 \
 python3-filelock \
 python3-munch \
 python3-requests \
 python3-requests-gssapi \
 python3-requests-toolbelt \
 python3-setuptools \
 "
