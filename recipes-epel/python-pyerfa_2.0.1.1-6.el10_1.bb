# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyerfa"
PV = "2.0.1.1"
PR = "6.el10_1"
PACKAGES = " \
 python3-pyerfa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyerfa-2.0.1.1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efd3169adee641f68dc5a4e3c0ac64f32c0ce6eff6a4c4f3a343fb2b876abfb3"

URI_x86_64_v2_python3-pyerfa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyerfa-2.0.1.1-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyerfa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyerfa}"
SRC_URI[x86_64_v2_python3-pyerfa.sha256sum] = "4f3365ff6c6b0cf705d5c029d08b465f81fd9e311fa7f7b7e9e8eabf3bce57fd"

URI_aarch64_python3-pyerfa = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyerfa-2.0.1.1-6.el10_1.aarch64.rpm;name=aarch64_python3-pyerfa;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyerfa}"
SRC_URI[aarch64_python3-pyerfa.sha256sum] = "2fc1ba886d4edf306d99818239bf734b9412fe09dafc8189fc969a19b9b7674d"

RDEPENDS:python3-pyerfa = " \
 erfa \
 glibc \
 python3 \
 python3-numpy \
 "
