# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-terminal_size0.2"
PV = "0.2.6"
PR = "4.el10_0"
PACKAGES = " \
 rust-terminal_size0.2+default-devel \
 rust-terminal_size0.2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-terminal_size0.2-0.2.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a1679f28399be0356c6cecda90747d4cdbaf4cf2ee281a3aec9c54ec1f3f62e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size0.2+default-devel-0.2.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size0.2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-terminal_size0.2+default-devel.sha256sum] = "c305ef616b1a3a2d9946c427a14725014c3b4ffaa348cdf83678384a96683207"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size0.2-devel-0.2.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size0.2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-terminal_size0.2-devel.sha256sum] = "1475f10c284aec37627891e07ec87990dbf62f1a2ece467fd2506bfaae0e0b99"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size0.2+default-devel-0.2.6-4.el10_0.noarch.rpm;name=aarch64_rust-terminal_size0.2+default-devel;unpack=0"
SRC_URI[aarch64_rust-terminal_size0.2+default-devel.sha256sum] = "c8df37df8b98042664305f0357d3ac63149aae8ebfd9a440246a4bb63ad73b38"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size0.2-devel-0.2.6-4.el10_0.noarch.rpm;name=aarch64_rust-terminal_size0.2-devel;unpack=0"
SRC_URI[aarch64_rust-terminal_size0.2-devel.sha256sum] = "c3aeb373b13f962ea4fa15740e24eb61b76a071a14e7e5449bf82a114c3d2445"

RDEPENDS:rust-terminal_size0.2+default-devel = " \
 cargo \
 rust-terminal_size0.2-devel \
 "
RDEPENDS:rust-terminal_size0.2-devel = " \
 cargo \
 rust-rustix+default-devel \
 rust-rustix+stdio-devel \
 rust-rustix+termios-devel \
 "
