# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-server"
PV = "26.08.1"
PR = "1.1.el10_3"
PACKAGES = " \
 akonadi-server \
 akonadi-server-devel \
 akonadi-server-doc \
 akonadi-server-mysql \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akonadi-server-26.08.1-1.1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a1f38c84cd2e75d9de83a0eea741277c43ec72e9fc5a123a604f6421ec09ef8c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-26.08.1-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server;unpack=0"
SRC_URI[x86_64_v2_akonadi-server.sha256sum] = "ead761209171a75a32d16d8ebf2d3159fd1887f50ff1a6b9a5b2dba25796cde4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-devel-26.08.1-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-devel;unpack=0"
SRC_URI[x86_64_v2_akonadi-server-devel.sha256sum] = "c15353dffd33ac0fbd0b2e8e3c038ba572139671706d4208b2edf76c51432ba6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-doc-26.08.1-1.1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-server-doc;unpack=0"
SRC_URI[x86_64_v2_akonadi-server-doc.sha256sum] = "c6ddad2ffaf9e098e6634ac1bf8c6fae5d0a63e79e3c7c3f4b58675c4551c14c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-mysql-26.08.1-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-mysql;unpack=0"
SRC_URI[x86_64_v2_akonadi-server-mysql.sha256sum] = "04d92c44e956ee17f8f6b614128ec2f0c884a0407c3c1f21ab83b4e5729f0d1a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-26.08.1-1.1.el10_3.aarch64.rpm;name=aarch64_akonadi-server;unpack=0"
SRC_URI[aarch64_akonadi-server.sha256sum] = "9017ef65370be72392704a1fc6f2672a5ef782b67b79e5c80db63042ced256d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-devel-26.08.1-1.1.el10_3.aarch64.rpm;name=aarch64_akonadi-server-devel;unpack=0"
SRC_URI[aarch64_akonadi-server-devel.sha256sum] = "94ae024c12cf3af5c21762bbd1b0944dcbfcf115bcb74a9860d38d7101198726"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-doc-26.08.1-1.1.el10_3.noarch.rpm;name=aarch64_akonadi-server-doc;unpack=0"
SRC_URI[aarch64_akonadi-server-doc.sha256sum] = "da7d7c543f50539dfc44a5b9f23eac6f011965603465a1e694549136784eff69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-mysql-26.08.1-1.1.el10_3.aarch64.rpm;name=aarch64_akonadi-server-mysql;unpack=0"
SRC_URI[aarch64_akonadi-server-mysql.sha256sum] = "a253f9cb78d1d799f36db03356fa425550680448bb15a63827bf5f48071946e2"

RDEPENDS:akonadi-server = " \
 alternatives \
 bash \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 libxml2 \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xz-libs \
 "
RDEPENDS:akonadi-server-devel = " \
 akonadi-server \
 cmake-filesystem \
 glibc \
 kf6-kconfig \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kcoreaddons-devel \
 kf6-ki18n \
 kf6-kio-devel \
 kf6-kitemmodels-devel \
 kf6-kxmlgui-devel \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-server-doc = " \
 "
RDEPENDS:akonadi-server-mysql = " \
 akonadi-server \
 alternatives \
 bash \
 qt6-qtbase-mysql \
 virtual/mariadb-server-any \
 "
