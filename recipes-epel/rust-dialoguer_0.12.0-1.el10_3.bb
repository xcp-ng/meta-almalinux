# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dialoguer"
PV = "0.12.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-dialoguer+completion-devel \
 rust-dialoguer+default-devel \
 rust-dialoguer+editor-devel \
 rust-dialoguer+fuzzy-matcher-devel \
 rust-dialoguer+fuzzy-select-devel \
 rust-dialoguer+history-devel \
 rust-dialoguer+password-devel \
 rust-dialoguer+tempfile-devel \
 rust-dialoguer+zeroize-devel \
 rust-dialoguer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dialoguer-0.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6de8465affe27b05cee72b131806ce1e21eeb3529f10fff520ec1a981e263abf"

URI_x86_64_v2_rust-dialoguer+completion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+completion-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+completion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+completion-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+completion-devel.sha256sum] = "b891738167c4792ef2cd602e59df67c207cfe7350c6b49419e685cb914ebc5d0"

URI_x86_64_v2_rust-dialoguer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+default-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+default-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+default-devel.sha256sum] = "45c0e8d8cc3eaf8c3c6eb89fedfdf84b13fa203b6e9253b8f7de6b8f8857b302"

URI_x86_64_v2_rust-dialoguer+editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+editor-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+editor-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+editor-devel.sha256sum] = "4cdb1ae664293672c38e09ecec3126513bb6855f5a426e2d0a172213223925b6"

URI_x86_64_v2_rust-dialoguer+fuzzy-matcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+fuzzy-matcher-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+fuzzy-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+fuzzy-matcher-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+fuzzy-matcher-devel.sha256sum] = "8ad0ecdc83a13288830762c28bbb9bf1e77c59d5f559519f4c8082661feb22e1"

URI_x86_64_v2_rust-dialoguer+fuzzy-select-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+fuzzy-select-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+fuzzy-select-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+fuzzy-select-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+fuzzy-select-devel.sha256sum] = "64a3590e5347079a1dd7eb16f62a991c5d297e1e127ec78fd523b7eb8814bb52"

URI_x86_64_v2_rust-dialoguer+history-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+history-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+history-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+history-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+history-devel.sha256sum] = "0f951aa13828b5b18a9189195e4a88faa69af7b4132fe9d8c1d10182755c8bc2"

URI_x86_64_v2_rust-dialoguer+password-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+password-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+password-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+password-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+password-devel.sha256sum] = "802ed91ec9b7b909e4ab9eab4d039f3a9f7fd1a2551bd68ef0109b1818452e86"

URI_x86_64_v2_rust-dialoguer+tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+tempfile-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+tempfile-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+tempfile-devel.sha256sum] = "27c65773a698174b5202c8b11981148d3a385f3bb89de23d67dfda1174dbd32f"

URI_x86_64_v2_rust-dialoguer+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+zeroize-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+zeroize-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+zeroize-devel.sha256sum] = "06f393598546f111362d94b8f8e6b711057bd13647e83322902e2004c1f8b54d"

URI_x86_64_v2_rust-dialoguer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer-devel-0.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer-devel}"
SRC_URI[x86_64_v2_rust-dialoguer-devel.sha256sum] = "94c721717d7e4db38672009eb29bf943032aec5cd3e7ccbf2bc7309989cd9d3e"

URI_aarch64_rust-dialoguer+completion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+completion-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer+completion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+completion-devel}"
SRC_URI[aarch64_rust-dialoguer+completion-devel.sha256sum] = "fddd42cc2bb89a0cd1d5c725487de69cef896466c0bafe996bbf04838af820cc"

URI_aarch64_rust-dialoguer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+default-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+default-devel}"
SRC_URI[aarch64_rust-dialoguer+default-devel.sha256sum] = "e79db520bad11a660a595678da6182e3dbc27842fd627d5a173c3030317bc251"

URI_aarch64_rust-dialoguer+editor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+editor-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer+editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+editor-devel}"
SRC_URI[aarch64_rust-dialoguer+editor-devel.sha256sum] = "02053c39590f8e7f9f4a943a7de3a37188511c1a8cb86c018342424634ec52b4"

URI_aarch64_rust-dialoguer+fuzzy-matcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+fuzzy-matcher-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer+fuzzy-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+fuzzy-matcher-devel}"
SRC_URI[aarch64_rust-dialoguer+fuzzy-matcher-devel.sha256sum] = "ad7c0f23d8b4a801f14900d4a5cf59c9df2d8bd21053400ef220752d2c360978"

URI_aarch64_rust-dialoguer+fuzzy-select-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+fuzzy-select-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer+fuzzy-select-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+fuzzy-select-devel}"
SRC_URI[aarch64_rust-dialoguer+fuzzy-select-devel.sha256sum] = "8993f41d2d7e67c76ac5d64a50d38e4dd81b2e23a56757422fbda5a930e97cff"

URI_aarch64_rust-dialoguer+history-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+history-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer+history-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+history-devel}"
SRC_URI[aarch64_rust-dialoguer+history-devel.sha256sum] = "d5eaac614479995485f19170699c3ace663d343347c7134e33907f9877d81100"

URI_aarch64_rust-dialoguer+password-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+password-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer+password-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+password-devel}"
SRC_URI[aarch64_rust-dialoguer+password-devel.sha256sum] = "c6726b019aa7f54b9d5bfa1b3d496fa4ea448975d14f37462c464167545055a4"

URI_aarch64_rust-dialoguer+tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+tempfile-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+tempfile-devel}"
SRC_URI[aarch64_rust-dialoguer+tempfile-devel.sha256sum] = "f5d53950484e68610ec00a89dbf4b0ba5f2a4799ef89f9ed3fd4f6b53d6c02a5"

URI_aarch64_rust-dialoguer+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+zeroize-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+zeroize-devel}"
SRC_URI[aarch64_rust-dialoguer+zeroize-devel.sha256sum] = "c17781c917e3f14391e848c022611150d4e39b0caa3005e94817fb846d4ee8e1"

URI_aarch64_rust-dialoguer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer-devel-0.12.0-1.el10_3.noarch.rpm;name=aarch64_rust-dialoguer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer-devel}"
SRC_URI[aarch64_rust-dialoguer-devel.sha256sum] = "86bf383cd541d5056b889966cf69b3de53df47f54ddfc9faa0201c0b4b76c41e"

RDEPENDS:rust-dialoguer+completion-devel = " \
 cargo \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+default-devel = " \
 cargo \
 rust-dialoguer+editor-devel \
 rust-dialoguer+password-devel \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+editor-devel = " \
 cargo \
 rust-dialoguer+tempfile-devel \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+fuzzy-matcher-devel = " \
 cargo \
 rust-dialoguer-devel \
 rust-fuzzy-matcher+default-devel \
 "
RDEPENDS:rust-dialoguer+fuzzy-select-devel = " \
 cargo \
 rust-dialoguer+fuzzy-matcher-devel \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+history-devel = " \
 cargo \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+password-devel = " \
 cargo \
 rust-dialoguer+zeroize-devel \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+tempfile-devel = " \
 cargo \
 rust-dialoguer-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-dialoguer+zeroize-devel = " \
 cargo \
 rust-dialoguer-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-dialoguer-devel = " \
 cargo \
 rust \
 rust-console+default-devel \
 rust-shell-words+default-devel \
 "
