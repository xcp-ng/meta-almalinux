# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sgmllib3k"
PV = "1.0.0"
PR = "17.el10_0"
PACKAGES = " \
 python3-sgmllib3k \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sgmllib3k-1.0.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd6d611f8d69569eda91a4091f13e77efc0bb91f611152a63d3429c769182692"

URI_x86_64_v2_python3-sgmllib3k = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sgmllib3k-1.0.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sgmllib3k;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sgmllib3k}"
SRC_URI[x86_64_v2_python3-sgmllib3k.sha256sum] = "b180cdf850dce0924a339233a9d252e8c9bf11c7bacb690f1fae0c65ec84eaa1"

URI_aarch64_python3-sgmllib3k = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sgmllib3k-1.0.0-17.el10_0.noarch.rpm;name=aarch64_python3-sgmllib3k;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sgmllib3k}"
SRC_URI[aarch64_python3-sgmllib3k.sha256sum] = "668c59cd860725c7afe73f79e1a7c2e03875bfe8a98a823dbfb488540d4dc807"

RDEPENDS:python3-sgmllib3k = " \
 python3 \
 "
