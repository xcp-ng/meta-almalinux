# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-caffeine"
PV = "58"
PR = "1.el10_1"
PACKAGES = " \
 gnome-shell-extension-caffeine \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-caffeine-58-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab27d5bbc32474e223c8392067da7e78b74f605e71e3b135f852be2748fcafcf"

URI_x86_64_v2_gnome-shell-extension-caffeine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-caffeine-58-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-caffeine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-caffeine}"
SRC_URI[x86_64_v2_gnome-shell-extension-caffeine.sha256sum] = "2febfc8ea51a6ff480794a7baff2989a1d17694847e4b8fcc1d246781dd99d88"

URI_aarch64_gnome-shell-extension-caffeine = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-caffeine-58-1.el10_1.noarch.rpm;name=aarch64_gnome-shell-extension-caffeine;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-caffeine}"
SRC_URI[aarch64_gnome-shell-extension-caffeine.sha256sum] = "e7e9c11a0a4e71cb6c5dd72ec0bc077ecb18d719a556629eeb5d038fe264f6ad"

RDEPENDS:gnome-shell-extension-caffeine = " \
 gnome-shell-extension-common \
 "
