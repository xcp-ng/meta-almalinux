# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-crcmod"
PV = "1.7"
PR = "13.el10_1"
PACKAGES = " \
 python-crcmod-doc \
 python3-crcmod \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-crcmod-1.7-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cd598c0e8fc5342b0ef2329b9f0fa6352ae24be5c05aadafc366988aa5c43de"

URI_x86_64_v2_python-crcmod-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-crcmod-doc-1.7-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-crcmod-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-crcmod-doc}"
SRC_URI[x86_64_v2_python-crcmod-doc.sha256sum] = "b65a17b200e12e452cb3d1e5c382a5d1b7e1f3b3de6ae506e6c6b2d277f3eee3"

URI_x86_64_v2_python3-crcmod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-crcmod-1.7-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-crcmod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-crcmod}"
SRC_URI[x86_64_v2_python3-crcmod.sha256sum] = "791b426c9a26646673244718e4ed3c74a7e92234c5b62c4728b56316f66a8821"

URI_aarch64_python-crcmod-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-crcmod-doc-1.7-13.el10_1.noarch.rpm;name=aarch64_python-crcmod-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-crcmod-doc}"
SRC_URI[aarch64_python-crcmod-doc.sha256sum] = "ab06c608f6a004d679abd33a826c57e5214788b0d40274a2a402d484400eb96d"

URI_aarch64_python3-crcmod = "${EPEL_MIRROR}/aarch64/Packages/p/python3-crcmod-1.7-13.el10_1.aarch64.rpm;name=aarch64_python3-crcmod;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-crcmod}"
SRC_URI[aarch64_python3-crcmod.sha256sum] = "cf817b84aac5c6f3e6e182fee87582c831be1fe1e355ffc9f701ec84fb8c7c08"

RDEPENDS:python-crcmod-doc = " \
 "
RDEPENDS:python3-crcmod:x86_64_v2 = " \
 glibc \
 python3 \
"
RDEPENDS:python3-crcmod:aarch64 = " \
 python3 \
"
