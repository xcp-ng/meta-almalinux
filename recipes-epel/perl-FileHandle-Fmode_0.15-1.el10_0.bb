# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-FileHandle-Fmode"
PV = "0.15"
PR = "1.el10_0"
PACKAGES = " \
 perl-FileHandle-Fmode \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-FileHandle-Fmode-0.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "778c79d9008dae3f9d53399e664860f740bbf5c847599c1aa6e2712c2f38e390"

URI_x86_64_v2_perl-FileHandle-Fmode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-FileHandle-Fmode-0.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-FileHandle-Fmode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-FileHandle-Fmode}"
SRC_URI[x86_64_v2_perl-FileHandle-Fmode.sha256sum] = "5a0d364430c8ac8c754f928854c2065e0a716cdf3f969c17f92079d756a0f4b3"

URI_aarch64_perl-FileHandle-Fmode = "${EPEL_MIRROR}/aarch64/Packages/p/perl-FileHandle-Fmode-0.15-1.el10_0.aarch64.rpm;name=aarch64_perl-FileHandle-Fmode;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-FileHandle-Fmode}"
SRC_URI[aarch64_perl-FileHandle-Fmode.sha256sum] = "089f3b224fb4006645608cb6e2256fc7803f347114a311e52684d7bf0786cf1c"

RDEPENDS:perl-FileHandle-Fmode = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-Fcntl \
 perl-constant \
 perl-libs \
 "
