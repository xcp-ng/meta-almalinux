# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wcslib"
PV = "8.4"
PR = "1.el10_0"
PACKAGES = " \
 wcslib \
 wcslib-devel \
 wcslib-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wcslib-8.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f969a6a58c9662ee09a7385151eb3321b507f9d8c4b823f61deb973cdefb4250"

URI_x86_64_v2_wcslib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wcslib-8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wcslib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wcslib}"
SRC_URI[x86_64_v2_wcslib.sha256sum] = "40af14a83e46b19eaf14d42403a759b43d5241627e783c6989ca3b5f4e1f1495"

URI_x86_64_v2_wcslib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wcslib-devel-8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wcslib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wcslib-devel}"
SRC_URI[x86_64_v2_wcslib-devel.sha256sum] = "875b9a9d175ae697e72d52846e9540170324c967fd7ade994df583d7d03eed16"

URI_x86_64_v2_wcslib-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wcslib-utils-8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wcslib-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wcslib-utils}"
SRC_URI[x86_64_v2_wcslib-utils.sha256sum] = "6bb28509db282b7a5cfc70e0b8c7c54893bf1e04d6fd4af6db9afc266dc10af5"

URI_aarch64_wcslib = "${EPEL_MIRROR}/aarch64/Packages/w/wcslib-8.4-1.el10_0.aarch64.rpm;name=aarch64_wcslib;unpack=0"
SRC_URI:append = " ${URI_aarch64_wcslib}"
SRC_URI[aarch64_wcslib.sha256sum] = "c8fdb296ad2ee1b24f7c6de762238a4019db62d5d99096d0ea5a8f1b7444e554"

URI_aarch64_wcslib-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wcslib-devel-8.4-1.el10_0.aarch64.rpm;name=aarch64_wcslib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wcslib-devel}"
SRC_URI[aarch64_wcslib-devel.sha256sum] = "3e716c238f92fb5cffb5783229e3eab0b83ec45625d0fb4e0e82ba8b8ee49dde"

URI_aarch64_wcslib-utils = "${EPEL_MIRROR}/aarch64/Packages/w/wcslib-utils-8.4-1.el10_0.aarch64.rpm;name=aarch64_wcslib-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_wcslib-utils}"
SRC_URI[aarch64_wcslib-utils.sha256sum] = "0dddb0fc282176d4af79f4b6cd3aa48a3129625fb6cf325bcdf59fdc2e0be345"

RDEPENDS:wcslib = " \
 glibc \
 "
RDEPENDS:wcslib-devel = " \
 pkgconf-pkg-config \
 wcslib \
 "
RDEPENDS:wcslib-utils = " \
 cfitsio \
 glibc \
 wcslib \
 "
