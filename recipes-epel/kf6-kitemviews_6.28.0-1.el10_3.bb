# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemviews"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kitemviews \
 kf6-kitemviews-devel \
 kf6-kitemviews-doc \
 kf6-kitemviews-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemviews-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "859b47fcbdfaa9a5024596940ee6ea31fb0d5b268300af1801f2099e08ef03dd"

URI_x86_64_v2_kf6-kitemviews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews}"
SRC_URI[x86_64_v2_kf6-kitemviews.sha256sum] = "403ba747a3d88c83c854099163a447ae61a04965733ae7c887b723cd54adfb2b"

URI_x86_64_v2_kf6-kitemviews-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-devel}"
SRC_URI[x86_64_v2_kf6-kitemviews-devel.sha256sum] = "cf31dfd5e67ce9ed8a967820a7359dc736f916eb65c03ada30379e485e852f9f"

URI_x86_64_v2_kf6-kitemviews-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemviews-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-doc}"
SRC_URI[x86_64_v2_kf6-kitemviews-doc.sha256sum] = "cca870039eeea77823133daada42ec465e04bc8bc8a0802abb9ba62da057e0b9"

URI_x86_64_v2_kf6-kitemviews-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemviews-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-html}"
SRC_URI[x86_64_v2_kf6-kitemviews-html.sha256sum] = "488660e88896a58158596536fb7476eacfbda6168baebab13f5c2fa505b0213d"

URI_aarch64_kf6-kitemviews = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kitemviews;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews}"
SRC_URI[aarch64_kf6-kitemviews.sha256sum] = "43e3fe20211c9e5a1864d02a1f8d7555fc1df85fbd339d2f8770a0122104c414"

URI_aarch64_kf6-kitemviews-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kitemviews-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-devel}"
SRC_URI[aarch64_kf6-kitemviews-devel.sha256sum] = "0dffd0d84bc77904c20e44ad066feecd458382b3b7b04e28af64884286a683b4"

URI_aarch64_kf6-kitemviews-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kitemviews-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-doc}"
SRC_URI[aarch64_kf6-kitemviews-doc.sha256sum] = "06211555da38c827fa47f3016d9b8468ea652e233f4d4f06fbb379060b92d24d"

URI_aarch64_kf6-kitemviews-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kitemviews-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-html}"
SRC_URI[aarch64_kf6-kitemviews-html.sha256sum] = "d099c9e22e33f36592001ac8d2af4d8021ce21a72858f4edd59a9f85203354b3"

RDEPENDS:kf6-kitemviews = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kitemviews \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-doc = " \
 "
RDEPENDS:kf6-kitemviews-html = " \
 "
