# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mysqltuner"
PV = "2.8.45"
PR = "1.el10_3"
PACKAGES = " \
 mysqltuner \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mysqltuner-2.8.45-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "529ebf856e1d9fccc211e3f63c6427159231cba7c93b31ccec0c812d4b7227e8"

URI_x86_64_v2_mysqltuner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mysqltuner-2.8.45-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mysqltuner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysqltuner}"
SRC_URI[x86_64_v2_mysqltuner.sha256sum] = "5f2c12bbf26d7061fc019a60ea2aab9d039e5a6d65e46e7fbb604e5250c606b9"

URI_aarch64_mysqltuner = "${EPEL_MIRROR}/aarch64/Packages/m/mysqltuner-2.8.45-1.el10_3.noarch.rpm;name=aarch64_mysqltuner;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysqltuner}"
SRC_URI[aarch64_mysqltuner.sha256sum] = "aba309f7edace01d0952ba6941b7f4514290d42860c45cb4c9aecfa19eee6f68"

RDEPENDS:mysqltuner = " \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-interpreter \
 perl-libs \
 virtual/mysql-any_or_mariadb-any \
 which \
 "
