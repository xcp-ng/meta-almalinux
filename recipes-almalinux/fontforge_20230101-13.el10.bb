# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fontforge"
PV = "20230101"
PR = "13.el10"
PACKAGES = " \
 fontforge \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/fontforge-20230101-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ceb168e16d3c57e88fd027e3b2e7e30a48effc6f01bda66fe89ab96851d3c302"

URI_x86_64_v2_fontforge = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fontforge-20230101-13.el10.x86_64_v2.rpm;name=x86_64_v2_fontforge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontforge}"
SRC_URI[x86_64_v2_fontforge.sha256sum] = "61020445dfdccf40a843df78be2cd20a5d7826d5edd2c77582b3a7b264c7ed9a"

URI_aarch64_fontforge = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fontforge-20230101-13.el10.aarch64.rpm;name=aarch64_fontforge;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontforge}"
SRC_URI[aarch64_fontforge.sha256sum] = "0fd71ae7734ee6335ce14faf4c4e978f35eea1548e27784b2effcd05d6f95ba9"

RDEPENDS:fontforge = " \
 cairo \
 freetype \
 giflib \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libgcc \
 libjpeg-turbo \
 libpng \
 libspiro \
 libstdc++ \
 libtiff \
 libxml2 \
 pango \
 potrace \
 python3 \
 python3-libs \
 readline \
 woff2 \
 xdg-utils \
 zlib-ng-compat \
 "
