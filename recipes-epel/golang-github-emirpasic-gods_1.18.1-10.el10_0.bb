# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-emirpasic-gods"
PV = "1.18.1"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-emirpasic-gods-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-emirpasic-gods-1.18.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91431289a3b2e5c98ac91ec0a62bc4f82509eb23e78846344aa54abe642d577e"

URI_x86_64_v2_golang-github-emirpasic-gods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-emirpasic-gods-devel-1.18.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-emirpasic-gods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-emirpasic-gods-devel}"
SRC_URI[x86_64_v2_golang-github-emirpasic-gods-devel.sha256sum] = "8d4106536d30d1926f0054fe09a5a477cd3fdf2a6b1ec33e521c935778dd52f8"

URI_aarch64_golang-github-emirpasic-gods-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-emirpasic-gods-devel-1.18.1-10.el10_0.noarch.rpm;name=aarch64_golang-github-emirpasic-gods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-emirpasic-gods-devel}"
SRC_URI[aarch64_golang-github-emirpasic-gods-devel.sha256sum] = "1f7ce0784e76d04ec90a4f593f3f71c1cc9efcb30143d85c9934d163db9fdc54"

RDEPENDS:golang-github-emirpasic-gods-devel = " \
 go-filesystem \
 "
