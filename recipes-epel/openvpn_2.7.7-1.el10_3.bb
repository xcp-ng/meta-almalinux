# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvpn"
PV = "2.7.7"
PR = "1.el10_3"
PACKAGES = " \
 openvpn \
 openvpn-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openvpn-2.7.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dfcee4a08906810742ffef7d6972ac34b3ee80b891b01e366974f844b4de2d67"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-2.7.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn;unpack=0"
SRC_URI[x86_64_v2_openvpn.sha256sum] = "f92883719ef3fd031a7afbdf2da69877aae77fadb4d46a7b44a983ab8e4f7f15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-devel-2.7.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn-devel;unpack=0"
SRC_URI[x86_64_v2_openvpn-devel.sha256sum] = "228770c10343e3c2dbd606e2604cd6fb3bdc49089cb2e7d08ce4586d9d9a96e3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openvpn-2.7.7-1.el10_3.aarch64.rpm;name=aarch64_openvpn;unpack=0"
SRC_URI[aarch64_openvpn.sha256sum] = "141e1bac0d090e7cd4a443b9bbf8c47c98a02eb25cfbf49b406c3009f37c31f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openvpn-devel-2.7.7-1.el10_3.aarch64.rpm;name=aarch64_openvpn-devel;unpack=0"
SRC_URI[aarch64_openvpn-devel.sha256sum] = "d21b0c0d1fd07a85d67f2cfd4d2befeebd3f594b8c44bd7459dfd155698203cc"

RDEPENDS:openvpn = " \
 bash \
 gawk \
 glibc \
 libcap-ng \
 libnl3 \
 libselinux \
 lz4-libs \
 lzo \
 openssl-libs \
 pam-libs \
 pkcs11-helper \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:openvpn-devel = " \
 "
