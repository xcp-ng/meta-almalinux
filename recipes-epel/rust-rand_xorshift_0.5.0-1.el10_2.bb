# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xorshift"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_xorshift+default-devel \
 rust-rand_xorshift+serde-devel \
 rust-rand_xorshift-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xorshift-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25474975a35d4a5867464e5e61bdac34a5b0c55b0b35e7e24b6758c2f2f3b364"

URI_x86_64_v2_rust-rand_xorshift+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift+default-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift+default-devel.sha256sum] = "30fa750909b1e544060b2e9adcdb0165b2b8d35a6141a64d2ebc2f95b60400af"

URI_x86_64_v2_rust-rand_xorshift+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift+serde-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift+serde-devel.sha256sum] = "f1214f05a700eee09925ce63daf339307da8eb72279d688bce4b0818b3c64762"

URI_x86_64_v2_rust-rand_xorshift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift-devel-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift-devel.sha256sum] = "108b44e8434efadc63665b1be06e3aa24abafa3d59d2cb22eda23be5c0039afb"

URI_aarch64_rust-rand_xorshift+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift+default-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xorshift+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift+default-devel}"
SRC_URI[aarch64_rust-rand_xorshift+default-devel.sha256sum] = "20bb3aaa4a6dbebab136127b9e67ee0640905d30c44c7e6dfab11e5e600ba84b"

URI_aarch64_rust-rand_xorshift+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift+serde-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xorshift+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift+serde-devel}"
SRC_URI[aarch64_rust-rand_xorshift+serde-devel.sha256sum] = "80579a4b229c88f73403a5b47238dea3d7c7822b44b07e7a6c05b478e0a7ae9a"

URI_aarch64_rust-rand_xorshift-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift-devel-0.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift-devel}"
SRC_URI[aarch64_rust-rand_xorshift-devel.sha256sum] = "aa776dae9e97dc320e0b07832bae04e3498941eede50ff24dbf9d7c13cf20c1f"

RDEPENDS:rust-rand_xorshift+default-devel = " \
 cargo \
 rust-rand_xorshift-devel \
 "
RDEPENDS:rust-rand_xorshift+serde-devel = " \
 cargo \
 rust-rand_xorshift-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rand_xorshift-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
