# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spamass-milter"
PV = "0.4.0"
PR = "30.el10_1"
PACKAGES = " \
 spamass-milter \
 spamass-milter-postfix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spamass-milter-0.4.0-30.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5961b280d3e793a39a766bc3eda9370ef7de07b3688c37d9e8ce21641ba0c0f8"

URI_x86_64_v2_spamass-milter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamass-milter-0.4.0-30.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spamass-milter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spamass-milter}"
SRC_URI[x86_64_v2_spamass-milter.sha256sum] = "f383bc42ebbc719d19e244d94a0757c472702d223d651d2c73906c13337d7280"

URI_x86_64_v2_spamass-milter-postfix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamass-milter-postfix-0.4.0-30.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_spamass-milter-postfix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spamass-milter-postfix}"
SRC_URI[x86_64_v2_spamass-milter-postfix.sha256sum] = "f3210ec53abf591106ddc3282148268b5951f17a851d64ab762682d4e4023dfa"

URI_aarch64_spamass-milter = "${EPEL_MIRROR}/aarch64/Packages/s/spamass-milter-0.4.0-30.el10_1.aarch64.rpm;name=aarch64_spamass-milter;unpack=0"
SRC_URI:append = " ${URI_aarch64_spamass-milter}"
SRC_URI[aarch64_spamass-milter.sha256sum] = "b2748fdf593ab07d191b70c3b34a0b340cf12702bc9b923acf2b1451eb7f11be"

URI_aarch64_spamass-milter-postfix = "${EPEL_MIRROR}/aarch64/Packages/s/spamass-milter-postfix-0.4.0-30.el10_1.noarch.rpm;name=aarch64_spamass-milter-postfix;unpack=0"
SRC_URI:append = " ${URI_aarch64_spamass-milter-postfix}"
SRC_URI[aarch64_spamass-milter-postfix.sha256sum] = "fe397461b20b47c0b34acf4c706c6225d191937a34e68957d4c283fc719bfc7d"

RDEPENDS:spamass-milter = " \
 bash \
 glibc \
 glibc-common \
 libgcc \
 libstdc++ \
 sendmail-milter \
 shadow-utils \
 spamassassin \
 systemd \
 virtual//usr/sbin/sendmail \
 virtual/coreutils \
 "
RDEPENDS:spamass-milter-postfix = " \
 bash \
 postfix \
 shadow-utils \
 spamass-milter \
 "
