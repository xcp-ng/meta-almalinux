# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtserialbus"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtserialbus \
 qt5-qtserialbus-devel \
 qt5-qtserialbus-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtserialbus-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64a7e5da2fc1276a7219bbf3e3c22d8f4f31c1efc926122af1918efc9fceea0b"

URI_x86_64_v2_qt5-qtserialbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus}"
SRC_URI[x86_64_v2_qt5-qtserialbus.sha256sum] = "32a5dd0baa9235b9b262f3e1c9009a5d22eae7d670efa27c2c77f346038f31a7"

URI_x86_64_v2_qt5-qtserialbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus-devel}"
SRC_URI[x86_64_v2_qt5-qtserialbus-devel.sha256sum] = "eb44e927832d82858dc3ddfb6560838c6461fb008b814b0e255643cecedac33e"

URI_x86_64_v2_qt5-qtserialbus-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtserialbus-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtserialbus-examples}"
SRC_URI[x86_64_v2_qt5-qtserialbus-examples.sha256sum] = "e92440797cdfe8585c66bd21581debff2ac705081de6d356623e74f59d4b57ec"

URI_aarch64_qt5-qtserialbus = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtserialbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus}"
SRC_URI[aarch64_qt5-qtserialbus.sha256sum] = "3d509b7301592187a29176c47deaa0cefc039e9b363acb85c8ebc5117938700c"

URI_aarch64_qt5-qtserialbus-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtserialbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus-devel}"
SRC_URI[aarch64_qt5-qtserialbus-devel.sha256sum] = "66061457ab1bf9ea66a5f50740d94fad7c46c532b068a50538d2b4bd3416e9f0"

URI_aarch64_qt5-qtserialbus-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtserialbus-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtserialbus-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtserialbus-examples}"
SRC_URI[aarch64_qt5-qtserialbus-examples.sha256sum] = "25604ba2eed04ab287701bce723f0b63c3c3b21ebc6d8595c58078044efcc447"

RDEPENDS:qt5-qtserialbus = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtserialport \
 "
RDEPENDS:qt5-qtserialbus-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtserialbus \
 "
RDEPENDS:qt5-qtserialbus-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtserialbus \
 qt5-qtserialport \
 "
