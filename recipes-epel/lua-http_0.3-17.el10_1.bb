# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-http"
PV = "0.3"
PR = "17.el10_1"
PACKAGES = " \
 lua-http \
 lua-http-doc \
 lua5.1-http \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-http-0.3-17.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "680bde98ec73d5b57c643427f3ee3d1957e45b6c8fc62b86ff8035e709c23f08"

URI_x86_64_v2_lua-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-http-0.3-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-http}"
SRC_URI[x86_64_v2_lua-http.sha256sum] = "bc1d134df2fbc80353b058a7177fab41a79b4f5b3eff1d7a5299df69a57ce3ac"

URI_x86_64_v2_lua-http-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-http-doc-0.3-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua-http-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-http-doc}"
SRC_URI[x86_64_v2_lua-http-doc.sha256sum] = "2cd753d29e17c2cae64143f09568917d49c2b120e076663318277cfbecdbc194"

URI_x86_64_v2_lua5.1-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-http-0.3-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lua5.1-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-http}"
SRC_URI[x86_64_v2_lua5.1-http.sha256sum] = "d337b6f54c1e288e91643f309908eff9af26dc2ef69f9ce2da4c81aa3b4f127f"

URI_aarch64_lua-http = "${EPEL_MIRROR}/aarch64/Packages/l/lua-http-0.3-17.el10_1.noarch.rpm;name=aarch64_lua-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-http}"
SRC_URI[aarch64_lua-http.sha256sum] = "758c7a29da4d75467f9b06f7689943edf8afd94d3e849cd6ea56d8ef81d868ba"

URI_aarch64_lua-http-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lua-http-doc-0.3-17.el10_1.noarch.rpm;name=aarch64_lua-http-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-http-doc}"
SRC_URI[aarch64_lua-http-doc.sha256sum] = "b0d55d78cf9b6f90eba1d4465b0500c88c66c360e55a1fe83f0425bb44d759b0"

URI_aarch64_lua5.1-http = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-http-0.3-17.el10_1.noarch.rpm;name=aarch64_lua5.1-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-http}"
SRC_URI[aarch64_lua5.1-http.sha256sum] = "0f2203580430ec3b6365275d02ddc6c986d8377c3fb3f5a5507c5110a6460bac"

RDEPENDS:lua-http = " \
 lua-basexx \
 lua-binaryheap \
 lua-cqueues \
 lua-fifo \
 lua-lpeg \
 lua-lpeg-patterns \
 lua-luaossl \
 "
RDEPENDS:lua-http-doc = " \
 lua-http \
 lua5.1-http \
 "
RDEPENDS:lua5.1-http = " \
 lua5.1-basexx \
 lua5.1-binaryheap \
 lua5.1-bitop \
 lua5.1-compat53 \
 lua5.1-cqueues \
 lua5.1-fifo \
 lua5.1-lpeg \
 lua5.1-lpeg-patterns \
 lua5.1-luaossl \
 "
