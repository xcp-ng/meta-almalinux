# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fftw"
PV = "3.3.10"
PR = "15.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 fftw \
 fftw-devel \
 fftw-doc \
 fftw-libs \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
 fftw-libs-single \
 fftw-openmpi-devel \
 fftw-openmpi-libs \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
 fftw-openmpi-static \
 fftw-static \
"
PACKAGES:aarch64 = " \
 fftw \
 fftw-devel \
 fftw-doc \
 fftw-libs \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-single \
 fftw-openmpi-devel \
 fftw-openmpi-libs \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
 fftw-openmpi-static \
 fftw-static \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fftw-3.3.10-15.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c553e67d3767caf21e61e47464ba537d0a347125cd5452d2c40156bca0ef7665"

URI_x86_64_v2_fftw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw}"
SRC_URI[x86_64_v2_fftw.sha256sum] = "b465643741523f425dd21906590b1d1d796315e413ed30fa1c93377c56882fdd"

URI_x86_64_v2_fftw-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-devel-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-devel}"
SRC_URI[x86_64_v2_fftw-devel.sha256sum] = "0637de9e9d442a5c25bd0dfc51e7c2f0e28a801bd25f8d8d87f0ed494a534b7b"

URI_x86_64_v2_fftw-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fftw-doc-3.3.10-15.el10.alma.1.noarch.rpm;name=x86_64_v2_fftw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-doc}"
SRC_URI[x86_64_v2_fftw-doc.sha256sum] = "a2b1470aea9c5900cd2431f5442acd0840fe728ed4084ed5e1d71610bd82e5a5"

URI_x86_64_v2_fftw-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs}"
SRC_URI[x86_64_v2_fftw-libs.sha256sum] = "7ca0eeb9453ab551b6fade1efcd5b59175ed8922161da99e918a0096226493b5"

URI_x86_64_v2_fftw-libs-double = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-double-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-double;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs-double}"
SRC_URI[x86_64_v2_fftw-libs-double.sha256sum] = "d06528d088934d388ca35ff4574f559ddccef2f8ad76d96e51df1dcb6d994b3f"

URI_x86_64_v2_fftw-libs-long = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-long-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-long;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs-long}"
SRC_URI[x86_64_v2_fftw-libs-long.sha256sum] = "c5c0f335f8f5c8a62ece7057e54b18bec21b8b416f0ec2025b9286a706603b63"

URI_x86_64_v2_fftw-libs-quad = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-quad-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-quad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs-quad}"
SRC_URI[x86_64_v2_fftw-libs-quad.sha256sum] = "ef0b4826a89ef4c82e33a77c5671ae5db4cd223063d3b79d6ad4d1790120173c"

URI_x86_64_v2_fftw-libs-single = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-libs-single-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-libs-single;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-libs-single}"
SRC_URI[x86_64_v2_fftw-libs-single.sha256sum] = "651972c0fb3765d61fa1338773ca38d035613cd8c2afc6168e8a58c6a4a6153b"

URI_x86_64_v2_fftw-openmpi-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-devel-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-devel}"
SRC_URI[x86_64_v2_fftw-openmpi-devel.sha256sum] = "4b30874199a86c79075cc0093bb820045666ba3cc2415ecfaaf197ace127c779"

URI_x86_64_v2_fftw-openmpi-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-libs}"
SRC_URI[x86_64_v2_fftw-openmpi-libs.sha256sum] = "11a2e485f6786c6713c7e7cf42069b01470742c8e9187e74f59b330fb00aa0a5"

URI_x86_64_v2_fftw-openmpi-libs-double = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-double-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs-double;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-libs-double}"
SRC_URI[x86_64_v2_fftw-openmpi-libs-double.sha256sum] = "8fef4b836c08bdebd03b434b24bee4d5d808cdf61b2a3ffc84a57174c9b83a39"

URI_x86_64_v2_fftw-openmpi-libs-long = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-long-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs-long;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-libs-long}"
SRC_URI[x86_64_v2_fftw-openmpi-libs-long.sha256sum] = "6282a22c58e18a9ac8088ccd9e62680097aeaf59a50ea4c68033b56c28651cc3"

URI_x86_64_v2_fftw-openmpi-libs-single = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-libs-single-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-libs-single;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-libs-single}"
SRC_URI[x86_64_v2_fftw-openmpi-libs-single.sha256sum] = "78649a854a5c57f7e9e9a927c1f0c89039fd83c40e2f38b8d02c3712d24fc87f"

URI_x86_64_v2_fftw-openmpi-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-openmpi-static-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-openmpi-static}"
SRC_URI[x86_64_v2_fftw-openmpi-static.sha256sum] = "bd531b88623554e49416a85b933bb8c144562eaaae05a3569640d5f5aeb54552"

URI_x86_64_v2_fftw-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fftw-static-3.3.10-15.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fftw-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fftw-static}"
SRC_URI[x86_64_v2_fftw-static.sha256sum] = "d148fc7be668287b010476d5808cef1487cb65fc8e3e9cfd2287d8192185fbba"

URI_aarch64_fftw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw}"
SRC_URI[aarch64_fftw.sha256sum] = "0ccd67de86028cfcd3b27be3b089dc999ef15d5f6174e9f8cf411d84dde343fb"

URI_aarch64_fftw-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-devel-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-devel}"
SRC_URI[aarch64_fftw-devel.sha256sum] = "9bffe11245e05c9f64d6c92c19310f72cef5d708dfe65bb805dcc8f4182d7cbc"

URI_aarch64_fftw-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fftw-doc-3.3.10-15.el10.alma.1.noarch.rpm;name=aarch64_fftw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-doc}"
SRC_URI[aarch64_fftw-doc.sha256sum] = "a2b1470aea9c5900cd2431f5442acd0840fe728ed4084ed5e1d71610bd82e5a5"

URI_aarch64_fftw-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-libs}"
SRC_URI[aarch64_fftw-libs.sha256sum] = "94e80e5ac7736028886125cb53c106ca03f73c8b9defc360e3f325b0401218fb"

URI_aarch64_fftw-libs-double = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-double-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-libs-double;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-libs-double}"
SRC_URI[aarch64_fftw-libs-double.sha256sum] = "f591cdd35638b3b35f2085217d714286e2fe1a2e291c25c5c9a82aa171aba7d2"

URI_aarch64_fftw-libs-long = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-long-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-libs-long;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-libs-long}"
SRC_URI[aarch64_fftw-libs-long.sha256sum] = "713b77e57f111be15b03067ce681ef5a47318ce27098e4d19f3dd059a1e22066"

URI_aarch64_fftw-libs-single = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-libs-single-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-libs-single;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-libs-single}"
SRC_URI[aarch64_fftw-libs-single.sha256sum] = "511c33cfed1b9f3e7aed8a56ed6ef6344e705ea92956d5c80c805a0f157eaabe"

URI_aarch64_fftw-openmpi-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-devel-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-devel}"
SRC_URI[aarch64_fftw-openmpi-devel.sha256sum] = "8f60d4bec1767728efd01577f8c28c68ec8fbbc134fcecc544a52668d55f6dce"

URI_aarch64_fftw-openmpi-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-libs}"
SRC_URI[aarch64_fftw-openmpi-libs.sha256sum] = "b9af463cb9ed6de0857bcb65e1e4036ff8a8c1af76e43f4c244a2369e4310e26"

URI_aarch64_fftw-openmpi-libs-double = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-double-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-libs-double;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-libs-double}"
SRC_URI[aarch64_fftw-openmpi-libs-double.sha256sum] = "23e4bf19b7f4e5a02dbddf6ec1f6ed5a4ba034a39ccc608213b4966ae04353f9"

URI_aarch64_fftw-openmpi-libs-long = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-long-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-libs-long;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-libs-long}"
SRC_URI[aarch64_fftw-openmpi-libs-long.sha256sum] = "ae2434838dd2e6e1fbfbe899a688ad1e96fcae80254a6bd7e9b9ef315273d521"

URI_aarch64_fftw-openmpi-libs-single = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-libs-single-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-libs-single;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-libs-single}"
SRC_URI[aarch64_fftw-openmpi-libs-single.sha256sum] = "9dcd1096d9fa76fdc91319e87793f501e63d8c5fb41c73501a92d9c6858d68eb"

URI_aarch64_fftw-openmpi-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-openmpi-static-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-openmpi-static}"
SRC_URI[aarch64_fftw-openmpi-static.sha256sum] = "2342e7bedb122cb047fa8f37bee0240876ac80cdbf2cdd3aea5fd82ee82af438"

URI_aarch64_fftw-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fftw-static-3.3.10-15.el10.alma.1.aarch64.rpm;name=aarch64_fftw-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_fftw-static}"
SRC_URI[aarch64_fftw-static.sha256sum] = "1d9fe959ff76dcf78791d6870588ee4c16f1ee80f0ceffa7ba8d91101d5d8a80"

RDEPENDS:fftw:x86_64_v2 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
 fftw-libs-single \
 glibc \
"
RDEPENDS:fftw:aarch64 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-single \
 glibc \
"
RDEPENDS:fftw-devel = " \
 fftw \
 fftw-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:fftw-doc = " \
 "
RDEPENDS:fftw-libs:x86_64_v2 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-quad \
 fftw-libs-single \
"
RDEPENDS:fftw-libs:aarch64 = " \
 fftw-libs-double \
 fftw-libs-long \
 fftw-libs-single \
"
RDEPENDS:fftw-libs-double = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:fftw-libs-long = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:fftw-libs-quad = " \
 glibc \
 libgcc \
 libgomp \
 libquadmath \
 "
RDEPENDS:fftw-libs-single = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:fftw-openmpi-devel = " \
 fftw-devel \
 fftw-openmpi-libs \
 openmpi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:fftw-openmpi-libs = " \
 fftw-openmpi-libs-double \
 fftw-openmpi-libs-long \
 fftw-openmpi-libs-single \
 "
RDEPENDS:fftw-openmpi-libs-double = " \
 fftw-libs-double \
 glibc \
 openmpi \
 "
RDEPENDS:fftw-openmpi-libs-long = " \
 fftw-libs-long \
 glibc \
 openmpi \
 "
RDEPENDS:fftw-openmpi-libs-single = " \
 fftw-libs-single \
 glibc \
 openmpi \
 "
RDEPENDS:fftw-openmpi-static = " \
 fftw-openmpi-devel \
 fftw-static \
 "
RDEPENDS:fftw-static = " \
 fftw-devel \
 "
