# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sddm-kcm"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 sddm-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sddm-kcm-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36a18d2249dbd1c8c8fc51b5a09f723bc7f2fad7322ce56b6e8f3a972430905a"

URI_x86_64_v2_sddm-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-kcm-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sddm-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-kcm}"
SRC_URI[x86_64_v2_sddm-kcm.sha256sum] = "91eb8f5c8fcd2ac3537df141f2449d0a118c79f756ae81f551252b0da274f0c2"

URI_aarch64_sddm-kcm = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-kcm-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_sddm-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-kcm}"
SRC_URI[aarch64_sddm-kcm.sha256sum] = "6f41c4c3702813aa786a129317006d37ed899850abbcd7bceee66fb35c9b6e95"

RDEPENDS:sddm-kcm = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 sddm \
 "
