# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nbdkit"
PV = "1.44.1"
PR = "6.el10_1"
PACKAGES:x86_64_v2 = " \
 nbdkit \
 nbdkit-bash-completion \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-devel \
 nbdkit-example-plugins \
 nbdkit-linuxdisk-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-selinux \
 nbdkit-server \
 nbdkit-srpm-macros \
 nbdkit-ssh-plugin \
 nbdkit-tar-filter \
 nbdkit-tmpdisk-plugin \
 nbdkit-vddk-plugin \
 nbdkit-xz-filter \
"
PACKAGES:aarch64 = " \
 nbdkit \
 nbdkit-bash-completion \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-curl-plugin \
 nbdkit-devel \
 nbdkit-example-plugins \
 nbdkit-linuxdisk-plugin \
 nbdkit-nbd-plugin \
 nbdkit-python-plugin \
 nbdkit-selinux \
 nbdkit-server \
 nbdkit-srpm-macros \
 nbdkit-ssh-plugin \
 nbdkit-tar-filter \
 nbdkit-tmpdisk-plugin \
 nbdkit-xz-filter \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nbdkit-1.44.1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54e7e60d764e769df5c169f6fb0b91ca56d3a8e4a83d213238054f3d915aa9a2"

URI_x86_64_v2_nbdkit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit}"
SRC_URI[x86_64_v2_nbdkit.sha256sum] = "80c512f60103dc6f1ee3fdbf7a19c950eb3d39b06e370507937486143fc49977"

URI_x86_64_v2_nbdkit-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-bash-completion-1.44.1-6.el10_1.noarch.rpm;name=x86_64_v2_nbdkit-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-bash-completion}"
SRC_URI[x86_64_v2_nbdkit-bash-completion.sha256sum] = "7b5c913fb4d05248a6897a65e6196d908008e5fa1f05b6a111db3c00b1cb240d"

URI_x86_64_v2_nbdkit-basic-filters = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-basic-filters-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-basic-filters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-basic-filters}"
SRC_URI[x86_64_v2_nbdkit-basic-filters.sha256sum] = "7896a7892656dafa8045765a2cf5de9878227f6b0e209bda844f98b6388c2892"

URI_x86_64_v2_nbdkit-basic-plugins = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-basic-plugins-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-basic-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-basic-plugins}"
SRC_URI[x86_64_v2_nbdkit-basic-plugins.sha256sum] = "0db64c3a3a35c0b077bb23667cad482e086a7f6ba9bd7c059fa0e1fe8e1fbe29"

URI_x86_64_v2_nbdkit-curl-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-curl-plugin-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-curl-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-curl-plugin}"
SRC_URI[x86_64_v2_nbdkit-curl-plugin.sha256sum] = "3b56a75710d2d02203918d808a5e75eed5b2cff49fe60e544b038ab9d662c692"

URI_x86_64_v2_nbdkit-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nbdkit-devel-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-devel}"
SRC_URI[x86_64_v2_nbdkit-devel.sha256sum] = "54a2cc182228735c5104a1d7b101129d7ec2316c983f055e22a86fe729448e93"

URI_x86_64_v2_nbdkit-example-plugins = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nbdkit-example-plugins-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-example-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-example-plugins}"
SRC_URI[x86_64_v2_nbdkit-example-plugins.sha256sum] = "1c94ce43654f9f30f047d3e49007510de0085fbaf58f4c02639889ae3488bed2"

URI_x86_64_v2_nbdkit-linuxdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-linuxdisk-plugin-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-linuxdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-linuxdisk-plugin}"
SRC_URI[x86_64_v2_nbdkit-linuxdisk-plugin.sha256sum] = "d03b4acc6e79e5e1725763de65aadc76e5ef698fe41bbbc2081e567518f9a6c5"

URI_x86_64_v2_nbdkit-nbd-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-nbd-plugin-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-nbd-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-nbd-plugin}"
SRC_URI[x86_64_v2_nbdkit-nbd-plugin.sha256sum] = "559d9c3dd07769ed42c5e7bca444e1c86d3b3e35d66f88aae5127ffcb679d135"

URI_x86_64_v2_nbdkit-python-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-python-plugin-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-python-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-python-plugin}"
SRC_URI[x86_64_v2_nbdkit-python-plugin.sha256sum] = "2df6b6e3b6f6c1a73c377d8e13445fcd3111cd7f1777ce46a4ea2be6a0cd2de2"

URI_x86_64_v2_nbdkit-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-selinux-1.44.1-6.el10_1.noarch.rpm;name=x86_64_v2_nbdkit-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-selinux}"
SRC_URI[x86_64_v2_nbdkit-selinux.sha256sum] = "5dd81257e8d6b15b9e453f3f82a30eeed11c725251136023cd7d4691d0b205ff"

URI_x86_64_v2_nbdkit-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-server-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-server}"
SRC_URI[x86_64_v2_nbdkit-server.sha256sum] = "99feaaf64485ceb4183082574ca3e0890f720021bd99457e4010e59b49262364"

URI_x86_64_v2_nbdkit-srpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nbdkit-srpm-macros-1.44.1-6.el10_1.noarch.rpm;name=x86_64_v2_nbdkit-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-srpm-macros}"
SRC_URI[x86_64_v2_nbdkit-srpm-macros.sha256sum] = "77ba4240e6e394da2a80d7111094068406f36b3898fdd348f0835d877d4ebbdf"

URI_x86_64_v2_nbdkit-ssh-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-ssh-plugin-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-ssh-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-ssh-plugin}"
SRC_URI[x86_64_v2_nbdkit-ssh-plugin.sha256sum] = "82df3837528935264bf255a0a825e3cf707664f11c2040f2b0ac5f0ecb0d9c2e"

URI_x86_64_v2_nbdkit-tar-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-tar-filter-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-tar-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-tar-filter}"
SRC_URI[x86_64_v2_nbdkit-tar-filter.sha256sum] = "962b2d80b67effbf575c09bccab9d23fca056c32f69269452675e9df085361ff"

URI_x86_64_v2_nbdkit-tmpdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-tmpdisk-plugin-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-tmpdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-tmpdisk-plugin}"
SRC_URI[x86_64_v2_nbdkit-tmpdisk-plugin.sha256sum] = "0d31a10140c11a8b4593ca733caab341622927bde01fcc5ef6f926a1d5172bc0"

URI_x86_64_v2_nbdkit-vddk-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-vddk-plugin-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-vddk-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-vddk-plugin}"
SRC_URI[x86_64_v2_nbdkit-vddk-plugin.sha256sum] = "d1d8e95d54984ec3cc45d858742ba508838020cc96973d0c01dd2b264047064c"

URI_x86_64_v2_nbdkit-xz-filter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdkit-xz-filter-1.44.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_nbdkit-xz-filter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdkit-xz-filter}"
SRC_URI[x86_64_v2_nbdkit-xz-filter.sha256sum] = "e445f830569b73a27e114bce8f945ce7e795b74fc46dd1c41ae9f73a1299eead"

URI_aarch64_nbdkit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit}"
SRC_URI[aarch64_nbdkit.sha256sum] = "38e4801a9b01fc27d150c679b5448b825077259e98094cd5ac4fd91289939bca"

URI_aarch64_nbdkit-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-bash-completion-1.44.1-6.el10_1.noarch.rpm;name=aarch64_nbdkit-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-bash-completion}"
SRC_URI[aarch64_nbdkit-bash-completion.sha256sum] = "7b5c913fb4d05248a6897a65e6196d908008e5fa1f05b6a111db3c00b1cb240d"

URI_aarch64_nbdkit-basic-filters = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-basic-filters-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-basic-filters;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-basic-filters}"
SRC_URI[aarch64_nbdkit-basic-filters.sha256sum] = "95666b958d9d9451b9bc47431808d0ad7c3e9e9bef3e25280169014ae3bfc1e0"

URI_aarch64_nbdkit-basic-plugins = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-basic-plugins-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-basic-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-basic-plugins}"
SRC_URI[aarch64_nbdkit-basic-plugins.sha256sum] = "717325428a0845f6cd2f2a4b6723e906a7a63024221a4f96a88ba7f7d9a4fee5"

URI_aarch64_nbdkit-curl-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-curl-plugin-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-curl-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-curl-plugin}"
SRC_URI[aarch64_nbdkit-curl-plugin.sha256sum] = "968b01e4a9bbda49aad88fab9357032d42746c02371e480de3b293c772ae69fe"

URI_aarch64_nbdkit-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nbdkit-devel-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-devel}"
SRC_URI[aarch64_nbdkit-devel.sha256sum] = "55bc8a604a4ed5cf635394661db0bc2e8465fa137a7febc59feacbc06e2b1bdf"

URI_aarch64_nbdkit-example-plugins = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nbdkit-example-plugins-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-example-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-example-plugins}"
SRC_URI[aarch64_nbdkit-example-plugins.sha256sum] = "716e80cb69a4973d2113d19f5dbf68c92d9f17164ba51c6ef37460deb1f6a8df"

URI_aarch64_nbdkit-linuxdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-linuxdisk-plugin-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-linuxdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-linuxdisk-plugin}"
SRC_URI[aarch64_nbdkit-linuxdisk-plugin.sha256sum] = "4f2764b8b731a839cc0b9c067e925224912c2a250fcc310074f84d5c264e85ba"

URI_aarch64_nbdkit-nbd-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-nbd-plugin-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-nbd-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-nbd-plugin}"
SRC_URI[aarch64_nbdkit-nbd-plugin.sha256sum] = "6c85b9e637301c0b511b2be93193c51df2e87b77ba11ee33c156b3587092b56d"

URI_aarch64_nbdkit-python-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-python-plugin-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-python-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-python-plugin}"
SRC_URI[aarch64_nbdkit-python-plugin.sha256sum] = "45c575ff1ce494d786bd5b599402f01b666acd6ceba1e84d912c635873aa0cb2"

URI_aarch64_nbdkit-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-selinux-1.44.1-6.el10_1.noarch.rpm;name=aarch64_nbdkit-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-selinux}"
SRC_URI[aarch64_nbdkit-selinux.sha256sum] = "5dd81257e8d6b15b9e453f3f82a30eeed11c725251136023cd7d4691d0b205ff"

URI_aarch64_nbdkit-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-server-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-server}"
SRC_URI[aarch64_nbdkit-server.sha256sum] = "48404da2ed92163dbe76ed054e3849fcc983bee23a6b8c00298236756b259715"

URI_aarch64_nbdkit-srpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nbdkit-srpm-macros-1.44.1-6.el10_1.noarch.rpm;name=aarch64_nbdkit-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-srpm-macros}"
SRC_URI[aarch64_nbdkit-srpm-macros.sha256sum] = "77ba4240e6e394da2a80d7111094068406f36b3898fdd348f0835d877d4ebbdf"

URI_aarch64_nbdkit-ssh-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-ssh-plugin-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-ssh-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-ssh-plugin}"
SRC_URI[aarch64_nbdkit-ssh-plugin.sha256sum] = "dc477ee3c8d4f35a1aafc1158eedc4ab7e0406314561fe425fa13f1220dabff3"

URI_aarch64_nbdkit-tar-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-tar-filter-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-tar-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-tar-filter}"
SRC_URI[aarch64_nbdkit-tar-filter.sha256sum] = "f866b6167d08c51df42c14ce046fb773b8c156b396c85c4fdda84fe4bfab7034"

URI_aarch64_nbdkit-tmpdisk-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-tmpdisk-plugin-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-tmpdisk-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-tmpdisk-plugin}"
SRC_URI[aarch64_nbdkit-tmpdisk-plugin.sha256sum] = "739623b6f31db937b706378c60b720d71a34186757b72023d58b3ccbbbd25a33"

URI_aarch64_nbdkit-xz-filter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdkit-xz-filter-1.44.1-6.el10_1.aarch64.rpm;name=aarch64_nbdkit-xz-filter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdkit-xz-filter}"
SRC_URI[aarch64_nbdkit-xz-filter.sha256sum] = "d843e02cf85d4c2b51dbda1f0b51c51c11aa20c6b93cf9337bc22ed8722e510a"

RDEPENDS:nbdkit = " \
 nbdkit-basic-filters \
 nbdkit-basic-plugins \
 nbdkit-selinux \
 nbdkit-server \
 "
RDEPENDS:nbdkit-bash-completion = " \
 bash-completion \
 nbdkit-server \
 "
RDEPENDS:nbdkit-basic-filters = " \
 glibc \
 gnutls \
 libgcc \
 nbdkit-server \
 zlib-ng-compat \
 "
RDEPENDS:nbdkit-basic-plugins = " \
 glibc \
 gnutls \
 libgcc \
 libzstd \
 nbdkit-server \
 "
RDEPENDS:nbdkit-curl-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:nbdkit-devel = " \
 nbdkit-server \
 pkgconf-pkg-config \
 "
RDEPENDS:nbdkit-example-plugins = " \
 glibc \
 nbdkit-server \
 "
RDEPENDS:nbdkit-linuxdisk-plugin = " \
 e2fsprogs \
 glibc \
 libgcc \
 nbdkit-server \
 "
RDEPENDS:nbdkit-nbd-plugin = " \
 glibc \
 libgcc \
 libnbd \
 nbdkit-server \
 "
RDEPENDS:nbdkit-python-plugin = " \
 glibc \
 libgcc \
 nbdkit-server \
 python3-libs \
 "
RDEPENDS:nbdkit-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:nbdkit-server = " \
 glibc \
 gnutls \
 libgcc \
 libselinux \
 "
RDEPENDS:nbdkit-srpm-macros = " \
 bash \
 "
RDEPENDS:nbdkit-ssh-plugin = " \
 glibc \
 libgcc \
 libssh \
 nbdkit-server \
 "
RDEPENDS:nbdkit-tar-filter = " \
 glibc \
 libgcc \
 nbdkit-server \
 tar \
 "
RDEPENDS:nbdkit-tmpdisk-plugin = " \
 e2fsprogs \
 glibc \
 libgcc \
 nbdkit-server \
 util-linux \
 "
RDEPENDS:nbdkit-vddk-plugin = " \
 glibc \
 libgcc \
 libxcrypt-compat \
 nbdkit-server \
 "
RDEPENDS:nbdkit-xz-filter = " \
 glibc \
 libgcc \
 nbdkit-server \
 xz-libs \
 "
