# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbruch"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kbruch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbruch-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f10a078ce0dbf36a317d3d296e0210b36a04625348cf153726cef2f1ba4201f8"

URI_x86_64_v2_kbruch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbruch-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbruch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbruch}"
SRC_URI[x86_64_v2_kbruch.sha256sum] = "81496fb9c47e6a1f13ab9cdce9f9bfe2d88e3bde6987f9e7067837b37bc4253d"

URI_aarch64_kbruch = "${EPEL_MIRROR}/aarch64/Packages/k/kbruch-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kbruch;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbruch}"
SRC_URI[aarch64_kbruch.sha256sum] = "8c08db901c25b906d9fc067261b16c060b08cf20fb11b496a16d27761cccec96"

RDEPENDS:kbruch = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
