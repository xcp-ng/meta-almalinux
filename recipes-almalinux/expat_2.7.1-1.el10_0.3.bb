# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "expat"
PV = "2.7.1"
PR = "1.el10_0.3"
PACKAGES = " \
 expat \
 expat-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/expat-2.7.1-1.el10_0.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a48902b84f12074b32490a1bf641c4fb9619d01a6a03f1d5ebc479af0eb3b7e1"

URI_x86_64_v2_expat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/expat-2.7.1-1.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_expat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_expat}"
SRC_URI[x86_64_v2_expat.sha256sum] = "c2968d798f9c2d2ed4b6c77c1e97a7901087e82808d614e76ed0a419219cb5cb"

URI_x86_64_v2_expat-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/expat-devel-2.7.1-1.el10_0.3.x86_64_v2.rpm;name=x86_64_v2_expat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_expat-devel}"
SRC_URI[x86_64_v2_expat-devel.sha256sum] = "5ec1b1938dfb0522705195224b40ea998ef1d2cc8e4efe74f7c714c53242ac89"

URI_aarch64_expat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/expat-2.7.1-1.el10_0.3.aarch64.rpm;name=aarch64_expat;unpack=0"
SRC_URI:append = " ${URI_aarch64_expat}"
SRC_URI[aarch64_expat.sha256sum] = "4f561eafc4ae757c0b453e3e000c7f97f9184559fd0d5414375a9899ba296d45"

URI_aarch64_expat-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/expat-devel-2.7.1-1.el10_0.3.aarch64.rpm;name=aarch64_expat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_expat-devel}"
SRC_URI[aarch64_expat-devel.sha256sum] = "3c5c4fe728fb4bc10f2d7f1acd322c5230943962f90a11171620fcf32e036f24"

RDEPENDS:expat = " \
 glibc \
 "
RDEPENDS:expat-devel = " \
 expat \
 pkgconf-pkg-config \
 "
