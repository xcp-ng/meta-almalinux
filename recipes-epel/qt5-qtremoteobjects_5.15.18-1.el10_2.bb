# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtremoteobjects"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtremoteobjects \
 qt5-qtremoteobjects-devel \
 qt5-qtremoteobjects-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtremoteobjects-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d11ae57337d91cd5b5eed22c1ee075a39db2ef6d155f469e00dccb8b39b1d6a9"

URI_x86_64_v2_qt5-qtremoteobjects = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtremoteobjects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects.sha256sum] = "fcb7728a6a1df141d5172b4fdb7f4995f0dbe7ce50f9da37e34fcb343c19173b"

URI_x86_64_v2_qt5-qtremoteobjects-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtremoteobjects-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects-devel}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects-devel.sha256sum] = "fcef874d64eac39ff82d4e3f0a0ae2317edc8a75a9c1e8506fbc1947c1ca28aa"

URI_x86_64_v2_qt5-qtremoteobjects-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtremoteobjects-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects-examples}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects-examples.sha256sum] = "aea7b6351f2067609e1a4d02cd25350e2864d3abd4d30f742d10ec37d6f80fdb"

URI_aarch64_qt5-qtremoteobjects = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtremoteobjects;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects}"
SRC_URI[aarch64_qt5-qtremoteobjects.sha256sum] = "51be2bd4dc5e05ed23f8ee7587187edcc292118aa75db152b4a75d9c4cbc2698"

URI_aarch64_qt5-qtremoteobjects-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtremoteobjects-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects-devel}"
SRC_URI[aarch64_qt5-qtremoteobjects-devel.sha256sum] = "246fc9c3bdeb696ec462c646812db76ae51289a424858e7d55b64a1e4b36375a"

URI_aarch64_qt5-qtremoteobjects-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtremoteobjects-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects-examples}"
SRC_URI[aarch64_qt5-qtremoteobjects-examples.sha256sum] = "0feb89b60b689d2382d0f55d7cf2667fdf3c692914582402292f3df9ce7b607b"

RDEPENDS:qt5-qtremoteobjects = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtremoteobjects-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtremoteobjects \
 "
RDEPENDS:qt5-qtremoteobjects-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtremoteobjects \
 "
