# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cairo"
PV = "1.18.2"
PR = "2.el10_2.1"
PACKAGES = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 cairo-gobject-devel \
 cairo-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cairo-1.18.2-2.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "96f870f5f30b33e9deb21dbf0f1e9a53d9c8474184b9c2f46cac634320127340"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-1.18.2-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_cairo;unpack=0"
SRC_URI[x86_64_v2_cairo.sha256sum] = "f3d78f61f4ab5c187c0ea956cde868ffe776b9d9b5db10a45a26f1780a30bf06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-devel-1.18.2-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_cairo-devel;unpack=0"
SRC_URI[x86_64_v2_cairo-devel.sha256sum] = "4bb8588e5594af0ba74e022b4117b99be4f1262e74d4ebfe0014df8a5f019319"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-gobject-1.18.2-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_cairo-gobject;unpack=0"
SRC_URI[x86_64_v2_cairo-gobject.sha256sum] = "5333431d1585bcd624c140e6379cff421e0f81cadb7f3f08f880d6514af22b04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-gobject-devel-1.18.2-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_cairo-gobject-devel;unpack=0"
SRC_URI[x86_64_v2_cairo-gobject-devel.sha256sum] = "3919e8cab04221f71756d2f59ef0e46b8531c3fbf88d864ca8cea78b1ba113fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cairo-tools-1.18.2-2.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_cairo-tools;unpack=0"
SRC_URI[x86_64_v2_cairo-tools.sha256sum] = "b9d1cde5775d686fa5d641b2d5b907cc30e8bb9489c209fe47db3209f78af8f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-1.18.2-2.el10_2.1.aarch64.rpm;name=aarch64_cairo;unpack=0"
SRC_URI[aarch64_cairo.sha256sum] = "62c2f1f25e0d90cc6aa75a52d1b43a835cf2b974103a176a8b752baccfa344a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-devel-1.18.2-2.el10_2.1.aarch64.rpm;name=aarch64_cairo-devel;unpack=0"
SRC_URI[aarch64_cairo-devel.sha256sum] = "2ccd2598c1a44d0d0a50280555f01994ba2fbb5831b463977c429e6535ad1fb0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-gobject-1.18.2-2.el10_2.1.aarch64.rpm;name=aarch64_cairo-gobject;unpack=0"
SRC_URI[aarch64_cairo-gobject.sha256sum] = "a0e0a9cddd9a81c6adcc04418ca9a3cba218501b79f1f34fa5189ee69ef867c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-gobject-devel-1.18.2-2.el10_2.1.aarch64.rpm;name=aarch64_cairo-gobject-devel;unpack=0"
SRC_URI[aarch64_cairo-gobject-devel.sha256sum] = "fffe5dfbea5a05ee5bd118a8e5ada672d2e73aa288b4930bbc59ebbd1eb2d315"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cairo-tools-1.18.2-2.el10_2.1.aarch64.rpm;name=aarch64_cairo-tools;unpack=0"
SRC_URI[aarch64_cairo-tools.sha256sum] = "52b74a75499e0bfb0f6086382d77ddf47c645eacba0b1afb6ae0d318b869dc78"

RDEPENDS:cairo = " \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXext \
 libXrender \
 libpng \
 libxcb \
 pixman \
 zlib-ng-compat \
 "
RDEPENDS:cairo-devel = " \
 cairo \
 cairo-devel \
 fontconfig-devel \
 freetype-devel \
 libX11-devel \
 libXext-devel \
 libXrender-devel \
 libpng-devel \
 libxcb-devel \
 pixman-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:cairo-gobject = " \
 cairo \
 glib2 \
 glibc \
 "
RDEPENDS:cairo-gobject-devel = " \
 cairo-devel \
 cairo-gobject \
 fontconfig-devel \
 freetype-devel \
 glib2-devel \
 libX11-devel \
 libXext-devel \
 libXrender-devel \
 libpng-devel \
 libxcb-devel \
 pixman-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:cairo-tools = " \
 bash \
 cairo \
 glibc \
 zlib-ng-compat \
 "
