# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytesize"
PV = "2.3.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-bytesize+arbitrary-devel \
 rust-bytesize+default-devel \
 rust-bytesize+serde-devel \
 rust-bytesize+std-devel \
 rust-bytesize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytesize-2.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2631ef49d9e9bce659c63250f06671937c8a2daad52cf6842754b4b8c2b1a856"

URI_x86_64_v2_rust-bytesize+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+arbitrary-devel-2.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-bytesize+arbitrary-devel.sha256sum] = "b239f5ccfa541e60ea49933ea0cecd13610b3820b2011152b6e25e761c636cf1"

URI_x86_64_v2_rust-bytesize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+default-devel-2.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+default-devel}"
SRC_URI[x86_64_v2_rust-bytesize+default-devel.sha256sum] = "09321c7d8a07a38b100ba2a44c048e9039807397d33f57beed70471e8a96af4a"

URI_x86_64_v2_rust-bytesize+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+serde-devel-2.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+serde-devel}"
SRC_URI[x86_64_v2_rust-bytesize+serde-devel.sha256sum] = "9eb68961750f51786edfb3d3e6d301e6c1d59dae66e1367efcbc8b4ef93c5b3f"

URI_x86_64_v2_rust-bytesize+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize+std-devel-2.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize+std-devel}"
SRC_URI[x86_64_v2_rust-bytesize+std-devel.sha256sum] = "59233af2bcfbcfb89ebfa678cd73c550fac468b7764cf2f8428f0ac3aa6da4f8"

URI_x86_64_v2_rust-bytesize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize-devel-2.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize-devel}"
SRC_URI[x86_64_v2_rust-bytesize-devel.sha256sum] = "962c706d38774c1c8096b1d88dfd62a1d8e5bf029bf6e782cc08fb879c083659"

URI_aarch64_rust-bytesize+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+arbitrary-devel-2.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytesize+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+arbitrary-devel}"
SRC_URI[aarch64_rust-bytesize+arbitrary-devel.sha256sum] = "df03158ae79e0add410ebea0913d8520960aa7f869d88c92eb95f229ebfa1850"

URI_aarch64_rust-bytesize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+default-devel-2.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytesize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+default-devel}"
SRC_URI[aarch64_rust-bytesize+default-devel.sha256sum] = "f75027e7feaf1fe14e869c13157b9676452692c12944e622174dab43044c7595"

URI_aarch64_rust-bytesize+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+serde-devel-2.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytesize+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+serde-devel}"
SRC_URI[aarch64_rust-bytesize+serde-devel.sha256sum] = "a2f14cb6e702eb7b882663679619560a31aad57c71b8affed72b122fd28cd5b3"

URI_aarch64_rust-bytesize+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize+std-devel-2.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytesize+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize+std-devel}"
SRC_URI[aarch64_rust-bytesize+std-devel.sha256sum] = "04d4ac9cbed543886b5ecac31b1aa38260a8baf974a378781eb3d0c561301dd0"

URI_aarch64_rust-bytesize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize-devel-2.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize-devel}"
SRC_URI[aarch64_rust-bytesize-devel.sha256sum] = "210d4247110df043f0e86d14819d7ffb46a1864e76e8701b04094556cc1c2d65"

RDEPENDS:rust-bytesize+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize+default-devel = " \
 cargo \
 rust-bytesize+std-devel \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize+serde-devel = " \
 cargo \
 rust-bytesize-devel \
 rust-serde_core+default-devel \
 "
RDEPENDS:rust-bytesize+std-devel = " \
 cargo \
 rust-bytesize-devel \
 "
RDEPENDS:rust-bytesize-devel = " \
 cargo \
 rust \
 "
