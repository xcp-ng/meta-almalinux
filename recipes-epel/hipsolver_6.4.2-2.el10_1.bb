# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipsolver"
PV = "6.4.2"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 hipsolver \
 hipsolver-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipsolver-6.4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "559cf443bd8e915f6cb9eb2890fe7f3982c589c9d8fb32e31c65076e0e4cf7d1"

URI_x86_64_v2_hipsolver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsolver-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsolver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsolver}"
SRC_URI[x86_64_v2_hipsolver.sha256sum] = "ab2f4b4ae1eca776e7d515ecd2813acae5f89d3a22f232bce4c261732c50b7fa"

URI_x86_64_v2_hipsolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsolver-devel-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsolver-devel}"
SRC_URI[x86_64_v2_hipsolver-devel.sha256sum] = "097c6d04217a7d62e8635aad05ef55c7157f5c9ec61e0cf064cd52de129da92c"

RDEPENDS:hipsolver = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocm-hip \
 rocsolver \
 "
RDEPENDS:hipsolver-devel = " \
 cmake-filesystem \
 hipsolver \
 "
