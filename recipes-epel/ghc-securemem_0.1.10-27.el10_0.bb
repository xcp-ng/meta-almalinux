# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-securemem"
PV = "0.1.10"
PR = "27.el10_0"
PACKAGES = " \
 ghc-securemem \
 ghc-securemem-devel \
 ghc-securemem-doc \
 ghc-securemem-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-securemem-0.1.10-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "252d01e27e580187deff1b8159d5dfa6a9e44227a9f407baee8a542b1edb77d6"

URI_x86_64_v2_ghc-securemem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-securemem-0.1.10-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-securemem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-securemem}"
SRC_URI[x86_64_v2_ghc-securemem.sha256sum] = "275853e35ce8ebf48b5f132109b25414bc583609e7f62b29cebc857073926873"

URI_x86_64_v2_ghc-securemem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-securemem-devel-0.1.10-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-securemem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-securemem-devel}"
SRC_URI[x86_64_v2_ghc-securemem-devel.sha256sum] = "28e88492a979dcc3624ad46e74e7db67d06407704d284bb97e0364c6c24104b1"

URI_x86_64_v2_ghc-securemem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-securemem-doc-0.1.10-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-securemem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-securemem-doc}"
SRC_URI[x86_64_v2_ghc-securemem-doc.sha256sum] = "995cdd0633fc879f73f43731db68f7fdc52cd5fdc3ddb19a4395f5182e113e4e"

URI_x86_64_v2_ghc-securemem-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-securemem-prof-0.1.10-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-securemem-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-securemem-prof}"
SRC_URI[x86_64_v2_ghc-securemem-prof.sha256sum] = "602c9cb2b5006c85da70cf436bea249fbd97b9749ff4b32927d65b017808f54b"

URI_aarch64_ghc-securemem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-securemem-0.1.10-27.el10_0.aarch64.rpm;name=aarch64_ghc-securemem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-securemem}"
SRC_URI[aarch64_ghc-securemem.sha256sum] = "758b6660d57d4e1f8df78968a7d59b885f043a43a37438a75733a32bdf6ffa2e"

URI_aarch64_ghc-securemem-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-securemem-devel-0.1.10-27.el10_0.aarch64.rpm;name=aarch64_ghc-securemem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-securemem-devel}"
SRC_URI[aarch64_ghc-securemem-devel.sha256sum] = "9ff469a75e39f0f073fc1360390dcd6bf4cd8cded53a4057ea084935f5396864"

URI_aarch64_ghc-securemem-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-securemem-doc-0.1.10-27.el10_0.noarch.rpm;name=aarch64_ghc-securemem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-securemem-doc}"
SRC_URI[aarch64_ghc-securemem-doc.sha256sum] = "27f3b091ae1d6547f86be25d9e265858081279881f098daff839b60e7165b762"

URI_aarch64_ghc-securemem-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-securemem-prof-0.1.10-27.el10_0.aarch64.rpm;name=aarch64_ghc-securemem-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-securemem-prof}"
SRC_URI[aarch64_ghc-securemem-prof.sha256sum] = "c4111642f3c8bcca7146735ff0023a7e4d9406589970cacd21eba203056b6563"

RDEPENDS:ghc-securemem = " \
 ghc-array \
 ghc-base \
 ghc-basement \
 ghc-byteable \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-memory \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-securemem-devel = " \
 ghc-base-devel \
 ghc-byteable-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-memory-devel \
 ghc-securemem \
 "
RDEPENDS:ghc-securemem-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-securemem-prof = " \
 ghc-base-prof \
 ghc-byteable-prof \
 ghc-bytestring-prof \
 ghc-memory-prof \
 ghc-securemem-devel \
 "
