# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XString"
PV = "0.005"
PR = "16.el10"
PACKAGES = " \
 perl-XString \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-XString-0.005-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd16788399d5af43021405a18e0248b8c202146acdff0fb7fde72d85472e8375"

URI_x86_64_v2_perl-XString = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-XString-0.005-16.el10.x86_64_v2.rpm;name=x86_64_v2_perl-XString;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XString}"
SRC_URI[x86_64_v2_perl-XString.sha256sum] = "fa61a09b038f78ee9448817ae3d52b94f61a9fdb107e7eda73c3b90ab9a7f4b8"

URI_aarch64_perl-XString = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-XString-0.005-16.el10.aarch64.rpm;name=aarch64_perl-XString;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XString}"
SRC_URI[aarch64_perl-XString.sha256sum] = "b9723f712e4544efa1334dad903b9c786b1453e042bbbaa84c535fa8b0699e46"

RDEPENDS:perl-XString = " \
 glibc \
 perl-libs \
 "
