# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities-stats"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-activities-stats \
 plasma-activities-stats-devel \
 plasma-activities-stats-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-stats-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a7939695fcd25be568f18b808b5c671bb3ac40a89bae1670340dab4e46f8daa8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats;unpack=0"
SRC_URI[x86_64_v2_plasma-activities-stats.sha256sum] = "dda7c92ab6dd112d0ccefce4edf12195519a9788c9db095b9030a51f78ec0340"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats-devel;unpack=0"
SRC_URI[x86_64_v2_plasma-activities-stats-devel.sha256sum] = "75fa3a61ba8e7c0359008a8d5ee6cf40b0b40b4b837b5a92e7530f471fe9e335"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-stats-doc;unpack=0"
SRC_URI[x86_64_v2_plasma-activities-stats-doc.sha256sum] = "6140c0e6b37141f0d65b2fc521dd27953a909221d2d588239ef970213c836a65"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-activities-stats;unpack=0"
SRC_URI[aarch64_plasma-activities-stats.sha256sum] = "10cf6f47a715c4fb33b97c744a2dae4c1f8117738637153257682a00b6d6eee9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-activities-stats-devel;unpack=0"
SRC_URI[aarch64_plasma-activities-stats-devel.sha256sum] = "4d74f02b04b06cb389d98355096b895c63f9b0dfd487aa222f17a85a2e6d3bc5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma-activities-stats-doc;unpack=0"
SRC_URI[aarch64_plasma-activities-stats-doc.sha256sum] = "44fb4aabca78ea086e62b1ae2329552641c4807bfd5548ea528ebd47745d4bd9"

RDEPENDS:plasma-activities-stats = " \
 glibc \
 kf6-kconfig \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 "
RDEPENDS:plasma-activities-stats-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities-stats \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-stats-doc = " \
 "
