# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "procps-ng"
PV = "4.0.4"
PR = "8.el10"
PACKAGES = " \
 procps-ng \
 procps-ng-devel \
 procps-ng-i18n \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/procps-ng-4.0.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c56b8a26d7039c7e1e9a8155c81aea124558ae794ee812fdae35ecddcc082701"

URI_x86_64_v2_procps-ng = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/procps-ng-4.0.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_procps-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procps-ng}"
SRC_URI[x86_64_v2_procps-ng.sha256sum] = "0dac9ff6bdad84b31777f7056c37eb3ecf7b5d42033be677f555dc2a54dcad43"

URI_x86_64_v2_procps-ng-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/procps-ng-devel-4.0.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_procps-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procps-ng-devel}"
SRC_URI[x86_64_v2_procps-ng-devel.sha256sum] = "99de47295d6bbb41843ba32a07b76a9ea20c150ad2026fdcb46a3d4ae24175df"

URI_x86_64_v2_procps-ng-i18n = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/procps-ng-i18n-4.0.4-8.el10.noarch.rpm;name=x86_64_v2_procps-ng-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_procps-ng-i18n}"
SRC_URI[x86_64_v2_procps-ng-i18n.sha256sum] = "6b46100b70fb65f3c7ed20ca318fc4bea235f3fa226773b37290f450a0dafbee"

URI_aarch64_procps-ng = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/procps-ng-4.0.4-8.el10.aarch64.rpm;name=aarch64_procps-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_procps-ng}"
SRC_URI[aarch64_procps-ng.sha256sum] = "e0c062eb5c9311c4e7a55a60dfed90b2f67377b9c68356fe26eb6653e5b60d70"

URI_aarch64_procps-ng-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/procps-ng-devel-4.0.4-8.el10.aarch64.rpm;name=aarch64_procps-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_procps-ng-devel}"
SRC_URI[aarch64_procps-ng-devel.sha256sum] = "cfb712899f932e7a2d45d2bf83d83e780f742645eeb7af306c7fa05d0360b898"

URI_aarch64_procps-ng-i18n = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/procps-ng-i18n-4.0.4-8.el10.noarch.rpm;name=aarch64_procps-ng-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_procps-ng-i18n}"
SRC_URI[aarch64_procps-ng-i18n.sha256sum] = "6b46100b70fb65f3c7ed20ca318fc4bea235f3fa226773b37290f450a0dafbee"

RDEPENDS:procps-ng = " \
 glibc \
 ncurses-libs \
 systemd-libs \
 "
RDEPENDS:procps-ng-devel = " \
 pkgconf-pkg-config \
 procps-ng \
 "
RDEPENDS:procps-ng-i18n = " \
 procps-ng \
 "
