# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreenlocker"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kscreenlocker \
 kscreenlocker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kscreenlocker-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebe0b4b69d9de01b575390d3395524db1ccdaa3e3742304a7b22877a42b3cd5a"

URI_x86_64_v2_kscreenlocker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreenlocker}"
SRC_URI[x86_64_v2_kscreenlocker.sha256sum] = "f4812055e4022666a933803aded8986e8d98bdb5eb1d9c0b86592bab20ea4f22"

URI_x86_64_v2_kscreenlocker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreenlocker-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreenlocker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreenlocker-devel}"
SRC_URI[x86_64_v2_kscreenlocker-devel.sha256sum] = "3107e27dd0e7782c6374374542daa3a7f970476fcb24b6c89570153590bbe577"

URI_aarch64_kscreenlocker = "${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kscreenlocker;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreenlocker}"
SRC_URI[aarch64_kscreenlocker.sha256sum] = "b87123fc0ed8f76efa31b86b93eba25d6d375a586c9cd6baa44010c4acae1265"

URI_aarch64_kscreenlocker-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kscreenlocker-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kscreenlocker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreenlocker-devel}"
SRC_URI[aarch64_kscreenlocker-devel.sha256sum] = "93788a3cc4347f4cb3a2c0f7bed1c094d5135b171edcd1f2180a709c91eb89d6"

RDEPENDS:kscreenlocker = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxcb \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xcb-util-keysyms \
 "
RDEPENDS:kscreenlocker-devel = " \
 cmake-filesystem \
 kscreenlocker \
 "
