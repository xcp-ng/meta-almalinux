# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rstest0.23"
PV = "0.23.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rstest0.23+async-timeout-devel \
 rust-rstest0.23+crate-name-devel \
 rust-rstest0.23+default-devel \
 rust-rstest0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rstest0.23-0.23.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2c71755a7eaf4df8679f7cd1ca1af1f38daed2ea6f715ff958a45da02bc18c7"

URI_x86_64_v2_rust-rstest0.23+async-timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest0.23+async-timeout-devel-0.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest0.23+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest0.23+async-timeout-devel}"
SRC_URI[x86_64_v2_rust-rstest0.23+async-timeout-devel.sha256sum] = "7b36288d403d67cfd320b24c048ddedc3270323ba6150187f8a6ac458895113b"

URI_x86_64_v2_rust-rstest0.23+crate-name-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest0.23+crate-name-devel-0.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest0.23+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest0.23+crate-name-devel}"
SRC_URI[x86_64_v2_rust-rstest0.23+crate-name-devel.sha256sum] = "15135cd3ee8974f9c6eda509a22f1adf43d8160ae08a012a4f654d0a18357578"

URI_x86_64_v2_rust-rstest0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest0.23+default-devel-0.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest0.23+default-devel}"
SRC_URI[x86_64_v2_rust-rstest0.23+default-devel.sha256sum] = "dcef8980966dd9aa146cdbe0fbe88ce3f67214811902ac7a9a8a10bf431c92fb"

URI_x86_64_v2_rust-rstest0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest0.23-devel-0.23.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest0.23-devel}"
SRC_URI[x86_64_v2_rust-rstest0.23-devel.sha256sum] = "fd31a8a1d69e375d653d30703693395c2a0c7d9652f5316d7844ed94fdb6c305"

URI_aarch64_rust-rstest0.23+async-timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest0.23+async-timeout-devel-0.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-rstest0.23+async-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest0.23+async-timeout-devel}"
SRC_URI[aarch64_rust-rstest0.23+async-timeout-devel.sha256sum] = "a2614454b6fcd9769ae3b4e29da57d85592e46ecdb523d7e8184cad5caa7e3b5"

URI_aarch64_rust-rstest0.23+crate-name-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest0.23+crate-name-devel-0.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-rstest0.23+crate-name-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest0.23+crate-name-devel}"
SRC_URI[aarch64_rust-rstest0.23+crate-name-devel.sha256sum] = "17878979cd1b029a7e96c0e5a274ccf4227e5e137443cb2acdd64ad66c44e024"

URI_aarch64_rust-rstest0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest0.23+default-devel-0.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-rstest0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest0.23+default-devel}"
SRC_URI[aarch64_rust-rstest0.23+default-devel.sha256sum] = "5d07d25abd01995e2c050328e04d3f9032c42d36b1751ee304d3492dc2638175"

URI_aarch64_rust-rstest0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest0.23-devel-0.23.0-1.el10_1.noarch.rpm;name=aarch64_rust-rstest0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest0.23-devel}"
SRC_URI[aarch64_rust-rstest0.23-devel.sha256sum] = "84c6364c79ff18f074fcf2f36297794987e07f6b60a93ff29162fc297fbfcca8"

RDEPENDS:rust-rstest0.23+async-timeout-devel = " \
 cargo \
 rust-futures+default-devel \
 rust-futures-timer+default-devel \
 rust-rstest0.23-devel \
 rust-rstest_macros0.23+async-timeout-devel \
 "
RDEPENDS:rust-rstest0.23+crate-name-devel = " \
 cargo \
 rust-rstest0.23-devel \
 rust-rstest_macros0.23+crate-name-devel \
 "
RDEPENDS:rust-rstest0.23+default-devel = " \
 cargo \
 rust-rstest0.23+async-timeout-devel \
 rust-rstest0.23+crate-name-devel \
 rust-rstest0.23-devel \
 "
RDEPENDS:rust-rstest0.23-devel = " \
 cargo \
 rust \
 rust-rstest_macros0.23-devel \
 rust-rustc_version+default-devel \
 "
