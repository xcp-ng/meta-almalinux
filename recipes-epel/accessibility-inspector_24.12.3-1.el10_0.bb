# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accessibility-inspector"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 accessibility-inspector \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/accessibility-inspector-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09e0580b2d5fedc27c219834c91409a20c84e644478e37d8d36c986c5b8bfbe7"

URI_x86_64_v2_accessibility-inspector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accessibility-inspector-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_accessibility-inspector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_accessibility-inspector}"
SRC_URI[x86_64_v2_accessibility-inspector.sha256sum] = "a79a267161411e6fc5d9a4689a355e43875784777127e77c3f901cd03a95659c"

URI_aarch64_accessibility-inspector = "${EPEL_MIRROR}/aarch64/Packages/a/accessibility-inspector-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_accessibility-inspector;unpack=0"
SRC_URI:append = " ${URI_aarch64_accessibility-inspector}"
SRC_URI[aarch64_accessibility-inspector.sha256sum] = "d2158c321679e744b53407f34e6c7f47ba1499cf39e67c7ff4a80d7ca1a1570a"

RDEPENDS:accessibility-inspector = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
