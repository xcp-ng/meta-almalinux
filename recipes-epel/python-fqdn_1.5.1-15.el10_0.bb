# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fqdn"
PV = "1.5.1"
PR = "15.el10_0"
PACKAGES = " \
 python3-fqdn \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fqdn-1.5.1-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25ab081d0bc1f311fe1b6e99337f654786b55a9a266a45a5ead60406428cb131"

URI_x86_64_v2_python3-fqdn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fqdn-1.5.1-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fqdn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fqdn}"
SRC_URI[x86_64_v2_python3-fqdn.sha256sum] = "ad3738940604b22ecb648d072782adb2908d025096a369c91dd43947bd325707"

URI_aarch64_python3-fqdn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fqdn-1.5.1-15.el10_0.noarch.rpm;name=aarch64_python3-fqdn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fqdn}"
SRC_URI[aarch64_python3-fqdn.sha256sum] = "dde45197a274e7d2ad7c98c2a247be48db7c5339aa2753bafa7c6e74ae03bde7"

RDEPENDS:python3-fqdn = " \
 python3 \
 "
