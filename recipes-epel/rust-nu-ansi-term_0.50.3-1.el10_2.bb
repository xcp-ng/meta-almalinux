# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nu-ansi-term"
PV = "0.50.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-nu-ansi-term+default-devel \
 rust-nu-ansi-term+derive_serde_style-devel \
 rust-nu-ansi-term+gnu_legacy-devel \
 rust-nu-ansi-term+serde-devel \
 rust-nu-ansi-term+std-devel \
 rust-nu-ansi-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nu-ansi-term-0.50.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a34f39b6a0eb9c85593c6fa921fb9019e99e351546ba31298ec0a69884926416"

URI_x86_64_v2_rust-nu-ansi-term+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+default-devel-0.50.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term+default-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term+default-devel.sha256sum] = "859c654fdabcdca1696a03c67cad255a1460da20f2e7a203be16e2461faf80d0"

URI_x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+derive_serde_style-devel-0.50.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel.sha256sum] = "43406f486319a6be68a7289473528b19b25a292e698896550c52e1f113a51477"

URI_x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+gnu_legacy-devel-0.50.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel.sha256sum] = "b7ea202f97ba46de3d7ab5da7ff886f51697d854d76ce24e16ca0f9041ef1e50"

URI_x86_64_v2_rust-nu-ansi-term+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+serde-devel-0.50.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term+serde-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term+serde-devel.sha256sum] = "f0ac1e26334b0cec8a65c0cecede23132c6b04e1e858a4416ececf1a261774ec"

URI_x86_64_v2_rust-nu-ansi-term+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+std-devel-0.50.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term+std-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term+std-devel.sha256sum] = "36cef10d044e9fd69f1bcb4c242325c4de3ac1521c082c50b5232a50e1970387"

URI_x86_64_v2_rust-nu-ansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term-devel-0.50.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nu-ansi-term-devel}"
SRC_URI[x86_64_v2_rust-nu-ansi-term-devel.sha256sum] = "5d150e9dc8226c0f25bc0fc08d9a687c9fd2a9681aab4d7c9deba02d8c4be1fd"

URI_aarch64_rust-nu-ansi-term+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+default-devel-0.50.3-1.el10_2.noarch.rpm;name=aarch64_rust-nu-ansi-term+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term+default-devel}"
SRC_URI[aarch64_rust-nu-ansi-term+default-devel.sha256sum] = "ae7e8ce9fe33b8139c65ad27c61d10070bdec9360d1969a1c8a69aa4e76193d7"

URI_aarch64_rust-nu-ansi-term+derive_serde_style-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+derive_serde_style-devel-0.50.3-1.el10_2.noarch.rpm;name=aarch64_rust-nu-ansi-term+derive_serde_style-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term+derive_serde_style-devel}"
SRC_URI[aarch64_rust-nu-ansi-term+derive_serde_style-devel.sha256sum] = "8dd023ac7032fb24c1d8b96c1a0a354e32048db868ec6d8e1baa1dbd90651cec"

URI_aarch64_rust-nu-ansi-term+gnu_legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+gnu_legacy-devel-0.50.3-1.el10_2.noarch.rpm;name=aarch64_rust-nu-ansi-term+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term+gnu_legacy-devel}"
SRC_URI[aarch64_rust-nu-ansi-term+gnu_legacy-devel.sha256sum] = "946b4db799d44909043bc1636299efbca8f15162f895412df831ed412344a1e7"

URI_aarch64_rust-nu-ansi-term+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+serde-devel-0.50.3-1.el10_2.noarch.rpm;name=aarch64_rust-nu-ansi-term+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term+serde-devel}"
SRC_URI[aarch64_rust-nu-ansi-term+serde-devel.sha256sum] = "a0ec81fabf436ec9e1b5fd2a856d0eb498e817bd0789976d7924e623bc347967"

URI_aarch64_rust-nu-ansi-term+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+std-devel-0.50.3-1.el10_2.noarch.rpm;name=aarch64_rust-nu-ansi-term+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term+std-devel}"
SRC_URI[aarch64_rust-nu-ansi-term+std-devel.sha256sum] = "9fc2c82d49f60b8ab71c95881e99930ee6f8e952773b99f0bbb5309d903ef4f1"

URI_aarch64_rust-nu-ansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term-devel-0.50.3-1.el10_2.noarch.rpm;name=aarch64_rust-nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nu-ansi-term-devel}"
SRC_URI[aarch64_rust-nu-ansi-term-devel.sha256sum] = "3f90aefd4df47c7a500b8451d8f817ca33346ab2ba7f7fbfa2a62b947f7b0996"

RDEPENDS:rust-nu-ansi-term+default-devel = " \
 cargo \
 rust-nu-ansi-term+std-devel \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term+derive_serde_style-devel = " \
 cargo \
 rust-nu-ansi-term+serde-devel \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term+gnu_legacy-devel = " \
 cargo \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term+serde-devel = " \
 cargo \
 rust-nu-ansi-term-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-nu-ansi-term+std-devel = " \
 cargo \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term-devel = " \
 cargo \
 rust \
 "
