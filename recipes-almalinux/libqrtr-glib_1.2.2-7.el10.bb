# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libqrtr-glib"
PV = "1.2.2"
PR = "7.el10"
PACKAGES = " \
 libqrtr-glib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libqrtr-glib-1.2.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "719ffcf8a514ceda2b5c13b71790dfcaffde62793ec21d6988162b9051542e7f"

URI_x86_64_v2_libqrtr-glib = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libqrtr-glib-1.2.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_libqrtr-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libqrtr-glib}"
SRC_URI[x86_64_v2_libqrtr-glib.sha256sum] = "a1d4739d2bf41a3be62a0266197db9ce35e390365eca95379e7a259b6822be2c"

URI_aarch64_libqrtr-glib = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libqrtr-glib-1.2.2-7.el10.aarch64.rpm;name=aarch64_libqrtr-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_libqrtr-glib}"
SRC_URI[aarch64_libqrtr-glib.sha256sum] = "a965d8318bf8c8302321087777043214c5f99eceea278b03cfca7da5fad36869"

RDEPENDS:libqrtr-glib = " \
 glib2 \
 glibc \
 libgcc \
 "
