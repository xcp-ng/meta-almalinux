# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-npm-package-json"
PV = "0.1.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-npm-package-json+default-devel \
 rust-npm-package-json-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-npm-package-json-0.1.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20475c9a37865fde0106b494b1eafc14c75cebd90845750538eb4e34f2e02cea"

URI_x86_64_v2_rust-npm-package-json+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-npm-package-json+default-devel-0.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-npm-package-json+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-npm-package-json+default-devel}"
SRC_URI[x86_64_v2_rust-npm-package-json+default-devel.sha256sum] = "e9d27b6432ddbb3ae8f646f3a9968b07d255f944e329a364ddd15e4602f4cafc"

URI_x86_64_v2_rust-npm-package-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-npm-package-json-devel-0.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-npm-package-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-npm-package-json-devel}"
SRC_URI[x86_64_v2_rust-npm-package-json-devel.sha256sum] = "9a3a71987a5e15626718012b2e282bb95c4111f713df74a0eb5009d852422338"

URI_aarch64_rust-npm-package-json+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-npm-package-json+default-devel-0.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-npm-package-json+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-npm-package-json+default-devel}"
SRC_URI[aarch64_rust-npm-package-json+default-devel.sha256sum] = "3f02088fab5ff29dfe384328303801f6d4c92506dae660fc3347e962d1e7420d"

URI_aarch64_rust-npm-package-json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-npm-package-json-devel-0.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-npm-package-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-npm-package-json-devel}"
SRC_URI[aarch64_rust-npm-package-json-devel.sha256sum] = "31fc02c48faae1da5e44f0964e9be3f30a88b0425833d30506a1cec4024cdb73"

RDEPENDS:rust-npm-package-json+default-devel = " \
 cargo \
 rust-npm-package-json-devel \
 "
RDEPENDS:rust-npm-package-json-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror1+default-devel \
 "
