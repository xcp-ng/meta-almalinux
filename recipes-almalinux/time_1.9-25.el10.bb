# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "time"
PV = "1.9"
PR = "25.el10"
PACKAGES = " \
 time \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/time-1.9-25.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eb7dffd230a01ab86765ce7d23847855e26634c75a2fe1fd373599e701c08aef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/time-1.9-25.el10.x86_64_v2.rpm;name=x86_64_v2_time;unpack=0"
SRC_URI[x86_64_v2_time.sha256sum] = "aaf7a2446716e11b0c5445bf9f03825bbd4f21ab1343c40ace49a7d71324bc47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/time-1.9-25.el10.aarch64.rpm;name=aarch64_time;unpack=0"
SRC_URI[aarch64_time.sha256sum] = "cda1822fd941494ca398cfd93a7c98edb0bd74d63d6f6ac91f2ae6f44b3f8f09"

RDEPENDS:time = " \
 glibc \
 "
