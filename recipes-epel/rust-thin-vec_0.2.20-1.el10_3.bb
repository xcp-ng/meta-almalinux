# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thin-vec"
PV = "0.2.20"
PR = "1.el10_3"
PACKAGES = " \
 rust-thin-vec+const_new-devel \
 rust-thin-vec+default-devel \
 rust-thin-vec+gecko-ffi-devel \
 rust-thin-vec+serde-devel \
 rust-thin-vec+std-devel \
 rust-thin-vec-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-thin-vec-0.2.20-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bf2f926e5f979227859cbb17a81a0afe1d79a066030ba91acc928456bba58b2f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+const_new-devel-0.2.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+const_new-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thin-vec+const_new-devel.sha256sum] = "cda9a16603145bd57c333df69af5bb5ebade99cdc7219140bec8a2e65af8a9c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+default-devel-0.2.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thin-vec+default-devel.sha256sum] = "3ce752c22730896c90cbc82ba31823bb08e26b59ca3d8a96cdae9da0707f5c70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+gecko-ffi-devel-0.2.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+gecko-ffi-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thin-vec+gecko-ffi-devel.sha256sum] = "4043ad2ed96dccfc4af2f6b46b4e16a08dafd94d09ec776145710d4b3d62cf40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+serde-devel-0.2.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thin-vec+serde-devel.sha256sum] = "9fb09a9cec943020f0fa7e846806c6c5a944ee581f5daea9a82857305c0ccfc0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec+std-devel-0.2.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thin-vec+std-devel.sha256sum] = "244836d0a8fc28fd385408f8b0c5519485b6342dc1ebc9488f734724f71e8a73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thin-vec-devel-0.2.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thin-vec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thin-vec-devel.sha256sum] = "21711e1591498858bff49fb5ba08fe686322e33a9b2c6710586bd6d6df42e390"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+const_new-devel-0.2.20-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+const_new-devel;unpack=0"
SRC_URI[aarch64_rust-thin-vec+const_new-devel.sha256sum] = "1b7866fd720b372a651ea957d740295711486a5fa8dcd7d02def14b47f272a8b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+default-devel-0.2.20-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+default-devel;unpack=0"
SRC_URI[aarch64_rust-thin-vec+default-devel.sha256sum] = "0bb0cd564595eb9038b123f72f493687539f40eae423564b1dbf2645d18e68ab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+gecko-ffi-devel-0.2.20-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+gecko-ffi-devel;unpack=0"
SRC_URI[aarch64_rust-thin-vec+gecko-ffi-devel.sha256sum] = "933fbd7af2d810c32b8cbd01e7781fd700dcc5b7286c86a8da38b59364f5aa7e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+serde-devel-0.2.20-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+serde-devel;unpack=0"
SRC_URI[aarch64_rust-thin-vec+serde-devel.sha256sum] = "26ea9e96c3e552d3f62751cbf1c0d89f5ee7e610b9e7612c23400aa0d3ecb708"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec+std-devel-0.2.20-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec+std-devel;unpack=0"
SRC_URI[aarch64_rust-thin-vec+std-devel.sha256sum] = "bc4eb6352d7197a16759b7e2a44f076e9f367a03ce6f8aa462f9e5df6a7628ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thin-vec-devel-0.2.20-1.el10_3.noarch.rpm;name=aarch64_rust-thin-vec-devel;unpack=0"
SRC_URI[aarch64_rust-thin-vec-devel.sha256sum] = "691cd0ef9382786e94c7a12142a9989e7628c14a1ab0a281fd50d23e83eb86fd"

RDEPENDS:rust-thin-vec+const_new-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+default-devel = " \
 cargo \
 rust-thin-vec+std-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+gecko-ffi-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec+std-devel = " \
 cargo \
 rust-thin-vec-devel \
 "
RDEPENDS:rust-thin-vec-devel = " \
 cargo \
 rust \
 "
