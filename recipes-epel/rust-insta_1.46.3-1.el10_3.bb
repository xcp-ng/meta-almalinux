# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-insta"
PV = "1.46.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-insta+_cargo_insta_internal-devel \
 rust-insta+clap-devel \
 rust-insta+colors-devel \
 rust-insta+console-devel \
 rust-insta+csv-devel \
 rust-insta+default-devel \
 rust-insta+filters-devel \
 rust-insta+glob-devel \
 rust-insta+globset-devel \
 rust-insta+json-devel \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+redactions-devel \
 rust-insta+regex-devel \
 rust-insta+ron-devel \
 rust-insta+serde-devel \
 rust-insta+toml-devel \
 rust-insta+walkdir-devel \
 rust-insta+yaml-devel \
 rust-insta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-insta-1.46.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c9f0f9af6a4a091f103ed70202ef57964774846361d7d355085df96063a1298"

URI_x86_64_v2_rust-insta+_cargo_insta_internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+_cargo_insta_internal-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+_cargo_insta_internal-devel}"
SRC_URI[x86_64_v2_rust-insta+_cargo_insta_internal-devel.sha256sum] = "8dacf3b4f2e7d065dfa6934919872b883adc7b3966e06b823de52c3a0ef33b20"

URI_x86_64_v2_rust-insta+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+clap-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+clap-devel}"
SRC_URI[x86_64_v2_rust-insta+clap-devel.sha256sum] = "001766b8e15b2d56e7d187efae5c83e6da04e123b4a6fc36059a028919da41fc"

URI_x86_64_v2_rust-insta+colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+colors-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+colors-devel}"
SRC_URI[x86_64_v2_rust-insta+colors-devel.sha256sum] = "577d4034da9c758fe955424cec68e95b7a2d895130eed27150a057468ddf0b32"

URI_x86_64_v2_rust-insta+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+console-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+console-devel}"
SRC_URI[x86_64_v2_rust-insta+console-devel.sha256sum] = "4352513ab3198d5473f3174e18cef3e055385db80b3f7750e3a943d79e8855bf"

URI_x86_64_v2_rust-insta+csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+csv-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+csv-devel}"
SRC_URI[x86_64_v2_rust-insta+csv-devel.sha256sum] = "48529946eeec7672b62be69be1073204a85ac89faee254640e340cd2c8ba679a"

URI_x86_64_v2_rust-insta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+default-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+default-devel}"
SRC_URI[x86_64_v2_rust-insta+default-devel.sha256sum] = "a4e443b2376c15720e1f988b94a8a5b5afd08eb1b8ac22ee6228da9b8c258252"

URI_x86_64_v2_rust-insta+filters-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+filters-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+filters-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+filters-devel}"
SRC_URI[x86_64_v2_rust-insta+filters-devel.sha256sum] = "c6afb8da50ec50eccd88efc8e29705408c68a307b38971aa95bb6e3979a1332a"

URI_x86_64_v2_rust-insta+glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+glob-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+glob-devel}"
SRC_URI[x86_64_v2_rust-insta+glob-devel.sha256sum] = "212601563357fe0fa264cadf296240e8e6a7c0670152d4b3d7a35f10d89f5e7a"

URI_x86_64_v2_rust-insta+globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+globset-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+globset-devel}"
SRC_URI[x86_64_v2_rust-insta+globset-devel.sha256sum] = "0a07cb5a6e9d5c03fef51eb012c4ee86c164530084c9c2a3014a65fe5b82a78f"

URI_x86_64_v2_rust-insta+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+json-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+json-devel}"
SRC_URI[x86_64_v2_rust-insta+json-devel.sha256sum] = "7c7e36665e5d44d7efa95a8364b97b456a411d11dee131b721c1cd3f06f8824c"

URI_x86_64_v2_rust-insta+pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+pest-devel}"
SRC_URI[x86_64_v2_rust-insta+pest-devel.sha256sum] = "c25f3a313fedd8d137f52d437d760763d2a58ea16be1d55906c4dc2db14ad26e"

URI_x86_64_v2_rust-insta+pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest_derive-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+pest_derive-devel}"
SRC_URI[x86_64_v2_rust-insta+pest_derive-devel.sha256sum] = "3214c1f215c0dc467adb895ec97fd1cab90bcaf4d303906b38d6121a4ca84688"

URI_x86_64_v2_rust-insta+redactions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+redactions-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+redactions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+redactions-devel}"
SRC_URI[x86_64_v2_rust-insta+redactions-devel.sha256sum] = "9e1054aab192a74dff712e38b5fd9cb8760e48493a41c990ae6b4ccc775c90fa"

URI_x86_64_v2_rust-insta+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+regex-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+regex-devel}"
SRC_URI[x86_64_v2_rust-insta+regex-devel.sha256sum] = "4cca7285548590b0d1f54abfe34c083513bab66349b79997fc81ff045286c7bc"

URI_x86_64_v2_rust-insta+ron-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+ron-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+ron-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+ron-devel}"
SRC_URI[x86_64_v2_rust-insta+ron-devel.sha256sum] = "5b4cfda2f6d83a047aa478ce9381b0e4c099de04f3a3b78192dc7ccbdf892e4b"

URI_x86_64_v2_rust-insta+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+serde-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+serde-devel}"
SRC_URI[x86_64_v2_rust-insta+serde-devel.sha256sum] = "1518543d8869d32d3148c55572a2ad35a1451d1b8cb8c9af27abbfcfc421bd88"

URI_x86_64_v2_rust-insta+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+toml-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+toml-devel}"
SRC_URI[x86_64_v2_rust-insta+toml-devel.sha256sum] = "d2819e3ccbcce838c3dc7b72e76bb62df1dc5d705428ef877197c47a6e4cec62"

URI_x86_64_v2_rust-insta+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+walkdir-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+walkdir-devel}"
SRC_URI[x86_64_v2_rust-insta+walkdir-devel.sha256sum] = "696f629ccc574ccf4a0ca3cdfc2aee34f7f3c13d536c45fba13fe4f6a1060beb"

URI_x86_64_v2_rust-insta+yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+yaml-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta+yaml-devel}"
SRC_URI[x86_64_v2_rust-insta+yaml-devel.sha256sum] = "0ecd5a52e16d49cd7b2f5cb27711ae7d1c00aaa00e15191d61a8ac63e4283026"

URI_x86_64_v2_rust-insta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta-devel-1.46.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta-devel}"
SRC_URI[x86_64_v2_rust-insta-devel.sha256sum] = "ae8f305f0a9516e5a22e684fd2f04062861d1471a91386992c7f0f665a71b6d7"

URI_aarch64_rust-insta+_cargo_insta_internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+_cargo_insta_internal-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+_cargo_insta_internal-devel}"
SRC_URI[aarch64_rust-insta+_cargo_insta_internal-devel.sha256sum] = "2d59586c95e9f719f924c945ab6285ffb79bca07df8c64cf033c5cb05ec811ae"

URI_aarch64_rust-insta+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+clap-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+clap-devel}"
SRC_URI[aarch64_rust-insta+clap-devel.sha256sum] = "887669641bb44d52febb78045eecba6b19c4ed8d2edb937e745945f05027d3af"

URI_aarch64_rust-insta+colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+colors-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+colors-devel}"
SRC_URI[aarch64_rust-insta+colors-devel.sha256sum] = "4275801a0a03ecc979c6fd7ee8e925a59fdf09cc253946ffdc294dbf53068853"

URI_aarch64_rust-insta+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+console-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+console-devel}"
SRC_URI[aarch64_rust-insta+console-devel.sha256sum] = "39cd5e32b0db1e0d086d090d1f90b87c26b77571d8860c8a824ea452e957c61e"

URI_aarch64_rust-insta+csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+csv-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+csv-devel}"
SRC_URI[aarch64_rust-insta+csv-devel.sha256sum] = "383f42e84acf68b7b8ee795a8a0f394228dc5de3e8465dcd3ac5cdb29cdc792d"

URI_aarch64_rust-insta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+default-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+default-devel}"
SRC_URI[aarch64_rust-insta+default-devel.sha256sum] = "cdf3c92845ea44481dd8f273c233a1ec377501a2edb9ba96a78f3176e57489aa"

URI_aarch64_rust-insta+filters-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+filters-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+filters-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+filters-devel}"
SRC_URI[aarch64_rust-insta+filters-devel.sha256sum] = "aefbaf837cd8142be9c40a29d5e89fe1473bafe0d03c94186750d5df13f66c11"

URI_aarch64_rust-insta+glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+glob-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+glob-devel}"
SRC_URI[aarch64_rust-insta+glob-devel.sha256sum] = "b5fd2cefbd30ac3d664d98801f296d8ac894c1e5d146a7bfb8cfbe75add02bb5"

URI_aarch64_rust-insta+globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+globset-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+globset-devel}"
SRC_URI[aarch64_rust-insta+globset-devel.sha256sum] = "47098f1143a5e1cf647990917f73f2f41e959d30fa3256d7dc94180eaa7a6fa4"

URI_aarch64_rust-insta+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+json-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+json-devel}"
SRC_URI[aarch64_rust-insta+json-devel.sha256sum] = "66840159e875be3e3e5e887a3959ef06920059720cf5541a329bcadb33e01b51"

URI_aarch64_rust-insta+pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+pest-devel}"
SRC_URI[aarch64_rust-insta+pest-devel.sha256sum] = "e20b3487117e67ce87df1e63c024a65e72949be6259da09d8f940356f8f9ec87"

URI_aarch64_rust-insta+pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest_derive-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+pest_derive-devel}"
SRC_URI[aarch64_rust-insta+pest_derive-devel.sha256sum] = "f8fc8c42263e2ec341f1a6faf0140907e3931f7c667d1e02bc71f726dd7b2f05"

URI_aarch64_rust-insta+redactions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+redactions-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+redactions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+redactions-devel}"
SRC_URI[aarch64_rust-insta+redactions-devel.sha256sum] = "aefed3bff0e4854f4c626548b8671903ea12dfbbb7d0f1365f6c053c91d60f58"

URI_aarch64_rust-insta+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+regex-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+regex-devel}"
SRC_URI[aarch64_rust-insta+regex-devel.sha256sum] = "d6e8934d09c2626591c267bce7e5815bc36fe9f289eb40d54d69038ab6ee7226"

URI_aarch64_rust-insta+ron-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+ron-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+ron-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+ron-devel}"
SRC_URI[aarch64_rust-insta+ron-devel.sha256sum] = "6cb1be29837a90b00a5509607d8f65efb59cbfedd97417ad0f6664cc6ff744b6"

URI_aarch64_rust-insta+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+serde-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+serde-devel}"
SRC_URI[aarch64_rust-insta+serde-devel.sha256sum] = "7c871171a05cabc53102f819dc2786bc86a6eefe36a73dcee85d87c3ff506191"

URI_aarch64_rust-insta+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+toml-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+toml-devel}"
SRC_URI[aarch64_rust-insta+toml-devel.sha256sum] = "15f574857e66152c787340627ecb63440a0e78681f542857ccf715d9eea5649a"

URI_aarch64_rust-insta+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+walkdir-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+walkdir-devel}"
SRC_URI[aarch64_rust-insta+walkdir-devel.sha256sum] = "3f17cddaa6394d087e7071eb952f01cb6d051294fe4ccd63764e72a0480ade25"

URI_aarch64_rust-insta+yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+yaml-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta+yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta+yaml-devel}"
SRC_URI[aarch64_rust-insta+yaml-devel.sha256sum] = "4aaf414e990add6dad1e8cb9e8f8416b4b69c360f980d1371c4c132d1fb79596"

URI_aarch64_rust-insta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta-devel-1.46.3-1.el10_3.noarch.rpm;name=aarch64_rust-insta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta-devel}"
SRC_URI[aarch64_rust-insta-devel.sha256sum] = "39eb3ae7165661199a7c669992ad06bf3fcd121bb191e541199c3c3c7242a526"

RDEPENDS:rust-insta+_cargo_insta_internal-devel = " \
 cargo \
 rust-insta+clap-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+clap-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+colors-devel = " \
 cargo \
 rust-insta+console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+console-devel = " \
 cargo \
 rust-console+std-devel \
 rust-console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+default-devel = " \
 cargo \
 rust-insta+colors-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+filters-devel = " \
 cargo \
 rust-insta+regex-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+glob-devel = " \
 cargo \
 rust-insta+globset-devel \
 rust-insta+walkdir-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+globset-devel = " \
 cargo \
 rust-globset+default-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+json-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+pest-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest+default-devel \
 "
RDEPENDS:rust-insta+pest_derive-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest_derive+default-devel \
 "
RDEPENDS:rust-insta+redactions-devel = " \
 cargo \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+regex-devel = " \
 cargo \
 rust-insta-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-insta+ron-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-ron+default-devel \
 "
RDEPENDS:rust-insta+serde-devel = " \
 cargo \
 rust-insta-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-insta+toml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-toml_writer+default-devel \
 virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ \
 virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~ \
 virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ \
 virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ \
 "
RDEPENDS:rust-insta+walkdir-devel = " \
 cargo \
 rust-insta-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-insta+yaml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta-devel = " \
 cargo \
 rust \
 rust-once_cell+default-devel \
 rust-similar2+default-devel \
 rust-similar2+inline-devel \
 rust-tempfile+default-devel \
 "
