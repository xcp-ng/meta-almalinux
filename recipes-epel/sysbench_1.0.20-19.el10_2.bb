# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sysbench"
PV = "1.0.20"
PR = "19.el10_2"
PACKAGES = " \
 sysbench \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sysbench-1.0.20-19.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "130f7f4916ce67ea4f9580629b11d3ae3b72faff8d4bcf91ffd3541265f82d4f"

URI_x86_64_v2_sysbench = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sysbench-1.0.20-19.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sysbench;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sysbench}"
SRC_URI[x86_64_v2_sysbench.sha256sum] = "88968334369b3aa604b35b355d21bf7160e8d226aa613c87f88741a5ede0213c"

URI_aarch64_sysbench = "${EPEL_MIRROR}/aarch64/Packages/s/sysbench-1.0.20-19.el10_2.aarch64.rpm;name=aarch64_sysbench;unpack=0"
SRC_URI:append = " ${URI_aarch64_sysbench}"
SRC_URI[aarch64_sysbench.sha256sum] = "23013909c498957347300960576fe5f8701aaa4158b540ececf6d74b53e799ce"

RDEPENDS:sysbench = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libpq \
 luajit \
 mariadb-connector-c \
 "
