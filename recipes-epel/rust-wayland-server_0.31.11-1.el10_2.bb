# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-server"
PV = "0.31.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-wayland-server+default-devel \
 rust-wayland-server+log-devel \
 rust-wayland-server-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-server-0.31.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8dc6c84374287fd72bc360f4b6c63f0f6f015b0c6a404668da060dc8bcdb9d42"

URI_x86_64_v2_rust-wayland-server+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+default-devel-0.31.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+default-devel.sha256sum] = "a136a3561999bf5ed52da96057ae3491dc4b1e0b27155ac1ee8cb084230ade2f"

URI_x86_64_v2_rust-wayland-server+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+log-devel-0.31.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+log-devel.sha256sum] = "c4cbbbce8c9ecf1e80918e5ef466ef1483938514e3e17b4ba85749a632184dd1"

URI_x86_64_v2_rust-wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server-devel-0.31.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-server-devel.sha256sum] = "b808480b359e51796f7895c4d178b3ce8b9d2c68fc4313bd7b536fa22694cddd"

URI_aarch64_rust-wayland-server+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+default-devel-0.31.11-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+default-devel}"
SRC_URI[aarch64_rust-wayland-server+default-devel.sha256sum] = "4648b1b020371c085588542daa6e1ef7305689ef45c8b874e2f0cfd510f2d8ad"

URI_aarch64_rust-wayland-server+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+log-devel-0.31.11-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-server+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+log-devel}"
SRC_URI[aarch64_rust-wayland-server+log-devel.sha256sum] = "94f6703247c6391b141cef3fe2303dee5d1bb04d24e989eca38328397cbade8d"

URI_aarch64_rust-wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server-devel-0.31.11-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-server-devel.sha256sum] = "218c3d5c01115120ea05ea47d8ff13a92355d91fc7bbcfcbe44d5f6fc89b1773"

RDEPENDS:rust-wayland-server+default-devel = " \
 cargo \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-downcast-rs1+default-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
