# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntpsec"
PV = "1.2.4"
PR = "8.el10_3"
PACKAGES = " \
 ntpsec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntpsec-1.2.4-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f724b4397080d998d68d4611abcc00a62b1ef01ef97571a5a365b8a3005e5b8"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - ntpsec: libcap.so.2()(64bit)

URI_x86_64_v2_ntpsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntpsec-1.2.4-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntpsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpsec}"
SRC_URI[x86_64_v2_ntpsec.sha256sum] = "d9c59a230b76a67ea0867533097cb9c7497db206ada725c723b2da92e681c98d"
RPROVIDES:ntpsec:x86_64_v2 = "virtual/ntpsec_or_chrony"

URI_aarch64_ntpsec = "${EPEL_MIRROR}/aarch64/Packages/n/ntpsec-1.2.4-8.el10_3.aarch64.rpm;name=aarch64_ntpsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpsec}"
SRC_URI[aarch64_ntpsec.sha256sum] = "e7e73be5f3f5d7d6695d6f7f65cc22f412152c43f78447e9f26f0f8bf4602e76"
RPROVIDES:ntpsec:aarch64 = "virtual/ntpsec_or_chrony"

RDEPENDS:ntpsec:x86_64_v2 = " \
 bash \
 glibc \
 libbsd \
 libcap \
 openssl-libs \
 python3 \
 systemd \
"
RDEPENDS:ntpsec:aarch64 = " \
 bash \
 glibc \
 libbsd \
 openssl-libs \
 python3 \
 systemd \
"

PROVIDES:append:x86_64_v2 = " rpm/virtual/ntpsec_or_chrony"

PROVIDES:append:aarch64 = " rpm/virtual/ntpsec_or_chrony"
