# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wcwidth"
PV = "0.2.13"
PR = "1.el10"
PACKAGES = " \
 python3-wcwidth \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-wcwidth-0.2.13-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8c197a5b4e603ac317547a8b01faa5179ed25f046952b437113a881307deb01"

URI_x86_64_v2_python3-wcwidth = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-wcwidth-0.2.13-1.el10.noarch.rpm;name=x86_64_v2_python3-wcwidth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wcwidth}"
SRC_URI[x86_64_v2_python3-wcwidth.sha256sum] = "d4f8d2382eb30e310f5a14e79c1a2e4d6133a9abf43c790572881bf9163fead2"

URI_aarch64_python3-wcwidth = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-wcwidth-0.2.13-1.el10.noarch.rpm;name=aarch64_python3-wcwidth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wcwidth}"
SRC_URI[aarch64_python3-wcwidth.sha256sum] = "d4f8d2382eb30e310f5a14e79c1a2e4d6133a9abf43c790572881bf9163fead2"

RDEPENDS:python3-wcwidth = " \
 python3 \
 "
