# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-configobj"
PV = "5.0.8"
PR = "10.el10"
PACKAGES = " \
 python3-configobj \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-configobj-5.0.8-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f74584331e080055e08fd3542ece54bcbeefe1ae6689d78fa7b6b74b58e1147d"

URI_x86_64_v2_python3-configobj = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-configobj-5.0.8-10.el10.noarch.rpm;name=x86_64_v2_python3-configobj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configobj}"
SRC_URI[x86_64_v2_python3-configobj.sha256sum] = "7070f34110f4dba45faa4315d60ed767e7931c901e6fe02f3d0ca7f686eb81c7"

URI_aarch64_python3-configobj = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-configobj-5.0.8-10.el10.noarch.rpm;name=aarch64_python3-configobj;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configobj}"
SRC_URI[aarch64_python3-configobj.sha256sum] = "7070f34110f4dba45faa4315d60ed767e7931c901e6fe02f3d0ca7f686eb81c7"

RDEPENDS:python3-configobj = " \
 python3 \
 python3-six \
 "
