# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-auth"
PE = "1"
PV = "2.45.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-google-auth \
 python3-google-auth+aiohttp \
 python3-google-auth+enterprise_cert \
 python3-google-auth+pyopenssl \
 python3-google-auth+requests \
 python3-google-auth+urllib3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-auth-2.45.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27f509641d5d818ddef6b58385aabbfeb57c151916828d5e5e09d49fa53c8f14"

URI_x86_64_v2_python3-google-auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth-2.45.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth}"
SRC_URI[x86_64_v2_python3-google-auth.sha256sum] = "5a5e6c998b02f9442acc10c642ba602d7ade7b0e41cb6b4b667f8c2c99ebf7d2"

URI_x86_64_v2_python3-google-auth+aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+aiohttp-2.45.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+aiohttp}"
SRC_URI[x86_64_v2_python3-google-auth+aiohttp.sha256sum] = "10b1dd00bc027e5de4b0c2408af6eceee33ec3d310c340b66f0306b848b71a78"

URI_x86_64_v2_python3-google-auth+enterprise_cert = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+enterprise_cert-2.45.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+enterprise_cert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+enterprise_cert}"
SRC_URI[x86_64_v2_python3-google-auth+enterprise_cert.sha256sum] = "e9bd5f05df9a629e98b533bd6c1f6dd6365231cf91dd77a265936dcff4392858"

URI_x86_64_v2_python3-google-auth+pyopenssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+pyopenssl-2.45.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+pyopenssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+pyopenssl}"
SRC_URI[x86_64_v2_python3-google-auth+pyopenssl.sha256sum] = "9b4caa8c126edff3312f2b473bd5e6506e20607c61967f7d065fe3d10a30cdaa"

URI_x86_64_v2_python3-google-auth+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+requests-2.45.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+requests}"
SRC_URI[x86_64_v2_python3-google-auth+requests.sha256sum] = "37c2fe707fdcfbc540321a1a0916cb59b6c15a02d08e36cc629417a48424755f"

URI_x86_64_v2_python3-google-auth+urllib3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+urllib3-2.45.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+urllib3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+urllib3}"
SRC_URI[x86_64_v2_python3-google-auth+urllib3.sha256sum] = "14ce2fc0931ca8c3ab9a54f2270835f16c7545b8ef949eb35675af5a78bd8973"

URI_aarch64_python3-google-auth = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth-2.45.0-1.el10_1.noarch.rpm;name=aarch64_python3-google-auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth}"
SRC_URI[aarch64_python3-google-auth.sha256sum] = "ae868085f281e4cb021fc35d48a29acdd33cd55a81b123a874e49b38ce9926e9"

URI_aarch64_python3-google-auth+aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+aiohttp-2.45.0-1.el10_1.noarch.rpm;name=aarch64_python3-google-auth+aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+aiohttp}"
SRC_URI[aarch64_python3-google-auth+aiohttp.sha256sum] = "b6bf347c403c0820c90e71970938c2aa6a81384eaf6670862e1b152bf9e8f55c"

URI_aarch64_python3-google-auth+enterprise_cert = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+enterprise_cert-2.45.0-1.el10_1.noarch.rpm;name=aarch64_python3-google-auth+enterprise_cert;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+enterprise_cert}"
SRC_URI[aarch64_python3-google-auth+enterprise_cert.sha256sum] = "ba3b027ba0c2ac83f29e6a08cc10277f463ff7b611c6e2ae71bc3b847e4fc25d"

URI_aarch64_python3-google-auth+pyopenssl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+pyopenssl-2.45.0-1.el10_1.noarch.rpm;name=aarch64_python3-google-auth+pyopenssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+pyopenssl}"
SRC_URI[aarch64_python3-google-auth+pyopenssl.sha256sum] = "7ff7591f5de33778617a0f4a30b2cf118a18afdfad1523277c295ea1ed261424"

URI_aarch64_python3-google-auth+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+requests-2.45.0-1.el10_1.noarch.rpm;name=aarch64_python3-google-auth+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+requests}"
SRC_URI[aarch64_python3-google-auth+requests.sha256sum] = "4213de8df930bab31cf5497700affb13bcfc306deeefd17996adb82f94de3494"

URI_aarch64_python3-google-auth+urllib3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+urllib3-2.45.0-1.el10_1.noarch.rpm;name=aarch64_python3-google-auth+urllib3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+urllib3}"
SRC_URI[aarch64_python3-google-auth+urllib3.sha256sum] = "e245b13baad6fa11e0ea14e41c6858b67b85da4aa799d0368b72134e7c228a2d"

RDEPENDS:python3-google-auth = " \
 python3 \
 python3-cachetools \
 python3-pyasn1-modules \
 python3-rsa \
 "
RDEPENDS:python3-google-auth+aiohttp = " \
 python3 \
 python3-aiohttp \
 python3-google-auth \
 python3-requests \
 "
RDEPENDS:python3-google-auth+enterprise_cert = " \
 python3 \
 python3-cryptography \
 python3-google-auth \
 python3-pyOpenSSL \
 "
RDEPENDS:python3-google-auth+pyopenssl = " \
 python3 \
 python3-cryptography \
 python3-google-auth \
 python3-pyOpenSSL \
 "
RDEPENDS:python3-google-auth+requests = " \
 python3 \
 python3-google-auth \
 python3-requests \
 "
RDEPENDS:python3-google-auth+urllib3 = " \
 python3 \
 python3-google-auth \
 python3-packaging \
 python3-urllib3 \
 "
