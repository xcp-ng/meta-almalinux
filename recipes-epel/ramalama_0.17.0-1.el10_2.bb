# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ramalama"
PV = "0.17.0"
PR = "1.el10_2"
PACKAGES = " \
 ramalama \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ramalama-0.17.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90e7ee5822f5147728d7a2f357d9609b02d16e5c0832ddb8aeb1e026f43e313b"

URI_x86_64_v2_ramalama = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ramalama-0.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ramalama;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ramalama}"
SRC_URI[x86_64_v2_ramalama.sha256sum] = "e9ebc86fdbfe2c656cfa6dc4a6b1d820b4e11ac62c70d204673831adab09fd1e"

URI_aarch64_ramalama = "${EPEL_MIRROR}/aarch64/Packages/r/ramalama-0.17.0-1.el10_2.noarch.rpm;name=aarch64_ramalama;unpack=0"
SRC_URI:append = " ${URI_aarch64_ramalama}"
SRC_URI[aarch64_ramalama.sha256sum] = "5cfa7e7a80c9ab796a6fa526c308a7d5a576bffdf72142c780ef45f4a42282b3"

RDEPENDS:ramalama = " \
 podman \
 python3 \
 python3-argcomplete \
 python3-jinja2 \
 python3-jsonschema \
 python3-pyyaml \
 "
