# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sanlock"
PV = "4.0.0"
PR = "1.el10"
PACKAGES = " \
 sanlock \
 sanlock-devel \
 sanlock-lib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sanlock-4.0.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a3a97d5d77d9c03b6029e255571c49d2aab4d4da00f383dd87547ac7a107b3e"

URI_x86_64_v2_sanlock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-4.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock}"
SRC_URI[x86_64_v2_sanlock.sha256sum] = "4f4e7d38c772d98cc4a72d927d2e415d8d18030035566cbe2c6fb496f53c47e1"

URI_x86_64_v2_sanlock-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sanlock-devel-4.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock-devel}"
SRC_URI[x86_64_v2_sanlock-devel.sha256sum] = "f67e5db3fa9f10705b1871f7f69cdbeed67abc4177bd1fe136502d5a4c348e9b"

URI_x86_64_v2_sanlock-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-lib-4.0.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock-lib}"
SRC_URI[x86_64_v2_sanlock-lib.sha256sum] = "c86aa10c1d5fb7afaa328431b32a1589ae7d0652c8b29a9c96cd62f7afcfaf87"

URI_aarch64_sanlock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-4.0.0-1.el10.aarch64.rpm;name=aarch64_sanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock}"
SRC_URI[aarch64_sanlock.sha256sum] = "b5d742ee82e3ada780e8fec02b9db5aed736d73a1e9bbf41da72dd582415ba0b"

URI_aarch64_sanlock-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sanlock-devel-4.0.0-1.el10.aarch64.rpm;name=aarch64_sanlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock-devel}"
SRC_URI[aarch64_sanlock-devel.sha256sum] = "63bca7f1a9944ba5435f657c3d649e49dbf20080b6c580e0e9d2a6ff9d50bf38"

URI_aarch64_sanlock-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-lib-4.0.0-1.el10.aarch64.rpm;name=aarch64_sanlock-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock-lib}"
SRC_URI[aarch64_sanlock-lib.sha256sum] = "f2b39994f3ee442e10bd2c6f17e4be0ec520adf89627033bb361f3db8ba1618c"

RDEPENDS:sanlock = " \
 bash \
 glibc \
 libaio \
 libblkid \
 libuuid \
 sanlock-lib \
 systemd \
 "
RDEPENDS:sanlock-devel = " \
 pkgconf-pkg-config \
 sanlock-lib \
 "
RDEPENDS:sanlock-lib = " \
 glibc \
 libaio \
 libblkid \
 "
