# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcachegrind"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kcachegrind \
 kcachegrind-converters \
 qcachegrind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcachegrind-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4138bf0f945d2b7e6d7188f2016bc59849a10f6d73b7ca1e978a49a74d7b5e6"

URI_x86_64_v2_kcachegrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcachegrind}"
SRC_URI[x86_64_v2_kcachegrind.sha256sum] = "5ebbef9f7ec78ed26c8b42ed1c4a945fe4f68717df77667265af5187881fa2d3"

URI_x86_64_v2_kcachegrind-converters = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcachegrind-converters-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcachegrind-converters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcachegrind-converters}"
SRC_URI[x86_64_v2_kcachegrind-converters.sha256sum] = "fabc48b7091777165b293146bcf62e8f38fad0ee1739a9e1d63ab01b4569044b"

URI_x86_64_v2_qcachegrind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcachegrind-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcachegrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcachegrind}"
SRC_URI[x86_64_v2_qcachegrind.sha256sum] = "1579f5b02d9a90ed2e79e28144d2b8ab0a8208ac417e4fea807cd8cef77f1a98"

URI_aarch64_kcachegrind = "${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kcachegrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcachegrind}"
SRC_URI[aarch64_kcachegrind.sha256sum] = "b3e46ac92da7eaa10c6de199fe62805e646861558e00a0ef9c13fda578629e65"

URI_aarch64_kcachegrind-converters = "${EPEL_MIRROR}/aarch64/Packages/k/kcachegrind-converters-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kcachegrind-converters;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcachegrind-converters}"
SRC_URI[aarch64_kcachegrind-converters.sha256sum] = "6f741260d04a52b6cfa69d3674606ece7da82fcab2b9c79694940ff935ac6a31"

URI_aarch64_qcachegrind = "${EPEL_MIRROR}/aarch64/Packages/q/qcachegrind-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_qcachegrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcachegrind}"
SRC_URI[aarch64_qcachegrind.sha256sum] = "40b82bcd7e9e0af7d66b15888c149860334fdf42f5b0b4c4ef6daad0bf60fbe5"

RDEPENDS:kcachegrind = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kcachegrind-converters = " \
 kcachegrind \
 perl-Getopt-Std \
 perl-IO \
 perl-interpreter \
 perl-libs \
 php-cli \
 python3 \
 "
RDEPENDS:qcachegrind = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
