# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mitchellh-hashstructure"
PV = "1.1.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-mitchellh-hashstructure-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mitchellh-hashstructure-1.1.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b99fca256b90ae423abe26605b5f41012907546dd05ec0377c8e70200e6d819"

URI_x86_64_v2_golang-github-mitchellh-hashstructure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mitchellh-hashstructure-devel-1.1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mitchellh-hashstructure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mitchellh-hashstructure-devel}"
SRC_URI[x86_64_v2_golang-github-mitchellh-hashstructure-devel.sha256sum] = "480e9ad7c29400c7d4ad5e07c0f053fab76cddcb1f662f90809ba757a497fe42"

URI_aarch64_golang-github-mitchellh-hashstructure-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mitchellh-hashstructure-devel-1.1.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-mitchellh-hashstructure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mitchellh-hashstructure-devel}"
SRC_URI[aarch64_golang-github-mitchellh-hashstructure-devel.sha256sum] = "286985dd412a260ee4e3be1a3a13ed448eda9bb3cd2d2531587cb6cd7ec0aa57"

RDEPENDS:golang-github-mitchellh-hashstructure-devel = " \
 go-filesystem \
 "
