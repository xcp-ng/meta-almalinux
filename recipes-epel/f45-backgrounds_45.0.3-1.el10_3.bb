# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "f45-backgrounds"
PV = "45.0.3"
PR = "1.el10_3"
PACKAGES = " \
 f45-backgrounds \
 f45-backgrounds-base \
 f45-backgrounds-budgie \
 f45-backgrounds-gnome \
 f45-backgrounds-gnome-time-of-day \
 f45-backgrounds-kde \
 f45-backgrounds-mate \
 f45-backgrounds-mate-time-of-day \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/f45-backgrounds-45.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cc50f4b95d3fa08383efd59f77ce40b5b19c128b299a77eb9c1a59f475d1420"

URI_x86_64_v2_f45-backgrounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f45-backgrounds-45.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_f45-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f45-backgrounds}"
SRC_URI[x86_64_v2_f45-backgrounds.sha256sum] = "88a53db326625b23c4a7ea3ec056ee6e447d7007f7ef3bb9a7bbeae1bda9c917"

URI_x86_64_v2_f45-backgrounds-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f45-backgrounds-base-45.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_f45-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f45-backgrounds-base}"
SRC_URI[x86_64_v2_f45-backgrounds-base.sha256sum] = "f716b8094855e9ad49324410237e68ea8cec2c8c16170b215a3d77cca6ced7a9"

URI_x86_64_v2_f45-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f45-backgrounds-budgie-45.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_f45-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f45-backgrounds-budgie}"
SRC_URI[x86_64_v2_f45-backgrounds-budgie.sha256sum] = "3919fcb5db1b98f049de9d6bf01c530c127b5bcd9ac1da66b3cab3fe1756688e"

URI_x86_64_v2_f45-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f45-backgrounds-gnome-45.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_f45-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f45-backgrounds-gnome}"
SRC_URI[x86_64_v2_f45-backgrounds-gnome.sha256sum] = "289dc91a10a366d5b25583ca1bc931c5756e74c7ed958cda5a377f64ba23a3c1"

URI_x86_64_v2_f45-backgrounds-gnome-time-of-day = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f45-backgrounds-gnome-time-of-day-45.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_f45-backgrounds-gnome-time-of-day;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f45-backgrounds-gnome-time-of-day}"
SRC_URI[x86_64_v2_f45-backgrounds-gnome-time-of-day.sha256sum] = "17887311c70e23c740ce8cbd442c6151b8895bdca187a26b475bfe49d72d47ba"

URI_x86_64_v2_f45-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f45-backgrounds-kde-45.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_f45-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f45-backgrounds-kde}"
SRC_URI[x86_64_v2_f45-backgrounds-kde.sha256sum] = "8bfd9d6d7f47cd63195eb7bd6c51f5bfb76f721bb5405d1cbfad01bc05c168ea"

URI_x86_64_v2_f45-backgrounds-mate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f45-backgrounds-mate-45.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_f45-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f45-backgrounds-mate}"
SRC_URI[x86_64_v2_f45-backgrounds-mate.sha256sum] = "c3fa7df7e167aff297cb5ac0d27cc7a96f226d074ddddc15a7fab7484d86f731"

URI_x86_64_v2_f45-backgrounds-mate-time-of-day = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f45-backgrounds-mate-time-of-day-45.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_f45-backgrounds-mate-time-of-day;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f45-backgrounds-mate-time-of-day}"
SRC_URI[x86_64_v2_f45-backgrounds-mate-time-of-day.sha256sum] = "1b0bd207401fbe0af11743bc30161180f42481821441c30598416fd956e7b646"

URI_aarch64_f45-backgrounds = "${EPEL_MIRROR}/aarch64/Packages/f/f45-backgrounds-45.0.3-1.el10_3.noarch.rpm;name=aarch64_f45-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_f45-backgrounds}"
SRC_URI[aarch64_f45-backgrounds.sha256sum] = "0657a6e8b098e2a1eb4c2624992a75d05bb9aa04f51e99672349f8bf793c7b0e"

URI_aarch64_f45-backgrounds-base = "${EPEL_MIRROR}/aarch64/Packages/f/f45-backgrounds-base-45.0.3-1.el10_3.noarch.rpm;name=aarch64_f45-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_f45-backgrounds-base}"
SRC_URI[aarch64_f45-backgrounds-base.sha256sum] = "63fc8fd48a65cbb2dc141e3426998cacea21dded6cfa003fd9f8c93e312275cc"

URI_aarch64_f45-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/f/f45-backgrounds-budgie-45.0.3-1.el10_3.noarch.rpm;name=aarch64_f45-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_f45-backgrounds-budgie}"
SRC_URI[aarch64_f45-backgrounds-budgie.sha256sum] = "f11fc64908f3cdabe24aa700e3365026ab64caf97e8acc0646335d87161f8fa8"

URI_aarch64_f45-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/f/f45-backgrounds-gnome-45.0.3-1.el10_3.noarch.rpm;name=aarch64_f45-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_f45-backgrounds-gnome}"
SRC_URI[aarch64_f45-backgrounds-gnome.sha256sum] = "2bdc81a7016025bce64138375b7e4288ab586d44e52b9e4397e990488ced6752"

URI_aarch64_f45-backgrounds-gnome-time-of-day = "${EPEL_MIRROR}/aarch64/Packages/f/f45-backgrounds-gnome-time-of-day-45.0.3-1.el10_3.noarch.rpm;name=aarch64_f45-backgrounds-gnome-time-of-day;unpack=0"
SRC_URI:append = " ${URI_aarch64_f45-backgrounds-gnome-time-of-day}"
SRC_URI[aarch64_f45-backgrounds-gnome-time-of-day.sha256sum] = "76cd78ce47e47984deb5004cad948b670688fdf71fa0312bcfd01b8cf4994732"

URI_aarch64_f45-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/f/f45-backgrounds-kde-45.0.3-1.el10_3.noarch.rpm;name=aarch64_f45-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_f45-backgrounds-kde}"
SRC_URI[aarch64_f45-backgrounds-kde.sha256sum] = "911dadaa097d48f07d718ae63503a63b9748273b1766ba98bd2794d4593a38e3"

URI_aarch64_f45-backgrounds-mate = "${EPEL_MIRROR}/aarch64/Packages/f/f45-backgrounds-mate-45.0.3-1.el10_3.noarch.rpm;name=aarch64_f45-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_aarch64_f45-backgrounds-mate}"
SRC_URI[aarch64_f45-backgrounds-mate.sha256sum] = "487a58952f28ae7b5e5bc1813315d1931cf10f463dd028bc591e81c1aeba35a7"

URI_aarch64_f45-backgrounds-mate-time-of-day = "${EPEL_MIRROR}/aarch64/Packages/f/f45-backgrounds-mate-time-of-day-45.0.3-1.el10_3.noarch.rpm;name=aarch64_f45-backgrounds-mate-time-of-day;unpack=0"
SRC_URI:append = " ${URI_aarch64_f45-backgrounds-mate-time-of-day}"
SRC_URI[aarch64_f45-backgrounds-mate-time-of-day.sha256sum] = "25eb4f0e4c5a839be887e411c89dfb8f975652fe93cf667533fe65b5eb049873"

RDEPENDS:f45-backgrounds = " \
 f45-backgrounds-budgie \
 f45-backgrounds-gnome \
 f45-backgrounds-kde \
 f45-backgrounds-mate \
 "
RDEPENDS:f45-backgrounds-base = " \
 jxl-pixbuf-loader \
 kf6-kimageformats \
 "
RDEPENDS:f45-backgrounds-budgie = " \
 f45-backgrounds-base \
 "
RDEPENDS:f45-backgrounds-gnome = " \
 f45-backgrounds-base \
 "
RDEPENDS:f45-backgrounds-gnome-time-of-day = " \
 f45-backgrounds-base \
 "
RDEPENDS:f45-backgrounds-kde = " \
 f45-backgrounds-base \
 kde-filesystem \
 "
RDEPENDS:f45-backgrounds-mate = " \
 f45-backgrounds-base \
 "
RDEPENDS:f45-backgrounds-mate-time-of-day = " \
 f45-backgrounds-base \
 "
