# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-thunderbolt"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-thunderbolt \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-thunderbolt-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3cc04dff69a9556a8f5ecfe5fa7db87d69289aab59362f965cbe8d0e82eaac64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-thunderbolt-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-thunderbolt;unpack=0"
SRC_URI[x86_64_v2_plasma-thunderbolt.sha256sum] = "5e92a6c3837ea420ad4167b8a3c255d2d64bf5c21705a2e654ab4b345aa1bd9c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-thunderbolt-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-thunderbolt;unpack=0"
SRC_URI[aarch64_plasma-thunderbolt.sha256sum] = "8d1c1491c8e26828b5c8e19c8e213d1a519ceaebef2076f072720cc57f8da97d"

RDEPENDS:plasma-thunderbolt = " \
 bolt \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
