# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mksh"
PV = "59c"
PR = "13.el10"
PACKAGES = " \
 mksh \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mksh-59c-13.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "97f2cab882f713c6cf1485f624e65755e0fceecae25bed2e699783fedcb4b4e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mksh-59c-13.el10.x86_64_v2.rpm;name=x86_64_v2_mksh;unpack=0"
SRC_URI[x86_64_v2_mksh.sha256sum] = "5064395a8ea56f0dd4829623dd9d87cf032fe20048e8b15c763422b719203220"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mksh-59c-13.el10.aarch64.rpm;name=aarch64_mksh;unpack=0"
SRC_URI[aarch64_mksh.sha256sum] = "605d076bb8ecd07fffcaf650225a7eff22252c24f3473d34b82734d9a1935e2c"

RDEPENDS:mksh = " \
 alternatives \
 bash \
 glibc \
 grep \
 sed \
 "
