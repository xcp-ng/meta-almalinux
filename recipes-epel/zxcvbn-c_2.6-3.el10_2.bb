# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zxcvbn-c"
PV = "2.6"
PR = "3.el10_2"
PACKAGES = " \
 zxcvbn-c \
 zxcvbn-c-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/z/zxcvbn-c-2.6-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e51d2aec3f820299d46b9412b47c3674e41692909fce546d223229e11c5ac7e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zxcvbn-c-2.6-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zxcvbn-c;unpack=0"
SRC_URI[x86_64_v2_zxcvbn-c.sha256sum] = "2f1888fe2f2fdfeeb13ec890b20ca6ccaef7f3f8ac8efb30a923cc795b1175f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zxcvbn-c-devel-2.6-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zxcvbn-c-devel;unpack=0"
SRC_URI[x86_64_v2_zxcvbn-c-devel.sha256sum] = "95ec5fe5e3922c6c81e79525480cabc63407d61af3e1e25ad2cc5048a7e8d28b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zxcvbn-c-2.6-3.el10_2.aarch64.rpm;name=aarch64_zxcvbn-c;unpack=0"
SRC_URI[aarch64_zxcvbn-c.sha256sum] = "fd76da0735f444d7f3cebe9580d65fc546b5f4a8ea2dd7e0e8e90e12c0e78f66"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zxcvbn-c-devel-2.6-3.el10_2.aarch64.rpm;name=aarch64_zxcvbn-c-devel;unpack=0"
SRC_URI[aarch64_zxcvbn-c-devel.sha256sum] = "f6610e314998b8ff71fb67367ce9b731190a50b7ce54b4379c100454af095d50"

RDEPENDS:zxcvbn-c = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:zxcvbn-c-devel = " \
 zxcvbn-c \
 "
