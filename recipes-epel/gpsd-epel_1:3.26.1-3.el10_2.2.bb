# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsd-epel"
PE = "1"
PV = "3.26.1"
PR = "3.el10_2.2"
PACKAGES = " \
 gpsd-devel \
 gpsd-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gpsd-epel-3.26.1-3.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4a0c3ebb61213859023383502874aa68af7f7f3e0cf735cd08d8d69faf2ab212"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gpsd-devel-3.26.1-3.el10_2.2.aarch64.rpm;name=aarch64_gpsd-devel;unpack=0"
SRC_URI[aarch64_gpsd-devel.sha256sum] = "08c61a6b75ea96812960bde80a8761f73a6c3df3355fb7cc972d530b23642250"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gpsd-libs-3.26.1-3.el10_2.2.aarch64.rpm;name=aarch64_gpsd-libs;unpack=0"
SRC_URI[aarch64_gpsd-libs.sha256sum] = "30cef1cfe0203e604d262362a3ada5567243b32b03edf05acaf61a93fd81a0db"

RDEPENDS:gpsd-devel = " \
 gpsd-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:gpsd-libs = " \
 dbus-libs \
 glibc \
 "
