# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-community-internal_test_tools"
PV = "0.19.0"
PR = "1.el10_1"
PACKAGES = " \
 ansible-collection-community-internal_test_tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ansible-collection-community-internal_test_tools-0.19.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07bae4c9a701fdb70589c9539abe16efd588e84441ab2849ec0073f35a3b087f"

URI_x86_64_v2_ansible-collection-community-internal_test_tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ansible-collection-community-internal_test_tools-0.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ansible-collection-community-internal_test_tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-community-internal_test_tools}"
SRC_URI[x86_64_v2_ansible-collection-community-internal_test_tools.sha256sum] = "1d4f22499b5a8e763e928d04366225c329e08f523a5c5a32c45b64849ebab73b"

URI_aarch64_ansible-collection-community-internal_test_tools = "${EPEL_MIRROR}/aarch64/Packages/a/ansible-collection-community-internal_test_tools-0.19.0-1.el10_1.noarch.rpm;name=aarch64_ansible-collection-community-internal_test_tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-community-internal_test_tools}"
SRC_URI[aarch64_ansible-collection-community-internal_test_tools.sha256sum] = "c0f5b8376798c7805ee8161120b89b2e7ce86b2cc3347a3f6cf7c416a5b1cc62"

RDEPENDS:ansible-collection-community-internal_test_tools = " \
 ansible-core \
 "
