# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "open-vm-tools"
PV = "12.5.0"
PR = "1.el10_0.1"
PACKAGES:x86_64_v2 = " \
 open-vm-tools \
 open-vm-tools-desktop \
 open-vm-tools-salt-minion \
 open-vm-tools-sdmp \
 open-vm-tools-test \
"
PACKAGES:aarch64 = " \
 open-vm-tools \
 open-vm-tools-desktop \
 open-vm-tools-test \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/open-vm-tools-12.5.0-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb58ac2f8f957d38ef13777870b20d0e1d6035ede9e457e23cfca45a2ef07387"

URI_x86_64_v2_open-vm-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools}"
SRC_URI[x86_64_v2_open-vm-tools.sha256sum] = "51e865b8a84a34c6188b0dc14b2a41b3366e3ccb196448b26762fae3ff661667"

URI_x86_64_v2_open-vm-tools-desktop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-desktop-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools-desktop}"
SRC_URI[x86_64_v2_open-vm-tools-desktop.sha256sum] = "da20b9bc3e5246a8e092d741388aac38344abe54575772c2cb348c575de4d3ca"

URI_x86_64_v2_open-vm-tools-salt-minion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-salt-minion-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-salt-minion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools-salt-minion}"
SRC_URI[x86_64_v2_open-vm-tools-salt-minion.sha256sum] = "680c148350e75eca4f673b3a6ee8299801035e6fa7fc16a9cc1510054eead4ef"

URI_x86_64_v2_open-vm-tools-sdmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-sdmp-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-sdmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools-sdmp}"
SRC_URI[x86_64_v2_open-vm-tools-sdmp.sha256sum] = "72c1e4f2a9f40862d8c1aa9dc902eff199c4cabf3bc3868042dae71d9443a07a"

URI_x86_64_v2_open-vm-tools-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/open-vm-tools-test-12.5.0-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_open-vm-tools-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vm-tools-test}"
SRC_URI[x86_64_v2_open-vm-tools-test.sha256sum] = "81d94f92be2f728a58f70e4132a5e750345e9064313151a867b77e4b795929b2"

URI_aarch64_open-vm-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-vm-tools-12.5.0-1.el10_0.1.aarch64.rpm;name=aarch64_open-vm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_open-vm-tools}"
SRC_URI[aarch64_open-vm-tools.sha256sum] = "dcc1df9bd2e0ec8039c0ef1354eb7eea8d77da587f7954b1a9c4a757ac4f08c3"

URI_aarch64_open-vm-tools-desktop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-vm-tools-desktop-12.5.0-1.el10_0.1.aarch64.rpm;name=aarch64_open-vm-tools-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_open-vm-tools-desktop}"
SRC_URI[aarch64_open-vm-tools-desktop.sha256sum] = "9e83eec91c75ae27daf52db306d7d708019d0541d974836cd7fa1f123ac5c044"

URI_aarch64_open-vm-tools-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/open-vm-tools-test-12.5.0-1.el10_0.1.aarch64.rpm;name=aarch64_open-vm-tools-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_open-vm-tools-test}"
SRC_URI[aarch64_open-vm-tools-test.sha256sum] = "2450fb41b3713ce99d0a90e95cfe9802bd593fd9f96bd9351a19f43876c78d85"

RDEPENDS:open-vm-tools:x86_64_v2 = " \
 bash \
 dbus-tools \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 grep \
 iproute \
 libdrm \
 libgcc \
 libmspack \
 libtirpc \
 libxml2 \
 openssl-libs \
 pciutils \
 sed \
 systemd \
 systemd-libs \
 tar \
 util-linux \
 virtual/coreutils \
 which \
 xmlsec1 \
 xmlsec1-openssl \
"
RDEPENDS:open-vm-tools:aarch64 = " \
 bash \
 dbus-tools \
 fuse3 \
 fuse3-libs \
 glib2 \
 glibc \
 grep \
 iproute \
 libdrm \
 libmspack \
 libtirpc \
 libxml2 \
 openssl-libs \
 pciutils \
 sed \
 systemd \
 systemd-libs \
 tar \
 util-linux \
 virtual/coreutils \
 which \
 xmlsec1 \
 xmlsec1-openssl \
"
RDEPENDS:open-vm-tools-desktop = " \
 atk \
 bash \
 cairo \
 fuse3-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libX11 \
 libXext \
 libXi \
 libXinerama \
 libXrandr \
 libXtst \
 libdrm \
 libgcc \
 libstdc++ \
 libtirpc \
 open-vm-tools \
 pango \
 systemd-libs \
 "
RDEPENDS:open-vm-tools-salt-minion = " \
 bash \
 curl \
 gawk \
 grep \
 open-vm-tools \
 systemd \
 virtual/coreutils \
 "
RDEPENDS:open-vm-tools-sdmp = " \
 bash \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 grep \
 iproute \
 open-vm-tools \
 procps-ng \
 virtual/coreutils \
 "
RDEPENDS:open-vm-tools-test = " \
 glib2 \
 glibc \
 open-vm-tools \
 "
