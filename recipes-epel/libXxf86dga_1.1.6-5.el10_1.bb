# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXxf86dga"
PV = "1.1.6"
PR = "5.el10_1"
PACKAGES = " \
 libXxf86dga \
 libXxf86dga-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libXxf86dga-1.1.6-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37f795585a765e7b7ad9ac15d6c64614288a8d386bd5ec9f22c418becc088416"

URI_x86_64_v2_libXxf86dga = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXxf86dga-1.1.6-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXxf86dga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXxf86dga}"
SRC_URI[x86_64_v2_libXxf86dga.sha256sum] = "03b6f7882a351480e085c400290fa4c9e8979d79a2459d1ac20da99edaf8a45a"

URI_x86_64_v2_libXxf86dga-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXxf86dga-devel-1.1.6-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXxf86dga-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXxf86dga-devel}"
SRC_URI[x86_64_v2_libXxf86dga-devel.sha256sum] = "9c06a9f8d24be86505da415459f1ad8a598423b00e7528a2622278481f3ce97c"

URI_aarch64_libXxf86dga = "${EPEL_MIRROR}/aarch64/Packages/l/libXxf86dga-1.1.6-5.el10_1.aarch64.rpm;name=aarch64_libXxf86dga;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXxf86dga}"
SRC_URI[aarch64_libXxf86dga.sha256sum] = "3716a1bc7e5e6f018d00d058dc68ce90511e75011f60be8c41ffbdcf57134f54"

URI_aarch64_libXxf86dga-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXxf86dga-devel-1.1.6-5.el10_1.aarch64.rpm;name=aarch64_libXxf86dga-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXxf86dga-devel}"
SRC_URI[aarch64_libXxf86dga-devel.sha256sum] = "e3602ef74e8420daf2b880310acc1bb5e4ad67c53ef704b3d9db118e58a14a53"

RDEPENDS:libXxf86dga = " \
 glibc \
 libX11 \
 libXext \
 "
RDEPENDS:libXxf86dga-devel = " \
 libX11-devel \
 libXext-devel \
 libXxf86dga \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
