# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-libreswan"
PV = "1.2.30"
PR = "1.el10"
PACKAGES = " \
 NetworkManager-libreswan \
 NetworkManager-libreswan-gnome \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/NetworkManager-libreswan-1.2.30-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9392a07166578edc03008bacfa5e3d108ce42fed870f7596a8a50701549b1b5d"

URI_x86_64_v2_NetworkManager-libreswan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-1.2.30-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libreswan}"
SRC_URI[x86_64_v2_NetworkManager-libreswan.sha256sum] = "160c8837c10aa3e23c5937ec848468488555cea7b2c857a7586dab18b1ba3ed8"

URI_x86_64_v2_NetworkManager-libreswan-gnome = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-gnome-1.2.30-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libreswan-gnome}"
SRC_URI[x86_64_v2_NetworkManager-libreswan-gnome.sha256sum] = "f7f343214a6260aac29bb288b8786d9f311767a8c565f6198d7cfadce04a8aee"

URI_aarch64_NetworkManager-libreswan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-1.2.30-1.el10.aarch64.rpm;name=aarch64_NetworkManager-libreswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libreswan}"
SRC_URI[aarch64_NetworkManager-libreswan.sha256sum] = "31e29bd244918f94a7d11fcf77f58475cf05e0214b800de206e4269aad01733b"

URI_aarch64_NetworkManager-libreswan-gnome = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-gnome-1.2.30-1.el10.aarch64.rpm;name=aarch64_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libreswan-gnome}"
SRC_URI[aarch64_NetworkManager-libreswan-gnome.sha256sum] = "e5615d5f44af4bf58ed5414bcf4e048ba206d03a0b0263be7449108262acdb51"

RDEPENDS:NetworkManager-libreswan = " \
 NetworkManager \
 NetworkManager-libnm \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 libnl3 \
 libreswan-minimal \
 "
RDEPENDS:NetworkManager-libreswan-gnome = " \
 NetworkManager-libnm \
 NetworkManager-libreswan \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 pango \
 shared-mime-info \
 vulkan-loader \
 "
