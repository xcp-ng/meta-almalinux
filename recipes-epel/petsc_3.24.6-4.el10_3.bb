# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "petsc"
PV = "3.24.6"
PR = "4.el10_3"
PACKAGES = " \
 petsc \
 petsc-devel \
 petsc-doc \
 petsc-mpich \
 petsc-mpich-devel \
 petsc-openmpi \
 petsc-openmpi-devel \
 petsc64 \
 petsc64-devel \
 python3-petsc-mpich \
 python3-petsc-openmpi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/petsc-3.24.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8761309eec25b8822713164de825ff1dd3949df3885cfc98707eca91561b9f33"

URI_x86_64_v2_petsc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc}"
SRC_URI[x86_64_v2_petsc.sha256sum] = "61857b731aaf7720ab9f1261f2667c93ad5b4f4b62b948dddc1715a949ca4311"

URI_x86_64_v2_petsc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-devel-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-devel}"
SRC_URI[x86_64_v2_petsc-devel.sha256sum] = "edbb05ff35a1442efc3fe7f3cb12ea106c46f7efe4d88ce92682f410b3b6c703"

URI_x86_64_v2_petsc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-doc-3.24.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_petsc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-doc}"
SRC_URI[x86_64_v2_petsc-doc.sha256sum] = "0e0dc0bd9ad882b8610df3912bcf36b1962eeb8a24da02099e07f2c0bd5f21d5"

URI_x86_64_v2_petsc-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-mpich-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-mpich}"
SRC_URI[x86_64_v2_petsc-mpich.sha256sum] = "5dcb8f8e4be210e90ed2d8f2113082151994464e9f3683b475e8567b400c7930"

URI_x86_64_v2_petsc-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-mpich-devel-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-mpich-devel}"
SRC_URI[x86_64_v2_petsc-mpich-devel.sha256sum] = "61cb8c4ed3dc2ce9d3079d1ffe757ad76fb9a5a614e170c75a21ea9a4c625538"

URI_x86_64_v2_petsc-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-openmpi-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-openmpi}"
SRC_URI[x86_64_v2_petsc-openmpi.sha256sum] = "17615cfa7b3aecd9535d44aadd06ddac2650e65a89cad3443e652a51e3d5c804"

URI_x86_64_v2_petsc-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc-openmpi-devel-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc-openmpi-devel}"
SRC_URI[x86_64_v2_petsc-openmpi-devel.sha256sum] = "0b6b3851ce3afa7387c01d206c3eacb82337281078aacef1c77a6f9f9142b8b4"

URI_x86_64_v2_petsc64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc64-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc64}"
SRC_URI[x86_64_v2_petsc64.sha256sum] = "f285702c3d1e3d2b602e01cf2809c87a43293bb5e319b8d1cf16b58af008fc8d"

URI_x86_64_v2_petsc64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/petsc64-devel-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_petsc64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_petsc64-devel}"
SRC_URI[x86_64_v2_petsc64-devel.sha256sum] = "911dc1c7ebe62d23b9497ae72933d34725b9a415f6a8bf227db6386cedf1f9a3"

URI_x86_64_v2_python3-petsc-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-petsc-mpich-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-petsc-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-petsc-mpich}"
SRC_URI[x86_64_v2_python3-petsc-mpich.sha256sum] = "99f9770945ea88a727ddb04f7949499cc15ea47ce51911eccfcaf6fdae1ddfc0"

URI_x86_64_v2_python3-petsc-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-petsc-openmpi-3.24.6-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-petsc-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-petsc-openmpi}"
SRC_URI[x86_64_v2_python3-petsc-openmpi.sha256sum] = "bad738e6a7acc1e6bea95bfecdc1bd6db39bab96eb49eeb1ac1d845a21bff951"

URI_aarch64_petsc = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_petsc;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc}"
SRC_URI[aarch64_petsc.sha256sum] = "d596cb75fdeb35f5fda4e72ee8a345ffd2c15ed77c2dbab1de3e23114f834ec9"

URI_aarch64_petsc-devel = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-devel-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_petsc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-devel}"
SRC_URI[aarch64_petsc-devel.sha256sum] = "3500f2a0dedb96b1a65f951ab32b9467176c67fc2d362cda1bd9b18f79fc18e1"

URI_aarch64_petsc-doc = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-doc-3.24.6-4.el10_3.noarch.rpm;name=aarch64_petsc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-doc}"
SRC_URI[aarch64_petsc-doc.sha256sum] = "8a301d9becd9e689daba881b1755cdc92f63d8f63bf1ec3a543cde05300bcd02"

URI_aarch64_petsc-mpich = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-mpich-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_petsc-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-mpich}"
SRC_URI[aarch64_petsc-mpich.sha256sum] = "9c27d1f8f7d00530b2605da19ade522f7a9717d5661ec371318c6d1bffc47f50"

URI_aarch64_petsc-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-mpich-devel-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_petsc-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-mpich-devel}"
SRC_URI[aarch64_petsc-mpich-devel.sha256sum] = "cc410ff43c5e8c251dd24d0f9491cdd4e668e46b3b052c7c53d8353b03ab2445"

URI_aarch64_petsc-openmpi = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-openmpi-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_petsc-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-openmpi}"
SRC_URI[aarch64_petsc-openmpi.sha256sum] = "92eecb3d6d524f155bd20cd0ed99a5e6aa417b33ef5f015c146d39afa7211422"

URI_aarch64_petsc-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/p/petsc-openmpi-devel-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_petsc-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc-openmpi-devel}"
SRC_URI[aarch64_petsc-openmpi-devel.sha256sum] = "ec2ddc89441ba62e89ab26a7ae0ba3f09a3d34bb5ae04c5a3a002c50df864519"

URI_aarch64_petsc64 = "${EPEL_MIRROR}/aarch64/Packages/p/petsc64-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_petsc64;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc64}"
SRC_URI[aarch64_petsc64.sha256sum] = "540ef64ad1c4018b857fb21d31bd232aa625077473a7b2fe3c9beaa9588b5f51"

URI_aarch64_petsc64-devel = "${EPEL_MIRROR}/aarch64/Packages/p/petsc64-devel-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_petsc64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_petsc64-devel}"
SRC_URI[aarch64_petsc64-devel.sha256sum] = "a6a380b0aa9970e7fd15bb8d97faaa4fcc1258b2ce80b60a35c1ccfe0b9efef9"

URI_aarch64_python3-petsc-mpich = "${EPEL_MIRROR}/aarch64/Packages/p/python3-petsc-mpich-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_python3-petsc-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-petsc-mpich}"
SRC_URI[aarch64_python3-petsc-mpich.sha256sum] = "6c625136e8787932b582df52b09916b68aeebad182fb0383fafce39f7f6f8abb"

URI_aarch64_python3-petsc-openmpi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-petsc-openmpi-3.24.6-4.el10_3.aarch64.rpm;name=aarch64_python3-petsc-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-petsc-openmpi}"
SRC_URI[aarch64_python3-petsc-openmpi.sha256sum] = "132c69ce12622fb8c20503f5339ef4213791ba640442cc6a9de6bf3c526342ad"

RDEPENDS:petsc = " \
 SuperLU \
 flexiblas-netlib \
 glibc \
 hdf5 \
 libX11 \
 libgcc \
 libstdc++ \
 metis \
 "
RDEPENDS:petsc-devel = " \
 gcc-gfortran \
 petsc \
 pkgconf-pkg-config \
 "
RDEPENDS:petsc-doc = " \
 "
RDEPENDS:petsc-mpich = " \
 MUMPS-mpich \
 flexiblas-netlib \
 glibc \
 hdf5-mpich \
 hypre-mpich \
 libX11 \
 libgcc \
 libstdc++ \
 metis \
 mpich \
 ptscotch-mpich \
 scalapack-mpich \
 superlu_dist-mpich \
 "
RDEPENDS:petsc-mpich-devel = " \
 hdf5-mpich-devel \
 mpich-devel \
 petsc-mpich \
 "
RDEPENDS:petsc-openmpi = " \
 MUMPS-openmpi \
 flexiblas-netlib \
 glibc \
 hdf5-openmpi \
 hypre-openmpi \
 libX11 \
 libgcc \
 libstdc++ \
 metis \
 openmpi \
 ptscotch-openmpi \
 scalapack-openmpi \
 superlu_dist-openmpi \
 "
RDEPENDS:petsc-openmpi-devel = " \
 hdf5-openmpi-devel \
 openmpi-devel \
 petsc-openmpi \
 "
RDEPENDS:petsc64 = " \
 flexiblas-netlib64 \
 glibc \
 hdf5 \
 libX11 \
 libgcc \
 libstdc++ \
 metis64 \
 "
RDEPENDS:petsc64-devel = " \
 gcc-gfortran \
 petsc64 \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-petsc-mpich = " \
 MUMPS-mpich \
 glibc \
 hdf5-mpich \
 mpich \
 petsc-mpich \
 ptscotch-mpich \
 python3 \
 scalapack-mpich \
 "
RDEPENDS:python3-petsc-openmpi = " \
 MUMPS-openmpi \
 glibc \
 hdf5-openmpi \
 openmpi \
 petsc-openmpi \
 ptscotch-openmpi \
 python3 \
 scalapack-openmpi \
 "
