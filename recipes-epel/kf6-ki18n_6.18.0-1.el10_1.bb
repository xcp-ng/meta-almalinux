# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ki18n"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-ki18n \
 kf6-ki18n-devel \
 kf6-ki18n-doc \
 kf6-ki18n-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ki18n-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ceecb84c405e8efa7966240bb301c4af3cb02a45cc44eaf3fd0f2c40dd2f7970"

URI_x86_64_v2_kf6-ki18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n}"
SRC_URI[x86_64_v2_kf6-ki18n.sha256sum] = "006bb487c99cd499606d5f5cbb3e1b37121c8501faf0e24e00d74af0e40860a2"

URI_x86_64_v2_kf6-ki18n-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ki18n-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-devel}"
SRC_URI[x86_64_v2_kf6-ki18n-devel.sha256sum] = "a357b222d952518b4479ba909d056dbd7a541d2049bb2bb81cca559156156f8a"

URI_x86_64_v2_kf6-ki18n-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ki18n-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-doc}"
SRC_URI[x86_64_v2_kf6-ki18n-doc.sha256sum] = "99e9a294f8f2012ebc4bf766399b518ee87de66b42c09faf60c850cfa188d78b"

URI_x86_64_v2_kf6-ki18n-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ki18n-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ki18n-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ki18n-html}"
SRC_URI[x86_64_v2_kf6-ki18n-html.sha256sum] = "fbbcb9907d432d78ef59ec5c8dfc5358688f2afdaa48e430e855fe29e4f5678c"

URI_aarch64_kf6-ki18n = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-ki18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n}"
SRC_URI[aarch64_kf6-ki18n.sha256sum] = "e5e574ade24b8d6cfa630d04f2e795e941cfab5013e0d56f7794d3f02f6ae56c"

URI_aarch64_kf6-ki18n-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-ki18n-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-devel}"
SRC_URI[aarch64_kf6-ki18n-devel.sha256sum] = "84e6e9a87bb4184dd9d0b0a3142db47c10a6fb567cca85c25799deb5e8eb9dae"

URI_aarch64_kf6-ki18n-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-ki18n-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-doc}"
SRC_URI[aarch64_kf6-ki18n-doc.sha256sum] = "f09231857e174372bf1c6d2cf679e605fa2dd05a229387b60159be90586b84ce"

URI_aarch64_kf6-ki18n-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ki18n-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-ki18n-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ki18n-html}"
SRC_URI[aarch64_kf6-ki18n-html.sha256sum] = "2c9286a3db96b537d145fc59ea0587d2291fc369dc90010b85edc33b79c81209"

RDEPENDS:kf6-ki18n = " \
 glibc \
 iso-codes \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ki18n-devel = " \
 cmake-filesystem \
 gettext \
 kf6-ki18n \
 python3 \
 "
RDEPENDS:kf6-ki18n-doc = " \
 "
RDEPENDS:kf6-ki18n-html = " \
 "
