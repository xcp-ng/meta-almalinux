# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git2-curl"
PV = "0.21.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-git2-curl+default-devel \
 rust-git2-curl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git2-curl-0.21.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e45a991b53f4143c44068c997028b17b93b533dd793d22bf0f62bfa89f1b778d"

URI_x86_64_v2_rust-git2-curl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2-curl+default-devel-0.21.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2-curl+default-devel}"
SRC_URI[x86_64_v2_rust-git2-curl+default-devel.sha256sum] = "b6ddb040a0f0669452622284f8698afc3b17907d192bc7549c972d5b64ea40b9"

URI_x86_64_v2_rust-git2-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2-curl-devel-0.21.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2-curl-devel}"
SRC_URI[x86_64_v2_rust-git2-curl-devel.sha256sum] = "7d89889e1a62832e2ab85faae6b32cfe363d9267ef6d492a37a3520943ce8823"

URI_aarch64_rust-git2-curl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2-curl+default-devel-0.21.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2-curl+default-devel}"
SRC_URI[aarch64_rust-git2-curl+default-devel.sha256sum] = "580b2f13c5b746f258cf62392f3f91c293cc0165b99e583870ea2368f2414c52"

URI_aarch64_rust-git2-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2-curl-devel-0.21.0-1.el10_1.noarch.rpm;name=aarch64_rust-git2-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2-curl-devel}"
SRC_URI[aarch64_rust-git2-curl-devel.sha256sum] = "a22d7a5f1da4ca120abf25afefe263aa5befb64c5eff5a13e16ea08c26a06204"

RDEPENDS:rust-git2-curl+default-devel = " \
 cargo \
 rust-git2-curl-devel \
 "
RDEPENDS:rust-git2-curl-devel = " \
 cargo \
 rust-curl+default-devel \
 rust-git2-devel \
 rust-log+default-devel \
 rust-url+default-devel \
 "
