# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4"
PV = "8.4.24"
PR = "2.el10"
PACKAGES = " \
 php8.4 \
 php8.4-bcmath \
 php8.4-cli \
 php8.4-common \
 php8.4-dba \
 php8.4-dbg \
 php8.4-devel \
 php8.4-embedded \
 php8.4-enchant \
 php8.4-ffi \
 php8.4-fpm \
 php8.4-gd \
 php8.4-gmp \
 php8.4-intl \
 php8.4-ldap \
 php8.4-mbstring \
 php8.4-mysqlnd \
 php8.4-odbc \
 php8.4-opcache \
 php8.4-pdo \
 php8.4-pgsql \
 php8.4-process \
 php8.4-snmp \
 php8.4-soap \
 php8.4-xml \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php8.4-8.4.24-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d2e366df3430e4cfd62b74924a3a247e1c30feb7464526cd5545c60ce3629878"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4;unpack=0"
SRC_URI[x86_64_v2_php8.4.sha256sum] = "a9b73ca5a3735af3a10caefb39306441289d9122a987f1b0a2c287184a0f9540"
RPROVIDES:php8.4:append:x86_64_v2 = " virtual/php"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-bcmath-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-bcmath;unpack=0"
SRC_URI[x86_64_v2_php8.4-bcmath.sha256sum] = "4b4aef3e6891b7acbdd7ff23c2809042c844d0699195f7518740baeeccf2f8ec"
RPROVIDES:php8.4-bcmath:append:x86_64_v2 = " virtual/php-bcmath"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-cli-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-cli;unpack=0"
SRC_URI[x86_64_v2_php8.4-cli.sha256sum] = "28572e0f5b266ec6ddeabee9be787752a75772762de14a967d4645bfdf03520f"
RPROVIDES:php8.4-cli:append:x86_64_v2 = " virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-common-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-common;unpack=0"
SRC_URI[x86_64_v2_php8.4-common.sha256sum] = "f71ea472974c45b48b302593abef9eae3db0863faca807f89eed4ee1702aa988"
RPROVIDES:php8.4-common:append:x86_64_v2 = " virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_x86-64_ virtual/php-json virtual/php-json_x86-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_x86-64_ virtual/php-spl virtual/php-spl_x86-64_ virtual/php-tokenizer virtual/php-tokenizer_x86-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-dba-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-dba;unpack=0"
SRC_URI[x86_64_v2_php8.4-dba.sha256sum] = "3c31284b4b14c381fdb956fdef52ee3c66231a8f315bddc3c20e0d18516696cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-dbg-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-dbg;unpack=0"
SRC_URI[x86_64_v2_php8.4-dbg.sha256sum] = "f457de20d2e8726f8dd3327f8e96d0468792a95c0bafe55d5be658aa4a84f519"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-devel-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-devel;unpack=0"
SRC_URI[x86_64_v2_php8.4-devel.sha256sum] = "f67af42a83628524b16519f5e48d42e705ab62f47db2cf1ad648a728cea6c43b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-embedded-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-embedded;unpack=0"
SRC_URI[x86_64_v2_php8.4-embedded.sha256sum] = "71ceca7f72aa16b314f530341ebffbedcc3f620d5228710b1f262916767eb500"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-enchant-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-enchant;unpack=0"
SRC_URI[x86_64_v2_php8.4-enchant.sha256sum] = "b1d40593a6f6fb3dc64d46b2bc38608d816d436aa35d5bfe45a2e6603cfa7c4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-ffi-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-ffi;unpack=0"
SRC_URI[x86_64_v2_php8.4-ffi.sha256sum] = "287f8b302a6a13cc69e0fe81b1124b5158dae19fdb7f971b59902872e1393cbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-fpm-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-fpm;unpack=0"
SRC_URI[x86_64_v2_php8.4-fpm.sha256sum] = "c055a2f274c9e4ae5dc1a42cd690626438145491549dd355cfb608b1cbed4905"
RPROVIDES:php8.4-fpm:append:x86_64_v2 = " virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-gd-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-gd;unpack=0"
SRC_URI[x86_64_v2_php8.4-gd.sha256sum] = "ca9e013fed24bd4d8cfc757c166e3e684f8650329a796cd1e26f5d6d7cc52acc"
RPROVIDES:php8.4-gd:append:x86_64_v2 = " virtual/php-gd virtual/php-gd_x86-64_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-gmp-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-gmp;unpack=0"
SRC_URI[x86_64_v2_php8.4-gmp.sha256sum] = "16061c8c283dd63b4e226fc1b55df8ba33a3e5c50c38830b82aa18476b77cade"
RPROVIDES:php8.4-gmp:append:x86_64_v2 = " virtual/php-gmp"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-intl-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-intl;unpack=0"
SRC_URI[x86_64_v2_php8.4-intl.sha256sum] = "17b8d0013be108387a4ecdf66d86105c2480d688b726c3476dfd07642b8b5709"
RPROVIDES:php8.4-intl:append:x86_64_v2 = " virtual/php-intl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-ldap-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-ldap;unpack=0"
SRC_URI[x86_64_v2_php8.4-ldap.sha256sum] = "ea5c6862aef0df8bdbed3b280af7ab1d0b5fd4c59f850b1277ae9555f0d2b03b"
RPROVIDES:php8.4-ldap:append:x86_64_v2 = " virtual/php-ldap"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-mbstring-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-mbstring;unpack=0"
SRC_URI[x86_64_v2_php8.4-mbstring.sha256sum] = "0cbf8cd3e35536e16eef5ce738559240707b91be207e0472efbf6708adb3d75b"
RPROVIDES:php8.4-mbstring:append:x86_64_v2 = " virtual/php-mbstring"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-mysqlnd-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-mysqlnd;unpack=0"
SRC_URI[x86_64_v2_php8.4-mysqlnd.sha256sum] = "149f5d9fc7d0e2d9fb096d7d11e491c931da7293e7e302b21cff3b9ec6b434ef"
RPROVIDES:php8.4-mysqlnd:append:x86_64_v2 = " virtual/php-mysqli virtual/php-mysqlnd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-odbc-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-odbc;unpack=0"
SRC_URI[x86_64_v2_php8.4-odbc.sha256sum] = "79c21964ccf6f1264b86e2e1522998c2cad647bfafda1d4c1afd29dc7eab7901"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-opcache-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-opcache;unpack=0"
SRC_URI[x86_64_v2_php8.4-opcache.sha256sum] = "99457aed7e58b81f5316b8bdb198aec4134ba202e7e86cc059e2f9f697a10dd1"
RPROVIDES:php8.4-opcache:append:x86_64_v2 = " virtual/php-opcache"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-pdo-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-pdo;unpack=0"
SRC_URI[x86_64_v2_php8.4-pdo.sha256sum] = "a993f182ebecabbf9ff84563a1f3dc3b6451f8d63eb8b82bd1ce26678004d172"
RPROVIDES:php8.4-pdo:append:x86_64_v2 = " virtual/php-pdo virtual/php-sqlite3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-pgsql-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-pgsql;unpack=0"
SRC_URI[x86_64_v2_php8.4-pgsql.sha256sum] = "776e544864fcbdeffbdf8b6b74f86d4b32aaba175232433d14ef48d20e0325af"
RPROVIDES:php8.4-pgsql:append:x86_64_v2 = " virtual/php-pgsql"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-process-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-process;unpack=0"
SRC_URI[x86_64_v2_php8.4-process.sha256sum] = "597fabd5644fcdff6a8c34df62bfce7363495aabdf9c96adf3ec55801f4161fd"
RPROVIDES:php8.4-process:append:x86_64_v2 = " virtual/php-posix virtual/php-process"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-snmp-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-snmp;unpack=0"
SRC_URI[x86_64_v2_php8.4-snmp.sha256sum] = "feaded24cdc25db2445b58cde195a43fe5455b923a61ad599f1eb70079dde65d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-soap-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-soap;unpack=0"
SRC_URI[x86_64_v2_php8.4-soap.sha256sum] = "87cdc5e3d05b06b72d3c68984e14858b8378dfe6139531ac63134e4f8771c2aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-xml-8.4.24-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-xml;unpack=0"
SRC_URI[x86_64_v2_php8.4-xml.sha256sum] = "28ccaed5cdfe90728c255eb9c91b6a2aa0b0db42ef38ab3e45308988b6e87c6e"
RPROVIDES:php8.4-xml:append:x86_64_v2 = " virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4;unpack=0"
SRC_URI[aarch64_php8.4.sha256sum] = "732ec4bcd405d29ec2860b2330003a5fd1640a45babb60496f7b7f6318b88889"
RPROVIDES:php8.4:append:aarch64 = " virtual/php"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-bcmath-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-bcmath;unpack=0"
SRC_URI[aarch64_php8.4-bcmath.sha256sum] = "7659e90085b4280064bf92b2d82e01d80141c8a25c9fff96c7a7546e1c4cf19d"
RPROVIDES:php8.4-bcmath:append:aarch64 = " virtual/php-bcmath"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-cli-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-cli;unpack=0"
SRC_URI[aarch64_php8.4-cli.sha256sum] = "ecbd2509acfc65e8ffd653a7122e60249bc0de7f15169874f8f14a805ba27685"
RPROVIDES:php8.4-cli:append:aarch64 = " virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-common-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-common;unpack=0"
SRC_URI[aarch64_php8.4-common.sha256sum] = "2d15d36a1a87c51295d1963d5bc4f79fe1a78c02cd3244873bd6d5201c128314"
RPROVIDES:php8.4-common:append:aarch64 = " virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_aarch-64_ virtual/php-json virtual/php-json_aarch-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_aarch-64_ virtual/php-spl virtual/php-spl_aarch-64_ virtual/php-tokenizer virtual/php-tokenizer_aarch-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-dba-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-dba;unpack=0"
SRC_URI[aarch64_php8.4-dba.sha256sum] = "535596f3e2e5f1c0ca01bc470c01a655b3c6e02c8e17d6b1ca42e8bc190c0e03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-dbg-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-dbg;unpack=0"
SRC_URI[aarch64_php8.4-dbg.sha256sum] = "8213f4bd6aeb9a7d7e706d08cd16c73fc2b067eeba523cef33b6a82636ada308"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-devel-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-devel;unpack=0"
SRC_URI[aarch64_php8.4-devel.sha256sum] = "3035d96396190e98a33d66707be347d46ac6dd94caa12351aed3ed6dd20b831e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-embedded-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-embedded;unpack=0"
SRC_URI[aarch64_php8.4-embedded.sha256sum] = "ff0c1392aeb58d3bb8106bf344b2aa19c9aa0d70165f9da1200a163a4a823911"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-enchant-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-enchant;unpack=0"
SRC_URI[aarch64_php8.4-enchant.sha256sum] = "d9f1e16bf8d242499f418e251e7e5b7144bdede798c70f07f63974d0b84c2b1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-ffi-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-ffi;unpack=0"
SRC_URI[aarch64_php8.4-ffi.sha256sum] = "ebfda3c8a96bf6cf4e7d2659c927d8a84694515bdc18296a9c7fff7727e86212"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-fpm-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-fpm;unpack=0"
SRC_URI[aarch64_php8.4-fpm.sha256sum] = "7ea723fe0b2d4e8bb39107d1fa58ac306deb4c4eba685e2fab71e627627e0a62"
RPROVIDES:php8.4-fpm:append:aarch64 = " virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-gd-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-gd;unpack=0"
SRC_URI[aarch64_php8.4-gd.sha256sum] = "820b55de3a21b774ad99cf0126ae1fac16ca001d9722095314c6b58a6c50d536"
RPROVIDES:php8.4-gd:append:aarch64 = " virtual/php-gd virtual/php-gd_aarch-64_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-gmp-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-gmp;unpack=0"
SRC_URI[aarch64_php8.4-gmp.sha256sum] = "f516d7c91fea01690c5be40668bb3ee9ec518c81ecf6f804ab033c744f96770d"
RPROVIDES:php8.4-gmp:append:aarch64 = " virtual/php-gmp"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-intl-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-intl;unpack=0"
SRC_URI[aarch64_php8.4-intl.sha256sum] = "bf978c48d008545e80df8b46f9352b0cd5d0cfa6900c5c97afda15f34203e283"
RPROVIDES:php8.4-intl:append:aarch64 = " virtual/php-intl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-ldap-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-ldap;unpack=0"
SRC_URI[aarch64_php8.4-ldap.sha256sum] = "638d5d144d5bede056b989f0ceeac60654cd2a955c7308a22072d9ed4a6570aa"
RPROVIDES:php8.4-ldap:append:aarch64 = " virtual/php-ldap"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-mbstring-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-mbstring;unpack=0"
SRC_URI[aarch64_php8.4-mbstring.sha256sum] = "0b7fe339b38dc23c82617ef8b351979a0ef56ffb57d7e22aa216049bba8e518e"
RPROVIDES:php8.4-mbstring:append:aarch64 = " virtual/php-mbstring"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-mysqlnd-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-mysqlnd;unpack=0"
SRC_URI[aarch64_php8.4-mysqlnd.sha256sum] = "c194a0a08028389bc5a6db984ae2dd3cf7f5b34b8486eb9bd146e4c1aca23250"
RPROVIDES:php8.4-mysqlnd:append:aarch64 = " virtual/php-mysqli virtual/php-mysqlnd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-odbc-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-odbc;unpack=0"
SRC_URI[aarch64_php8.4-odbc.sha256sum] = "0dd4f26bd6ea20ceb01c56c79f87e802df141a0f53ffebd88672c7827c090c8d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-opcache-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-opcache;unpack=0"
SRC_URI[aarch64_php8.4-opcache.sha256sum] = "4e60ff1b7f6001b336a12fd4f482dc1599bb56568bf75504fd98eeb9c837eacc"
RPROVIDES:php8.4-opcache:append:aarch64 = " virtual/php-opcache"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-pdo-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-pdo;unpack=0"
SRC_URI[aarch64_php8.4-pdo.sha256sum] = "4acdea3a4854d382a81297239e4c83544132c676185a91c0a8f4ea70ee8a40b6"
RPROVIDES:php8.4-pdo:append:aarch64 = " virtual/php-pdo virtual/php-sqlite3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-pgsql-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-pgsql;unpack=0"
SRC_URI[aarch64_php8.4-pgsql.sha256sum] = "4c6dbf93deafc82ca13d3679526045d7ee013417532966f4fc4ff31f198a161e"
RPROVIDES:php8.4-pgsql:append:aarch64 = " virtual/php-pgsql"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-process-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-process;unpack=0"
SRC_URI[aarch64_php8.4-process.sha256sum] = "25ee153b8d97c53674ce95c13299a732c4df558f796cbe948edff623e380be64"
RPROVIDES:php8.4-process:append:aarch64 = " virtual/php-posix virtual/php-process"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-snmp-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-snmp;unpack=0"
SRC_URI[aarch64_php8.4-snmp.sha256sum] = "69fffcd9b304cbd62adf62383bb224e5adf00a389313599953c7d4c8910ea347"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-soap-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-soap;unpack=0"
SRC_URI[aarch64_php8.4-soap.sha256sum] = "4b966438892934cc67714b8ad298014c1f0ff21837ff6cfa9798b2332f468530"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-xml-8.4.24-2.el10.aarch64.rpm;name=aarch64_php8.4-xml;unpack=0"
SRC_URI[aarch64_php8.4-xml.sha256sum] = "ec8d0836c994fc9b67383106e2b2d31378c946a7c303fa6cf3cb4479a0ac9053"
RPROVIDES:php8.4-xml:append:aarch64 = " virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

RDEPENDS:php8.4 = " \
 php8.4-common \
 "
RDEPENDS:php8.4-bcmath = " \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-cli = " \
 bash \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php8.4-common \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-common = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 tzdata \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:php8.4-dba = " \
 glibc \
 lmdb-libs \
 php8.4-common \
 tokyocabinet \
 "
RDEPENDS:php8.4-dbg = " \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php8.4-common \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-devel = " \
 autoconf \
 automake \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
 libtool \
 libxml2-devel \
 make \
 openssl-devel \
 pcre2-devel \
 php8.4-cli \
 php8.4-common \
 zlib-ng-compat-devel \
 "
RDEPENDS:php8.4-embedded = " \
 glibc \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php8.4-common \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-enchant = " \
 enchant2 \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-ffi = " \
 glibc \
 libffi \
 php8.4-common \
 "
RDEPENDS:php8.4-fpm = " \
 bash \
 glibc \
 httpd-filesystem \
 libacl \
 libselinux \
 libxcrypt \
 libxml2 \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 php8.4-common \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-gd = " \
 gd \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-gmp = " \
 glibc \
 gmp \
 php8.4-common \
 "
RDEPENDS:php8.4-intl = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 php8.4-common \
 "
RDEPENDS:php8.4-ldap = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 php8.4-common \
 "
RDEPENDS:php8.4-mbstring = " \
 glibc \
 oniguruma \
 php8.4-common \
 "
RDEPENDS:php8.4-mysqlnd = " \
 glibc \
 openssl-libs \
 php8.4-common \
 php8.4-pdo \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-odbc = " \
 glibc \
 php8.4-common \
 php8.4-pdo \
 unixODBC \
 "
RDEPENDS:php8.4-opcache:x86_64_v2 = " \
 capstone \
 glibc \
 libgcc \
 php8.4-common \
"
RDEPENDS:php8.4-opcache:aarch64 = " \
 capstone \
 glibc \
 php8.4-common \
"
RDEPENDS:php8.4-pdo = " \
 glibc \
 php8.4-common \
 sqlite-libs \
 "
RDEPENDS:php8.4-pgsql = " \
 glibc \
 libpq \
 php8.4-common \
 php8.4-pdo \
 "
RDEPENDS:php8.4-process = " \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-snmp = " \
 glibc \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php8.4-common \
 "
RDEPENDS:php8.4-soap = " \
 glibc \
 libxml2 \
 php8.4-common \
 "
RDEPENDS:php8.4-xml = " \
 glibc \
 libxml2 \
 libxslt \
 php8.4-common \
 "
