# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-meson"
PV = "0.5.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-meson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-meson-0.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9003f8958736285f08c4374e727780e513db7addbad567398efbe2658e2a94b"

URI_x86_64_v2_python3-colcon-meson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-meson-0.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-meson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-meson}"
SRC_URI[x86_64_v2_python3-colcon-meson.sha256sum] = "e50557d0b6200329efed995b77b12c55bc2b9ad0c27d5f86f1af9c6c3717527e"

URI_aarch64_python3-colcon-meson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-meson-0.5.0-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-meson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-meson}"
SRC_URI[aarch64_python3-colcon-meson.sha256sum] = "bcb267107660fa21ccbbf75dff41ccd29b25335c98610e84a47b6460c4e44934"

RDEPENDS:python3-colcon-meson = " \
 meson \
 python3 \
 python3-colcon-core \
 python3-colcon-library-path \
 "
