# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Geo-Distance"
PV = "0.25"
PR = "14.el10_0"
PACKAGES = " \
 perl-Geo-Distance \
 perl-Geo-Distance-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Geo-Distance-0.25-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd658b65455695c5e0e8ff1632b93449b962b936d186566a84e58a070d3438b8"

URI_x86_64_v2_perl-Geo-Distance = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Geo-Distance-0.25-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Geo-Distance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Geo-Distance}"
SRC_URI[x86_64_v2_perl-Geo-Distance.sha256sum] = "7eeaa50a5e357a923673324c7f0d498f38a30015bfdb04c4f62e7a77ba62a92a"

URI_x86_64_v2_perl-Geo-Distance-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Geo-Distance-tests-0.25-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Geo-Distance-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Geo-Distance-tests}"
SRC_URI[x86_64_v2_perl-Geo-Distance-tests.sha256sum] = "a161914032fccf6a9e4a6a7b512fc25b4f9e4d216815298aecdd8e49efe95df8"

URI_aarch64_perl-Geo-Distance = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Geo-Distance-0.25-14.el10_0.noarch.rpm;name=aarch64_perl-Geo-Distance;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Geo-Distance}"
SRC_URI[aarch64_perl-Geo-Distance.sha256sum] = "95110357e16306e5a2c266566fb3912e5f2c6169eff46a3febcc09d660dcadbe"

URI_aarch64_perl-Geo-Distance-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Geo-Distance-tests-0.25-14.el10_0.noarch.rpm;name=aarch64_perl-Geo-Distance-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Geo-Distance-tests}"
SRC_URI[aarch64_perl-Geo-Distance-tests.sha256sum] = "534c810365839f349e6ab34957db7ae63eec9965191cfb3d873135024acd7574"

RDEPENDS:perl-Geo-Distance = " \
 perl-Carp \
 perl-Const-Fast \
 perl-GIS-Distance \
 perl-Math-Complex \
 perl-libs \
 "
RDEPENDS:perl-Geo-Distance-tests = " \
 bash \
 perl-DBD-SQLite \
 perl-GIS-Distance \
 perl-Geo-Distance \
 perl-Math-Complex \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-interpreter \
 perl-libs \
 "
