# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debmirror"
PV = "2.47"
PR = "2.el10_0"
PACKAGES = " \
 debmirror \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debmirror-2.47-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea88c7a39eca34e7eefc272c8b3761aa6d97cfcf9b10b32a8f465e40eb70f5ec"

URI_x86_64_v2_debmirror = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debmirror-2.47-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_debmirror;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debmirror}"
SRC_URI[x86_64_v2_debmirror.sha256sum] = "e0caaca7289ac7fbd5d9384d3ce703d283506e0faab1cd95be09442f95789f2f"

URI_aarch64_debmirror = "${EPEL_MIRROR}/aarch64/Packages/d/debmirror-2.47-2.el10_0.noarch.rpm;name=aarch64_debmirror;unpack=0"
SRC_URI:append = " ${URI_aarch64_debmirror}"
SRC_URI[aarch64_debmirror.sha256sum] = "7d7bd27fad36a523e36991043e4363998921ce88e51cf325d44f3022c7c720ac"

RDEPENDS:debmirror = " \
 bzip2 \
 ed \
 findutils \
 gnupg2 \
 gzip \
 patch \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Fcntl \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Compress \
 perl-LockFile-Simple \
 perl-MIME-Base64 \
 perl-PathTools \
 perl-Storable \
 perl-URI \
 perl-if \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 rsync \
 virtual/coreutils \
 "
