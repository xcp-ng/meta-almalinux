# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bpaf"
PV = "0.9.24"
PR = "1.el10_3"
PACKAGES = " \
 rust-bpaf+autocomplete-devel \
 rust-bpaf+batteries-devel \
 rust-bpaf+bpaf_derive-devel \
 rust-bpaf+bright-color-devel \
 rust-bpaf+color-devel \
 rust-bpaf+default-devel \
 rust-bpaf+derive-devel \
 rust-bpaf+docgen-devel \
 rust-bpaf+dull-color-devel \
 rust-bpaf+extradocs-devel \
 rust-bpaf+owo-colors-devel \
 rust-bpaf+supports-color-devel \
 rust-bpaf+unstable-docs-devel \
 rust-bpaf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bpaf-0.9.24-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d27808a8ec504204f17f88a99673f0527815e6649b45fb2a1894cd94b0be0df4"

URI_x86_64_v2_rust-bpaf+autocomplete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+autocomplete-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+autocomplete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+autocomplete-devel}"
SRC_URI[x86_64_v2_rust-bpaf+autocomplete-devel.sha256sum] = "e944b375e7bdbfcd1beae3a383a2e67a95d1b3a8ec1c460fd552a8a5322605f2"

URI_x86_64_v2_rust-bpaf+batteries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+batteries-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+batteries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+batteries-devel}"
SRC_URI[x86_64_v2_rust-bpaf+batteries-devel.sha256sum] = "fff80e6d22606ec21360f886dd22ca0b57d7872f3399fe1cd82e24352fb52f4a"

URI_x86_64_v2_rust-bpaf+bpaf_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+bpaf_derive-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+bpaf_derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf+bpaf_derive-devel.sha256sum] = "775a54b0ffebca9deacf985707d61a13531d4cff4ee8b7b86d04fba51284b783"

URI_x86_64_v2_rust-bpaf+bright-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+bright-color-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+bright-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+bright-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+bright-color-devel.sha256sum] = "fa5f550bcfbb53fb9f727fb090e8caa074bd89719e4049cc82b686907751ba53"

URI_x86_64_v2_rust-bpaf+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+color-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+color-devel.sha256sum] = "dea94d2cf1d84c741fc8a7fbde77ababe7071ccf2b4735bf9c04d0062b298562"

URI_x86_64_v2_rust-bpaf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+default-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+default-devel}"
SRC_URI[x86_64_v2_rust-bpaf+default-devel.sha256sum] = "eca198f9154c3d539fb1122a2db1884f624903582a4069754e8b43027e0b525c"

URI_x86_64_v2_rust-bpaf+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+derive-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf+derive-devel.sha256sum] = "fd09bba3d950b99fb2d8760d798af475474ef4dd2d240efde7db711d59efa733"

URI_x86_64_v2_rust-bpaf+docgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+docgen-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+docgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+docgen-devel}"
SRC_URI[x86_64_v2_rust-bpaf+docgen-devel.sha256sum] = "9066babbac3489e03ed8e0568794e4ce07b7c78896c4c99438d09b2a1fbe03fd"

URI_x86_64_v2_rust-bpaf+dull-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+dull-color-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+dull-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+dull-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+dull-color-devel.sha256sum] = "c08adcb88ac236e9b84b0f6704ca30e59ae6aab2da16af6e6d154fe56cb2e187"

URI_x86_64_v2_rust-bpaf+extradocs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+extradocs-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+extradocs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+extradocs-devel}"
SRC_URI[x86_64_v2_rust-bpaf+extradocs-devel.sha256sum] = "4c2986aaf0870721b67bd9d6c2848cdedfb92958c724d0e86c58698bbf135bf6"

URI_x86_64_v2_rust-bpaf+owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+owo-colors-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+owo-colors-devel}"
SRC_URI[x86_64_v2_rust-bpaf+owo-colors-devel.sha256sum] = "87eeb124d1821c67c46faaab9eecfeb1cb47b5d702aca5180edd22a3d9510d43"

URI_x86_64_v2_rust-bpaf+supports-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+supports-color-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+supports-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+supports-color-devel.sha256sum] = "621286ce253411b4c6061ce107556ea23fca75576c368c81fe15fa6560588049"

URI_x86_64_v2_rust-bpaf+unstable-docs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+unstable-docs-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+unstable-docs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+unstable-docs-devel}"
SRC_URI[x86_64_v2_rust-bpaf+unstable-docs-devel.sha256sum] = "e2ad12c2ebece165ba123856c62a38b40a879b6bc3803f48e3ff337ae843344f"

URI_x86_64_v2_rust-bpaf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf-devel-0.9.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf-devel}"
SRC_URI[x86_64_v2_rust-bpaf-devel.sha256sum] = "14435da447e9b5471783ec4af7206bed3b264298d04de4f5f9cfb2eaa82fdb06"

URI_aarch64_rust-bpaf+autocomplete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+autocomplete-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+autocomplete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+autocomplete-devel}"
SRC_URI[aarch64_rust-bpaf+autocomplete-devel.sha256sum] = "8bd076846c12ccc81342dce5ff62f89e72b270b6e0866e4b3f340fe06e98cf86"

URI_aarch64_rust-bpaf+batteries-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+batteries-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+batteries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+batteries-devel}"
SRC_URI[aarch64_rust-bpaf+batteries-devel.sha256sum] = "9d609420990396380066ae45aaa94238700b6f1a4f111dd9a2dae02d7fa7ee8a"

URI_aarch64_rust-bpaf+bpaf_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+bpaf_derive-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+bpaf_derive-devel}"
SRC_URI[aarch64_rust-bpaf+bpaf_derive-devel.sha256sum] = "b9208876dcd8663f4539ac9c313284a7893035b4e9c05b78169be5fcb8075530"

URI_aarch64_rust-bpaf+bright-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+bright-color-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+bright-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+bright-color-devel}"
SRC_URI[aarch64_rust-bpaf+bright-color-devel.sha256sum] = "a76d89f4fc92e4762d3982eacc472f467654d3898dff09a54d27a3b371c66971"

URI_aarch64_rust-bpaf+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+color-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+color-devel}"
SRC_URI[aarch64_rust-bpaf+color-devel.sha256sum] = "d787cf2793e1cbafeed7d7d0473661a4630eb63efad2a69274c4b52f99cd0e90"

URI_aarch64_rust-bpaf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+default-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+default-devel}"
SRC_URI[aarch64_rust-bpaf+default-devel.sha256sum] = "41b3e5aa2e46bb1329a24ab556060a6f123f99ce51db5f9806dde00a89832d93"

URI_aarch64_rust-bpaf+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+derive-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+derive-devel}"
SRC_URI[aarch64_rust-bpaf+derive-devel.sha256sum] = "b7491287ff98f6850689f79c50940dbaeb0d40ef57ef00a8ee579e0da717316c"

URI_aarch64_rust-bpaf+docgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+docgen-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+docgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+docgen-devel}"
SRC_URI[aarch64_rust-bpaf+docgen-devel.sha256sum] = "ba303f590a5637a7cf6a547c2aeaac717b70788199f1564ea431c50306d7d751"

URI_aarch64_rust-bpaf+dull-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+dull-color-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+dull-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+dull-color-devel}"
SRC_URI[aarch64_rust-bpaf+dull-color-devel.sha256sum] = "d1aea5fca91a993445c86921aa9a7ab38a477e0c213fd0149785901e8d03540e"

URI_aarch64_rust-bpaf+extradocs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+extradocs-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+extradocs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+extradocs-devel}"
SRC_URI[aarch64_rust-bpaf+extradocs-devel.sha256sum] = "761338ba6b4238de38ec89f03242bb3118b7066789f07032d01d01a67b2936ca"

URI_aarch64_rust-bpaf+owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+owo-colors-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+owo-colors-devel}"
SRC_URI[aarch64_rust-bpaf+owo-colors-devel.sha256sum] = "6004766a4d260cbdc75a66574fbc5b9082dd0e6a42a9f19f334a3dd78b7231bd"

URI_aarch64_rust-bpaf+supports-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+supports-color-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+supports-color-devel}"
SRC_URI[aarch64_rust-bpaf+supports-color-devel.sha256sum] = "f6dc1954f150fb0ce033702e763f711a148e1e84f1a8d62adfd685bd80111427"

URI_aarch64_rust-bpaf+unstable-docs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+unstable-docs-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf+unstable-docs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+unstable-docs-devel}"
SRC_URI[aarch64_rust-bpaf+unstable-docs-devel.sha256sum] = "bcd1a35ee18f9d6ee94deda6040b1c4a3774a237f9af51144adff586a8e54d55"

URI_aarch64_rust-bpaf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf-devel-0.9.24-1.el10_3.noarch.rpm;name=aarch64_rust-bpaf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf-devel}"
SRC_URI[aarch64_rust-bpaf-devel.sha256sum] = "9e99b819ec196c8b756ffcfcf93d3b569f488183c28e4eef15fa1eb12cccb26e"

RDEPENDS:rust-bpaf+autocomplete-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+batteries-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+bpaf_derive-devel = " \
 cargo \
 rust-bpaf-devel \
 rust-bpaf_derive+default-devel \
 "
RDEPENDS:rust-bpaf+bright-color-devel = " \
 cargo \
 rust-bpaf+color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+color-devel = " \
 cargo \
 rust-bpaf+owo-colors-devel \
 rust-bpaf+supports-color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+default-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+derive-devel = " \
 cargo \
 rust-bpaf+bpaf_derive-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+docgen-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+dull-color-devel = " \
 cargo \
 rust-bpaf+color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+extradocs-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+owo-colors-devel = " \
 cargo \
 rust-bpaf-devel \
 virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~ \
 "
RDEPENDS:rust-bpaf+supports-color-devel = " \
 cargo \
 rust-bpaf-devel \
 virtual/crate_supports-color/default__ge_2.0.0_with_crate_supports-color/default__lt_4.0.0~ \
 "
RDEPENDS:rust-bpaf+unstable-docs-devel = " \
 cargo \
 rust-bpaf+autocomplete-devel \
 rust-bpaf+batteries-devel \
 rust-bpaf+derive-devel \
 rust-bpaf+docgen-devel \
 rust-bpaf+extradocs-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf-devel = " \
 cargo \
 rust \
 "
