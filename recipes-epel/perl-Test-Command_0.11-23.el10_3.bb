# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Command"
PV = "0.11"
PR = "23.el10_3"
PACKAGES = " \
 perl-Test-Command \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-Command-0.11-23.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b25b9dc857bf0f6260b9fa54c8e50f220a70e47f7b3f7fe263f4498f22f00340"

URI_x86_64_v2_perl-Test-Command = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Command-0.11-23.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Command}"
SRC_URI[x86_64_v2_perl-Test-Command.sha256sum] = "526b68e709a510659468d8a0058834133f2530b946a3b7605ff4bb5828fe824a"

URI_aarch64_perl-Test-Command = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Command-0.11-23.el10_3.noarch.rpm;name=aarch64_perl-Test-Command;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Command}"
SRC_URI[aarch64_perl-Test-Command.sha256sum] = "6741f0bb203d194f143ec6211bc70e7ef9cae30229aa3c5edb6b0c60dff8da3c"

RDEPENDS:perl-Test-Command = " \
 perl-Carp \
 perl-File-Temp \
 perl-Test-Simple \
 perl-base \
 perl-libs \
 "
