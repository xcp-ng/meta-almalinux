# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "metis"
PV = "5.1.0.3"
PR = "8.el10_1"
PACKAGES = " \
 metis \
 metis-devel \
 metis64 \
 metis64-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/metis-5.1.0.3-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bc9adbadf9e9980481281e9d12c12a8a33f37b4f219151d80837283d57a27f9"

URI_x86_64_v2_metis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/metis-5.1.0.3-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_metis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_metis}"
SRC_URI[x86_64_v2_metis.sha256sum] = "66b1b65995531c5c88736a427677da03e50976e9b150ad85629b457d8b3b63fc"

URI_x86_64_v2_metis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/metis-devel-5.1.0.3-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_metis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_metis-devel}"
SRC_URI[x86_64_v2_metis-devel.sha256sum] = "8741a12f241305a00bd9ef8de593d4f355610f45d637ac7d4a599a30c78484e7"

URI_x86_64_v2_metis64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/metis64-5.1.0.3-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_metis64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_metis64}"
SRC_URI[x86_64_v2_metis64.sha256sum] = "c2957c61f84f69ac1d1be1314845befb55138e8d6c9eb541640868b0a63b7931"

URI_x86_64_v2_metis64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/metis64-devel-5.1.0.3-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_metis64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_metis64-devel}"
SRC_URI[x86_64_v2_metis64-devel.sha256sum] = "e90e7f03210249bbe5a770b498954289fc186566931a7d66f877693502b312e2"

URI_aarch64_metis = "${EPEL_MIRROR}/aarch64/Packages/m/metis-5.1.0.3-8.el10_1.aarch64.rpm;name=aarch64_metis;unpack=0"
SRC_URI:append = " ${URI_aarch64_metis}"
SRC_URI[aarch64_metis.sha256sum] = "933fad931185053215266efbf226cab4ab8961fb4200b68a4da4d77efe721761"

URI_aarch64_metis-devel = "${EPEL_MIRROR}/aarch64/Packages/m/metis-devel-5.1.0.3-8.el10_1.aarch64.rpm;name=aarch64_metis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_metis-devel}"
SRC_URI[aarch64_metis-devel.sha256sum] = "e4d84395a8d94b166b69529c4e277a7194413f541cfed72f95b33dc3e9f9f63a"

URI_aarch64_metis64 = "${EPEL_MIRROR}/aarch64/Packages/m/metis64-5.1.0.3-8.el10_1.aarch64.rpm;name=aarch64_metis64;unpack=0"
SRC_URI:append = " ${URI_aarch64_metis64}"
SRC_URI[aarch64_metis64.sha256sum] = "a62c540e93cbfeeedb89b0412f44f5d37970407467d8fb4523b40c0cc0e9f5e3"

URI_aarch64_metis64-devel = "${EPEL_MIRROR}/aarch64/Packages/m/metis64-devel-5.1.0.3-8.el10_1.aarch64.rpm;name=aarch64_metis64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_metis64-devel}"
SRC_URI[aarch64_metis64-devel.sha256sum] = "b892b8672e0eb583584abf27d27b167250fc226b017f2c6647a8d82cfc587c40"

RDEPENDS:metis = " \
 glibc \
 libgcc \
 libgomp \
 pcre2 \
 "
RDEPENDS:metis-devel = " \
 metis \
 "
RDEPENDS:metis64 = " \
 glibc \
 libgcc \
 libgomp \
 pcre2 \
 "
RDEPENDS:metis64-devel = " \
 metis64 \
 "
