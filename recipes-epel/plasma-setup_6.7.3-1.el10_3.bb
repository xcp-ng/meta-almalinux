# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-setup"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-setup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-setup-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c16b21d920e5f9ea009b765aabbb808d1501a36178ef7ff4bb5b1161855646b"

URI_x86_64_v2_plasma-setup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-setup-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-setup}"
SRC_URI[x86_64_v2_plasma-setup.sha256sum] = "5b8e4a0f61fd1ce743b882e87332a792c03ce30cc23febc354d6f4ee4c645bfe"

URI_aarch64_plasma-setup = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-setup-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-setup}"
SRC_URI[aarch64_plasma-setup.sha256sum] = "723b4fbd7e7ba689ccca268317780fec94af5b7ad6d9ccc3d351349cacebe7a9"

RDEPENDS:plasma-setup = " \
 bash \
 dbus-common \
 glibc \
 kf6-filesystem \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libstdc++ \
 plasma-desktop \
 plasma-lookandfeel-fedora \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 virtual/system-backgrounds-kde \
 "
