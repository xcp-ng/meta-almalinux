# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foldhash"
PV = "0.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-foldhash+default-devel \
 rust-foldhash+std-devel \
 rust-foldhash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foldhash-0.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb43afa17978b940b539252fbcf7ea67e5cd00ece137f13c6873287cbee4c5a7"

URI_x86_64_v2_rust-foldhash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash+default-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash+default-devel}"
SRC_URI[x86_64_v2_rust-foldhash+default-devel.sha256sum] = "877ca8ce2274230101ac7177c5422f771c0849ecc83dedd8c7e9cfeedc4f748b"

URI_x86_64_v2_rust-foldhash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash+std-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash+std-devel}"
SRC_URI[x86_64_v2_rust-foldhash+std-devel.sha256sum] = "4a5952a718295631603c7eb123cacc9e209d5907ce1b67915ed099b6516808a0"

URI_x86_64_v2_rust-foldhash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash-devel}"
SRC_URI[x86_64_v2_rust-foldhash-devel.sha256sum] = "7e5f84d30b794807c1c697796ec868c1827107c9af7718feb306b0f832b7fd45"

URI_aarch64_rust-foldhash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash+default-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-foldhash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash+default-devel}"
SRC_URI[aarch64_rust-foldhash+default-devel.sha256sum] = "2d31a94e7dee5986168eaff48c56507d6473effcedf743e024f89a4f19277857"

URI_aarch64_rust-foldhash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash+std-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-foldhash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash+std-devel}"
SRC_URI[aarch64_rust-foldhash+std-devel.sha256sum] = "4e5f8f1c637a29bca1e896003e17b86a09e30e1e5a57d64574ae1e97099e397d"

URI_aarch64_rust-foldhash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-foldhash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash-devel}"
SRC_URI[aarch64_rust-foldhash-devel.sha256sum] = "6990d28bcde85df0cbb11b4b948c5c45b0c5c9c7e9dd6a562909fbba5066f448"

RDEPENDS:rust-foldhash+default-devel = " \
 cargo \
 rust-foldhash+std-devel \
 rust-foldhash-devel \
 "
RDEPENDS:rust-foldhash+std-devel = " \
 cargo \
 rust-foldhash-devel \
 "
RDEPENDS:rust-foldhash-devel = " \
 cargo \
 rust \
 "
