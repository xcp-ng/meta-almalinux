# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-karchive"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-karchive \
 kf6-karchive-devel \
 kf6-karchive-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-karchive-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7dcfb7a7b2b40c66e1c343272bc6b20c50e83bcbe6153c5df22a905d15cf61dc"

URI_x86_64_v2_kf6-karchive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive}"
SRC_URI[x86_64_v2_kf6-karchive.sha256sum] = "3cb74cbc0f38b1d0bf85e290e2c60a604e4160ccfb341cf1cc10a57cb3605b39"

URI_x86_64_v2_kf6-karchive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-devel}"
SRC_URI[x86_64_v2_kf6-karchive-devel.sha256sum] = "16f14cd15af54535544bc0d2fa6682b32628b2bbf8d4bf407d92b059a9b10f70"

URI_x86_64_v2_kf6-karchive-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-karchive-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-doc}"
SRC_URI[x86_64_v2_kf6-karchive-doc.sha256sum] = "8b315d27dd5f2c7b2efa4f8a3bb9453c98d6309e7790b58136c629db9c0772b0"

URI_aarch64_kf6-karchive = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-karchive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive}"
SRC_URI[aarch64_kf6-karchive.sha256sum] = "6d8e57a75762d74d732e296ca54ead829bf2686851cae98e6fb9253f274683df"

URI_aarch64_kf6-karchive-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-karchive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-devel}"
SRC_URI[aarch64_kf6-karchive-devel.sha256sum] = "af3cf0e217813099516968cfa521058860c4c4451daa30fd6db5c3a6d2f5ea61"

URI_aarch64_kf6-karchive-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-karchive-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-doc}"
SRC_URI[aarch64_kf6-karchive-doc.sha256sum] = "395be7dafd6c4829e0afef23d05626d4d20cde33af4606d6e8231b989560331a"

RDEPENDS:kf6-karchive = " \
 bzip2-libs \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libzstd \
 qt6-qtbase \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:kf6-karchive-devel = " \
 cmake-filesystem \
 kf6-karchive \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-karchive-doc = " \
 "
