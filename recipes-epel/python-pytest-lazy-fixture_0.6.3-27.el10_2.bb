# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-lazy-fixture"
PV = "0.6.3"
PR = "27.el10_2"
PACKAGES = " \
 python3-pytest-lazy-fixture \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-lazy-fixture-0.6.3-27.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9e510793630d540bd11f86c9d2f1e74614d6b9fc02de4c9645bc7873aef5215"

URI_x86_64_v2_python3-pytest-lazy-fixture = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-lazy-fixture-0.6.3-27.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-lazy-fixture;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-lazy-fixture}"
SRC_URI[x86_64_v2_python3-pytest-lazy-fixture.sha256sum] = "dd04344dc48d9207709fc4e45fb380fa75eee8e26bf2c9a50bd363245613a514"

URI_aarch64_python3-pytest-lazy-fixture = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-lazy-fixture-0.6.3-27.el10_2.noarch.rpm;name=aarch64_python3-pytest-lazy-fixture;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-lazy-fixture}"
SRC_URI[aarch64_python3-pytest-lazy-fixture.sha256sum] = "0579c154fc3be75e6e430dde51d9c53e7d660c51753a0cba5a6a29ac5cdbf915"

RDEPENDS:python3-pytest-lazy-fixture = " \
 python3 \
 python3-pytest \
 "
