# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Context-Preserve"
PV = "0.03"
PR = "25.el10_2"
PACKAGES = " \
 perl-Context-Preserve \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Context-Preserve-0.03-25.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20d0e6bb486df23a265583d80a802bc420d0521ff3fa1cebe438a5e84c45e3a1"

URI_x86_64_v2_perl-Context-Preserve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Context-Preserve-0.03-25.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Context-Preserve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Context-Preserve}"
SRC_URI[x86_64_v2_perl-Context-Preserve.sha256sum] = "4e559b1b83e17c09c57c503b5505db63ce21b6e46ac6557a45492b4b13a8894c"

URI_aarch64_perl-Context-Preserve = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Context-Preserve-0.03-25.el10_2.noarch.rpm;name=aarch64_perl-Context-Preserve;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Context-Preserve}"
SRC_URI[aarch64_perl-Context-Preserve.sha256sum] = "16c756485613660986420fc8ea5fda17b8a6023fcc0839a9f8ed7009982baa22"

RDEPENDS:perl-Context-Preserve = " \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-libs \
 "
