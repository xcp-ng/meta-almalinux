# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-BrowserDetect"
PV = "3.40"
PR = "4.el10_0"
PACKAGES = " \
 perl-HTTP-BrowserDetect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-BrowserDetect-3.40-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8b488e1c4b8e86d3f451a32620e14555c63f97ed54a0e166f19656940495723"

URI_x86_64_v2_perl-HTTP-BrowserDetect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-BrowserDetect-3.40-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-BrowserDetect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-BrowserDetect}"
SRC_URI[x86_64_v2_perl-HTTP-BrowserDetect.sha256sum] = "bb35a26cc3d1bd5ca86c7be10738881a1edbfb475608351fa22bf84365e4804e"

URI_aarch64_perl-HTTP-BrowserDetect = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-BrowserDetect-3.40-4.el10_0.noarch.rpm;name=aarch64_perl-HTTP-BrowserDetect;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-BrowserDetect}"
SRC_URI[aarch64_perl-HTTP-BrowserDetect.sha256sum] = "e9ef25da3ce4a4fca223e5f2c974490144e35fa5466049b0e1ea771246b1d617"

RDEPENDS:perl-HTTP-BrowserDetect = " \
 perl-libs \
 "
