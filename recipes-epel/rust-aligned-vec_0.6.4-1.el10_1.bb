# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aligned-vec"
PV = "0.6.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-aligned-vec+default-devel \
 rust-aligned-vec+serde-devel \
 rust-aligned-vec+std-devel \
 rust-aligned-vec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aligned-vec-0.6.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76bed66f592a3a962de4be9bde2bbb571df0e9e6617f12aa8e9354904f927122"

URI_x86_64_v2_rust-aligned-vec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec+default-devel-0.6.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec+default-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec+default-devel.sha256sum] = "07affbdbfe3e8cdde640075819ee5aa314a42b3dc051e5154a43a560002449e5"

URI_x86_64_v2_rust-aligned-vec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec+serde-devel-0.6.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec+serde-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec+serde-devel.sha256sum] = "cf10eb8264012cac02cf7c44466d87dacd001ac45415172063148536b9478d1f"

URI_x86_64_v2_rust-aligned-vec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec+std-devel-0.6.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec+std-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec+std-devel.sha256sum] = "f389ac6089e7ed6f55f1efad64fadeace7be3a39694b741494412909eb2ffcea"

URI_x86_64_v2_rust-aligned-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec-devel-0.6.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec-devel.sha256sum] = "4a4c00afde9e2ab1ec41a8ee5cd2fb5242ad1498266642bcdcedd9dd0e5c38b3"

URI_aarch64_rust-aligned-vec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec+default-devel-0.6.4-1.el10_1.noarch.rpm;name=aarch64_rust-aligned-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec+default-devel}"
SRC_URI[aarch64_rust-aligned-vec+default-devel.sha256sum] = "5eb1d73273bf41292628a1d80b21e559b084d776eb964ab6e872f97cc5c1dcd0"

URI_aarch64_rust-aligned-vec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec+serde-devel-0.6.4-1.el10_1.noarch.rpm;name=aarch64_rust-aligned-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec+serde-devel}"
SRC_URI[aarch64_rust-aligned-vec+serde-devel.sha256sum] = "cd40f05500eccf978bd32a2661638108a4d0dd6658b25236752cb9bf0ba1c8c5"

URI_aarch64_rust-aligned-vec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec+std-devel-0.6.4-1.el10_1.noarch.rpm;name=aarch64_rust-aligned-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec+std-devel}"
SRC_URI[aarch64_rust-aligned-vec+std-devel.sha256sum] = "47eda7a9519eb5ba19d08668192ff8e62378e2e0f7d8bbb4af09250da7aa50ed"

URI_aarch64_rust-aligned-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec-devel-0.6.4-1.el10_1.noarch.rpm;name=aarch64_rust-aligned-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec-devel}"
SRC_URI[aarch64_rust-aligned-vec-devel.sha256sum] = "8f32062259defd5bd7a4a8a8abe5bf8d4e89854bb2e0d4f4d58f0e59cecceabe"

RDEPENDS:rust-aligned-vec+default-devel = " \
 cargo \
 rust-aligned-vec+std-devel \
 rust-aligned-vec-devel \
 "
RDEPENDS:rust-aligned-vec+serde-devel = " \
 cargo \
 rust-aligned-vec-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-aligned-vec+std-devel = " \
 cargo \
 rust-aligned-vec-devel \
 "
RDEPENDS:rust-aligned-vec-devel = " \
 cargo \
 rust-equator+default-devel \
 "
