# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_edit"
PV = "0.22.27"
PR = "1.el10_0"
PACKAGES = " \
 rust-toml_edit+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit+perf-devel \
 rust-toml_edit+serde-devel \
 rust-toml_edit+unbounded-devel \
 rust-toml_edit+unstable-debug-devel \
 rust-toml_edit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_edit-0.22.27-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33dfd90f1e2b44e3335cc3b9adaf83a0cecde74d4f65d22450d59a91ca7817e1"

URI_x86_64_v2_rust-toml_edit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+default-devel-0.22.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+default-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+default-devel.sha256sum] = "985f7f930d93648f33521cc891585268dafe26a6deaa9461ab35810df94d219a"

URI_x86_64_v2_rust-toml_edit+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+display-devel-0.22.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+display-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+display-devel.sha256sum] = "1a59fa89b76ec67935271465e226e3e35a3c4d3be0d75bb6f31e19393dc6397d"

URI_x86_64_v2_rust-toml_edit+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+parse-devel-0.22.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+parse-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+parse-devel.sha256sum] = "d711dba98227446ab88f7e3aff2c3fd7eb605ff7839e906f8f2846aaf50e97fc"

URI_x86_64_v2_rust-toml_edit+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+perf-devel-0.22.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+perf-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+perf-devel.sha256sum] = "738dfaabde49c3fe0d9cf84e35ac2d6861a67e2570f33ee84fa2d054aa561be2"

URI_x86_64_v2_rust-toml_edit+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+serde-devel-0.22.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+serde-devel.sha256sum] = "14ef94c3412f0758118ac3aaba1c3161f75205497c459df003ef260eebf9ec2b"

URI_x86_64_v2_rust-toml_edit+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+unbounded-devel-0.22.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+unbounded-devel.sha256sum] = "6c8f639dbd050df1d6351e94920bdf9cd591b78f2ac813c10c22a18e830717be"

URI_x86_64_v2_rust-toml_edit+unstable-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+unstable-debug-devel-0.22.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+unstable-debug-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+unstable-debug-devel.sha256sum] = "60ee1bbf35aba80b3deb53e9c04c07a7fa9bef3e03559b9fdaaec719c9ef651d"

URI_x86_64_v2_rust-toml_edit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit-devel-0.22.27-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit-devel}"
SRC_URI[x86_64_v2_rust-toml_edit-devel.sha256sum] = "18fa11b3d3fc71c5697d1c90fb977acc5df09392fc42ca86c5ba4f038f06ac66"

URI_aarch64_rust-toml_edit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+default-devel-0.22.27-1.el10_0.noarch.rpm;name=aarch64_rust-toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+default-devel}"
SRC_URI[aarch64_rust-toml_edit+default-devel.sha256sum] = "f5643202793ee5dbdbd61e964adfe074741dadedf641283c3765240509c38c1c"

URI_aarch64_rust-toml_edit+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+display-devel-0.22.27-1.el10_0.noarch.rpm;name=aarch64_rust-toml_edit+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+display-devel}"
SRC_URI[aarch64_rust-toml_edit+display-devel.sha256sum] = "a02353d9d9315ed20b20cfbfb64b726d25d572b1c71a6b295887c8a1b6311f28"

URI_aarch64_rust-toml_edit+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+parse-devel-0.22.27-1.el10_0.noarch.rpm;name=aarch64_rust-toml_edit+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+parse-devel}"
SRC_URI[aarch64_rust-toml_edit+parse-devel.sha256sum] = "331cceef2218ba28900d983b500f51840f4a725b0087633d340256cb3adf9691"

URI_aarch64_rust-toml_edit+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+perf-devel-0.22.27-1.el10_0.noarch.rpm;name=aarch64_rust-toml_edit+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+perf-devel}"
SRC_URI[aarch64_rust-toml_edit+perf-devel.sha256sum] = "51d6a9c153dabf2a60e631ce5cc19bf70f286b51365e8f08a6c8a681ab4460fe"

URI_aarch64_rust-toml_edit+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+serde-devel-0.22.27-1.el10_0.noarch.rpm;name=aarch64_rust-toml_edit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+serde-devel}"
SRC_URI[aarch64_rust-toml_edit+serde-devel.sha256sum] = "21f1a13557c07c6f231318b738a5a1d3988ba4ec0dc23cc560a714e92c55d73e"

URI_aarch64_rust-toml_edit+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+unbounded-devel-0.22.27-1.el10_0.noarch.rpm;name=aarch64_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+unbounded-devel}"
SRC_URI[aarch64_rust-toml_edit+unbounded-devel.sha256sum] = "8bb029c7f3c6646e134bc1594ee1fde1ebde242cc391f97ee0707077f891e614"

URI_aarch64_rust-toml_edit+unstable-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+unstable-debug-devel-0.22.27-1.el10_0.noarch.rpm;name=aarch64_rust-toml_edit+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+unstable-debug-devel}"
SRC_URI[aarch64_rust-toml_edit+unstable-debug-devel.sha256sum] = "a984292c871eb3fd52dc667c301bed3ab0de526c372c36a056e80ea91b21b3ed"

URI_aarch64_rust-toml_edit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit-devel-0.22.27-1.el10_0.noarch.rpm;name=aarch64_rust-toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit-devel}"
SRC_URI[aarch64_rust-toml_edit-devel.sha256sum] = "b09f3a4fdd9a127238e48bb63f7150162b01287f1727068ebab75ae8d3ef68f5"

RDEPENDS:rust-toml_edit+default-devel = " \
 cargo \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+display-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-toml_write+default-devel \
 "
RDEPENDS:rust-toml_edit+parse-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-winnow+default-devel \
 "
RDEPENDS:rust-toml_edit+perf-devel = " \
 cargo \
 rust-kstring+default-devel \
 rust-kstring+max_inline-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-toml_datetime+serde-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+unbounded-devel = " \
 cargo \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+unstable-debug-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-winnow+debug-devel \
 rust-winnow+default-devel \
 "
RDEPENDS:rust-toml_edit-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-toml_datetime+default-devel \
 "
