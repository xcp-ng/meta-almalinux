# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-kubernetes"
PE = "1"
PV = "34.1.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-kubernetes \
 python3-kubernetes-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-kubernetes-34.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d99e0b48114e0da96fbc31187eaafb8d35723e290e089a4cad5756da6a7ad36f"

URI_x86_64_v2_python3-kubernetes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kubernetes-34.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kubernetes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kubernetes}"
SRC_URI[x86_64_v2_python3-kubernetes.sha256sum] = "0ac451c8fe4ec8c669c6da2e7d84bb05961d3874513da766b88b0f36206f02ed"

URI_x86_64_v2_python3-kubernetes-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kubernetes-tests-34.1.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kubernetes-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kubernetes-tests}"
SRC_URI[x86_64_v2_python3-kubernetes-tests.sha256sum] = "4811ff033e975eb996130fd687ecc0485bc92f50f797340a8ad5a69ff94085c6"

URI_aarch64_python3-kubernetes = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kubernetes-34.1.0-2.el10_2.noarch.rpm;name=aarch64_python3-kubernetes;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kubernetes}"
SRC_URI[aarch64_python3-kubernetes.sha256sum] = "b0e2cfd0346a429967341751294b23e0a2b148c1e0028995bcd4be653c352bb4"

URI_aarch64_python3-kubernetes-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kubernetes-tests-34.1.0-2.el10_2.noarch.rpm;name=aarch64_python3-kubernetes-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kubernetes-tests}"
SRC_URI[aarch64_python3-kubernetes-tests.sha256sum] = "04f100eeb1e6160888024aa1750b9f52ffa949c62fc089158efe9f863f8f5380"

RDEPENDS:python3-kubernetes = " \
 python3 \
 python3-certifi \
 python3-dateutil \
 python3-durationpy \
 python3-google-auth \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-urllib3 \
 python3-websocket-client \
 "
RDEPENDS:python3-kubernetes-tests = " \
 python3 \
 python3-kubernetes \
 "
