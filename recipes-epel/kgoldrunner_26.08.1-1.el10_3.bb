# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgoldrunner"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kgoldrunner \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kgoldrunner-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f52c1bd90960bb79904d72f15834dd2049a79182b7587f5dfbd392842c2fc9a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgoldrunner-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgoldrunner;unpack=0"
SRC_URI[x86_64_v2_kgoldrunner.sha256sum] = "f80d4c0baf8d1fd1caf3348790cda6caa2f11ec72e195c44e5671ac778124300"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kgoldrunner-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kgoldrunner;unpack=0"
SRC_URI[aarch64_kgoldrunner.sha256sum] = "b16cfaf491bbd52f25eca2e57f2abbf76a7ecca6040002bce4d2c69b8be5a77b"

RDEPENDS:kgoldrunner = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
