# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-argos"
PV = "3^20250327git1326404"
PR = "3.el10_1"
PACKAGES = " \
 gnome-shell-extension-argos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-argos-3^20250327git1326404-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54289a93a1cd2abef4fa9428c773c95243395d1362507337a95b3210ba643ef5"

URI_x86_64_v2_gnome-shell-extension-argos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-argos-3^20250327git1326404-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-argos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-argos}"
SRC_URI[x86_64_v2_gnome-shell-extension-argos.sha256sum] = "29158f624fd06c0f18852f2d7d667cb959dbcaa04d29f07c2d8e5d8407905945"

URI_aarch64_gnome-shell-extension-argos = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-argos-3^20250327git1326404-3.el10_1.noarch.rpm;name=aarch64_gnome-shell-extension-argos;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-argos}"
SRC_URI[aarch64_gnome-shell-extension-argos.sha256sum] = "32f1683fa8d6be57d3f92aef679754d7e476912a53eb056fafa32b023887f6a9"

RDEPENDS:gnome-shell-extension-argos = " \
 gnome-shell \
 xdg-terminal-exec \
 "
