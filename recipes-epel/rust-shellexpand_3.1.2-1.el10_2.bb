# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shellexpand"
PV = "3.1.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+bstr-devel \
 rust-shellexpand+default-devel \
 rust-shellexpand+dirs-devel \
 rust-shellexpand+full-devel \
 rust-shellexpand+full-msrv-1-31-devel \
 rust-shellexpand+full-msrv-1-51-devel \
 rust-shellexpand+os_str_bytes-devel \
 rust-shellexpand+path-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-shellexpand-3.1.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5abf161c87e9dd1d5786ed4679d09784daa458586b9fdeff83f8eea6246d375"

URI_x86_64_v2_rust-shellexpand+base-0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+base-0-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+base-0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+base-0-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+base-0-devel.sha256sum] = "ab00d737acec3f188a842a3d353f3007d2aba5c8140bfeb81571b40abcfad81d"

URI_x86_64_v2_rust-shellexpand+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+bstr-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+bstr-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+bstr-devel.sha256sum] = "907d4fe489c505ea8786f572e7e371c7dd9e5dabdd1339d96f3f1a527aef415c"

URI_x86_64_v2_rust-shellexpand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+default-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+default-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+default-devel.sha256sum] = "83232cd79b0ba7c56bceda4fc934fad2163b6785b90c30eb77cba68b9dcbcf7b"

URI_x86_64_v2_rust-shellexpand+dirs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+dirs-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+dirs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+dirs-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+dirs-devel.sha256sum] = "f13c31e5d09dc0d512756991bcac110c07717e4d50f7908a6e9d4efecb6aae98"

URI_x86_64_v2_rust-shellexpand+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+full-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+full-devel.sha256sum] = "0d41bc0c703e4346c8176eb4c3552b8c520c8ee701be2f988fe8f18b29c91293"

URI_x86_64_v2_rust-shellexpand+full-msrv-1-31-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-msrv-1-31-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-msrv-1-31-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+full-msrv-1-31-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+full-msrv-1-31-devel.sha256sum] = "97eee45316fc0de79e7a639ae19647a6cb76aafb1a266478275446b79939a3a8"

URI_x86_64_v2_rust-shellexpand+full-msrv-1-51-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-msrv-1-51-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-msrv-1-51-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+full-msrv-1-51-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+full-msrv-1-51-devel.sha256sum] = "9b9b13c2631df0c7a8f89e9425b1f0834ced341616b18821916abe4b2c41f56e"

URI_x86_64_v2_rust-shellexpand+os_str_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+os_str_bytes-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+os_str_bytes-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+os_str_bytes-devel.sha256sum] = "22f3c06a304650ce02716b9df5d4816c78ffeaa00032e703cc30fca6deebff2b"

URI_x86_64_v2_rust-shellexpand+path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+path-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+path-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+path-devel.sha256sum] = "9ea70d9866cdc8ee90342545bade5995111e1d479c5ab5f91e1696451db09e49"

URI_x86_64_v2_rust-shellexpand+tilde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+tilde-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+tilde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand+tilde-devel}"
SRC_URI[x86_64_v2_rust-shellexpand+tilde-devel.sha256sum] = "a7b2a118e3de1728944c0df47009263a529003e79e74eb6d9ce2ca8fcf4bf3e0"

URI_x86_64_v2_rust-shellexpand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand-devel-3.1.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shellexpand-devel}"
SRC_URI[x86_64_v2_rust-shellexpand-devel.sha256sum] = "03457d9fedb7d28894670c1b86d4db59bb207f228ed9005292315baaf9cd77c8"

URI_aarch64_rust-shellexpand+base-0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+base-0-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+base-0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+base-0-devel}"
SRC_URI[aarch64_rust-shellexpand+base-0-devel.sha256sum] = "4ab571ab2182a8dc32ce5e0a468f0d1a0dc8e5006823316dab55ca0596fa28bb"

URI_aarch64_rust-shellexpand+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+bstr-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+bstr-devel}"
SRC_URI[aarch64_rust-shellexpand+bstr-devel.sha256sum] = "535ea63a59dc0f2872d47c3e9d32696c3f952b5e746e9d1bb110fc26b4fb3994"

URI_aarch64_rust-shellexpand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+default-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+default-devel}"
SRC_URI[aarch64_rust-shellexpand+default-devel.sha256sum] = "00eae5b8af7623d554ded2be556a3975ae5b8c66dc5f5c0d11beec0661d86f3b"

URI_aarch64_rust-shellexpand+dirs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+dirs-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+dirs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+dirs-devel}"
SRC_URI[aarch64_rust-shellexpand+dirs-devel.sha256sum] = "441dfe5e3cb87ed26ec567362d3bcb0e53f193cfee818c7c6728d391ac32ef50"

URI_aarch64_rust-shellexpand+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+full-devel}"
SRC_URI[aarch64_rust-shellexpand+full-devel.sha256sum] = "f268dfc26a6f7f3fc1ba4053a67df48321dfd1bafb587b21b8e5f0f80401a286"

URI_aarch64_rust-shellexpand+full-msrv-1-31-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-msrv-1-31-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+full-msrv-1-31-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+full-msrv-1-31-devel}"
SRC_URI[aarch64_rust-shellexpand+full-msrv-1-31-devel.sha256sum] = "537f6e05d5c82164df3a66e442a03babd40a64f466844626f8295dbcdd377d7c"

URI_aarch64_rust-shellexpand+full-msrv-1-51-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-msrv-1-51-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+full-msrv-1-51-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+full-msrv-1-51-devel}"
SRC_URI[aarch64_rust-shellexpand+full-msrv-1-51-devel.sha256sum] = "21cfd6cc63898daa827a4699360107a8358c2e17cdad42ea71d70b4ae73168f0"

URI_aarch64_rust-shellexpand+os_str_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+os_str_bytes-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+os_str_bytes-devel}"
SRC_URI[aarch64_rust-shellexpand+os_str_bytes-devel.sha256sum] = "c69732cb5b09c48ee4c3587b81a83be76dbde106b81793bad8d885cbf3ac4fc9"

URI_aarch64_rust-shellexpand+path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+path-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+path-devel}"
SRC_URI[aarch64_rust-shellexpand+path-devel.sha256sum] = "db99216da20ad4c803f66ca6aaa783f099513318544033f896f854a0895e141a"

URI_aarch64_rust-shellexpand+tilde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+tilde-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand+tilde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand+tilde-devel}"
SRC_URI[aarch64_rust-shellexpand+tilde-devel.sha256sum] = "34d9fb53635b0ecb9aede0478dbe1cb60de939534956a3dce67068f326240d83"

URI_aarch64_rust-shellexpand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand-devel-3.1.2-1.el10_2.noarch.rpm;name=aarch64_rust-shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shellexpand-devel}"
SRC_URI[aarch64_rust-shellexpand-devel.sha256sum] = "a580d8811f6adf2e6c597e59a668d42b445d4d044bbf283d3020cd8fbe7c1174"

RDEPENDS:rust-shellexpand+base-0-devel = " \
 cargo \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+bstr-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+default-devel = " \
 cargo \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+dirs-devel = " \
 cargo \
 rust-dirs+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-devel = " \
 cargo \
 rust-shellexpand+full-msrv-1-51-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-msrv-1-31-devel = " \
 cargo \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-msrv-1-51-devel = " \
 cargo \
 rust-shellexpand+full-msrv-1-31-devel \
 rust-shellexpand+path-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+os_str_bytes-devel = " \
 cargo \
 rust-os_str_bytes6+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+path-devel = " \
 cargo \
 rust-shellexpand+bstr-devel \
 rust-shellexpand+os_str_bytes-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+tilde-devel = " \
 cargo \
 rust-shellexpand+dirs-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand-devel = " \
 bash \
 cargo \
 rust \
 "
