# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ssldump"
PV = "1.9"
PR = "1.el10_0"
PACKAGES = " \
 ssldump \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/ssldump-1.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7fcc2ad24081b1e4ea32f6408c5a103ef4aac77201e930f152a35b6b3d17cd67"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ssldump-1.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ssldump;unpack=0"
SRC_URI[x86_64_v2_ssldump.sha256sum] = "60cf10f605b82e1216abb9f9341e064e0d704cc637791c28f45cf561beca5735"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/ssldump-1.9-1.el10_0.aarch64.rpm;name=aarch64_ssldump;unpack=0"
SRC_URI[aarch64_ssldump.sha256sum] = "39c26439e37a7dd9296de3f90a2d71866bca1dde011c5d02dd5f126ce33d0756"

RDEPENDS:ssldump = " \
 glibc \
 json-c \
 libnet \
 libpcap \
 openssl-libs \
 "
