# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jpegoptim"
PV = "1.5.6"
PR = "1.el10_2"
PACKAGES = " \
 jpegoptim \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jpegoptim-1.5.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0453701342598db08099cf063d72a4d0e6593a65efdb890174350968ac6b60aa"

URI_x86_64_v2_jpegoptim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jpegoptim-1.5.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jpegoptim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jpegoptim}"
SRC_URI[x86_64_v2_jpegoptim.sha256sum] = "7108f21ef864130cfa88ac224084b90d6e7b126e5f608d8242f34b6d613fbd5e"

URI_aarch64_jpegoptim = "${EPEL_MIRROR}/aarch64/Packages/j/jpegoptim-1.5.6-1.el10_2.aarch64.rpm;name=aarch64_jpegoptim;unpack=0"
SRC_URI:append = " ${URI_aarch64_jpegoptim}"
SRC_URI[aarch64_jpegoptim.sha256sum] = "12c63aab4bc2cd1a470a5ac743f3a7718a12a15a4363f7c13e67a9214ec815d2"

RDEPENDS:jpegoptim = " \
 glibc \
 libjpeg-turbo \
 "
