# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liblc3"
PV = "1.0.4"
PR = "6.el10"
PACKAGES = " \
 liblc3 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/liblc3-1.0.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d4bddb587d4d43e5d702cb7959e7728f9fcc1ae8d74ef17e22a5c4a3626596b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liblc3-1.0.4-6.el10.x86_64_v2.rpm;name=x86_64_v2_liblc3;unpack=0"
SRC_URI[x86_64_v2_liblc3.sha256sum] = "ff738ceb9f0046d716d469e10ebfb4fad590bbe8033149317245feb8922457ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liblc3-1.0.4-6.el10.aarch64.rpm;name=aarch64_liblc3;unpack=0"
SRC_URI[aarch64_liblc3.sha256sum] = "c8815ff0b88e13012032b765730b35b639e9f7a2382706cd8ef09b0d814a196a"

RDEPENDS:liblc3 = " \
 glibc \
 "
