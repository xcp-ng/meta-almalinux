# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kasts"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kasts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kasts-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f085daa3fc2fec98a958e005c34bfae0278acc704803c0fb757326d36281665c"

URI_x86_64_v2_kasts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kasts-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kasts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kasts}"
SRC_URI[x86_64_v2_kasts.sha256sum] = "75385e338bb0e7c708bce39db3520c03f965f7a88834d1d794ab56d334513c12"

URI_aarch64_kasts = "${EPEL_MIRROR}/aarch64/Packages/k/kasts-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kasts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kasts}"
SRC_URI[aarch64_kasts.sha256sum] = "732539759c8903ef1c7fe661883e68ad82415370b176ce9cf32c33d8d2ba75b1"

RDEPENDS:kasts = " \
 glibc \
 kf6-breeze-icons \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kwindowsystem \
 kf6-syndication \
 kf6-threadweaver \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qtkeychain-qt6 \
 taglib \
 vlc-libs \
 "
