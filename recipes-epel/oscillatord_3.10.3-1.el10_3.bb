# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oscillatord"
PV = "3.10.3"
PR = "1.el10_3"
PACKAGES = " \
 oscillatord \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oscillatord-3.10.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64fe37e81cb00669caea2674f168488471348e4f9fdf5fbcf4aeb3e4bc05ebae"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - oscillatord: libff.so.0.0.0()(64bit)
# - oscillatord: libubloxcfg.so.0.0.0()(64bit)
# - oscillatord: ubloxcfg >= 1.16-1.20260223git499048b

URI_x86_64_v2_oscillatord = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oscillatord-3.10.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oscillatord;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oscillatord}"
SRC_URI[x86_64_v2_oscillatord.sha256sum] = "c16c1de8d7a0186fcd7791bad4ffd88da6670a84465018a6994f4fe26db523dd"

URI_aarch64_oscillatord = "${EPEL_MIRROR}/aarch64/Packages/o/oscillatord-3.10.3-1.el10_3.aarch64.rpm;name=aarch64_oscillatord;unpack=0"
SRC_URI:append = " ${URI_aarch64_oscillatord}"
SRC_URI[aarch64_oscillatord.sha256sum] = "abfff0e36c90605df08be69f1f5423997134dd40be4cd9dcaa6d562f8fde3aa6"

RDEPENDS:oscillatord:x86_64_v2 = " \
 bash \
 glibc \
 json-c \
 libgcc \
 liboscillator-disciplining \
"
RDEPENDS:oscillatord:aarch64 = " \
 bash \
 glibc \
 json-c \
 libgcc \
 liboscillator-disciplining \
 ubloxcfg \
"
