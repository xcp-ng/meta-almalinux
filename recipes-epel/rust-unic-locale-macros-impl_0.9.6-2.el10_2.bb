# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-locale-macros-impl"
PV = "0.9.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-unic-locale-macros-impl+default-devel \
 rust-unic-locale-macros-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-locale-macros-impl-0.9.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f67c72d7160f2d78a484cff158ef944b3884bed220dfbee5d891cba3a91a1bcf"

URI_x86_64_v2_rust-unic-locale-macros-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale-macros-impl+default-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale-macros-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-locale-macros-impl+default-devel}"
SRC_URI[x86_64_v2_rust-unic-locale-macros-impl+default-devel.sha256sum] = "df8a678160ca5d9f6cb7f6bf5cbab6c11fd2c2fa7e69b5001ac6c47c3ab7efca"

URI_x86_64_v2_rust-unic-locale-macros-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale-macros-impl-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale-macros-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-locale-macros-impl-devel}"
SRC_URI[x86_64_v2_rust-unic-locale-macros-impl-devel.sha256sum] = "c8a99eaf48443b826ddfcb4c9a963f24562dacb56b8a7f8aeab74c4b94a999dc"

URI_aarch64_rust-unic-locale-macros-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale-macros-impl+default-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale-macros-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-locale-macros-impl+default-devel}"
SRC_URI[aarch64_rust-unic-locale-macros-impl+default-devel.sha256sum] = "f7bade8a7c99cb598a22e39cc888f8f7bceaef18ede3567f44103a36001393ef"

URI_aarch64_rust-unic-locale-macros-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale-macros-impl-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale-macros-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-locale-macros-impl-devel}"
SRC_URI[aarch64_rust-unic-locale-macros-impl-devel.sha256sum] = "875bab11ba736fd52e9736133c2bc47b52fd3dcb328edaa16fb9adec5ec67ca9"

RDEPENDS:rust-unic-locale-macros-impl+default-devel = " \
 cargo \
 rust-unic-locale-macros-impl-devel \
 "
RDEPENDS:rust-unic-locale-macros-impl-devel = " \
 cargo \
 rust-proc-macro-hack+default-devel \
 rust-quote+default-devel \
 rust-syn2+parsing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2-devel \
 rust-unic-locale-impl+default-devel \
 "
