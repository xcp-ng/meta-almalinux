# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-erased-serde"
PV = "0.4.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-erased-serde+alloc-devel \
 rust-erased-serde+default-devel \
 rust-erased-serde+std-devel \
 rust-erased-serde+unstable-debug-devel \
 rust-erased-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-erased-serde-0.4.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d6345fa15c31b401df282ba4db3b2d09940a4faebc60de447c65d04bbb5009c"

URI_x86_64_v2_rust-erased-serde+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+alloc-devel-0.4.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+alloc-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+alloc-devel.sha256sum] = "a3d5e0881ec10b1f2691022b04a68259610188b61c5df1a55dc8570bf129fe51"

URI_x86_64_v2_rust-erased-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+default-devel-0.4.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+default-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+default-devel.sha256sum] = "3909c41fcbd41d60f5979231bb43953915ae36f962950fc23799b63920066c60"

URI_x86_64_v2_rust-erased-serde+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+std-devel-0.4.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+std-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+std-devel.sha256sum] = "d1acc0b836d41f3a94a80e8741587fd6eda92412e692cc60c04ba8ce3c3a3469"

URI_x86_64_v2_rust-erased-serde+unstable-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+unstable-debug-devel-0.4.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+unstable-debug-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+unstable-debug-devel.sha256sum] = "0f1501186b42b75cf5c3aa38e4cca9a778c22f1999fb413ca606108529248659"

URI_x86_64_v2_rust-erased-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde-devel-0.4.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde-devel}"
SRC_URI[x86_64_v2_rust-erased-serde-devel.sha256sum] = "8e0896e4e80a7cb0960a7d340c5c20041871f2a5fb85ccca0fb141ffb37b99ac"

URI_aarch64_rust-erased-serde+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+alloc-devel-0.4.10-1.el10_1.noarch.rpm;name=aarch64_rust-erased-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+alloc-devel}"
SRC_URI[aarch64_rust-erased-serde+alloc-devel.sha256sum] = "1522a51a763f4887aa1328bc34f8087a4e1ea1e9cceebae8d5fd0d35f444e0ee"

URI_aarch64_rust-erased-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+default-devel-0.4.10-1.el10_1.noarch.rpm;name=aarch64_rust-erased-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+default-devel}"
SRC_URI[aarch64_rust-erased-serde+default-devel.sha256sum] = "e96e2a0648c7ad142ebaa35d9073dbd9e7722c70856dc818b1703739a01704b6"

URI_aarch64_rust-erased-serde+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+std-devel-0.4.10-1.el10_1.noarch.rpm;name=aarch64_rust-erased-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+std-devel}"
SRC_URI[aarch64_rust-erased-serde+std-devel.sha256sum] = "071fb67fb87e114c934abae82e036d99cfe10ccba38f5112eb400060e69b0e13"

URI_aarch64_rust-erased-serde+unstable-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+unstable-debug-devel-0.4.10-1.el10_1.noarch.rpm;name=aarch64_rust-erased-serde+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+unstable-debug-devel}"
SRC_URI[aarch64_rust-erased-serde+unstable-debug-devel.sha256sum] = "763ba28d69c3b6ceb6c0137da9994833cb641a425b7399b3b14926e9220ef676"

URI_aarch64_rust-erased-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde-devel-0.4.10-1.el10_1.noarch.rpm;name=aarch64_rust-erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde-devel}"
SRC_URI[aarch64_rust-erased-serde-devel.sha256sum] = "76e591bd628d7e6037718c818728e713bb2f25eb8a2100106bd63b113984ba4e"

RDEPENDS:rust-erased-serde+alloc-devel = " \
 cargo \
 rust-erased-serde-devel \
 rust-serde_core+alloc-devel \
 "
RDEPENDS:rust-erased-serde+default-devel = " \
 cargo \
 rust-erased-serde+std-devel \
 rust-erased-serde-devel \
 "
RDEPENDS:rust-erased-serde+std-devel = " \
 cargo \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-serde_core+std-devel \
 "
RDEPENDS:rust-erased-serde+unstable-debug-devel = " \
 cargo \
 rust-erased-serde-devel \
 "
RDEPENDS:rust-erased-serde-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core-devel \
 rust-typeid+default-devel \
 "
