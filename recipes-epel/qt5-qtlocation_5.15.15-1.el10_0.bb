# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtlocation"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtlocation \
 qt5-qtlocation-devel \
 qt5-qtlocation-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtlocation-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c11710bfbefd55143003fc4b8ffae319141cc7dd133bade4c6e428446ae8c02"

URI_x86_64_v2_qt5-qtlocation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtlocation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation}"
SRC_URI[x86_64_v2_qt5-qtlocation.sha256sum] = "b6faaaf1da3eb91680d36f569d80c94f80a05d2db315aa5fef176955c94bf9f8"

URI_x86_64_v2_qt5-qtlocation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation-devel}"
SRC_URI[x86_64_v2_qt5-qtlocation-devel.sha256sum] = "d0e27b1d0a91a8e033bed8b96c2620163854c6195dacaebe93c33347a07dfeb1"

URI_x86_64_v2_qt5-qtlocation-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation-examples}"
SRC_URI[x86_64_v2_qt5-qtlocation-examples.sha256sum] = "d487e00bae62342760454770686f1afd6a37eb0ce4dd601fcc5c277f334a3224"

URI_aarch64_qt5-qtlocation = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtlocation;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation}"
SRC_URI[aarch64_qt5-qtlocation.sha256sum] = "021b1d5c7306948898c9289b31c627906177a300c0af85f62179a03891db9446"

URI_aarch64_qt5-qtlocation-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation-devel}"
SRC_URI[aarch64_qt5-qtlocation-devel.sha256sum] = "b57813a80e97e59e8e00093889f620d2c848b581d760200ed5b21f87afb03389"

URI_aarch64_qt5-qtlocation-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation-examples}"
SRC_URI[aarch64_qt5-qtlocation-examples.sha256sum] = "18fc7d188385b6723051516ea08ca181cfd0bfc2628f97de46420846ebcdf809"

RDEPENDS:qt5-qtlocation = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtlocation-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtlocation \
 qt5-qtlocation-devel \
 "
RDEPENDS:qt5-qtlocation-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtlocation \
 "
