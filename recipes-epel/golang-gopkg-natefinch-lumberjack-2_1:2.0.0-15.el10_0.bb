# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-natefinch-lumberjack-2"
PE = "1"
PV = "2.0.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-gopkg-natefinch-lumberjack-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-natefinch-lumberjack-2-2.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "361a417e7d6701d9396c1f3a436826c2016b19c7bfc382928459ceb3f2561b81"

URI_x86_64_v2_golang-gopkg-natefinch-lumberjack-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-natefinch-lumberjack-2-devel-2.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-natefinch-lumberjack-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-natefinch-lumberjack-2-devel}"
SRC_URI[x86_64_v2_golang-gopkg-natefinch-lumberjack-2-devel.sha256sum] = "09aa5ed0f6601fec1a0edcb3f51bafee03b2aec8060aaf34d4034f6b19070829"

URI_aarch64_golang-gopkg-natefinch-lumberjack-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-natefinch-lumberjack-2-devel-2.0.0-15.el10_0.noarch.rpm;name=aarch64_golang-gopkg-natefinch-lumberjack-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-natefinch-lumberjack-2-devel}"
SRC_URI[aarch64_golang-gopkg-natefinch-lumberjack-2-devel.sha256sum] = "661076f31a7cf9bb5b1fa97eab38391bd0efcdd0bfc39feec5bd50430cd8fdd7"

RDEPENDS:golang-gopkg-natefinch-lumberjack-2-devel = " \
 go-filesystem \
 "
