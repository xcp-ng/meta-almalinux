# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Format-Strptime"
PE = "1"
PV = "1.79"
PR = "7.el10_0"
PACKAGES = " \
 perl-DateTime-Format-Strptime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Format-Strptime-1.79-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "215795e86e4b1c4c3a4c467a599001ef0fa81839ad013c8f11f9c67341ab7aee"

URI_x86_64_v2_perl-DateTime-Format-Strptime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-Strptime-1.79-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-Strptime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-Strptime}"
SRC_URI[x86_64_v2_perl-DateTime-Format-Strptime.sha256sum] = "03396ee728ab471e203a44c3091b7797e8b45295242e24daec2ab276faedd964"

URI_aarch64_perl-DateTime-Format-Strptime = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-Strptime-1.79-7.el10_0.noarch.rpm;name=aarch64_perl-DateTime-Format-Strptime;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-Strptime}"
SRC_URI[aarch64_perl-DateTime-Format-Strptime.sha256sum] = "f3af55a50bd6b3f5f021381245ecec2bd33a0197580bf84dd8c28c9fb447685d"

RDEPENDS:perl-DateTime-Format-Strptime = " \
 perl-Carp \
 perl-DateTime \
 perl-DateTime-Format-Strptime \
 perl-DateTime-Locale \
 perl-DateTime-TimeZone \
 perl-Exporter \
 perl-Params-ValidationCompiler \
 perl-Specio \
 perl-Try-Tiny \
 perl-constant \
 perl-libs \
 perl-parent \
 "
