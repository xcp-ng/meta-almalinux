# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libuser"
PV = "0.64"
PR = "12.el10"
PACKAGES = " \
 libuser \
 libuser-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libuser-0.64-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "47a0818f3fb955decd1fb372ca9af90bbbf746a6693df04e23de0570ae5d6e52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libuser-0.64-12.el10.x86_64_v2.rpm;name=x86_64_v2_libuser;unpack=0"
SRC_URI[x86_64_v2_libuser.sha256sum] = "4f92b9ac29d77c7be5c2fd4b109523d7db618bfce4d6ee5bd573e9e6c0fb2021"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libuser-devel-0.64-12.el10.x86_64_v2.rpm;name=x86_64_v2_libuser-devel;unpack=0"
SRC_URI[x86_64_v2_libuser-devel.sha256sum] = "0196c7baec2955d10610ccffa64c8c3383e939c3ce210741adfded7fe87c5ae0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libuser-0.64-12.el10.aarch64.rpm;name=aarch64_libuser;unpack=0"
SRC_URI[aarch64_libuser.sha256sum] = "eb2313421d445a4b777880ea2b857f32c34116a829148d2839ca771c58cd756f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libuser-devel-0.64-12.el10.aarch64.rpm;name=aarch64_libuser-devel;unpack=0"
SRC_URI[aarch64_libuser-devel.sha256sum] = "a261301f3602d9fb6dab7c6cfeb619399e03882b47f52c044b4f767ad5c1e72b"

RDEPENDS:libuser = " \
 audit-libs \
 glib2 \
 glibc \
 libselinux \
 libxcrypt \
 openldap \
 pam-libs \
 popt \
 "
RDEPENDS:libuser-devel = " \
 glib2-devel \
 libuser \
 pkgconf-pkg-config \
 "
