# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-protocol"
PV = "0.53.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-protocol+async-client-devel \
 rust-gix-protocol+blocking-client-devel \
 rust-gix-protocol+default-devel \
 rust-gix-protocol+document-features-devel \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+futures-lite-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol+serde-devel \
 rust-gix-protocol-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-protocol-0.53.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2886f332605174bcafa983b3c49d77eb3a2306302c02dbc24e7ec4665defe668"

URI_x86_64_v2_rust-gix-protocol+async-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+async-client-devel-0.53.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+async-client-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+async-client-devel.sha256sum] = "24645d6a38a2052baca29a61c49aa05c97bffa1156b9d34eb0ea89b326428b63"

URI_x86_64_v2_rust-gix-protocol+blocking-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+blocking-client-devel-0.53.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+blocking-client-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+blocking-client-devel.sha256sum] = "3ebc18d74c0c1c72a33169fe58b7f1bac8e45e7c7efe65ec1dddace271acec5a"

URI_x86_64_v2_rust-gix-protocol+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+default-devel-0.53.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+default-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+default-devel.sha256sum] = "563655d4d738cd3845bd62e92a1d52bbbb1de190082ddd8f13ff42e187d1164e"

URI_x86_64_v2_rust-gix-protocol+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+document-features-devel-0.53.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+document-features-devel.sha256sum] = "d91dd623a00cab09b3152193737db8039b70919c3ea8f3cd0dc9bb8d49df9ad7"

URI_x86_64_v2_rust-gix-protocol+fetch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+fetch-devel-0.53.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+fetch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+fetch-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+fetch-devel.sha256sum] = "f0ea1476925fd58406d6705f78803c8034370944ae737873daf9fb12ed6495d7"

URI_x86_64_v2_rust-gix-protocol+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+futures-lite-devel-0.53.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+futures-lite-devel.sha256sum] = "a23b8574af2e53c156b322972e73579481e9f3da3a88258a68a2149fa9a4565a"

URI_x86_64_v2_rust-gix-protocol+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+handshake-devel-0.53.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+handshake-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+handshake-devel.sha256sum] = "b6164e0e7ca89528c207cf424340a550f78bd355ee81f874b0dfd6a5cdc42e09"

URI_x86_64_v2_rust-gix-protocol+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+serde-devel-0.53.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+serde-devel.sha256sum] = "4253ac3439e47a1e84b43b011938bbc5754c94e925eb4e2ffabd5c785f13d6b1"

URI_x86_64_v2_rust-gix-protocol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol-devel-0.53.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol-devel.sha256sum] = "e6bd9a61e5344761c7f5803932165a28b5ba400b9e3271e827c8c9ee62657160"

URI_aarch64_rust-gix-protocol+async-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+async-client-devel-0.53.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-protocol+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+async-client-devel}"
SRC_URI[aarch64_rust-gix-protocol+async-client-devel.sha256sum] = "864669bbf7863c6e47962cc054f622566359fae9c20088e23b0c560665c1dee3"

URI_aarch64_rust-gix-protocol+blocking-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+blocking-client-devel-0.53.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-protocol+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+blocking-client-devel}"
SRC_URI[aarch64_rust-gix-protocol+blocking-client-devel.sha256sum] = "0a8167c0b451a189667996b472fc8991d23fa7b1c2a0bed49f108d0b6c404ef0"

URI_aarch64_rust-gix-protocol+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+default-devel-0.53.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+default-devel}"
SRC_URI[aarch64_rust-gix-protocol+default-devel.sha256sum] = "c817c09210b5bffdd7fbd00b292912e1a9b052fcd478c27a0537a4f7be3f217a"

URI_aarch64_rust-gix-protocol+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+document-features-devel-0.53.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-protocol+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+document-features-devel}"
SRC_URI[aarch64_rust-gix-protocol+document-features-devel.sha256sum] = "a21d692267695f303ecf673fb0dd85eb12c96d8c9a9287328481360c850f5f8e"

URI_aarch64_rust-gix-protocol+fetch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+fetch-devel-0.53.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-protocol+fetch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+fetch-devel}"
SRC_URI[aarch64_rust-gix-protocol+fetch-devel.sha256sum] = "ccb0e06ae56b404d641993109e2b177cb28cf1649030bc73782da7d892bc575d"

URI_aarch64_rust-gix-protocol+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+futures-lite-devel-0.53.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-protocol+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-protocol+futures-lite-devel.sha256sum] = "08c900e655599b06f6c983e69354bd824f4e7e8695162b562e61da09223be593"

URI_aarch64_rust-gix-protocol+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+handshake-devel-0.53.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-protocol+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+handshake-devel}"
SRC_URI[aarch64_rust-gix-protocol+handshake-devel.sha256sum] = "e74b8ec9ab37892819a70a374fd28259a5380e23c69effbdfeaf7fbd8cbb34d3"

URI_aarch64_rust-gix-protocol+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+serde-devel-0.53.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+serde-devel}"
SRC_URI[aarch64_rust-gix-protocol+serde-devel.sha256sum] = "f9c7537c3ab7f200ab12b1586bc02173033b6663b9e6d7883a4388403676bd4b"

URI_aarch64_rust-gix-protocol-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol-devel-0.53.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol-devel}"
SRC_URI[aarch64_rust-gix-protocol-devel.sha256sum] = "07c466b7689e628c10406f20ef40f102f2bbf4974a62f6cde32318a158bde26c"

RDEPENDS:rust-gix-protocol+async-client-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-futures-io+default-devel \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+futures-lite-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol-devel \
 rust-gix-transport+async-client-devel \
 "
RDEPENDS:rust-gix-protocol+blocking-client-devel = " \
 cargo \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol-devel \
 rust-gix-transport+blocking-client-devel \
 rust-maybe-async+is_sync-devel \
 "
RDEPENDS:rust-gix-protocol+default-devel = " \
 cargo \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+fetch-devel = " \
 cargo \
 rust-gix-lock+default-devel \
 rust-gix-negotiate+default-devel \
 rust-gix-object+default-devel \
 rust-gix-protocol-devel \
 rust-gix-refspec+default-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-protocol+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+handshake-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-protocol-devel \
 rust-gix-shallow+serde-devel \
 rust-gix-transport+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-protocol-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-hash+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-shallow+default-devel \
 rust-gix-transport+default-devel \
 rust-gix-utils+default-devel \
 rust-maybe-async+default-devel \
 rust-thiserror+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
