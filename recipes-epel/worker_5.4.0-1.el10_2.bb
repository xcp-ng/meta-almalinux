# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "worker"
PV = "5.4.0"
PR = "1.el10_2"
PACKAGES = " \
 worker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/worker-5.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2725823f144218404c9515e9e78706d3726c5c666b92ba0d0600fb98870ad5c"

URI_x86_64_v2_worker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/worker-5.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_worker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_worker}"
SRC_URI[x86_64_v2_worker.sha256sum] = "14a3205ce82ddb23d70e90b8264a5e14a45a0d47baf47fbdc79fbf39c6441154"

URI_aarch64_worker = "${EPEL_MIRROR}/aarch64/Packages/w/worker-5.4.0-1.el10_2.aarch64.rpm;name=aarch64_worker;unpack=0"
SRC_URI:append = " ${URI_aarch64_worker}"
SRC_URI[aarch64_worker.sha256sum] = "a58de270b089574e44430321aa03c82f2aae3a3e735a7499c60e4f35a11dc319"

RDEPENDS:worker = " \
 bash \
 dbus-libs \
 file-libs \
 glibc \
 imlib2 \
 libX11 \
 libXft \
 libXinerama \
 libgcc \
 libstdc++ \
 lua-libs \
 openssl-libs \
 python3 \
 "
