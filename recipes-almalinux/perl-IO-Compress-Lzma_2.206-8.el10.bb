# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Compress-Lzma"
PV = "2.206"
PR = "8.el10"
PACKAGES = " \
 perl-IO-Compress-Lzma \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-IO-Compress-Lzma-2.206-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fcb51bb019672dfd52c1b6c48e21134980a0768b9109a6bd6a5365659c0c0bb"

URI_x86_64_v2_perl-IO-Compress-Lzma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-IO-Compress-Lzma-2.206-8.el10.noarch.rpm;name=x86_64_v2_perl-IO-Compress-Lzma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Compress-Lzma}"
SRC_URI[x86_64_v2_perl-IO-Compress-Lzma.sha256sum] = "a330c74d059049fc1772e46c23e671640b6a7409af3db815b90d0a3784738948"

URI_aarch64_perl-IO-Compress-Lzma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-IO-Compress-Lzma-2.206-8.el10.noarch.rpm;name=aarch64_perl-IO-Compress-Lzma;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Compress-Lzma}"
SRC_URI[aarch64_perl-IO-Compress-Lzma.sha256sum] = "a330c74d059049fc1772e46c23e671640b6a7409af3db815b90d0a3784738948"

RDEPENDS:perl-IO-Compress-Lzma = " \
 perl-Compress-Raw-Lzma \
 perl-Compress-Raw-Zlib \
 perl-Exporter \
 perl-IO-Compress \
 perl-IO-Compress-Lzma \
 perl-constant \
 perl-libs \
 "
