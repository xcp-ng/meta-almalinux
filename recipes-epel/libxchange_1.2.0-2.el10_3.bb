# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxchange"
PV = "1.2.0"
PR = "2.el10_3"
PACKAGES = " \
 libxchange \
 libxchange-devel \
 libxchange-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libxchange-1.2.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9cfe9bb6788bc4cdd90e6b9fcdaa2bb2d7ea823b5ae9e9c41dbd805e6c0425a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxchange-1.2.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxchange;unpack=0"
SRC_URI[x86_64_v2_libxchange.sha256sum] = "949b5b8ff5ca7135a1b58fab798b547e4296fd12330ffc0f5fed20c94b7f6c1b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxchange-devel-1.2.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxchange-devel;unpack=0"
SRC_URI[x86_64_v2_libxchange-devel.sha256sum] = "09d2a74665ddd5d78b89e9b4a6f1f35fc4ca7e086471194996baf1b08c23261b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxchange-doc-1.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libxchange-doc;unpack=0"
SRC_URI[x86_64_v2_libxchange-doc.sha256sum] = "d9aa0e8e779f9c7dea4c7af260d65db4c1eff03f9aebaf2bf6b1b37624f4faed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxchange-1.2.0-2.el10_3.aarch64.rpm;name=aarch64_libxchange;unpack=0"
SRC_URI[aarch64_libxchange.sha256sum] = "d571fe0354243ff866abf6faff85c4e1fd8dc3e62d0964eeb3fe6692ce1385db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxchange-devel-1.2.0-2.el10_3.aarch64.rpm;name=aarch64_libxchange-devel;unpack=0"
SRC_URI[aarch64_libxchange-devel.sha256sum] = "9cae37be4006b144b0d7361d68313bca94418d7373786cb889a70eb31a68b244"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxchange-doc-1.2.0-2.el10_3.noarch.rpm;name=aarch64_libxchange-doc;unpack=0"
SRC_URI[aarch64_libxchange-doc.sha256sum] = "8d4529525050a19c77b453de201d22715ecd1c4977f7136ca3454c72781d73b8"

RDEPENDS:libxchange = " \
 glibc \
 "
RDEPENDS:libxchange-devel = " \
 cmake-filesystem \
 libxchange \
 pkgconf-pkg-config \
 "
RDEPENDS:libxchange-doc = " \
 "
