# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SoapySDR"
PV = "0.8.1"
PR = "14.el10_0"
PACKAGES = " \
 SoapySDR \
 SoapySDR-devel \
 SoapySDR-doc \
 python3-SoapySDR \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SoapySDR-0.8.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7855d060f4edcdb50016e5e5521719d528501ff6ea947010f96fa3a352338acb"

URI_x86_64_v2_SoapySDR = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SoapySDR-0.8.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SoapySDR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SoapySDR}"
SRC_URI[x86_64_v2_SoapySDR.sha256sum] = "af810ddc3b21bcd5c0632151dfce52ae1f1fba598fd4aa9a24d1582e73f56fec"

URI_x86_64_v2_SoapySDR-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SoapySDR-devel-0.8.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SoapySDR-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SoapySDR-devel}"
SRC_URI[x86_64_v2_SoapySDR-devel.sha256sum] = "241c1d7420f1abf726bb1cd0ab6552df79dbdc908289e7739c7b302ea53f8f75"

URI_x86_64_v2_SoapySDR-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SoapySDR-doc-0.8.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_SoapySDR-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SoapySDR-doc}"
SRC_URI[x86_64_v2_SoapySDR-doc.sha256sum] = "0d955db1229be80843b803e4e0896fd37c323e21c3a5a5bd3fea7f4fb8ca4fdc"

URI_x86_64_v2_python3-SoapySDR = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-SoapySDR-0.8.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-SoapySDR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-SoapySDR}"
SRC_URI[x86_64_v2_python3-SoapySDR.sha256sum] = "6a7a0bb766acf6e46d750a4953a3c179b1b7516769295e5ec892d8f33dc09b0f"

URI_aarch64_SoapySDR = "${EPEL_MIRROR}/aarch64/Packages/s/SoapySDR-0.8.1-14.el10_0.aarch64.rpm;name=aarch64_SoapySDR;unpack=0"
SRC_URI:append = " ${URI_aarch64_SoapySDR}"
SRC_URI[aarch64_SoapySDR.sha256sum] = "81b7e22b2d86494c5e3d11351f4902c0f3dec438f89b724a392c544140c1f196"

URI_aarch64_SoapySDR-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SoapySDR-devel-0.8.1-14.el10_0.aarch64.rpm;name=aarch64_SoapySDR-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SoapySDR-devel}"
SRC_URI[aarch64_SoapySDR-devel.sha256sum] = "120c795dc44d66f65080b4bd875bfd8b456b4860cd8336d40f932a77fe3c4ac4"

URI_aarch64_SoapySDR-doc = "${EPEL_MIRROR}/aarch64/Packages/s/SoapySDR-doc-0.8.1-14.el10_0.noarch.rpm;name=aarch64_SoapySDR-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_SoapySDR-doc}"
SRC_URI[aarch64_SoapySDR-doc.sha256sum] = "043a74983f98d0cea427ab963ee76bff7bb26ce0c37d09abe883d8583e16cf4c"

URI_aarch64_python3-SoapySDR = "${EPEL_MIRROR}/aarch64/Packages/p/python3-SoapySDR-0.8.1-14.el10_0.aarch64.rpm;name=aarch64_python3-SoapySDR;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-SoapySDR}"
SRC_URI[aarch64_python3-SoapySDR.sha256sum] = "d4244e407c1754649f326b2a17d87108655794fccc18632d7fe180e860f2d1b0"

RDEPENDS:SoapySDR = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:SoapySDR-devel = " \
 SoapySDR \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:SoapySDR-doc = " \
 "
RDEPENDS:python3-SoapySDR = " \
 SoapySDR \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
