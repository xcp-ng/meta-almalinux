# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mdadm"
PV = "4.4"
PR = "5.el10.1"
PACKAGES = " \
 mdadm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mdadm-4.4-5.el10.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "28d4af7f714cf3468b9e1110acafddf832123edd43eb16e949890c2c7b4837e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mdadm-4.4-5.el10.1.x86_64_v2.rpm;name=x86_64_v2_mdadm;unpack=0"
SRC_URI[x86_64_v2_mdadm.sha256sum] = "dbb67e28345d5da73f623a8826339cb4f311a1faf597e60e8d5bc212bd6b3850"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mdadm-4.4-5.el10.1.aarch64.rpm;name=aarch64_mdadm;unpack=0"
SRC_URI[aarch64_mdadm.sha256sum] = "876063f9df5a282abbff55b4b521b8fda46cfac8ba7a215a8b63fff03843bdc3"

RDEPENDS:mdadm = " \
 bash \
 glibc \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
