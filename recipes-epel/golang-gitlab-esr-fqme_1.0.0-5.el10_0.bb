# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gitlab-esr-fqme"
PV = "1.0.0"
PR = "5.el10_0"
PACKAGES = " \
 golang-gitlab-esr-fqme-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gitlab-esr-fqme-1.0.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a50c909f0ac803d5794807000b7545a76329a449e130d7cbae8817c982d7dd41"

URI_x86_64_v2_golang-gitlab-esr-fqme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gitlab-esr-fqme-devel-1.0.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gitlab-esr-fqme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gitlab-esr-fqme-devel}"
SRC_URI[x86_64_v2_golang-gitlab-esr-fqme-devel.sha256sum] = "d5cc8a8b9deacc43e33c7066a2f537261db6f6fb58c5d66f2c506393b00f9a71"

URI_aarch64_golang-gitlab-esr-fqme-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gitlab-esr-fqme-devel-1.0.0-5.el10_0.noarch.rpm;name=aarch64_golang-gitlab-esr-fqme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gitlab-esr-fqme-devel}"
SRC_URI[aarch64_golang-gitlab-esr-fqme-devel.sha256sum] = "c5982e94172888a5488a4769bd8a81cd6d5bf8f649775595d4b73e7684ee776b"

RDEPENDS:golang-gitlab-esr-fqme-devel = " \
 go-filesystem \
 "
