# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scitokens-cpp"
PV = "1.4.0"
PR = "3.el10_2"
PACKAGES = " \
 scitokens-cpp \
 scitokens-cpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scitokens-cpp-1.4.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b88b77c4c1d61d5a54a85835903bd7dbeac60c6315ec007a5532893ed4f321f3"

URI_aarch64_scitokens-cpp = "${EPEL_MIRROR}/aarch64/Packages/s/scitokens-cpp-1.4.0-3.el10_2.aarch64.rpm;name=aarch64_scitokens-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_scitokens-cpp}"
SRC_URI[aarch64_scitokens-cpp.sha256sum] = "a27dbff52827824bc7effb3ecf84003664f3661fdcbaaa7d11823e3936cd3efe"

URI_aarch64_scitokens-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scitokens-cpp-devel-1.4.0-3.el10_2.aarch64.rpm;name=aarch64_scitokens-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scitokens-cpp-devel}"
SRC_URI[aarch64_scitokens-cpp-devel.sha256sum] = "6e75a0dc80c3ea7a6b54043635152bd539bb035b033a5030a80a8e51aec03530"

RDEPENDS:scitokens-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 openssl-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:scitokens-cpp-devel = " \
 scitokens-cpp \
 "
