# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcompletion"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcompletion \
 kf6-kcompletion-devel \
 kf6-kcompletion-doc \
 kf6-kcompletion-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcompletion-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12de325246b81cf927584b6c14215c6e780b4afe319710dc1de2f6078b9524aa"

URI_x86_64_v2_kf6-kcompletion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion}"
SRC_URI[x86_64_v2_kf6-kcompletion.sha256sum] = "8d0fc48d2f235d850f34ef1c766bd19d7f227705eb25997218f3765c42120c78"

URI_x86_64_v2_kf6-kcompletion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-devel}"
SRC_URI[x86_64_v2_kf6-kcompletion-devel.sha256sum] = "9cca11e4e7298448f71de100ac09c66b19c589b157af49911e3fb8eebf6eb290"

URI_x86_64_v2_kf6-kcompletion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcompletion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-doc}"
SRC_URI[x86_64_v2_kf6-kcompletion-doc.sha256sum] = "48e074e4e7f79698a03211884dd77629084cb85b9d17eb6687aee3595b57072c"

URI_x86_64_v2_kf6-kcompletion-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcompletion-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-html}"
SRC_URI[x86_64_v2_kf6-kcompletion-html.sha256sum] = "a7b5c50aad7de4782e8f57071aaf49580626b334939dac089a2f72da9ba69a46"

URI_aarch64_kf6-kcompletion = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcompletion;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion}"
SRC_URI[aarch64_kf6-kcompletion.sha256sum] = "4b6236b4d4b59b4677f0fce810f7a9a0dda3e8d0878a83e619ea615bc2bfc711"

URI_aarch64_kf6-kcompletion-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcompletion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-devel}"
SRC_URI[aarch64_kf6-kcompletion-devel.sha256sum] = "5ce8e901025d56d9bb7b6cec97d884abc7251d700317afcd751d414a9ebd0534"

URI_aarch64_kf6-kcompletion-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcompletion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-doc}"
SRC_URI[aarch64_kf6-kcompletion-doc.sha256sum] = "c53658485e9c7f0bd964829221ac373010f2e14880e9c9274a133308782daf5f"

URI_aarch64_kf6-kcompletion-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcompletion-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-html}"
SRC_URI[aarch64_kf6-kcompletion-html.sha256sum] = "532c4c416666ec8d59cf1275ddcc6a99bbd53b6ead0028c8217d791e75cec5a7"

RDEPENDS:kf6-kcompletion = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcompletion \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-doc = " \
 "
RDEPENDS:kf6-kcompletion-html = " \
 "
