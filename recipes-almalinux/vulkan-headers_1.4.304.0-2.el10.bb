# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-headers"
PV = "1.4.304.0"
PR = "2.el10"
PACKAGES = " \
 vulkan-headers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-headers-1.4.304.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25c04e32e6614ec6f719a9246175c393648a20d69b1f8736d8efa64949101eb9"

URI_x86_64_v2_vulkan-headers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-headers-1.4.304.0-2.el10.noarch.rpm;name=x86_64_v2_vulkan-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-headers}"
SRC_URI[x86_64_v2_vulkan-headers.sha256sum] = "c1e93ff1fa662600c693d7f0565c82c98461849a91799250ec9245cbbfba8810"

URI_aarch64_vulkan-headers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-headers-1.4.304.0-2.el10.noarch.rpm;name=aarch64_vulkan-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-headers}"
SRC_URI[aarch64_vulkan-headers.sha256sum] = "c1e93ff1fa662600c693d7f0565c82c98461849a91799250ec9245cbbfba8810"

RDEPENDS:vulkan-headers = " \
 cmake-filesystem \
 python3 \
 "
