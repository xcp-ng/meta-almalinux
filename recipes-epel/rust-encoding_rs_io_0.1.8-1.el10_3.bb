# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-encoding_rs_io"
PV = "0.1.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-encoding_rs_io+default-devel \
 rust-encoding_rs_io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-encoding_rs_io-0.1.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c496a4d4aa73b26d321d03f39d483fa4e56a6534d4f3fdadce70b75240c769e"

URI_x86_64_v2_rust-encoding_rs_io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs_io+default-devel-0.1.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs_io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs_io+default-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs_io+default-devel.sha256sum] = "521aec64fa39917c156a29ed058eeb31e6019734eb6e90265045bb03bbd33f72"

URI_x86_64_v2_rust-encoding_rs_io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-encoding_rs_io-devel-0.1.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-encoding_rs_io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-encoding_rs_io-devel}"
SRC_URI[x86_64_v2_rust-encoding_rs_io-devel.sha256sum] = "bb0385b75ad08e04516120f0eb284ef58e2997fdc011d286a6a31ed1d74b1d13"

URI_aarch64_rust-encoding_rs_io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs_io+default-devel-0.1.8-1.el10_3.noarch.rpm;name=aarch64_rust-encoding_rs_io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs_io+default-devel}"
SRC_URI[aarch64_rust-encoding_rs_io+default-devel.sha256sum] = "3950427b5ffaf8eec9193f50d18a5c611eea4200b2f34e00d31b91cd7228c322"

URI_aarch64_rust-encoding_rs_io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-encoding_rs_io-devel-0.1.8-1.el10_3.noarch.rpm;name=aarch64_rust-encoding_rs_io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-encoding_rs_io-devel}"
SRC_URI[aarch64_rust-encoding_rs_io-devel.sha256sum] = "7509392befdf3075ad72219b957ab2f72e51346c616c53903c6620dc85e90ff7"

RDEPENDS:rust-encoding_rs_io+default-devel = " \
 cargo \
 rust-encoding_rs_io-devel \
 "
RDEPENDS:rust-encoding_rs_io-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 "
