# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-Server"
PV = "2.014"
PR = "9.el10"
PACKAGES = " \
 perl-Net-Server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Net-Server-2.014-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d276c2b25b64a5c30bba59b66494f9ac58c02843387e360dbc768af6aceb90b"

URI_x86_64_v2_perl-Net-Server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Net-Server-2.014-9.el10.noarch.rpm;name=x86_64_v2_perl-Net-Server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-Server}"
SRC_URI[x86_64_v2_perl-Net-Server.sha256sum] = "9e733600aac73f65c629f6f82042195a7ee78cd0b62686ba7af3bb32f478920b"

URI_aarch64_perl-Net-Server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Net-Server-2.014-9.el10.noarch.rpm;name=aarch64_perl-Net-Server;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-Server}"
SRC_URI[aarch64_perl-Net-Server.sha256sum] = "9e733600aac73f65c629f6f82042195a7ee78cd0b62686ba7af3bb32f478920b"

RDEPENDS:perl-Net-Server = " \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Temp \
 perl-IO \
 perl-IO-Multiplex \
 perl-IO-Socket-IP \
 perl-Net-Server \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
