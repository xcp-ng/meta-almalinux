# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-IDEA"
PV = "1.10"
PR = "29.el10_0"
PACKAGES = " \
 perl-Crypt-IDEA \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-IDEA-1.10-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "492bff0c2555fe79a3c162bbca36daf4c83e34bb6dc5154d8ad8b6e08a66ae3f"

URI_x86_64_v2_perl-Crypt-IDEA = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-IDEA-1.10-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-IDEA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-IDEA}"
SRC_URI[x86_64_v2_perl-Crypt-IDEA.sha256sum] = "fa5479384171c092242af09057e6f2be63c22dc6105d8ac050f5c95ad9289f72"

URI_aarch64_perl-Crypt-IDEA = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-IDEA-1.10-29.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-IDEA;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-IDEA}"
SRC_URI[aarch64_perl-Crypt-IDEA.sha256sum] = "662ff6c711de23d140591a2c5d0eeb90f09b1ce0957ea0597ee647a8206b521f"

RDEPENDS:perl-Crypt-IDEA = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
