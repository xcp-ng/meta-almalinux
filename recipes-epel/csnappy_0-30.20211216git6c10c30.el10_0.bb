# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "csnappy"
PV = "0"
PR = "30.20211216git6c10c30.el10_0"
PACKAGES = " \
 csnappy \
 csnappy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/csnappy-0-30.20211216git6c10c30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7af85f7d64aa60a98d0a27e4b9feaf63ea9388dd13c6c387116165d57b179ebd"

URI_x86_64_v2_csnappy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csnappy-0-30.20211216git6c10c30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csnappy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csnappy}"
SRC_URI[x86_64_v2_csnappy.sha256sum] = "0467693bcdeb8a6b9425ecc2f90e48630f174c33fb765c3d6f573bfc9d50d905"

URI_x86_64_v2_csnappy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csnappy-devel-0-30.20211216git6c10c30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csnappy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csnappy-devel}"
SRC_URI[x86_64_v2_csnappy-devel.sha256sum] = "947600766f6b17f23b79bfa682de2c26a27fdfadaf37d5a3c16acf6174604dc7"

URI_aarch64_csnappy = "${EPEL_MIRROR}/aarch64/Packages/c/csnappy-0-30.20211216git6c10c30.el10_0.aarch64.rpm;name=aarch64_csnappy;unpack=0"
SRC_URI:append = " ${URI_aarch64_csnappy}"
SRC_URI[aarch64_csnappy.sha256sum] = "97bb463017f85c6c41362b43fc7fa1a2edf20562fa67431d74ff192cafdf7602"

URI_aarch64_csnappy-devel = "${EPEL_MIRROR}/aarch64/Packages/c/csnappy-devel-0-30.20211216git6c10c30.el10_0.aarch64.rpm;name=aarch64_csnappy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_csnappy-devel}"
SRC_URI[aarch64_csnappy-devel.sha256sum] = "7990c7b67d3591f2da07457d189330b04a9b8b579dde370a1716a53a96318b52"

RDEPENDS:csnappy = " \
 glibc \
 "
RDEPENDS:csnappy-devel = " \
 csnappy \
 "
