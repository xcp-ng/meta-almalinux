# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-connect"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kde-connect \
 kde-connect-libs \
 kde-connect-nautilus \
 kdeconnectd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kde-connect-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec06355879f872ff1c699a25df50ecf4a51b6c6985b4f0356ef52e9db5ac3b97"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect;unpack=0"
SRC_URI[x86_64_v2_kde-connect.sha256sum] = "4415f0548dbd3a4ccf4e76c55bb695077c6fdaf3cbf816ab05536fcecbe4e351"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect-libs;unpack=0"
SRC_URI[x86_64_v2_kde-connect-libs.sha256sum] = "3e84484f07b8343c998e198153352d79d02d97ee028425966664404be2956486"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-connect-nautilus-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-connect-nautilus;unpack=0"
SRC_URI[x86_64_v2_kde-connect-nautilus.sha256sum] = "d88c52a5848a3c82baf6fdef8eb3226942c6b8553d4698d04daebafb071bf140"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeconnectd-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeconnectd;unpack=0"
SRC_URI[x86_64_v2_kdeconnectd.sha256sum] = "eb715994e52183521aed8530214ba436f9a192131788531946a028211041fa6d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kde-connect;unpack=0"
SRC_URI[aarch64_kde-connect.sha256sum] = "f82873fbb6ce7d57e65aeb3d38b611e8761a214a8e454c22546ef546d9e79c11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kde-connect-libs;unpack=0"
SRC_URI[aarch64_kde-connect-libs.sha256sum] = "61e9181f839979f34c317e7e53569c5caff722ef9cf0b8ddd91f38daeca012c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-connect-nautilus-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kde-connect-nautilus;unpack=0"
SRC_URI[aarch64_kde-connect-nautilus.sha256sum] = "c9842e1e74cbc6235ba543dee85ee518417f85e25eb762ee54cad9c22876cb1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdeconnectd-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdeconnectd;unpack=0"
SRC_URI[aarch64_kdeconnectd.sha256sum] = "478e7f784c688c03b7c59c28daa88792aae012e2fd0c5e8757a3d2e1418c27f5"

RDEPENDS:kde-connect = " \
 fuse-sshfs \
 glibc \
 kde-cli-tools \
 kde-connect-libs \
 kdeconnectd \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpeople \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kf6-qqc2-desktop-style \
 libstdc++ \
 libwayland-client \
 qca-qt6-ossl \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kde-connect-libs = " \
 dbus-libs \
 glibc \
 kde-connect \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-solid \
 libX11 \
 libXtst \
 libei \
 libevdev \
 libfakekey \
 libstdc++ \
 libxkbcommon \
 openssl-libs \
 pulseaudio-qt-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtconnectivity \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kde-connect-nautilus = " \
 kdeconnectd \
 nautilus-python \
 "
RDEPENDS:kdeconnectd = " \
 glibc \
 kde-connect-libs \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
