# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-errno0.2"
PV = "0.2.8"
PR = "5.el10_1"
PACKAGES = " \
 rust-errno0.2+default-devel \
 rust-errno0.2+std-devel \
 rust-errno0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-errno0.2-0.2.8-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a70b3a0c34d01813272c3916672584acbcf1d50a7898158c6250ce16281bfba"

URI_x86_64_v2_rust-errno0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno0.2+default-devel-0.2.8-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno0.2+default-devel}"
SRC_URI[x86_64_v2_rust-errno0.2+default-devel.sha256sum] = "e6ba465a44077fb10c9ae735e6df51d408c1f20aa9d499ac6890210b8ea45c8a"
RPROVIDES:rust-errno0.2+default-devel:x86_64_v2 = "virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"

URI_x86_64_v2_rust-errno0.2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno0.2+std-devel-0.2.8-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno0.2+std-devel}"
SRC_URI[x86_64_v2_rust-errno0.2+std-devel.sha256sum] = "326557c62a39baa3b648fabd252867c1e2be39ba288c6be937e2f60b2f0c4a83"

URI_x86_64_v2_rust-errno0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno0.2-devel-0.2.8-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno0.2-devel}"
SRC_URI[x86_64_v2_rust-errno0.2-devel.sha256sum] = "c8eafba1209a6a86537645e9338776f45aecde76dc89d491b72282d048efaa5f"

URI_aarch64_rust-errno0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno0.2+default-devel-0.2.8-5.el10_1.noarch.rpm;name=aarch64_rust-errno0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno0.2+default-devel}"
SRC_URI[aarch64_rust-errno0.2+default-devel.sha256sum] = "0fe4523f50c3f26905ecab0012fc8c2832d53dbf04b009cbd6047b29572a63e8"
RPROVIDES:rust-errno0.2+default-devel:aarch64 = "virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"

URI_aarch64_rust-errno0.2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno0.2+std-devel-0.2.8-5.el10_1.noarch.rpm;name=aarch64_rust-errno0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno0.2+std-devel}"
SRC_URI[aarch64_rust-errno0.2+std-devel.sha256sum] = "0b351662d1e54bbbbd425dc5c04bb2d7ce4c7b10ecf79bdc9387ba167313babb"

URI_aarch64_rust-errno0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno0.2-devel-0.2.8-5.el10_1.noarch.rpm;name=aarch64_rust-errno0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno0.2-devel}"
SRC_URI[aarch64_rust-errno0.2-devel.sha256sum] = "b1e90a297877173875c67acd27b5f10050baf4e330bcfa5c772cd1e6a8a8da54"

RDEPENDS:rust-errno0.2+default-devel = " \
 cargo \
 rust-errno0.2+std-devel \
 rust-errno0.2-devel \
 "
RDEPENDS:rust-errno0.2+std-devel = " \
 cargo \
 rust-errno0.2-devel \
 "
RDEPENDS:rust-errno0.2-devel = " \
 cargo \
 rust-libc+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"
