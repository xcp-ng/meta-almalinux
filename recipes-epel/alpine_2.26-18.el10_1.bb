# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alpine"
PV = "2.26"
PR = "18.el10_1"
PACKAGES = " \
 alpine \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alpine-2.26-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc7065d2caae967996ccdbb5896c9beea8bb63080fa0a67372dc0aa3104415c6"

URI_x86_64_v2_alpine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alpine-2.26-18.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alpine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alpine}"
SRC_URI[x86_64_v2_alpine.sha256sum] = "157ed4c0b423560e6c2c58373e5fdae4811d8e20d47b39cddd4aad9177a6cd0c"

URI_aarch64_alpine = "${EPEL_MIRROR}/aarch64/Packages/a/alpine-2.26-18.el10_1.aarch64.rpm;name=aarch64_alpine;unpack=0"
SRC_URI:append = " ${URI_aarch64_alpine}"
SRC_URI[aarch64_alpine.sha256sum] = "54a981dbf523776aba6774076da010afe74d569d0387867a786e18d52c34434a"

RDEPENDS:alpine = " \
 glibc \
 hunspell \
 krb5-libs \
 libgcc \
 libxcrypt \
 mailcap \
 ncurses-libs \
 openldap \
 openssl-libs \
 virtual//usr/sbin/sendmail \
 "
