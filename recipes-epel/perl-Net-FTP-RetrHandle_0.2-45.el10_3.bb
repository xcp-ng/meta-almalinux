# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-FTP-RetrHandle"
PV = "0.2"
PR = "45.el10_3"
PACKAGES = " \
 perl-Net-FTP-RetrHandle \
 perl-Net-FTP-RetrHandle-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-FTP-RetrHandle-0.2-45.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1ebff5a0464dbbf7426cffee5ac7a43a0cdd4e09922dd2b806a4071d7d81ffe"

URI_x86_64_v2_perl-Net-FTP-RetrHandle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-RetrHandle-0.2-45.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-RetrHandle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-RetrHandle}"
SRC_URI[x86_64_v2_perl-Net-FTP-RetrHandle.sha256sum] = "6c1df25f008f43bd134dc54ca81ffedd9a3eda09b618dfdb29a990d51cddeb75"

URI_x86_64_v2_perl-Net-FTP-RetrHandle-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-RetrHandle-tests-0.2-45.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-RetrHandle-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-RetrHandle-tests}"
SRC_URI[x86_64_v2_perl-Net-FTP-RetrHandle-tests.sha256sum] = "e42b4c217214045a23bcaf7498953b75eecd3e1cee6c552f24f09de78521b8a5"

URI_aarch64_perl-Net-FTP-RetrHandle = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-RetrHandle-0.2-45.el10_3.noarch.rpm;name=aarch64_perl-Net-FTP-RetrHandle;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-RetrHandle}"
SRC_URI[aarch64_perl-Net-FTP-RetrHandle.sha256sum] = "56300ebc0e6b61482be6cb4bff96eb35742b99620cd88a55cf1e30af4c8d030f"

URI_aarch64_perl-Net-FTP-RetrHandle-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-RetrHandle-tests-0.2-45.el10_3.noarch.rpm;name=aarch64_perl-Net-FTP-RetrHandle-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-RetrHandle-tests}"
SRC_URI[aarch64_perl-Net-FTP-RetrHandle-tests.sha256sum] = "e851b08dc9f8fc55f3b970c516430a5d52254ba011c2b8141653c6a565eb5ca9"

RDEPENDS:perl-Net-FTP-RetrHandle = " \
 perl-Carp \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-base \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Net-FTP-RetrHandle-tests = " \
 bash \
 perl-Net-FTP-RetrHandle \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
