# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiohttp"
PV = "3.11.16"
PR = "1.el10_0"
PACKAGES = " \
 python3-aiohttp \
 python3-aiohttp+speedups \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiohttp-3.11.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78df7e7d7e4461e5e5f60e8c794bd2b372f7a09a807ce56aec094dd61ab19c4b"

URI_x86_64_v2_python3-aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiohttp-3.11.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiohttp}"
SRC_URI[x86_64_v2_python3-aiohttp.sha256sum] = "4dcabef055726d168e18ba5c96664058aff3252039d967c4896166faf1a2bd55"

URI_x86_64_v2_python3-aiohttp+speedups = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiohttp+speedups-3.11.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-aiohttp+speedups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiohttp+speedups}"
SRC_URI[x86_64_v2_python3-aiohttp+speedups.sha256sum] = "031bb2fae6793e3ad6c0193a02722758848f33bcd3b097b0eec035c619ff41bd"

URI_aarch64_python3-aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiohttp-3.11.16-1.el10_0.aarch64.rpm;name=aarch64_python3-aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiohttp}"
SRC_URI[aarch64_python3-aiohttp.sha256sum] = "f7feb1fb902fdfc79b0e95290c99e5264e720d81395c2d6137345970de259cbc"

URI_aarch64_python3-aiohttp+speedups = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiohttp+speedups-3.11.16-1.el10_0.aarch64.rpm;name=aarch64_python3-aiohttp+speedups;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiohttp+speedups}"
SRC_URI[aarch64_python3-aiohttp+speedups.sha256sum] = "42dd6042bfffa6f5b29304760656344bf2835da9d580de021927b114b0987322"

RDEPENDS:python3-aiohttp = " \
 glibc \
 llhttp \
 python3 \
 python3-aiohappyeyeballs \
 python3-aiosignal \
 python3-attrs \
 python3-frozenlist \
 python3-multidict \
 python3-propcache \
 python3-yarl \
 "
RDEPENDS:python3-aiohttp+speedups = " \
 python3 \
 python3-aiodns \
 python3-aiohttp \
 python3-brotli \
 "
