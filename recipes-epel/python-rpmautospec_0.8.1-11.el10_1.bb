# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rpmautospec"
PV = "0.8.1"
PR = "11.el10_1"
PACKAGES = " \
 python3-rpmautospec \
 python3-rpmautospec+all \
 python3-rpmautospec+click \
 python3-rpmautospec+pygit2 \
 python3-rpmautospec+rpm \
 rpmautospec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rpmautospec-0.8.1-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1dfdd08bc3d393ab5fe858c9b97219e4aca22804a286f1acd7bf5aae3c7ee62"

URI_x86_64_v2_python3-rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec-0.8.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec}"
SRC_URI[x86_64_v2_python3-rpmautospec.sha256sum] = "19b3a393beedbfcbfbe4ed844e4f5c846869aa2be59a581a49afecea728dfe75"

URI_x86_64_v2_python3-rpmautospec+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec+all-0.8.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec+all}"
SRC_URI[x86_64_v2_python3-rpmautospec+all.sha256sum] = "3ca646836d5214fac630dfaefd08aa4a826566f850c4705ebd5f7bffd7517566"

URI_x86_64_v2_python3-rpmautospec+click = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec+click-0.8.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec+click;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec+click}"
SRC_URI[x86_64_v2_python3-rpmautospec+click.sha256sum] = "2ab4af8419b06b4fcc1778625028ddce09ccae2619043c04f42ae5316defb3e1"

URI_x86_64_v2_python3-rpmautospec+pygit2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec+pygit2-0.8.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec+pygit2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec+pygit2}"
SRC_URI[x86_64_v2_python3-rpmautospec+pygit2.sha256sum] = "2577c2bb3f0299f35aa7764fd590ec62abe6d6afb0f6c92cbf71b5c13457a07d"

URI_x86_64_v2_python3-rpmautospec+rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec+rpm-0.8.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec+rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec+rpm}"
SRC_URI[x86_64_v2_python3-rpmautospec+rpm.sha256sum] = "c15d4416e4d81eb2c3f3132d39acf36cd8d403cfc55311a09bd49f4fef243f57"

URI_x86_64_v2_rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmautospec-0.8.1-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmautospec}"
SRC_URI[x86_64_v2_rpmautospec.sha256sum] = "c0cc8d434951ed4f7ff7e75e3c820ebbde364ca24df62bf09519570c4175a952"

URI_aarch64_python3-rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec-0.8.1-11.el10_1.noarch.rpm;name=aarch64_python3-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec}"
SRC_URI[aarch64_python3-rpmautospec.sha256sum] = "fd5dc8585e05119a53361d36b4abfb40d4f4897cc93dac3acbd6e88e1387c42e"

URI_aarch64_python3-rpmautospec+all = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec+all-0.8.1-11.el10_1.noarch.rpm;name=aarch64_python3-rpmautospec+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec+all}"
SRC_URI[aarch64_python3-rpmautospec+all.sha256sum] = "9dafae6e2de2a22cb5bdcfe3cacbc9c7f37674130ec8a3c10db581a1813fd107"

URI_aarch64_python3-rpmautospec+click = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec+click-0.8.1-11.el10_1.noarch.rpm;name=aarch64_python3-rpmautospec+click;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec+click}"
SRC_URI[aarch64_python3-rpmautospec+click.sha256sum] = "0338e5eb664bfc272fcf5aef1d62f7d71e1bb83032dba8928cac81cedb7a2d3a"

URI_aarch64_python3-rpmautospec+pygit2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec+pygit2-0.8.1-11.el10_1.noarch.rpm;name=aarch64_python3-rpmautospec+pygit2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec+pygit2}"
SRC_URI[aarch64_python3-rpmautospec+pygit2.sha256sum] = "080836cc2bb4bc152d33fab1ab51d4ca3d2f287050e40bba30006bf43dd220cf"

URI_aarch64_python3-rpmautospec+rpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec+rpm-0.8.1-11.el10_1.noarch.rpm;name=aarch64_python3-rpmautospec+rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec+rpm}"
SRC_URI[aarch64_python3-rpmautospec+rpm.sha256sum] = "d653a428c87befdc21aa66e9f45800374c563e75d50ee8a69c197bb4f67302c5"

URI_aarch64_rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/r/rpmautospec-0.8.1-11.el10_1.noarch.rpm;name=aarch64_rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmautospec}"
SRC_URI[aarch64_rpmautospec.sha256sum] = "dd900e1b04e43b21c764220c0ad31deebc0ce8ec16bf72eed750496f0390aef3"

RDEPENDS:python3-rpmautospec = " \
 python3 \
 python3-rpmautospec-core \
 "
RDEPENDS:python3-rpmautospec+all = " \
 python3 \
 python3-click \
 python3-pygit2 \
 python3-rpm \
 python3-rpmautospec \
 "
RDEPENDS:python3-rpmautospec+click = " \
 python3 \
 python3-click \
 python3-rpmautospec \
 "
RDEPENDS:python3-rpmautospec+pygit2 = " \
 python3 \
 python3-pygit2 \
 python3-rpmautospec \
 "
RDEPENDS:python3-rpmautospec+rpm = " \
 python3 \
 python3-rpm \
 python3-rpmautospec \
 "
RDEPENDS:rpmautospec = " \
 libgit2 \
 python3 \
 rpm-build-libs \
 rpm-libs \
 "
