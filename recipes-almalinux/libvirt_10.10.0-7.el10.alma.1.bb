# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvirt"
PV = "10.10.0"
PR = "7.el10.alma.1"
PACKAGES = " \
 libvirt \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-common \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 libvirt-daemon-kvm \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-plugin-sanlock \
 libvirt-daemon-proxy \
 libvirt-devel \
 libvirt-docs \
 libvirt-libs \
 libvirt-nss \
 libvirt-ssh-proxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvirt-10.10.0-7.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cee8d2ae14dd48bdcb84710ac520aac889c14874bca72ccccdc4837a208c8c86"

URI_x86_64_v2_libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt}"
SRC_URI[x86_64_v2_libvirt.sha256sum] = "e6b04baecbec668a88c13b0b09f5ebf7106a3fda113ec731e6122b288a692f8a"

URI_x86_64_v2_libvirt-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-client}"
SRC_URI[x86_64_v2_libvirt-client.sha256sum] = "9c8dc4a0178b107c41464aa6887a3b754b48d77b14f24c0786e4da5873f7da45"

URI_x86_64_v2_libvirt-client-qemu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-qemu-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client-qemu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-client-qemu}"
SRC_URI[x86_64_v2_libvirt-client-qemu.sha256sum] = "bf54e2a8bceb83bf803b4850f1dd533dba861cce3a8c3053eb3d221847fc80ac"

URI_x86_64_v2_libvirt-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon}"
SRC_URI[x86_64_v2_libvirt-daemon.sha256sum] = "29b29148bf550456632afb43d3627d314d18f497e6c5dfbd9203343e59990f3d"

URI_x86_64_v2_libvirt-daemon-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-common-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-common}"
SRC_URI[x86_64_v2_libvirt-daemon-common.sha256sum] = "ddb856a1ba11a2dac61f0f63933041e0e1c8aad1b368d81bf277f3b0b5917d31"

URI_x86_64_v2_libvirt-daemon-config-network = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-network-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-config-network}"
SRC_URI[x86_64_v2_libvirt-daemon-config-network.sha256sum] = "21d3bc08c4e871070a4d18589e4d15d863e71766100f978753e066a898e5f996"

URI_x86_64_v2_libvirt-daemon-config-nwfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-nwfilter-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-config-nwfilter}"
SRC_URI[x86_64_v2_libvirt-daemon-config-nwfilter.sha256sum] = "6070d4ba5796a9e1b11d04b2981a1e7637caaee3b9fdd184d143babb04967572"

URI_x86_64_v2_libvirt-daemon-driver-interface = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-interface-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-interface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-interface}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-interface.sha256sum] = "e0a82d2d181acd49fc8e8307e8d0fbe064f6672e0735b5a3b0a6b4f6b1ee9101"

URI_x86_64_v2_libvirt-daemon-driver-network = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-network-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-network}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-network.sha256sum] = "2d7c58979a5a14dbf70d3d576b9f2c9aabca84e25cd0124755b4d8f7794d0828"

URI_x86_64_v2_libvirt-daemon-driver-nodedev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nodedev-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-nodedev}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nodedev.sha256sum] = "6586087446776324d73c15e1c534a3d7a911f6317cd8e1860135f9011ebe9ba1"

URI_x86_64_v2_libvirt-daemon-driver-nwfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nwfilter-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-nwfilter}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nwfilter.sha256sum] = "d3d755a566bf14abfbd75daed7049942ab1889af70033242d85494e6168eab2d"

URI_x86_64_v2_libvirt-daemon-driver-qemu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-qemu-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-qemu}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-qemu.sha256sum] = "ac55cc1e3e4e0458e138058c15dd519c4ecf4cb78bde5f06558e97e6bb8a167b"

URI_x86_64_v2_libvirt-daemon-driver-secret = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-secret-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-secret;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-secret}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-secret.sha256sum] = "a10211def190687f6d250244516dc0f59bd2dafb12f16acd401601cf6f223243"

URI_x86_64_v2_libvirt-daemon-driver-storage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage.sha256sum] = "5b2571639d09e7f8be68fb87899b6cad668b0718266a25515b526091fe959e4b"

URI_x86_64_v2_libvirt-daemon-driver-storage-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-core-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-core}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-core.sha256sum] = "1f037d12ca2bba51d398e1581420dddd08dd6256c5b8770792eb3334a2549884"

URI_x86_64_v2_libvirt-daemon-driver-storage-disk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-disk-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-disk}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-disk.sha256sum] = "a95cb0f27f269f60b96145042e7793d480ff28ee71d2b82ae5ec8fba12024590"

URI_x86_64_v2_libvirt-daemon-driver-storage-iscsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-iscsi-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-iscsi}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-iscsi.sha256sum] = "edc222abd2fd76e1e4d393d2e84e4c41e62a4499797cb50fded95ae73f90c9e9"

URI_x86_64_v2_libvirt-daemon-driver-storage-logical = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-logical-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-logical}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-logical.sha256sum] = "5e0359801342bdde566b30f51ef9c07ed52c828e1a7fad71bab045b735575c55"

URI_x86_64_v2_libvirt-daemon-driver-storage-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-mpath-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-mpath}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-mpath.sha256sum] = "a86e0cdf24b49399a498d3bb3b2e83b9bf0ec6c93e9a0f81756aebaf80569ab9"

URI_x86_64_v2_libvirt-daemon-driver-storage-rbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-rbd-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-rbd}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-rbd.sha256sum] = "bde6b37be90d4cbc5a44f8f6d4032a747ea9de026840208fdd958122d9492151"

URI_x86_64_v2_libvirt-daemon-driver-storage-scsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-scsi-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-driver-storage-scsi}"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-scsi.sha256sum] = "3c03f921ea91ec1bc6c6592c38b4443617c70805cd664e168b087a51597f9297"

URI_x86_64_v2_libvirt-daemon-kvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-kvm-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-kvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-kvm}"
SRC_URI[x86_64_v2_libvirt-daemon-kvm.sha256sum] = "fb499575b36a458427f3427e27b9d7407a9d50191108fc613f8d78e56f9bc930"

URI_x86_64_v2_libvirt-daemon-lock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-lock-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-lock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-lock}"
SRC_URI[x86_64_v2_libvirt-daemon-lock.sha256sum] = "4be375408c8b4cc37edb947f5e16b86965c07a3f82ee158ce2c03f0bbe4b6419"

URI_x86_64_v2_libvirt-daemon-log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-log-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-log}"
SRC_URI[x86_64_v2_libvirt-daemon-log.sha256sum] = "c583883a96127945b9e5dc2df450594f53bd1654083cdf2c19f662797da4458e"

URI_x86_64_v2_libvirt-daemon-plugin-lockd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-plugin-lockd-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-plugin-lockd}"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-lockd.sha256sum] = "7a4350b3f9e1d89c091145c2d330d88e42563face465ed2354e5781b08abdbad"

URI_x86_64_v2_libvirt-daemon-plugin-sanlock = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-daemon-plugin-sanlock-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-plugin-sanlock}"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-sanlock.sha256sum] = "289972619594c71bf96cf6af981be9a15d654bd8757fc335b0d8d0b5ce639118"

URI_x86_64_v2_libvirt-daemon-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-proxy-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-daemon-proxy}"
SRC_URI[x86_64_v2_libvirt-daemon-proxy.sha256sum] = "5528098ab6b126f6f89ffcc4ad2354ad6592466bd392b6d1d4ded1cb1957d01b"

URI_x86_64_v2_libvirt-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-devel-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-devel}"
SRC_URI[x86_64_v2_libvirt-devel.sha256sum] = "9bb45cf120e0de459eb748a5a373ea1d3e206c13952208f5408df728a0027573"

URI_x86_64_v2_libvirt-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-docs-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-docs}"
SRC_URI[x86_64_v2_libvirt-docs.sha256sum] = "9899fdf47da55f7dc9d8f86fcf8dd32e050070140a1176b3488b44d0292da644"

URI_x86_64_v2_libvirt-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-libs-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-libs}"
SRC_URI[x86_64_v2_libvirt-libs.sha256sum] = "08233a7a1035d786ad6baec9c8543d35ba912a96344b84d6df0a9d89adee5512"

URI_x86_64_v2_libvirt-nss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-nss-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-nss}"
SRC_URI[x86_64_v2_libvirt-nss.sha256sum] = "9bdc116b1e573535cc2b90ddca434eba8159c7b5a4338e890348267b1afc11b4"

URI_x86_64_v2_libvirt-ssh-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-ssh-proxy-10.10.0-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-ssh-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvirt-ssh-proxy}"
SRC_URI[x86_64_v2_libvirt-ssh-proxy.sha256sum] = "fba039e0f5abee51f2414e9e9520108555cb199f584a3de2a9a5e2cd45790ba7"

URI_aarch64_libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt}"
SRC_URI[aarch64_libvirt.sha256sum] = "3db7404803e51e533e3bcbdfe6d74ddfdeee73a52386c820aacd053743a25d2f"

URI_aarch64_libvirt-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-client}"
SRC_URI[aarch64_libvirt-client.sha256sum] = "19d9f1ae2259be3ea5ba7ac0cce50a992a7d7eed248cefcf2ebcf0d965484d09"

URI_aarch64_libvirt-client-qemu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-qemu-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-client-qemu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-client-qemu}"
SRC_URI[aarch64_libvirt-client-qemu.sha256sum] = "26082257fbc5b9a4c19f0c7368436c6076a78e81026f6c861fc4832c8b6701ce"

URI_aarch64_libvirt-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon}"
SRC_URI[aarch64_libvirt-daemon.sha256sum] = "4a471c9bca247999e447032750f9a18ab383d3a1f939208a9d8e259eefef5e11"

URI_aarch64_libvirt-daemon-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-common-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-common}"
SRC_URI[aarch64_libvirt-daemon-common.sha256sum] = "744d61b620c6ec4664e074e583975ba24c200d49a1a92f7833554d4eecc2c271"

URI_aarch64_libvirt-daemon-config-network = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-network-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-config-network}"
SRC_URI[aarch64_libvirt-daemon-config-network.sha256sum] = "7b308092a1360c74fdd25933da76087816a41ef777099c8a43041e87369abb83"

URI_aarch64_libvirt-daemon-config-nwfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-nwfilter-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-config-nwfilter}"
SRC_URI[aarch64_libvirt-daemon-config-nwfilter.sha256sum] = "cc6f2617134c66b314258bff9c8b89710f1f2a0a90d52c4dbfc9ce376a2df90e"

URI_aarch64_libvirt-daemon-driver-interface = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-interface-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-interface;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-interface}"
SRC_URI[aarch64_libvirt-daemon-driver-interface.sha256sum] = "822d950ff0210f4db8c801ed25770277a6b20da0969d3f57c188fb1901bd99b3"

URI_aarch64_libvirt-daemon-driver-network = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-network-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-network}"
SRC_URI[aarch64_libvirt-daemon-driver-network.sha256sum] = "b296bd489f95d2acc801734482c35524144679732297dd70458386aa4dfd9fb1"

URI_aarch64_libvirt-daemon-driver-nodedev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nodedev-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-nodedev}"
SRC_URI[aarch64_libvirt-daemon-driver-nodedev.sha256sum] = "dd439f8d3eee1b01e10a333a58812ce3a881de97f524cfb293413f4daf32c988"

URI_aarch64_libvirt-daemon-driver-nwfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nwfilter-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-nwfilter}"
SRC_URI[aarch64_libvirt-daemon-driver-nwfilter.sha256sum] = "0d7ad144cefc0cd4c2d8bac22d883ec69ac0b346d80a448ff09733f1d3baa6de"

URI_aarch64_libvirt-daemon-driver-qemu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-qemu-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-qemu}"
SRC_URI[aarch64_libvirt-daemon-driver-qemu.sha256sum] = "e8a9d44c89bef36f8c70fb503051dbfa404ecc230f9a482e1909897cfe9486b9"

URI_aarch64_libvirt-daemon-driver-secret = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-secret-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-secret;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-secret}"
SRC_URI[aarch64_libvirt-daemon-driver-secret.sha256sum] = "b0ad0aa70568ee66b37d370bbd53f26672ac1cd1b2186a2b15a6790858649d11"

URI_aarch64_libvirt-daemon-driver-storage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage}"
SRC_URI[aarch64_libvirt-daemon-driver-storage.sha256sum] = "0bd03a3ebc288de78c72d94543b440989556d821e64a6b19ceed0824beecfd33"

URI_aarch64_libvirt-daemon-driver-storage-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-core-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-core}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-core.sha256sum] = "5b5f3e35470959b48dba74ff841eaa2164ec231a3ed9df47402d5597cf798205"

URI_aarch64_libvirt-daemon-driver-storage-disk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-disk-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-disk}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-disk.sha256sum] = "3bbe8e4d1c637d8072c6c5258d2ae7964fc035cc61bb9c3f3d2e7dafddfa8a2b"

URI_aarch64_libvirt-daemon-driver-storage-iscsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-iscsi-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-iscsi}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-iscsi.sha256sum] = "d21d6ae1c1ed2393daa016f39db879d5a4939d0fa696cda78b03cefdd8d09d56"

URI_aarch64_libvirt-daemon-driver-storage-logical = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-logical-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-logical}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-logical.sha256sum] = "12f2af8f9bca86255974cf76e31631117282701f7c67a7620fcfc8cc84db3690"

URI_aarch64_libvirt-daemon-driver-storage-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-mpath-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-mpath}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-mpath.sha256sum] = "3b572faab05735fc47cd92d2bfff61e14329de3661529423bce7c71e4376c0c0"

URI_aarch64_libvirt-daemon-driver-storage-rbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-rbd-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-rbd}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-rbd.sha256sum] = "00d13bd2a44790b825d7d221f09cf7091161414fe713b030cadd7220b0e2ffb4"

URI_aarch64_libvirt-daemon-driver-storage-scsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-scsi-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-driver-storage-scsi}"
SRC_URI[aarch64_libvirt-daemon-driver-storage-scsi.sha256sum] = "653cb96652150a8238210fb281f48301ff8b523b47099554ab131c7f95324eca"

URI_aarch64_libvirt-daemon-kvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-kvm-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-kvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-kvm}"
SRC_URI[aarch64_libvirt-daemon-kvm.sha256sum] = "ed843e5a7500de32ea5a98a925f510f3548fa99e9058a454e0b8aceb114b8c25"

URI_aarch64_libvirt-daemon-lock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-lock-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-lock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-lock}"
SRC_URI[aarch64_libvirt-daemon-lock.sha256sum] = "c679ba9672c73cb8bf55aeb71e4b6deabb141dfea8d71bba17b2e71bd8288b25"

URI_aarch64_libvirt-daemon-log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-log-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-log}"
SRC_URI[aarch64_libvirt-daemon-log.sha256sum] = "14cb9151d358759a0c9bf944635af95e8e0a8cc070d3559eb84b8de786acefc7"

URI_aarch64_libvirt-daemon-plugin-lockd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-plugin-lockd-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-plugin-lockd}"
SRC_URI[aarch64_libvirt-daemon-plugin-lockd.sha256sum] = "713602aa27283ad42d46fae2f0f013003bf69b04e004d5465a1cfa76fa61824a"

URI_aarch64_libvirt-daemon-plugin-sanlock = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-daemon-plugin-sanlock-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-plugin-sanlock}"
SRC_URI[aarch64_libvirt-daemon-plugin-sanlock.sha256sum] = "d68d8d6cfea3d8389152d6828a8b6bf8c919bcda05fa49634fae08871015e7e2"

URI_aarch64_libvirt-daemon-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-proxy-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-daemon-proxy}"
SRC_URI[aarch64_libvirt-daemon-proxy.sha256sum] = "da1f466c24fd3b408645707ecaeb7f1d675f7b44ec6ba2f5fdcd488f04e7477a"

URI_aarch64_libvirt-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-devel-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-devel}"
SRC_URI[aarch64_libvirt-devel.sha256sum] = "5f8563098580271eb289cee64584af509e368f446bca755dec13ade9dbabb987"

URI_aarch64_libvirt-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-docs-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-docs}"
SRC_URI[aarch64_libvirt-docs.sha256sum] = "97d9254478a43054e9772a6bc467291c0eb6f2ebf49a982bf90110e9b8b252dc"

URI_aarch64_libvirt-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-libs-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-libs}"
SRC_URI[aarch64_libvirt-libs.sha256sum] = "6b3ff4ced8fae6a1cb9e2cbe73a5bdabca829ea80efc7f4c2fcb973e4e7abac1"

URI_aarch64_libvirt-nss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-nss-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-nss}"
SRC_URI[aarch64_libvirt-nss.sha256sum] = "ac46c08718434c9840e86c3ebac76dad05edb18aa66815ea1dcd2ede9cc096c4"

URI_aarch64_libvirt-ssh-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-ssh-proxy-10.10.0-7.el10.alma.1.aarch64.rpm;name=aarch64_libvirt-ssh-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvirt-ssh-proxy}"
SRC_URI[aarch64_libvirt-ssh-proxy.sha256sum] = "7c7676d88132b5148dbc04cd60d2dbaf5fdaad14d4c7d4cad9827f77781c3088"

RDEPENDS:libvirt = " \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-libs \
 "
RDEPENDS:libvirt-client = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libvirt-libs \
 libxml2 \
 readline \
 "
RDEPENDS:libvirt-client-qemu = " \
 libvirt-libs \
 python3 \
 python3-cryptography \
 python3-libvirt \
 python3-lxml \
 "
RDEPENDS:libvirt-daemon = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-common = " \
 bash \
 dbus \
 dmidecode \
 gettext \
 glib2 \
 glibc \
 iproute \
 iproute-tc \
 libacl \
 libgcc \
 libvirt-libs \
 polkit \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:libvirt-daemon-config-network = " \
 bash \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-daemon-config-nwfilter = " \
 bash \
 libvirt-daemon-driver-nwfilter \
 "
RDEPENDS:libvirt-daemon-driver-interface = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-network = " \
 bash \
 dnsmasq \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 nftables \
 "
RDEPENDS:libvirt-daemon-driver-nodedev = " \
 bash \
 glib2 \
 glibc \
 kmod \
 libgcc \
 libpciaccess \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 mdevctl \
 systemd \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-nwfilter = " \
 bash \
 glib2 \
 glibc \
 iptables-nft \
 libgcc \
 libpcap \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-qemu = " \
 bash \
 bzip2 \
 glib2 \
 glibc \
 gnutls \
 gzip \
 libgcc \
 libnbd \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-log \
 libvirt-libs \
 libxml2 \
 lzop \
 numad \
 qemu-img \
 swtpm-tools \
 systemd-container \
 xz \
 zstd \
 "
RDEPENDS:libvirt-daemon-driver-secret = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage = " \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 "
RDEPENDS:libvirt-daemon-driver-storage-core = " \
 bash \
 glib2 \
 glibc \
 libblkid \
 libgcc \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 libxml2 \
 parted \
 qemu-img \
 scrub \
 util-linux \
 "
RDEPENDS:libvirt-daemon-driver-storage-disk = " \
 device-mapper \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 parted \
 "
RDEPENDS:libvirt-daemon-driver-storage-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-logical = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 lvm2 \
 "
RDEPENDS:libvirt-daemon-driver-storage-mpath = " \
 device-mapper \
 device-mapper-libs \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-rbd = " \
 glib2 \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-scsi = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-kvm = " \
 libvirt-daemon-common \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-ssh-proxy \
 qemu-kvm \
 "
RDEPENDS:libvirt-daemon-lock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-log = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-lockd = " \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-lock \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-sanlock = " \
 augeas \
 bash \
 glib2 \
 glibc \
 libgcc \
 libvirt-libs \
 sanlock \
 sanlock-lib \
 "
RDEPENDS:libvirt-daemon-proxy = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-devel = " \
 libvirt-devel \
 libvirt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libvirt-docs = " \
 "
RDEPENDS:libvirt-libs = " \
 audit-libs \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 glib2 \
 glibc \
 gnutls \
 json-c \
 libacl \
 libcap-ng \
 libgcc \
 libnl3 \
 libselinux \
 libssh \
 libtirpc \
 libxml2 \
 numactl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libvirt-nss = " \
 glibc \
 json-c \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-ssh-proxy = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-libs \
 libxml2 \
 "
