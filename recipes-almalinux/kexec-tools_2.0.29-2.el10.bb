# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kexec-tools"
PV = "2.0.29"
PR = "2.el10"
PACKAGES = " \
 kexec-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kexec-tools-2.0.29-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7805a1b0c916de7fd619edd12e4c43b9935ba095771f7c1cfc5770e3a2fd1d4b"

URI_x86_64_v2_kexec-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kexec-tools-2.0.29-2.el10.x86_64_v2.rpm;name=x86_64_v2_kexec-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kexec-tools}"
SRC_URI[x86_64_v2_kexec-tools.sha256sum] = "5b2bde80bd54de4cdc649b39625cd505c9bbaa00d9b531c114ef519708ca53f5"

URI_aarch64_kexec-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kexec-tools-2.0.29-2.el10.aarch64.rpm;name=aarch64_kexec-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kexec-tools}"
SRC_URI[aarch64_kexec-tools.sha256sum] = "1625d7128a68b4b3ff97bcd740e2d38ad1cb1701160bebbda1809e08c4ac61d1"

RDEPENDS:kexec-tools = " \
 glibc \
 xz-libs \
 zlib-ng-compat \
 "
