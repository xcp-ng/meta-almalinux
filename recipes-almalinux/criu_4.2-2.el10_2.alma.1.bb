# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "criu"
PV = "4.2"
PR = "2.el10_2.alma.1"
PACKAGES = " \
 crit \
 criu \
 criu-devel \
 criu-libs \
 python3-criu \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/criu-4.2-2.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5ead0e0f048387756c13bf828f25a80cc7988fb0ca8bf5b295dabdc77d606f06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crit-4.2-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_crit;unpack=0"
SRC_URI[x86_64_v2_crit.sha256sum] = "d3192a933d9619ed7123fe4fdc28bbde9857761c9560d84c25fa572b7cda9c00"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-4.2-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_criu;unpack=0"
SRC_URI[x86_64_v2_criu.sha256sum] = "4e4b1cd6c0d5f8b0cf3964a3d8f5b5155b4a407c2ce368da3092c8ec823789bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/criu-devel-4.2-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_criu-devel;unpack=0"
SRC_URI[x86_64_v2_criu-devel.sha256sum] = "7434a06cf1efa1dea0cf81ce3d6fa8166832f2a6e1b66848aa38afde79a285a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/criu-libs-4.2-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_criu-libs;unpack=0"
SRC_URI[x86_64_v2_criu-libs.sha256sum] = "649c16c153d64641529ed9bd7cf619eb62a4098dbb96dee728c237979dcb0b57"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-criu-4.2-2.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-criu;unpack=0"
SRC_URI[x86_64_v2_python3-criu.sha256sum] = "6df00091ee9f8d0d1882c2d3a6d7d104b90a7cbc92b7819e08a6d68b01e582fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crit-4.2-2.el10_2.alma.1.aarch64.rpm;name=aarch64_crit;unpack=0"
SRC_URI[aarch64_crit.sha256sum] = "deb1d49ed1b276868e17e572dbeb6dfaa8b3bca95c19145bee5bf00c6c12ea6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-4.2-2.el10_2.alma.1.aarch64.rpm;name=aarch64_criu;unpack=0"
SRC_URI[aarch64_criu.sha256sum] = "f2651e4711ae084ed77ea1a9f6ffc059d6e410120ba53f38724dbc4f6e1f78ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/criu-devel-4.2-2.el10_2.alma.1.aarch64.rpm;name=aarch64_criu-devel;unpack=0"
SRC_URI[aarch64_criu-devel.sha256sum] = "e378e038aef79bb49fbb803bd208a427663da509d32e88a6abaca7b627e06685"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/criu-libs-4.2-2.el10_2.alma.1.aarch64.rpm;name=aarch64_criu-libs;unpack=0"
SRC_URI[aarch64_criu-libs.sha256sum] = "c785d0e7f09fe84ff73bbe69e6aab95ac5b28e996ea75a696efc17dcc7721fc8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-criu-4.2-2.el10_2.alma.1.aarch64.rpm;name=aarch64_python3-criu;unpack=0"
SRC_URI[aarch64_python3-criu.sha256sum] = "1bc8221753d5e96789b4098e5eb4a7019003094a282f7786196eac276fafad7b"

RDEPENDS:crit = " \
 python3 \
 python3-criu \
 "
RDEPENDS:criu = " \
 bash \
 glibc \
 gnutls \
 libgcc \
 libnet \
 libnl3 \
 libselinux \
 libuuid \
 nftables \
 protobuf-c \
 "
RDEPENDS:criu-devel = " \
 criu \
 criu-libs \
 pkgconf-pkg-config \
 protobuf-c-devel \
 "
RDEPENDS:criu-libs = " \
 criu \
 glibc \
 protobuf-c \
 "
RDEPENDS:python3-criu = " \
 python3 \
 python3-protobuf \
 "
