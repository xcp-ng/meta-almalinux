# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdns-recursor"
PV = "5.4.5"
PR = "2.el10_2"
PACKAGES = " \
 pdns-recursor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pdns-recursor-5.4.5-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be0daaf8a666dcd4e9f5300b00918c1823fb432f65550a947608b7170f421558"

URI_x86_64_v2_pdns-recursor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-recursor-5.4.5-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-recursor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-recursor}"
SRC_URI[x86_64_v2_pdns-recursor.sha256sum] = "e15415aa1d6084c346cdb1dd50b8c5b3ebb82dd848b1ec116d558f2f75bff5c1"

URI_aarch64_pdns-recursor = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-recursor-5.4.5-2.el10_2.aarch64.rpm;name=aarch64_pdns-recursor;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-recursor}"
SRC_URI[aarch64_pdns-recursor.sha256sum] = "c377b7b5f5db96ae26407ce11fa4996ddad81996bbef30d62eb19a6d760b647e"

RDEPENDS:pdns-recursor = " \
 bash \
 boost-context \
 boost-filesystem \
 fstrm \
 glibc \
 libcap \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
