# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_runcon"
PV = "0.7.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-uu_runcon+default-devel \
 rust-uu_runcon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_runcon-0.7.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fa3523439e0ac5f420dd015997a5def8e35e1cfba3d1a779eb622d3359862b7"

URI_x86_64_v2_rust-uu_runcon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_runcon+default-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_runcon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_runcon+default-devel}"
SRC_URI[x86_64_v2_rust-uu_runcon+default-devel.sha256sum] = "13c13f5c9caca1eed14f28b730335d973953bc64a6362245dee74f4c9afde16b"

URI_x86_64_v2_rust-uu_runcon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_runcon-devel-0.7.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_runcon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_runcon-devel}"
SRC_URI[x86_64_v2_rust-uu_runcon-devel.sha256sum] = "b4b8c709054614dc8172d5b6e9d9ffefd3d22c7553821f5c2a392e5593d676d8"

URI_aarch64_rust-uu_runcon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_runcon+default-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_runcon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_runcon+default-devel}"
SRC_URI[aarch64_rust-uu_runcon+default-devel.sha256sum] = "59ada018a0dcd61445efbd73229125a08aef5146402fd50823d590ff6e45eff9"

URI_aarch64_rust-uu_runcon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_runcon-devel-0.7.0-2.el10_3.noarch.rpm;name=aarch64_rust-uu_runcon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_runcon-devel}"
SRC_URI[aarch64_rust-uu_runcon-devel.sha256sum] = "1b458d902ff863ca294b873fe1d3b10ed79af9ce169738b0c1adb4c92ce39d34"

RDEPENDS:rust-uu_runcon+default-devel = " \
 cargo \
 rust-uu_runcon-devel \
 "
RDEPENDS:rust-uu_runcon-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-selinux+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+perms-devel \
 rust-uucore+selinux-devel \
 "
