# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-spf13-cast"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-spf13-cast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-spf13-cast-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4ad0a48d01b5f42615530e94faa10f81c7545fb654cc874c3428304c1c45a5e"

URI_x86_64_v2_golang-github-spf13-cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-spf13-cast-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-spf13-cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-spf13-cast-devel}"
SRC_URI[x86_64_v2_golang-github-spf13-cast-devel.sha256sum] = "7caf2bc8b4fa26ed10a20154bc3cfed493b7fc433a93b8d8a838c65b300fd739"

URI_aarch64_golang-github-spf13-cast-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-spf13-cast-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-spf13-cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-spf13-cast-devel}"
SRC_URI[aarch64_golang-github-spf13-cast-devel.sha256sum] = "1e5d1fceea52ca552f236a40edaa07cbf7b6e5bbd468c42deab6939008bc897d"

RDEPENDS:golang-github-spf13-cast-devel = " \
 go-filesystem \
 "
