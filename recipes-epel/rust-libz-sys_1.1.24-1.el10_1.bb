# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-sys"
PV = "1.1.24"
PR = "1.el10_1"
PACKAGES = " \
 rust-libz-sys+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys+stock-zlib-devel \
 rust-libz-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-sys-1.1.24-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff7979a5b0f339b3ffd5398eeed47233a04f76e709082791bf08c6a8cf973306"

URI_x86_64_v2_rust-libz-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+default-devel-1.1.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-sys+default-devel.sha256sum] = "03dbc363a702f3b2fbedfa0711af2a608970f13fef947a7d0a9daa9a4152db14"

URI_x86_64_v2_rust-libz-sys+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+libc-devel-1.1.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys+libc-devel}"
SRC_URI[x86_64_v2_rust-libz-sys+libc-devel.sha256sum] = "0421c9a6d52dc0b3e812f0140d2a7cf02e33354079eba713645860155cc3dc10"

URI_x86_64_v2_rust-libz-sys+stock-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys+stock-zlib-devel-1.1.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys+stock-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys+stock-zlib-devel}"
SRC_URI[x86_64_v2_rust-libz-sys+stock-zlib-devel.sha256sum] = "19c1679e29ecd5d6dc084422be5fab49bfdbbc7444a6dfd6fb9c8205a4a3bbaf"

URI_x86_64_v2_rust-libz-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-sys-devel-1.1.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-sys-devel.sha256sum] = "cab34064b0de57a5e65c55657fb6a5c662447c77da110976c10d4ca499500b84"

URI_aarch64_rust-libz-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+default-devel-1.1.24-1.el10_1.noarch.rpm;name=aarch64_rust-libz-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys+default-devel}"
SRC_URI[aarch64_rust-libz-sys+default-devel.sha256sum] = "4139615ba05af1d610db526cdf1e4897c449de5b38b6a0f463bf6fd23e8ab80d"

URI_aarch64_rust-libz-sys+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+libc-devel-1.1.24-1.el10_1.noarch.rpm;name=aarch64_rust-libz-sys+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys+libc-devel}"
SRC_URI[aarch64_rust-libz-sys+libc-devel.sha256sum] = "dcee76330302dc596013aa057274f903eac73d9f21a7f0d3937d8608836e4eb9"

URI_aarch64_rust-libz-sys+stock-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys+stock-zlib-devel-1.1.24-1.el10_1.noarch.rpm;name=aarch64_rust-libz-sys+stock-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys+stock-zlib-devel}"
SRC_URI[aarch64_rust-libz-sys+stock-zlib-devel.sha256sum] = "dcc04354650ac022352d82d762f2f15b1066b706b0f10fb907e887e98399e4ee"

URI_aarch64_rust-libz-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-sys-devel-1.1.24-1.el10_1.noarch.rpm;name=aarch64_rust-libz-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-sys-devel}"
SRC_URI[aarch64_rust-libz-sys-devel.sha256sum] = "2cc3b2482601554c8075f3bc8b00a92df19f96b1243075e807db63646587e16d"

RDEPENDS:rust-libz-sys+default-devel = " \
 cargo \
 rust-libz-sys+libc-devel \
 rust-libz-sys+stock-zlib-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys+stock-zlib-devel = " \
 cargo \
 rust-libz-sys-devel \
 "
RDEPENDS:rust-libz-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 zlib-ng-compat-devel \
 "
