# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-qtl"
PV = "1.74"
PR = "7.el10_1"
PACKAGES = " \
 R-qtl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-qtl-1.74-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "258ae5ab8e015f97bfb15e5a4fdabf622344f9d5aef3e4f969df9ed764a7684b"

URI_x86_64_v2_R-qtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-qtl-1.74-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-qtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-qtl}"
SRC_URI[x86_64_v2_R-qtl.sha256sum] = "4663b51975877524274efabfcf5462e1a4637151d4ebe2cf4753e5f6ca0a26ec"

URI_aarch64_R-qtl = "${EPEL_MIRROR}/aarch64/Packages/r/R-qtl-1.74-7.el10_1.aarch64.rpm;name=aarch64_R-qtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-qtl}"
SRC_URI[aarch64_R-qtl.sha256sum] = "3d8912ec6c4d87ef322b11ab792cdb3543f3cabb7f214b561d254084d49106a8"

RDEPENDS:R-qtl = " \
 R-core \
 bash \
 flexiblas-netlib \
 glibc \
 ruby \
 "
