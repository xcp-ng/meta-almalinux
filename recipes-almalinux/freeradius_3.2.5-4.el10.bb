# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeradius"
PV = "3.2.5"
PR = "4.el10"
PACKAGES = " \
 freeradius \
 freeradius-devel \
 freeradius-doc \
 freeradius-krb5 \
 freeradius-ldap \
 freeradius-mysql \
 freeradius-perl \
 freeradius-postgresql \
 freeradius-rest \
 freeradius-sqlite \
 freeradius-unixODBC \
 freeradius-utils \
 python3-freeradius \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freeradius-3.2.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3f11fc7ccfdbf52fae1182c3880b19da95591990c1ef8ca50080fbcfe555f10"

URI_x86_64_v2_freeradius = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius}"
SRC_URI[x86_64_v2_freeradius.sha256sum] = "99cf9ef913b212faaa9931483dd2889b65d3951b4a6b6ddf21f00750341fb55b"

URI_x86_64_v2_freeradius-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-devel-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-devel}"
SRC_URI[x86_64_v2_freeradius-devel.sha256sum] = "084a2d443912411f52ce32c71698e85002b977aac313a3f4d3361aaf8fc318be"

URI_x86_64_v2_freeradius-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-doc-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-doc}"
SRC_URI[x86_64_v2_freeradius-doc.sha256sum] = "394e1edb6301616cff688eb86658fd7f57206f39b7b17e7e727a47b6d2737db4"

URI_x86_64_v2_freeradius-krb5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-krb5-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-krb5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-krb5}"
SRC_URI[x86_64_v2_freeradius-krb5.sha256sum] = "c69936f8998f11bbfc07f290c309fc079697f2822929302279665f785e78ad2e"

URI_x86_64_v2_freeradius-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-ldap-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-ldap}"
SRC_URI[x86_64_v2_freeradius-ldap.sha256sum] = "23ec3050013a6896f0230a3b5090b06be803d57f6abdae7d6a17561ceef2a099"

URI_x86_64_v2_freeradius-mysql = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-mysql-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-mysql}"
SRC_URI[x86_64_v2_freeradius-mysql.sha256sum] = "045b17837793855972785be3c15481f8c72144ee05e194d3620d7ebc05a0b818"

URI_x86_64_v2_freeradius-perl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-perl-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-perl}"
SRC_URI[x86_64_v2_freeradius-perl.sha256sum] = "01e7d6498cea2bb22d34fa32f4edec5a3c4e0d373f2bdd83213ae6d05d3aac29"

URI_x86_64_v2_freeradius-postgresql = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-postgresql-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-postgresql}"
SRC_URI[x86_64_v2_freeradius-postgresql.sha256sum] = "26a5699dd322c1c3b52966ee12594c7f4a45534792b037d1dd397e939613eb0f"

URI_x86_64_v2_freeradius-rest = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-rest-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-rest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-rest}"
SRC_URI[x86_64_v2_freeradius-rest.sha256sum] = "57a09ca849641ba1faea7e7acc2f9d9f050cf6eedb8b467ee437ab2f349a6097"

URI_x86_64_v2_freeradius-sqlite = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-sqlite-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-sqlite}"
SRC_URI[x86_64_v2_freeradius-sqlite.sha256sum] = "de639a474d3e11e60a765f97e5ed7a0fb921cfeede6b969e0e314eb3723a1e06"

URI_x86_64_v2_freeradius-unixODBC = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freeradius-unixODBC-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-unixODBC;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-unixODBC}"
SRC_URI[x86_64_v2_freeradius-unixODBC.sha256sum] = "6d6760eb52564588d1d23c077ce61924aee91e0e76fa70f43f96ba7577255914"

URI_x86_64_v2_freeradius-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freeradius-utils-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_freeradius-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freeradius-utils}"
SRC_URI[x86_64_v2_freeradius-utils.sha256sum] = "050e87a6a595d50a8a8ba3301132e5d4b78cecdb5b007d1983f124d5c449ec19"

URI_x86_64_v2_python3-freeradius = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-freeradius-3.2.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3-freeradius;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-freeradius}"
SRC_URI[x86_64_v2_python3-freeradius.sha256sum] = "7295c5db275dbcb72633464bba79caf856444997fc88848b1d82699ddcacbcb8"

URI_aarch64_freeradius = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius}"
SRC_URI[aarch64_freeradius.sha256sum] = "5753529fb0ce8cba5d1a1712c28372ea0e5e2248bccc77237864db77523b7b70"

URI_aarch64_freeradius-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-devel-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-devel}"
SRC_URI[aarch64_freeradius-devel.sha256sum] = "76a08d0ff25dfd93ba48286780688bf65ee1daa643830cb48efa2f510ba9a589"

URI_aarch64_freeradius-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-doc-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-doc}"
SRC_URI[aarch64_freeradius-doc.sha256sum] = "e547da864167f3d9b73db62784d69da522a16c58b6dacc72fe5ff0855b5160f8"

URI_aarch64_freeradius-krb5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-krb5-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-krb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-krb5}"
SRC_URI[aarch64_freeradius-krb5.sha256sum] = "16fcf6edadbab6e1f25a55cce5b7148600a54a9cc91c9bbede5fff0584670bcd"

URI_aarch64_freeradius-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-ldap-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-ldap}"
SRC_URI[aarch64_freeradius-ldap.sha256sum] = "755309a96bfa7747ec6c6adcbbcaf5c838fb0608bfea8a702c49cb0550659ef4"

URI_aarch64_freeradius-mysql = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-mysql-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-mysql}"
SRC_URI[aarch64_freeradius-mysql.sha256sum] = "5828ea02158356e2ac32a47555a5923c6ff8b9346c572fb9ccaaa2d829823ac5"

URI_aarch64_freeradius-perl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-perl-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-perl}"
SRC_URI[aarch64_freeradius-perl.sha256sum] = "70d71ac2ac4523a594f3b4d2290a58a77c32241bef3ce0581aba4203fdc6530e"

URI_aarch64_freeradius-postgresql = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-postgresql-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-postgresql}"
SRC_URI[aarch64_freeradius-postgresql.sha256sum] = "6d654ce37b6eefb63910d9b0c0a67dce440e8645e548473ee1940fc4150bd7b8"

URI_aarch64_freeradius-rest = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-rest-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-rest;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-rest}"
SRC_URI[aarch64_freeradius-rest.sha256sum] = "959f98ce457ef9a68fd1f6ba16c83a2a86d2cc72936c347ff34c6b4a9018b59f"

URI_aarch64_freeradius-sqlite = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-sqlite-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-sqlite}"
SRC_URI[aarch64_freeradius-sqlite.sha256sum] = "97c16629b5db926e5ff561d1c63f4e72f4dd262ff7a3440cad012a4f3b9d0c19"

URI_aarch64_freeradius-unixODBC = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freeradius-unixODBC-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-unixODBC;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-unixODBC}"
SRC_URI[aarch64_freeradius-unixODBC.sha256sum] = "9e0549962d835747280cdeb70bcd51f96d21c7a576435800add9785760b01402"

URI_aarch64_freeradius-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freeradius-utils-3.2.5-4.el10.aarch64.rpm;name=aarch64_freeradius-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_freeradius-utils}"
SRC_URI[aarch64_freeradius-utils.sha256sum] = "87c7199be8c9066926b0f8a850426648f414ef9deb53c030440f92b506544f48"

URI_aarch64_python3-freeradius = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-freeradius-3.2.5-4.el10.aarch64.rpm;name=aarch64_python3-freeradius;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-freeradius}"
SRC_URI[aarch64_python3-freeradius.sha256sum] = "f654d2c9ac72d5c78a1c0ad6c64b7acad22cb6fef16babfe38c3e0b0566d1140"

RDEPENDS:freeradius = " \
 bash \
 gdbm-libs \
 glibc \
 glibc-common \
 json-c \
 libpcap \
 libtalloc \
 libxcrypt \
 make \
 openssl \
 openssl-libs \
 pam-libs \
 perl-interpreter \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:freeradius-devel = " \
 freeradius \
 "
RDEPENDS:freeradius-doc = " \
 "
RDEPENDS:freeradius-krb5 = " \
 freeradius \
 glibc \
 krb5-libs \
 libcom_err \
 "
RDEPENDS:freeradius-ldap = " \
 freeradius \
 glibc \
 openldap \
 "
RDEPENDS:freeradius-mysql = " \
 freeradius \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:freeradius-perl = " \
 freeradius \
 glibc \
 perl-libs \
 "
RDEPENDS:freeradius-postgresql = " \
 freeradius \
 glibc \
 libpq \
 "
RDEPENDS:freeradius-rest = " \
 freeradius \
 glibc \
 json-c \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:freeradius-sqlite = " \
 freeradius \
 glibc \
 sqlite-libs \
 "
RDEPENDS:freeradius-unixODBC = " \
 freeradius \
 glibc \
 unixODBC \
 "
RDEPENDS:freeradius-utils = " \
 bash \
 freeradius \
 gdbm-libs \
 glibc \
 libpcap \
 libtalloc \
 openssl-libs \
 perl-DBI \
 perl-Fcntl \
 perl-File-Basename \
 perl-GDBM_File \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-POSIX \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:python3-freeradius = " \
 freeradius \
 glibc \
 python3 \
 python3-libs \
 "
