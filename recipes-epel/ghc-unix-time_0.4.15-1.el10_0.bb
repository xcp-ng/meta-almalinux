# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-unix-time"
PV = "0.4.15"
PR = "1.el10_0"
PACKAGES = " \
 ghc-unix-time \
 ghc-unix-time-devel \
 ghc-unix-time-doc \
 ghc-unix-time-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-unix-time-0.4.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7ca56e6accf009206b895114085f10c3da8b48837f588b44e3f2183c8c83d16"

URI_x86_64_v2_ghc-unix-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unix-time-0.4.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unix-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unix-time}"
SRC_URI[x86_64_v2_ghc-unix-time.sha256sum] = "4a8b62db77988887baa64c185ff51cbd3f864248e54edee0f2007cdd52e9c21d"

URI_x86_64_v2_ghc-unix-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unix-time-devel-0.4.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unix-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unix-time-devel}"
SRC_URI[x86_64_v2_ghc-unix-time-devel.sha256sum] = "f32b3beff6b084c49546fcddc318a45d20cda011d9d7908f885a23dffffc4b6f"

URI_x86_64_v2_ghc-unix-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unix-time-doc-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-unix-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unix-time-doc}"
SRC_URI[x86_64_v2_ghc-unix-time-doc.sha256sum] = "c093320843bc56cb2c018e6d05ab19fd3f7cbfcd790bb45da8dc6553fa1041be"

URI_x86_64_v2_ghc-unix-time-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-unix-time-prof-0.4.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-unix-time-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-unix-time-prof}"
SRC_URI[x86_64_v2_ghc-unix-time-prof.sha256sum] = "5f25132de4866b35b28f3f1f350ded0978dac69e05d580782039070138b0d402"

URI_aarch64_ghc-unix-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unix-time-0.4.15-1.el10_0.aarch64.rpm;name=aarch64_ghc-unix-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unix-time}"
SRC_URI[aarch64_ghc-unix-time.sha256sum] = "cd7ade93a6d6fb0091924c422c64a87664ba57f981ee7c904eb15a44398a9e5b"

URI_aarch64_ghc-unix-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unix-time-devel-0.4.15-1.el10_0.aarch64.rpm;name=aarch64_ghc-unix-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unix-time-devel}"
SRC_URI[aarch64_ghc-unix-time-devel.sha256sum] = "f68dcea3f5dc061e865547d7b09e155558d6f1d2de83be829b387eb5d43a5641"

URI_aarch64_ghc-unix-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unix-time-doc-0.4.15-1.el10_0.noarch.rpm;name=aarch64_ghc-unix-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unix-time-doc}"
SRC_URI[aarch64_ghc-unix-time-doc.sha256sum] = "f36ae02a7974ef8d7eeaca631ef9eae093288db5d8b8f655d694d4a209285e20"

URI_aarch64_ghc-unix-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-unix-time-prof-0.4.15-1.el10_0.aarch64.rpm;name=aarch64_ghc-unix-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-unix-time-prof}"
SRC_URI[aarch64_ghc-unix-time-prof.sha256sum] = "a43a05032a6a469cc92afbbe6bb03d235eb5e9d1a5c1d2ec2e244be0eb84df8e"

RDEPENDS:ghc-unix-time = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-old-locale \
 ghc-old-time \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-unix-time-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-old-time-devel \
 ghc-unix-time \
 "
RDEPENDS:ghc-unix-time-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-unix-time-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-old-time-prof \
 ghc-unix-time-devel \
 "
