# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-executable-path"
PV = "1.0.0"
PR = "10.el10_0"
PACKAGES = " \
 rust-executable-path+default-devel \
 rust-executable-path-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-executable-path-1.0.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59d69e16e76daec0ededa84a398988fb59b9486c8cee2a56151648f42f130351"

URI_x86_64_v2_rust-executable-path+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-executable-path+default-devel-1.0.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-executable-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-executable-path+default-devel}"
SRC_URI[x86_64_v2_rust-executable-path+default-devel.sha256sum] = "1506600ee25ec86828e41262385a72245e1aaf8e02d9d4c6f3cf03323bcd2f51"

URI_x86_64_v2_rust-executable-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-executable-path-devel-1.0.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-executable-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-executable-path-devel}"
SRC_URI[x86_64_v2_rust-executable-path-devel.sha256sum] = "7bbc1a7e060e80a676c69914d67d959170e8708db71283fd5b231d1c042181f8"

URI_aarch64_rust-executable-path+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-executable-path+default-devel-1.0.0-10.el10_0.noarch.rpm;name=aarch64_rust-executable-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-executable-path+default-devel}"
SRC_URI[aarch64_rust-executable-path+default-devel.sha256sum] = "dfa8803dbf917c1e632d4e8623d8e7518e4099b334a8fcaa5a88afa091b88442"

URI_aarch64_rust-executable-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-executable-path-devel-1.0.0-10.el10_0.noarch.rpm;name=aarch64_rust-executable-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-executable-path-devel}"
SRC_URI[aarch64_rust-executable-path-devel.sha256sum] = "3ba30c7f8a57486f356e3576157377e242832062799cb52ab46fa4c10e6fd8d5"

RDEPENDS:rust-executable-path+default-devel = " \
 cargo \
 rust-executable-path-devel \
 "
RDEPENDS:rust-executable-path-devel = " \
 cargo \
 "
