# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "felix-utils"
PV = "1.11.8"
PR = "10.el10"
PACKAGES = " \
 felix-utils \
 felix-utils-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/felix-utils-1.11.8-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd044f684fbf088ea97fff71bb2d433719562b5b04bada5c9ba34bdc3507af78"

URI_x86_64_v2_felix-utils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/felix-utils-1.11.8-10.el10.noarch.rpm;name=x86_64_v2_felix-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_felix-utils}"
SRC_URI[x86_64_v2_felix-utils.sha256sum] = "2812269fbf9902feea254f09641086e4cd2020eabd6d209608c377611dfcceb0"

URI_x86_64_v2_felix-utils-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/felix-utils-javadoc-1.11.8-10.el10.noarch.rpm;name=x86_64_v2_felix-utils-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_felix-utils-javadoc}"
SRC_URI[x86_64_v2_felix-utils-javadoc.sha256sum] = "bc3022fc4196f928780c35acf7a2447e0e76457d809ea4cf7b8b5b53f08a8713"

URI_aarch64_felix-utils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/felix-utils-1.11.8-10.el10.noarch.rpm;name=aarch64_felix-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_felix-utils}"
SRC_URI[aarch64_felix-utils.sha256sum] = "2812269fbf9902feea254f09641086e4cd2020eabd6d209608c377611dfcceb0"

URI_aarch64_felix-utils-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/felix-utils-javadoc-1.11.8-10.el10.noarch.rpm;name=aarch64_felix-utils-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_felix-utils-javadoc}"
SRC_URI[aarch64_felix-utils-javadoc.sha256sum] = "bc3022fc4196f928780c35acf7a2447e0e76457d809ea4cf7b8b5b53f08a8713"

RDEPENDS:felix-utils = " \
 javapackages-filesystem \
 "
RDEPENDS:felix-utils-javadoc = " \
 javapackages-filesystem \
 "
