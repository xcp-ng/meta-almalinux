# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librtprocess"
PV = "0.12.0"
PR = "15.el10_0"
PACKAGES = " \
 librtprocess \
 librtprocess-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/librtprocess-0.12.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c516dcf11000738a4a928f9406e01b26ece19058122c3336d0b262a0d014e66a"

URI_x86_64_v2_librtprocess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librtprocess-0.12.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librtprocess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librtprocess}"
SRC_URI[x86_64_v2_librtprocess.sha256sum] = "f81305da0e80ce8205c83d590c297d8cf1a9d62fc6eb0585cd29b2f9bcaac176"

URI_x86_64_v2_librtprocess-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librtprocess-devel-0.12.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librtprocess-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librtprocess-devel}"
SRC_URI[x86_64_v2_librtprocess-devel.sha256sum] = "0070aa6022231f50acf3c0c1a6aa22a51a017359d520eb50c34392f344de8808"

URI_aarch64_librtprocess = "${EPEL_MIRROR}/aarch64/Packages/l/librtprocess-0.12.0-15.el10_0.aarch64.rpm;name=aarch64_librtprocess;unpack=0"
SRC_URI:append = " ${URI_aarch64_librtprocess}"
SRC_URI[aarch64_librtprocess.sha256sum] = "23336c1da7d4f3a4b4613d69706a5a94db7b005f9c619ca1ef0f150369033c11"

URI_aarch64_librtprocess-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librtprocess-devel-0.12.0-15.el10_0.aarch64.rpm;name=aarch64_librtprocess-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librtprocess-devel}"
SRC_URI[aarch64_librtprocess-devel.sha256sum] = "81bd5bf0ebc8992d9e988d359ff0cded4d72871157b6a7c6c87f5ed738d0e465"

RDEPENDS:librtprocess = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 "
RDEPENDS:librtprocess-devel = " \
 cmake-filesystem \
 librtprocess \
 pkgconf-pkg-config \
 "
