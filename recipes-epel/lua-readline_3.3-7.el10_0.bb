# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-readline"
PV = "3.3"
PR = "7.el10_0"
PACKAGES = " \
 lua-readline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-readline-3.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e14103c155e15f640c4796efaf83a2fa76884a6bce0d3ecf05e19d97c551f1ee"

URI_x86_64_v2_lua-readline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-readline-3.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-readline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-readline}"
SRC_URI[x86_64_v2_lua-readline.sha256sum] = "7aa7a042ca9dcc763c6fc98ba3c3d4cb273a58d061536751b32b1a99236cb173"

URI_aarch64_lua-readline = "${EPEL_MIRROR}/aarch64/Packages/l/lua-readline-3.3-7.el10_0.aarch64.rpm;name=aarch64_lua-readline;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-readline}"
SRC_URI[aarch64_lua-readline.sha256sum] = "7362b12eef6a1f408e42fe87868a0158e3a720420a0e1abe5b421d09f2040c60"

RDEPENDS:lua-readline = " \
 glibc \
 lua-libs \
 lua-posix \
 "
