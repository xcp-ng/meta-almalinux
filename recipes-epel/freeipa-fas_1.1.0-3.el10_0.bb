# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freeipa-fas"
PV = "1.1.0"
PR = "3.el10_0"
PACKAGES = " \
 ipa-fas \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/freeipa-fas-1.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d6a685aabaa058386ac43e45c9c200f3b5215e4389d843553382ec51f89518e"

URI_x86_64_v2_ipa-fas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ipa-fas-1.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ipa-fas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-fas}"
SRC_URI[x86_64_v2_ipa-fas.sha256sum] = "120e56305cc30655dd1a4646694dce0170930540a663a1f39deac62350490266"

URI_aarch64_ipa-fas = "${EPEL_MIRROR}/aarch64/Packages/i/ipa-fas-1.1.0-3.el10_0.noarch.rpm;name=aarch64_ipa-fas;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-fas}"
SRC_URI[aarch64_ipa-fas.sha256sum] = "f52252148011ff8b179e8e61bad319ea96195f7be692cc7da41f84ce6314e9d0"

RDEPENDS:ipa-fas = " \
 bash \
 ipa-server \
 python3 \
 "
