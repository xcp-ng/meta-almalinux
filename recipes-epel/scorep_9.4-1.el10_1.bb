# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scorep"
PV = "9.4"
PR = "1.el10_1"
PACKAGES = " \
 scorep \
 scorep-config \
 scorep-doc \
 scorep-libs \
 scorep-mpich \
 scorep-mpich-config \
 scorep-mpich-libs \
 scorep-openmpi \
 scorep-openmpi-config \
 scorep-openmpi-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scorep-9.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a3076fb0936cefda88afe2bb07f18d4a34e8cd55acc088cb0d227cf7599ffba"

URI_x86_64_v2_scorep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-9.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep}"
SRC_URI[x86_64_v2_scorep.sha256sum] = "f5d0afd40562a07671ec20b6c556b9d56932e77ebb95f3499278864eefe2e2fb"

URI_x86_64_v2_scorep-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-config-9.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-config}"
SRC_URI[x86_64_v2_scorep-config.sha256sum] = "46bd00d1e1fe14227cb2e1e792202b01d1e69739c2806176a60bd0178cb71b26"

URI_x86_64_v2_scorep-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-doc-9.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_scorep-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-doc}"
SRC_URI[x86_64_v2_scorep-doc.sha256sum] = "bdf85bed8b09303f291a7aa6cfe5df913794060c99da193618adc82269004354"

URI_x86_64_v2_scorep-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-libs-9.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-libs}"
SRC_URI[x86_64_v2_scorep-libs.sha256sum] = "6f5160ae8d5f72e9815ac5d35c18f3fe2185c112cec75589dc98ba65fc076ed1"

URI_x86_64_v2_scorep-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-9.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich}"
SRC_URI[x86_64_v2_scorep-mpich.sha256sum] = "2b0fbb2c1fffd4ab0be02de480158156e8d45e030d0dc9fe0486cfaa4d230238"

URI_x86_64_v2_scorep-mpich-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-config-9.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich-config}"
SRC_URI[x86_64_v2_scorep-mpich-config.sha256sum] = "87644e62bc71555123944ba3098e542a9aa7b996356e2c1f2889b6ec1af89427"

URI_x86_64_v2_scorep-mpich-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-libs-9.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich-libs}"
SRC_URI[x86_64_v2_scorep-mpich-libs.sha256sum] = "58bb657da9066582a4a45ecf8c829dad708e63e955118c419e8d12e6d96d7609"

URI_x86_64_v2_scorep-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-9.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi}"
SRC_URI[x86_64_v2_scorep-openmpi.sha256sum] = "31f7453f12a7c2341569dddb6e7d3b1af466dfac2317fd72bd1e3896a63a160a"

URI_x86_64_v2_scorep-openmpi-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-config-9.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi-config}"
SRC_URI[x86_64_v2_scorep-openmpi-config.sha256sum] = "980d75ea3f16dc7ab7160a51516cd1386d70c50e982e214e54927aa6e0e43067"

URI_x86_64_v2_scorep-openmpi-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-libs-9.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi-libs}"
SRC_URI[x86_64_v2_scorep-openmpi-libs.sha256sum] = "129b7865dcdc04f46b34355618a9607c09eb2d5ab1aa1445f27c7bd3d77b8dc0"

URI_aarch64_scorep = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-9.4-1.el10_1.aarch64.rpm;name=aarch64_scorep;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep}"
SRC_URI[aarch64_scorep.sha256sum] = "fd969b03116e224f6dfaf27fde585f013699572f1b1b899f6fbd64f399226c57"

URI_aarch64_scorep-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-config-9.4-1.el10_1.aarch64.rpm;name=aarch64_scorep-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-config}"
SRC_URI[aarch64_scorep-config.sha256sum] = "981cf053e246426c29ecc86e1d33e582b9e66394ae902c12ff87792e3010efa7"

URI_aarch64_scorep-doc = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-doc-9.4-1.el10_1.noarch.rpm;name=aarch64_scorep-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-doc}"
SRC_URI[aarch64_scorep-doc.sha256sum] = "a0d994498286c7f548421daf3d47c9866c3ebd0a64803c111a39b8e94ececa84"

URI_aarch64_scorep-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-libs-9.4-1.el10_1.aarch64.rpm;name=aarch64_scorep-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-libs}"
SRC_URI[aarch64_scorep-libs.sha256sum] = "7d8fac7f0d09c5ec67f1976aef2e2431cbd19d7b195c7f270a025aa86c74dcee"

URI_aarch64_scorep-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-9.4-1.el10_1.aarch64.rpm;name=aarch64_scorep-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich}"
SRC_URI[aarch64_scorep-mpich.sha256sum] = "133d1ea47cd400f05500fd8c8b3e930679e50bb289eaed68f41409d942af838f"

URI_aarch64_scorep-mpich-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-config-9.4-1.el10_1.aarch64.rpm;name=aarch64_scorep-mpich-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich-config}"
SRC_URI[aarch64_scorep-mpich-config.sha256sum] = "39281a9bcfd2842d41cf778b5113fa9c7fbe5fb4fba628341be0b88e6779ef55"

URI_aarch64_scorep-mpich-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-libs-9.4-1.el10_1.aarch64.rpm;name=aarch64_scorep-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich-libs}"
SRC_URI[aarch64_scorep-mpich-libs.sha256sum] = "409365007a82735aacef0e73947fcabe96063e5d0e6472d8a4ec6c1498a51bcc"

URI_aarch64_scorep-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-9.4-1.el10_1.aarch64.rpm;name=aarch64_scorep-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi}"
SRC_URI[aarch64_scorep-openmpi.sha256sum] = "32e872dda07768216c3b8bd49948f827d4bee5a6f1a46be8d6c0cf2f4cd59356"

URI_aarch64_scorep-openmpi-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-config-9.4-1.el10_1.aarch64.rpm;name=aarch64_scorep-openmpi-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi-config}"
SRC_URI[aarch64_scorep-openmpi-config.sha256sum] = "4b32f69c385b3bb56403715723158181cc25b8b0274cd586444691299e973c99"

URI_aarch64_scorep-openmpi-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-libs-9.4-1.el10_1.aarch64.rpm;name=aarch64_scorep-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi-libs}"
SRC_URI[aarch64_scorep-openmpi-libs.sha256sum] = "e0182404e3fdbb26915aecca7e21c444cf25942ec844f5f8d5f44feb9cd44870"

RDEPENDS:scorep = " \
 bash \
 binutils-devel \
 clang-libs \
 cube-libs \
 cube-libs-devel \
 glibc \
 gotcha-devel \
 libgcc \
 libstdc++ \
 libunwind-devel \
 ocl-icd-devel \
 opari2 \
 otf2-devel \
 papi-devel \
 scorep-libs \
 "
RDEPENDS:scorep-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-doc = " \
 "
RDEPENDS:scorep-libs = " \
 scorep-config \
 "
RDEPENDS:scorep-mpich = " \
 bash \
 cube-libs \
 cube-libs-devel \
 glibc \
 libgcc \
 libstdc++ \
 otf2-devel \
 papi-devel \
 scorep-mpich-libs \
 "
RDEPENDS:scorep-mpich-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-mpich-libs = " \
 scorep-mpich-config \
 "
RDEPENDS:scorep-openmpi = " \
 bash \
 cube-libs \
 cube-libs-devel \
 glibc \
 libgcc \
 libstdc++ \
 otf2-devel \
 papi-devel \
 scorep-openmpi-libs \
 "
RDEPENDS:scorep-openmpi-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-openmpi-libs = " \
 scorep-openmpi-config \
 "
