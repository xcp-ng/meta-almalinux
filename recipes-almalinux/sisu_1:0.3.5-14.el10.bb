# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sisu"
PE = "1"
PV = "0.3.5"
PR = "14.el10"
PACKAGES = " \
 sisu \
 sisu-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sisu-0.3.5-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45d3cf3ea5da44be5ea64c4ffc9387ac34fb84b1cf0c56061891be4e2a3a80ca"

URI_x86_64_v2_sisu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sisu-0.3.5-14.el10.noarch.rpm;name=x86_64_v2_sisu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sisu}"
SRC_URI[x86_64_v2_sisu.sha256sum] = "c0dc7d7d8ca946dbf3eee8f38e44766273ffe3605d54b4f0a93502888e295127"

URI_x86_64_v2_sisu-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sisu-javadoc-0.3.5-14.el10.noarch.rpm;name=x86_64_v2_sisu-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sisu-javadoc}"
SRC_URI[x86_64_v2_sisu-javadoc.sha256sum] = "911c57a8c660976cd0562fd9cd754c344bdbd61bcb58bae0e7215747ebe8cc5a"

URI_aarch64_sisu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sisu-0.3.5-14.el10.noarch.rpm;name=aarch64_sisu;unpack=0"
SRC_URI:append = " ${URI_aarch64_sisu}"
SRC_URI[aarch64_sisu.sha256sum] = "c0dc7d7d8ca946dbf3eee8f38e44766273ffe3605d54b4f0a93502888e295127"

URI_aarch64_sisu-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sisu-javadoc-0.3.5-14.el10.noarch.rpm;name=aarch64_sisu-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sisu-javadoc}"
SRC_URI[aarch64_sisu-javadoc.sha256sum] = "911c57a8c660976cd0562fd9cd754c344bdbd61bcb58bae0e7215747ebe8cc5a"

RDEPENDS:sisu = " \
 cdi-api \
 javapackages-filesystem \
 plexus-classworlds \
 plexus-containers-component-annotations \
 plexus-utils \
 "
RDEPENDS:sisu-javadoc = " \
 javapackages-filesystem \
 "
