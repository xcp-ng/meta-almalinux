# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_lookup_identity"
PV = "1.0.0"
PR = "22.el10"
PACKAGES = " \
 mod_lookup_identity \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_lookup_identity-1.0.0-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1109caba95418405655c7e3ce1c784de623326ca532410df25768bb794bad57f"

URI_x86_64_v2_mod_lookup_identity = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_lookup_identity-1.0.0-22.el10.x86_64_v2.rpm;name=x86_64_v2_mod_lookup_identity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_lookup_identity}"
SRC_URI[x86_64_v2_mod_lookup_identity.sha256sum] = "b87dfbcd8d049f5a8c1f1eb5d83f3fe335ba1a95d121b2094104f447f9407a44"

URI_aarch64_mod_lookup_identity = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_lookup_identity-1.0.0-22.el10.aarch64.rpm;name=aarch64_mod_lookup_identity;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_lookup_identity}"
SRC_URI[aarch64_mod_lookup_identity.sha256sum] = "9163981f8dd3cc95da920273f31bb4bad16f9e958915716d643cf8e249e18d6a"

RDEPENDS:mod_lookup_identity = " \
 dbus-libs \
 glibc \
 httpd-core \
 "
