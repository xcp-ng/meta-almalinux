# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ftputil"
PV = "5.2.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-ftputil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ftputil-5.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0366060706c63ed160f088933cc298b7b0b6498ba61d047dde0de63160ac534"

URI_x86_64_v2_python3-ftputil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ftputil-5.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ftputil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ftputil}"
SRC_URI[x86_64_v2_python3-ftputil.sha256sum] = "5984576464beb7ddf72b15d2208c5e16a6f4d3f424588efdb79dbf6cb11265fd"

URI_aarch64_python3-ftputil = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ftputil-5.2.0-1.el10_3.noarch.rpm;name=aarch64_python3-ftputil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ftputil}"
SRC_URI[aarch64_python3-ftputil.sha256sum] = "9e7ed0aa6162acc43112d1728f35711c9bc65c459e50365d52ad6a5767c9db66"

RDEPENDS:python3-ftputil = " \
 ftp \
 python3 \
 "
