# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fisx"
PV = "1.3.2"
PR = "12.el10_2"
PACKAGES = " \
 python3-fisx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fisx-1.3.2-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e73d4f79e9a5a7fbc62b6c2c1a6a0dde9b13e36ce0b4befd8cddc81dd37b6296"

URI_x86_64_v2_python3-fisx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fisx-1.3.2-12.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fisx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fisx}"
SRC_URI[x86_64_v2_python3-fisx.sha256sum] = "50245ad8956887a907472e4c5be7d40cf0cc57416ca5e9da4e4e0575fc612fd7"

URI_aarch64_python3-fisx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fisx-1.3.2-12.el10_2.aarch64.rpm;name=aarch64_python3-fisx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fisx}"
SRC_URI[aarch64_python3-fisx.sha256sum] = "a3225b1379554df2fd285e754e707d3df45f57deb3e4f7da2d4ce648c6dc68a6"

RDEPENDS:python3-fisx = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "
