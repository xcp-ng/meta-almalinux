# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-pcp"
PV = "2.4.2"
PR = "1.el10"
PACKAGES = " \
 ansible-pcp \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-pcp-2.4.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1bf6412719f213a7a75b00e492bb31bf425bc6d94150595f9729474f1f7cf460"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-pcp-2.4.2-1.el10.noarch.rpm;name=x86_64_v2_ansible-pcp;unpack=0"
SRC_URI[x86_64_v2_ansible-pcp.sha256sum] = "5545cdb53315a99c143c9f15a0a96a784240d536c29df2e687da2fc6862c345e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-pcp-2.4.2-1.el10.noarch.rpm;name=aarch64_ansible-pcp;unpack=0"
SRC_URI[aarch64_ansible-pcp.sha256sum] = "5545cdb53315a99c143c9f15a0a96a784240d536c29df2e687da2fc6862c345e"

RDEPENDS:ansible-pcp = " \
 ansible-core \
 bash \
 "
