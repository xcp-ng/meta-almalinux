# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-time-locale-compat"
PV = "0.1.1.5"
PR = "25.el10_0"
PACKAGES = " \
 ghc-time-locale-compat \
 ghc-time-locale-compat-devel \
 ghc-time-locale-compat-doc \
 ghc-time-locale-compat-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-time-locale-compat-0.1.1.5-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82af146a4c5044d8f66eadf1220bdd53c587d18fc93886b3fab32cd2050f0e45"

URI_x86_64_v2_ghc-time-locale-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-locale-compat-0.1.1.5-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-locale-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-locale-compat}"
SRC_URI[x86_64_v2_ghc-time-locale-compat.sha256sum] = "9b4ce08b8de636f6c5e4ca4674789f3b781babb87784ead672f29acd9e2f1fde"

URI_x86_64_v2_ghc-time-locale-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-locale-compat-devel-0.1.1.5-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-locale-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-locale-compat-devel}"
SRC_URI[x86_64_v2_ghc-time-locale-compat-devel.sha256sum] = "0a4d82541b125c8faee7194fb13c4bff5d101dc2d8cec46838a37ba47f36acda"

URI_x86_64_v2_ghc-time-locale-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-locale-compat-doc-0.1.1.5-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-time-locale-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-locale-compat-doc}"
SRC_URI[x86_64_v2_ghc-time-locale-compat-doc.sha256sum] = "3304431e15bbfd054a7f207a05860cd9ff8153b16d2075e18fa8d412f4bf75ee"

URI_x86_64_v2_ghc-time-locale-compat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-locale-compat-prof-0.1.1.5-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-locale-compat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-locale-compat-prof}"
SRC_URI[x86_64_v2_ghc-time-locale-compat-prof.sha256sum] = "b23962124db8c6ffb16b002d7bd5132b9a25bec47faeba7422f7acaea69a4a0f"

URI_aarch64_ghc-time-locale-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-locale-compat-0.1.1.5-25.el10_0.aarch64.rpm;name=aarch64_ghc-time-locale-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-locale-compat}"
SRC_URI[aarch64_ghc-time-locale-compat.sha256sum] = "2bed800567ba69d8b99e5c25f67ebd6cc8f36fea4ea1c494ba9c5fd4fed4e66b"

URI_aarch64_ghc-time-locale-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-locale-compat-devel-0.1.1.5-25.el10_0.aarch64.rpm;name=aarch64_ghc-time-locale-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-locale-compat-devel}"
SRC_URI[aarch64_ghc-time-locale-compat-devel.sha256sum] = "850fd1ba05df1ec1cc6e351b7f385b85343e7159da5041b71dff4ed05e505df1"

URI_aarch64_ghc-time-locale-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-locale-compat-doc-0.1.1.5-25.el10_0.noarch.rpm;name=aarch64_ghc-time-locale-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-locale-compat-doc}"
SRC_URI[aarch64_ghc-time-locale-compat-doc.sha256sum] = "3c49ac0a3c6414972bb4442bfd3d74661e0d59e85f3c2ce30645e3dc96eb6741"

URI_aarch64_ghc-time-locale-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-locale-compat-prof-0.1.1.5-25.el10_0.aarch64.rpm;name=aarch64_ghc-time-locale-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-locale-compat-prof}"
SRC_URI[aarch64_ghc-time-locale-compat-prof.sha256sum] = "4bf9fcee2818868d9e286bf271f72d24717ceda30edd41dfcf407856083d1580"

RDEPENDS:ghc-time-locale-compat = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc-time-locale-compat-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-time-devel \
 ghc-time-locale-compat \
 "
RDEPENDS:ghc-time-locale-compat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-time-locale-compat-prof = " \
 ghc-base-prof \
 ghc-time-locale-compat-devel \
 ghc-time-prof \
 "
