# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtquick3dphysics"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 qt6-qtquick3dphysics \
 qt6-qtquick3dphysics-devel \
 qt6-qtquick3dphysics-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtquick3dphysics-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8561fa1b048ee45d1db23bd786ebd964742099f31d5c46f791c67ff1bd9f00a"

URI_x86_64_v2_qt6-qtquick3dphysics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtquick3dphysics-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquick3dphysics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquick3dphysics}"
SRC_URI[x86_64_v2_qt6-qtquick3dphysics.sha256sum] = "b096d14fa1f7e647ca3574bd3f4bc33a2f4b730dd60368c50a9446ec72e75b9c"

URI_x86_64_v2_qt6-qtquick3dphysics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtquick3dphysics-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquick3dphysics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquick3dphysics-devel}"
SRC_URI[x86_64_v2_qt6-qtquick3dphysics-devel.sha256sum] = "ab0914e1d07e03813a17486d5c29f7b65d7c38544dc674f606c1669b4b46713f"

URI_x86_64_v2_qt6-qtquick3dphysics-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtquick3dphysics-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtquick3dphysics-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtquick3dphysics-examples}"
SRC_URI[x86_64_v2_qt6-qtquick3dphysics-examples.sha256sum] = "b664ca25f9db3558ab7d73c8416ba8e3c23e45c922ddd6336584609426f6bfed"

URI_aarch64_qt6-qtquick3dphysics = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtquick3dphysics-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtquick3dphysics;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquick3dphysics}"
SRC_URI[aarch64_qt6-qtquick3dphysics.sha256sum] = "6f2f5e198e15dbe4e3ef4fe056e9c553ca3c819da283119e74220b35675dd283"

URI_aarch64_qt6-qtquick3dphysics-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtquick3dphysics-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtquick3dphysics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquick3dphysics-devel}"
SRC_URI[aarch64_qt6-qtquick3dphysics-devel.sha256sum] = "e9353bec34bfa22016b5330d12f7b152ea92d37515cab51df8879a99c6b70e33"

URI_aarch64_qt6-qtquick3dphysics-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtquick3dphysics-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtquick3dphysics-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtquick3dphysics-examples}"
SRC_URI[aarch64_qt6-qtquick3dphysics-examples.sha256sum] = "467bbbb20af7001ae63dd0c7b3fe7e8b2ba5f92299bbf6fe471d7ce362f9996d"

RDEPENDS:qt6-qtquick3dphysics = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 "
RDEPENDS:qt6-qtquick3dphysics-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative-devel \
 qt6-qtquick3d \
 qt6-qtquick3d-devel \
 qt6-qtquick3dphysics \
 "
RDEPENDS:qt6-qtquick3dphysics-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3dphysics \
 "
