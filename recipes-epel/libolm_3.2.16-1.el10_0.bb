# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libolm"
PV = "3.2.16"
PR = "1.el10_0"
PACKAGES = " \
 libolm \
 libolm-devel \
 libolm-python3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libolm-3.2.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e88df5a0a8a8aad24467aa1c5c568017a3ea3ddfd47078c0c486564f666b3d8"

URI_x86_64_v2_libolm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libolm-3.2.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libolm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libolm}"
SRC_URI[x86_64_v2_libolm.sha256sum] = "83ee0963d16b2903a7929e76026873afe0a1d75c8b34a9515e932d7fdd935c6a"

URI_x86_64_v2_libolm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libolm-devel-3.2.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libolm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libolm-devel}"
SRC_URI[x86_64_v2_libolm-devel.sha256sum] = "540041feabb045be348a26a9759c1c29c854817c241b20b67d6f51ad529b3720"

URI_x86_64_v2_libolm-python3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libolm-python3-3.2.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libolm-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libolm-python3}"
SRC_URI[x86_64_v2_libolm-python3.sha256sum] = "2b3e274d446f743e8bfafdd0625bb9a4e611246fb5afe1212857a34d1c96f4ae"

URI_aarch64_libolm = "${EPEL_MIRROR}/aarch64/Packages/l/libolm-3.2.16-1.el10_0.aarch64.rpm;name=aarch64_libolm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libolm}"
SRC_URI[aarch64_libolm.sha256sum] = "c0c359f9a84f780e2fef27e1e7e54e6e33ed3715cb1239e16a06cfa34afe38b4"

URI_aarch64_libolm-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libolm-devel-3.2.16-1.el10_0.aarch64.rpm;name=aarch64_libolm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libolm-devel}"
SRC_URI[aarch64_libolm-devel.sha256sum] = "f97a6679d37bfdb1d87d88c033f079e431a3b7d1f805442cc06a5f644e756551"

URI_aarch64_libolm-python3 = "${EPEL_MIRROR}/aarch64/Packages/l/libolm-python3-3.2.16-1.el10_0.aarch64.rpm;name=aarch64_libolm-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libolm-python3}"
SRC_URI[aarch64_libolm-python3.sha256sum] = "00ff643a7820e48fb0d36c9e1ab5d57bffa8069cdc6fc66701975ad7237e149d"

RDEPENDS:libolm = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:libolm-devel = " \
 cmake-filesystem \
 libolm \
 pkgconf-pkg-config \
 "
RDEPENDS:libolm-python3 = " \
 glibc \
 libolm \
 python3 \
 python3-cffi \
 "
