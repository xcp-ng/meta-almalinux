# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl-sys"
PV = "0.9.117"
PR = "1.el10_2"
PACKAGES = " \
 rust-openssl-sys+bindgen-devel \
 rust-openssl-sys+default-devel \
 rust-openssl-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-sys-0.9.117-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6e8bc88b2696dc36128b8cba7eafe7f4467b22b371d3a1722232c2d430e03ca"

URI_x86_64_v2_rust-openssl-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys+bindgen-devel-0.9.117-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys+bindgen-devel.sha256sum] = "a918436d9812bc437f5a5e8b58af4cb15a7de6250a87cf7bf2ad98f6f482f20e"

URI_x86_64_v2_rust-openssl-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys+default-devel-0.9.117-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys+default-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys+default-devel.sha256sum] = "845ea49e57540e1d7e0a0a9a1178f290499507f8abbcf20c4a96ffab33b2e998"

URI_x86_64_v2_rust-openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys-devel-0.9.117-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys-devel.sha256sum] = "87d23578f44c38972f502c4dc59563cdb0e9bd248911bd0aaf9cfd023b28122d"

URI_aarch64_rust-openssl-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys+bindgen-devel-0.9.117-1.el10_2.noarch.rpm;name=aarch64_rust-openssl-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys+bindgen-devel}"
SRC_URI[aarch64_rust-openssl-sys+bindgen-devel.sha256sum] = "fb462cd446d057d8f389b005262e2a466b4ade897114de90d7ad0d17539fc115"

URI_aarch64_rust-openssl-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys+default-devel-0.9.117-1.el10_2.noarch.rpm;name=aarch64_rust-openssl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys+default-devel}"
SRC_URI[aarch64_rust-openssl-sys+default-devel.sha256sum] = "612c3c96f321d6938214d65105ea4881e4a524f821b60d659ec03f7520ca3208"

URI_aarch64_rust-openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys-devel-0.9.117-1.el10_2.noarch.rpm;name=aarch64_rust-openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys-devel}"
SRC_URI[aarch64_rust-openssl-sys-devel.sha256sum] = "91b7eb212d92b263aacc8d646721dfc844e33c28bb66609994efb76caf82562d"

RDEPENDS:rust-openssl-sys+bindgen-devel = " \
 cargo \
 rust-bindgen+default-devel \
 rust-bindgen+experimental-devel \
 rust-openssl-sys-devel \
 "
RDEPENDS:rust-openssl-sys+default-devel = " \
 cargo \
 rust-openssl-sys-devel \
 "
RDEPENDS:rust-openssl-sys-devel = " \
 cargo \
 openssl-devel \
 rust \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
