# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire"
PV = "1.4.11"
PR = "1.1.1.el10"
PACKAGES = " \
 pipewire \
 pipewire-alsa \
 pipewire-devel \
 pipewire-gstreamer \
 pipewire-jack-audio-connection-kit \
 pipewire-jack-audio-connection-kit-devel \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pipewire-module-x11 \
 pipewire-plugin-libcamera \
 pipewire-pulseaudio \
 pipewire-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pipewire-1.4.11-1.1.1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "174a4c2aaa368f3b650996c303f227679523b14a89c95385344ccefc4e37f3be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire;unpack=0"
SRC_URI[x86_64_v2_pipewire.sha256sum] = "984330bcb1742c1920cdfe821cfbf36d250e739708ff627c573180011d34f5a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-alsa-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-alsa;unpack=0"
SRC_URI[x86_64_v2_pipewire-alsa.sha256sum] = "e54dc53a6585ca60fe7a228c9ad0091e076a799302bff7cb72ad4eddbb775041"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-devel-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-devel;unpack=0"
SRC_URI[x86_64_v2_pipewire-devel.sha256sum] = "122ebbe0a47db5315515968ff2ab6e2b103fd6403c1432f06eb645c2e772002e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-gstreamer-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-gstreamer;unpack=0"
SRC_URI[x86_64_v2_pipewire-gstreamer.sha256sum] = "94f246974d36e287571f1d408c208fa63b82f6298b6bf868d8aed4c25a5011ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit.sha256sum] = "8282e6a6ade6d403bdff20701b1e188fad961dca9531d08eb7c74aa333126752"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-devel.sha256sum] = "e193add942b8002e2dce30b83b475bb6bba3e2e4986597c790813010b323a5dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI[x86_64_v2_pipewire-jack-audio-connection-kit-libs.sha256sum] = "522623480d39600e1d3cde48e3de928f89d1020578f6b057cdb66f1433453d50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-libs-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-libs;unpack=0"
SRC_URI[x86_64_v2_pipewire-libs.sha256sum] = "7431fdfd82cc2c069cd0f5bf2ec66380e6f44c25024073eeca71c7d2f68392dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-module-x11-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-x11;unpack=0"
SRC_URI[x86_64_v2_pipewire-module-x11.sha256sum] = "c9fcbbb5f63312d5300f34d524ac9b2edcfca51b1d3d900315c3d2227a65299a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-plugin-libcamera-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-plugin-libcamera;unpack=0"
SRC_URI[x86_64_v2_pipewire-plugin-libcamera.sha256sum] = "fcb8cabaa05ceeb142e0513f03d28ccaaa39d438bc2cecce3ec3fdd2c6a57592"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-pulseaudio-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-pulseaudio;unpack=0"
SRC_URI[x86_64_v2_pipewire-pulseaudio.sha256sum] = "75c1d3c0b03fc99edba39021eb11297b762f611de0fab7b7b7e129095fc8e508"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pipewire-utils-1.4.11-1.1.1.el10.x86_64_v2.rpm;name=x86_64_v2_pipewire-utils;unpack=0"
SRC_URI[x86_64_v2_pipewire-utils.sha256sum] = "d3f0ec6576fd987a7b62a122218283092e9aa202842e1387cb80783415ac782a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire;unpack=0"
SRC_URI[aarch64_pipewire.sha256sum] = "daf29ee326b1a8bd7c94e72e64596c807e0dd5d3b68c41e3d308031f08d3007c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-alsa-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-alsa;unpack=0"
SRC_URI[aarch64_pipewire-alsa.sha256sum] = "88b5ca9fda50352bc6f8469d30c7c9cdb3d89e32d294d19c3e10efb843879c06"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-devel-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-devel;unpack=0"
SRC_URI[aarch64_pipewire-devel.sha256sum] = "2c8b664d438344f87080dea4b14671396f19ded716198f18524ede531d0e342e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-gstreamer-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-gstreamer;unpack=0"
SRC_URI[aarch64_pipewire-gstreamer.sha256sum] = "b7f26b302bfa777b3cc9b4a4d088394e44985efa8ea8a3f8fb555aaf6cef652b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit;unpack=0"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit.sha256sum] = "439fb91c1c76189d8f2d5341b2f51eb6593c98642417acf3ec87926bb39f8b4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-devel-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-devel;unpack=0"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-devel.sha256sum] = "02131876c6dad00cf8a8c9437eaad1f8a0887f7f54f4ed7ae79f549d9ce27f4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-jack-audio-connection-kit-libs-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-jack-audio-connection-kit-libs;unpack=0"
SRC_URI[aarch64_pipewire-jack-audio-connection-kit-libs.sha256sum] = "3d105de61e1557c6506d717f38b9832dc17057a30b083f6dc64843a984f9cf56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-libs-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-libs;unpack=0"
SRC_URI[aarch64_pipewire-libs.sha256sum] = "4447abd8bcca85ace5eb4f0c5d93d9ef23ab90470861882711b27742c45bf210"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-module-x11-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-module-x11;unpack=0"
SRC_URI[aarch64_pipewire-module-x11.sha256sum] = "ef4fcf1d2d6230f3f7c2407afe10832c72839158b0523fa10a88329092b78827"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-plugin-libcamera-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-plugin-libcamera;unpack=0"
SRC_URI[aarch64_pipewire-plugin-libcamera.sha256sum] = "ce497767b49622d241e15c7bcc4f4495d1c0f69bb27eb0478fa640a6fca4f47c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-pulseaudio-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-pulseaudio;unpack=0"
SRC_URI[aarch64_pipewire-pulseaudio.sha256sum] = "ff99e3dc3c5c5dd038166cfcaa92a27e5652330288b2425ca32df676783bc43c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pipewire-utils-1.4.11-1.1.1.el10.aarch64.rpm;name=aarch64_pipewire-utils;unpack=0"
SRC_URI[aarch64_pipewire-utils.sha256sum] = "735c5f0a7037923332ddff3f39f1d3030f72894b13fc9296ae4f5ec7e7b87b35"

RDEPENDS:pipewire = " \
 bash \
 glibc \
 pipewire-libs \
 rtkit \
 systemd \
 wireplumber \
 "
RDEPENDS:pipewire-alsa = " \
 alsa-lib \
 glibc \
 pipewire-libs \
 "
RDEPENDS:pipewire-devel = " \
 pipewire-devel \
 pipewire-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 pipewire-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit = " \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-devel = " \
 pipewire-jack-audio-connection-kit-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pipewire-jack-audio-connection-kit-libs = " \
 bash \
 glibc \
 pipewire-jack-audio-connection-kit \
 pipewire-libs \
 "
RDEPENDS:pipewire-libs = " \
 alsa-lib \
 avahi-libs \
 bluez-libs \
 dbus-libs \
 fdk-aac-free \
 fftw-libs-single \
 glib2 \
 glibc \
 libgcc \
 liblc3 \
 libldac \
 libsbc \
 libselinux \
 libsndfile \
 libstdc++ \
 libusb1 \
 openssl-libs \
 opus \
 pulseaudio-libs \
 systemd-libs \
 webrtc-audio-processing \
 "
RDEPENDS:pipewire-module-x11 = " \
 glibc \
 libX11 \
 libXfixes \
 libcanberra \
 pipewire-libs \
 "
RDEPENDS:pipewire-plugin-libcamera = " \
 glibc \
 libcamera \
 libdrm \
 libgcc \
 libstdc++ \
 pipewire-libs \
 "
RDEPENDS:pipewire-pulseaudio = " \
 avahi-libs \
 bash \
 dbus-libs \
 glib2 \
 glibc \
 libgcc \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:pipewire-utils = " \
 alsa-lib \
 dbus-libs \
 glibc \
 libgcc \
 libsndfile \
 ncurses-libs \
 pipewire \
 pipewire-libs \
 readline \
 "
