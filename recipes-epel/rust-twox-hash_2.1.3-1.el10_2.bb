# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-twox-hash"
PV = "2.1.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-twox-hash+alloc-devel \
 rust-twox-hash+default-devel \
 rust-twox-hash+random-devel \
 rust-twox-hash+serialize-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-twox-hash-2.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98e2ee011b5d5162a63e54ffad853a396d8d6421c96fa82349ff951f4a64d0f4"

URI_x86_64_v2_rust-twox-hash+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+alloc-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+alloc-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+alloc-devel.sha256sum] = "a8075f1c71f42f9c275683f3971474ff56eb7e46bc161e3db7a54089207dee1e"

URI_x86_64_v2_rust-twox-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+default-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+default-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+default-devel.sha256sum] = "18d8b7aaafad1387d8f40430607c998653df53e178438db2c404c8efbfd2c291"

URI_x86_64_v2_rust-twox-hash+random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+random-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+random-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+random-devel.sha256sum] = "9e5587764ce2c616b59649d6d347ef33940d99a4701585b3c7e6da2dd24e0db9"

URI_x86_64_v2_rust-twox-hash+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+serialize-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+serialize-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+serialize-devel.sha256sum] = "e38c6be422b40fb32842444737efba1abc8079eaf5126c17ec7e12888425bb8c"

URI_x86_64_v2_rust-twox-hash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+std-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+std-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+std-devel.sha256sum] = "f7a58f9c9c541a57b06be8830faafcd68b0567f10e2c888b16cc8dab9e2b3b06"

URI_x86_64_v2_rust-twox-hash+xxhash32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash32-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash32-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash32-devel.sha256sum] = "40105898a85fdcc15b4f0ff33eb50a7b4b472e60b8e1a5a5e14bf6cae677d6a1"

URI_x86_64_v2_rust-twox-hash+xxhash3_128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_128-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash3_128-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_128-devel.sha256sum] = "38374fb297797d9243307820083c0fb1a03be94a74a872ea15e23ceeee02784a"

URI_x86_64_v2_rust-twox-hash+xxhash3_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_64-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash3_64-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_64-devel.sha256sum] = "d6323a375f0533efd25d3c26127623892fa68c13105ad58616e0513c58c189cf"

URI_x86_64_v2_rust-twox-hash+xxhash64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash64-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash+xxhash64-devel}"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash64-devel.sha256sum] = "40b349cbc2d10bcc4ff5b645b20337e54fb278af24d6295e7124c33a039ad5a9"

URI_x86_64_v2_rust-twox-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash-devel-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash-devel}"
SRC_URI[x86_64_v2_rust-twox-hash-devel.sha256sum] = "204200ce741992cc35fe18c23d23e08fbacc9d32abad0137e86ea1a434631700"

URI_aarch64_rust-twox-hash+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+alloc-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+alloc-devel}"
SRC_URI[aarch64_rust-twox-hash+alloc-devel.sha256sum] = "bd2ae0633e7fd8e432bcd322db0bcb428ec2d7c22c2bda1cda71426d0d185f18"

URI_aarch64_rust-twox-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+default-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+default-devel}"
SRC_URI[aarch64_rust-twox-hash+default-devel.sha256sum] = "bb62fe227d0ffd365bec96af3d1637649f775c4bf2dc15cbee07208f67e33661"

URI_aarch64_rust-twox-hash+random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+random-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+random-devel}"
SRC_URI[aarch64_rust-twox-hash+random-devel.sha256sum] = "bd5552fbc973dc875120ecbabd17c3161de29aa9c7444de76e2f482b8efec5d3"

URI_aarch64_rust-twox-hash+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+serialize-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+serialize-devel}"
SRC_URI[aarch64_rust-twox-hash+serialize-devel.sha256sum] = "615252fd8d67b637257850b715dacb939f693540ef80fd4a912162af0dbd0f3d"

URI_aarch64_rust-twox-hash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+std-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+std-devel}"
SRC_URI[aarch64_rust-twox-hash+std-devel.sha256sum] = "2edc41bad9188077bed46f47ec383d22566177e3c9b1650f7aee23a0b3459c49"

URI_aarch64_rust-twox-hash+xxhash32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash32-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash32-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash32-devel.sha256sum] = "cfb0095c2a0246910030fefbf403920877781229257d7ccf2d45093a60984351"

URI_aarch64_rust-twox-hash+xxhash3_128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_128-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash3_128-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash3_128-devel.sha256sum] = "f5b3e4ec786b389ca2d5f89db01860e95418c130932855fe00540aad2e7c936a"

URI_aarch64_rust-twox-hash+xxhash3_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_64-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash3_64-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash3_64-devel.sha256sum] = "3c387108324f0976c898e5fa975870ad9b82b721f3ccc6243e8a968800fda720"

URI_aarch64_rust-twox-hash+xxhash64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash64-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash+xxhash64-devel}"
SRC_URI[aarch64_rust-twox-hash+xxhash64-devel.sha256sum] = "3420d83b13438fbcd2a81e8fb1227946743892ddb10c80f6797e50fb013b1098"

URI_aarch64_rust-twox-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash-devel-2.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash-devel}"
SRC_URI[aarch64_rust-twox-hash-devel.sha256sum] = "2d5035eb0994480ffb372b5c2430501894183624436d6b7058b6f2072363c2ab"

RDEPENDS:rust-twox-hash+alloc-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+default-devel = " \
 cargo \
 rust-twox-hash+random-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+random-devel = " \
 cargo \
 rust-twox-hash-devel \
 virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 \
 virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0 \
 "
RDEPENDS:rust-twox-hash+serialize-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+std-devel = " \
 cargo \
 rust-twox-hash+alloc-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash32-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_128-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash-devel = " \
 cargo \
 rust \
 "
