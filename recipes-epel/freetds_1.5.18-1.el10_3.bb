# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freetds"
PV = "1.5.18"
PR = "1.el10_3"
PACKAGES = " \
 freetds \
 freetds-devel \
 freetds-doc \
 freetds-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/freetds-1.5.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16931087693baefd286dd2ec848278073bcb41d43507c11fe0c491364a0943b4"

URI_x86_64_v2_freetds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freetds-1.5.18-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freetds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetds}"
SRC_URI[x86_64_v2_freetds.sha256sum] = "53ba8c2cd9eda65c678ddcab50cece1d0b0c4f010993034f6e30212e4c2d23a3"

URI_x86_64_v2_freetds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freetds-devel-1.5.18-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freetds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetds-devel}"
SRC_URI[x86_64_v2_freetds-devel.sha256sum] = "9b08826bb0774292127c2a212295972f97e357e0426816987dfddb248bb12ba0"

URI_x86_64_v2_freetds-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freetds-doc-1.5.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_freetds-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetds-doc}"
SRC_URI[x86_64_v2_freetds-doc.sha256sum] = "e872e8f77b508a864d43ea8f7b1b058e599f4d91d5115e8d40a7b80766778160"

URI_x86_64_v2_freetds-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freetds-libs-1.5.18-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freetds-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetds-libs}"
SRC_URI[x86_64_v2_freetds-libs.sha256sum] = "486591917a090e6a959081c7fa4cee90c0557ad6518a04fd39c863dda4cc2344"

URI_aarch64_freetds = "${EPEL_MIRROR}/aarch64/Packages/f/freetds-1.5.18-1.el10_3.aarch64.rpm;name=aarch64_freetds;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetds}"
SRC_URI[aarch64_freetds.sha256sum] = "824551104063ab6e646f67c60a29fbef2072dfb45d0422bd49fcdd8214a46ef7"

URI_aarch64_freetds-devel = "${EPEL_MIRROR}/aarch64/Packages/f/freetds-devel-1.5.18-1.el10_3.aarch64.rpm;name=aarch64_freetds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetds-devel}"
SRC_URI[aarch64_freetds-devel.sha256sum] = "1cd7f23e95c87fd28fce3e6207a640fe658ab97529e6da0e9b72e0cc6e15af16"

URI_aarch64_freetds-doc = "${EPEL_MIRROR}/aarch64/Packages/f/freetds-doc-1.5.18-1.el10_3.noarch.rpm;name=aarch64_freetds-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetds-doc}"
SRC_URI[aarch64_freetds-doc.sha256sum] = "0235b097e3aa6d1685bfabfe64856bbcbfcf5a1f8bc75e3b034419efbb076d8f"

URI_aarch64_freetds-libs = "${EPEL_MIRROR}/aarch64/Packages/f/freetds-libs-1.5.18-1.el10_3.aarch64.rpm;name=aarch64_freetds-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetds-libs}"
SRC_URI[aarch64_freetds-libs.sha256sum] = "12b18ee78be3e6affdddd984659078338cc8745148f04ff48aa371f1537f6cc6"

RDEPENDS:freetds = " \
 bash \
 freetds-libs \
 glibc \
 gnutls \
 krb5-libs \
 libgcrypt \
 libtasn1 \
 readline \
 unixODBC \
 "
RDEPENDS:freetds-devel = " \
 freetds-libs \
 "
RDEPENDS:freetds-doc = " \
 "
RDEPENDS:freetds-libs = " \
 freetds \
 glibc \
 gnutls \
 krb5-libs \
 libgcrypt \
 libgpg-error \
 libtasn1 \
 unixODBC \
 "
