# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-equator"
PV = "0.4.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-equator+default-devel \
 rust-equator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-equator-0.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a519ca3bc9d7219a0a6237ccc4dbfb2500da2a6c926eba8eb52398973a28112"

URI_x86_64_v2_rust-equator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator+default-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator+default-devel}"
SRC_URI[x86_64_v2_rust-equator+default-devel.sha256sum] = "7227f470f43d84b4c746e46f6567b4f5076d500ada190ebcd9304fea5129621f"

URI_x86_64_v2_rust-equator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator-devel}"
SRC_URI[x86_64_v2_rust-equator-devel.sha256sum] = "557ba8df34febf34126f4992e355e8ec2eee973aa9a0d6ef0a3c842ec3305f55"

URI_aarch64_rust-equator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator+default-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-equator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator+default-devel}"
SRC_URI[aarch64_rust-equator+default-devel.sha256sum] = "697b70d3092baa6dc6d0f5fe06af5e8f82d383a593f703018970e8f91d688c76"

URI_aarch64_rust-equator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-equator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator-devel}"
SRC_URI[aarch64_rust-equator-devel.sha256sum] = "d3691c0fd62e5f9f369375349514c4d5f088934991c703e04c620e72d404a54a"

RDEPENDS:rust-equator+default-devel = " \
 cargo \
 rust-equator-devel \
 "
RDEPENDS:rust-equator-devel = " \
 cargo \
 rust-equator-macro+default-devel \
 "
