# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-content-range"
PV = "0.2.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-http-content-range+default-devel \
 rust-http-content-range-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-content-range-0.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a1990b8553d5b29d2ab55e80480115a396947168a840c263d1e5268b6917fdf"

URI_x86_64_v2_rust-http-content-range+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-content-range+default-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-content-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-content-range+default-devel}"
SRC_URI[x86_64_v2_rust-http-content-range+default-devel.sha256sum] = "c9eccad3ee0af7b4212ba2e997925004f033148d8ecb0e3c0129dea70720eb41"

URI_x86_64_v2_rust-http-content-range-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-content-range-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-content-range-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-content-range-devel}"
SRC_URI[x86_64_v2_rust-http-content-range-devel.sha256sum] = "f5c2c57562f3ee8d4b2f03760a4f01852ebfd1242f4b3a2976d096da02ba43e8"

URI_aarch64_rust-http-content-range+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-content-range+default-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-http-content-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-content-range+default-devel}"
SRC_URI[aarch64_rust-http-content-range+default-devel.sha256sum] = "7291b7848880a54fcb27cca176e8008c946e0cf67c8945ce73318e1fa463671a"

URI_aarch64_rust-http-content-range-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-content-range-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-http-content-range-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-content-range-devel}"
SRC_URI[aarch64_rust-http-content-range-devel.sha256sum] = "9da5725d856cc529076d0a83644355bcae9e745bff22afc095217e736820b144"

RDEPENDS:rust-http-content-range+default-devel = " \
 cargo \
 rust-http-content-range-devel \
 "
RDEPENDS:rust-http-content-range-devel = " \
 cargo \
 rust \
 "
