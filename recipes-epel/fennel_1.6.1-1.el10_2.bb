# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fennel"
PV = "1.6.1"
PR = "1.el10_2"
PACKAGES = " \
 fennel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fennel-1.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "724c38f5db39012d296cf0fd6591e5bc35f7b5a8efb53e10197f0a0b7aa9e724"

URI_x86_64_v2_fennel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fennel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fennel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fennel}"
SRC_URI[x86_64_v2_fennel.sha256sum] = "cf0d0067833539ae32d00401b06984a420c3d3a67da15e9d768fe454a1105487"

URI_aarch64_fennel = "${EPEL_MIRROR}/aarch64/Packages/f/fennel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_fennel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fennel}"
SRC_URI[aarch64_fennel.sha256sum] = "be922af65a094ff602e1830ca0959ee01428a609237f137b0390c5f006354c7f"

RDEPENDS:fennel = " \
 lua \
 lua-libs \
 "
