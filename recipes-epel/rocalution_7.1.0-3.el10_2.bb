# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocalution"
PV = "7.1.0"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 rocalution \
 rocalution-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocalution-7.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a80e20e1ed0fe24fbb7ee3d9b72292553d643dd17f82f21810705211777c222"

URI_x86_64_v2_rocalution = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocalution-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocalution;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocalution}"
SRC_URI[x86_64_v2_rocalution.sha256sum] = "3454f506b793846a2cc7373766891ecd8b621f7d80c04819541f8def46ea1060"

URI_x86_64_v2_rocalution-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocalution-devel-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocalution-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocalution-devel}"
SRC_URI[x86_64_v2_rocalution-devel.sha256sum] = "d20ba17d39c651d72ee6a5260f4125e2219854d16522ef36219e34d85c0a5e02"

RDEPENDS:rocalution = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocm-hip \
 rocrand \
 rocsparse \
 "
RDEPENDS:rocalution-devel = " \
 cmake-filesystem \
 rocalution \
 "
