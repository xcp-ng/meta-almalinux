# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khangman"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 khangman \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/khangman-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3fef2c5ef74db2e9f93dd3e05a8b7e77bbb58c29d25c67176f89b4c32b8d56b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khangman-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khangman;unpack=0"
SRC_URI[x86_64_v2_khangman.sha256sum] = "7c633ea8bd008fb2d86b6e0ced0cc49f7f31dda4ff36f385707e84896ab6c4ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/khangman-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_khangman;unpack=0"
SRC_URI[aarch64_khangman.sha256sum] = "a0bf71363a38eaf3bde3d0a39579b19924e2507e2ec1a933eef9bf0634de60e6"

RDEPENDS:khangman = " \
 dustin-domestic-manners-fonts \
 dustin-dustismo-roman-fonts \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 libkeduvocdocument \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
