# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvterm"
PV = "0.3.3"
PR = "1.el10_0"
PACKAGES = " \
 libvterm \
 libvterm-devel \
 libvterm-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvterm-0.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "434770d51b4cd12d65e445d256535afb65f4f9648c6b5832043cb0f875ed13c3"

URI_x86_64_v2_libvterm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvterm-0.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvterm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvterm}"
SRC_URI[x86_64_v2_libvterm.sha256sum] = "1fba68e5d2da18288a99f7bc19f3d2e5410663afdcaa71cd33ab25334ded3616"

URI_x86_64_v2_libvterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvterm-devel-0.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvterm-devel}"
SRC_URI[x86_64_v2_libvterm-devel.sha256sum] = "c7b5973951246f3f54394fc2addd5eb2d7669341464964ecfd05e4a4730bb69a"

URI_x86_64_v2_libvterm-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvterm-tools-0.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvterm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvterm-tools}"
SRC_URI[x86_64_v2_libvterm-tools.sha256sum] = "dcb14465d6a25cad9a4ef21a6735e2d4ca497d8e8791c55ea0925de8b657f86a"

URI_aarch64_libvterm = "${EPEL_MIRROR}/aarch64/Packages/l/libvterm-0.3.3-1.el10_0.aarch64.rpm;name=aarch64_libvterm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvterm}"
SRC_URI[aarch64_libvterm.sha256sum] = "7bb41f9803f7e5bc0a93e5304039800ae039a34093813e1541dfcaac1218aab7"

URI_aarch64_libvterm-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libvterm-devel-0.3.3-1.el10_0.aarch64.rpm;name=aarch64_libvterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvterm-devel}"
SRC_URI[aarch64_libvterm-devel.sha256sum] = "d46db705327b501e05fe7d520722c59b4fd5961bdb72ee685dd58fce114571d1"

URI_aarch64_libvterm-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libvterm-tools-0.3.3-1.el10_0.aarch64.rpm;name=aarch64_libvterm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvterm-tools}"
SRC_URI[aarch64_libvterm-tools.sha256sum] = "6bb7ef427689cda94c217021da30a90b6dc4c550a3d43eefa83622765d38a36c"

RDEPENDS:libvterm = " \
 glibc \
 "
RDEPENDS:libvterm-devel = " \
 libvterm \
 pkgconf-pkg-config \
 "
RDEPENDS:libvterm-tools = " \
 glibc \
 libvterm \
 "
