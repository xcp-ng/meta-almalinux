# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alligator"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 alligator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alligator-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c82b0f64a1f896d78676f12dc3d2804640448d9f48ab961b178d996f72ffb52e"

URI_x86_64_v2_alligator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alligator-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alligator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alligator}"
SRC_URI[x86_64_v2_alligator.sha256sum] = "a17abf5c4e7c2d141c5d1e651f37f409df6642fb12e96461648056f0e334cb3d"

URI_aarch64_alligator = "${EPEL_MIRROR}/aarch64/Packages/a/alligator-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_alligator;unpack=0"
SRC_URI:append = " ${URI_aarch64_alligator}"
SRC_URI[aarch64_alligator.sha256sum] = "f221aa5be16deaead3d27d5a4f46e0de8432339b666d17fc3490da0646b18445"

RDEPENDS:alligator = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
