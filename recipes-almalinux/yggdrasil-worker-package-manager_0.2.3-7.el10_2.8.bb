# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yggdrasil-worker-package-manager"
PV = "0.2.3"
PR = "7.el10_2.8"
PACKAGES = " \
 yggdrasil-worker-package-manager \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yggdrasil-worker-package-manager-0.2.3-7.el10_2.8.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "197cdd18cebae75430c1013c12c308c61494ff8deca854b506a2fa811b2195ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yggdrasil-worker-package-manager-0.2.3-7.el10_2.8.x86_64_v2.rpm;name=x86_64_v2_yggdrasil-worker-package-manager;unpack=0"
SRC_URI[x86_64_v2_yggdrasil-worker-package-manager.sha256sum] = "892e944bef3aa7ff0df2c26ce55eea80eb7b1b1fd89bbfd375624f95db30884c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yggdrasil-worker-package-manager-0.2.3-7.el10_2.8.aarch64.rpm;name=aarch64_yggdrasil-worker-package-manager;unpack=0"
SRC_URI[aarch64_yggdrasil-worker-package-manager.sha256sum] = "b8f9242c332ac62bb26ef97b50d97a500e47a1c1e9c9d61783b26449e61cdcc8"

RDEPENDS:yggdrasil-worker-package-manager = " \
 bash \
 glibc \
 "
