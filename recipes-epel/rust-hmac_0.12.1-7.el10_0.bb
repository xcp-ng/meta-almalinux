# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hmac"
PV = "0.12.1"
PR = "7.el10_0"
PACKAGES = " \
 rust-hmac+default-devel \
 rust-hmac+reset-devel \
 rust-hmac+std-devel \
 rust-hmac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hmac-0.12.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c66f5314fe08e52fb17d0017568558c3272cb5e2ca3171906b90f5171fe87f1e"

URI_x86_64_v2_rust-hmac+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac+default-devel-0.12.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hmac+default-devel}"
SRC_URI[x86_64_v2_rust-hmac+default-devel.sha256sum] = "d8ca64a38ce799ab03170673ad0af5c231c2878228df9f32f87b4d54c147272a"

URI_x86_64_v2_rust-hmac+reset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac+reset-devel-0.12.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac+reset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hmac+reset-devel}"
SRC_URI[x86_64_v2_rust-hmac+reset-devel.sha256sum] = "f6d88724de39f6b0745294bc3deea13dcec298cba3ff97fa806cb989ebedcc7e"

URI_x86_64_v2_rust-hmac+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac+std-devel-0.12.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hmac+std-devel}"
SRC_URI[x86_64_v2_rust-hmac+std-devel.sha256sum] = "b491c5f74be73e6edf5c8399707178527aa2528f678dccc4b1bc9ab8ab763817"

URI_x86_64_v2_rust-hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hmac-devel-0.12.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hmac-devel}"
SRC_URI[x86_64_v2_rust-hmac-devel.sha256sum] = "217c959f1e8585446cff19134b8740ab678545fe844b98c1cc8ad2c370e2e4bc"

URI_aarch64_rust-hmac+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac+default-devel-0.12.1-7.el10_0.noarch.rpm;name=aarch64_rust-hmac+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hmac+default-devel}"
SRC_URI[aarch64_rust-hmac+default-devel.sha256sum] = "b7a3187bfb9bd3311a46319e655dfbd415b46a20083a99b8306772d388e9fb13"

URI_aarch64_rust-hmac+reset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac+reset-devel-0.12.1-7.el10_0.noarch.rpm;name=aarch64_rust-hmac+reset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hmac+reset-devel}"
SRC_URI[aarch64_rust-hmac+reset-devel.sha256sum] = "9bb22c43e1903e5549913eecf39117ebf2821c722b2217f589454eeb6ea1ea0d"

URI_aarch64_rust-hmac+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac+std-devel-0.12.1-7.el10_0.noarch.rpm;name=aarch64_rust-hmac+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hmac+std-devel}"
SRC_URI[aarch64_rust-hmac+std-devel.sha256sum] = "796e068798264eb2d7fc0822b1548defcd637cf05ef82e679d04cbc85c875bca"

URI_aarch64_rust-hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hmac-devel-0.12.1-7.el10_0.noarch.rpm;name=aarch64_rust-hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hmac-devel}"
SRC_URI[aarch64_rust-hmac-devel.sha256sum] = "8be26afa7e901f2ea96794529dfe517c372f875b4ba753c3944ab32c9e17d070"

RDEPENDS:rust-hmac+default-devel = " \
 cargo \
 rust-hmac-devel \
 "
RDEPENDS:rust-hmac+reset-devel = " \
 cargo \
 rust-hmac-devel \
 "
RDEPENDS:rust-hmac+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-hmac-devel \
 "
RDEPENDS:rust-hmac-devel = " \
 cargo \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
