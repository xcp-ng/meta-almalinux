# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libutempter"
PV = "1.2.1"
PR = "15.el10"
PACKAGES = " \
 libutempter \
 libutempter-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libutempter-1.2.1-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "532b97bffe9e78ebf6a348ba8a2bc157895a9584a6cd9bf8736ae66d0524dc16"

URI_x86_64_v2_libutempter = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libutempter-1.2.1-15.el10.x86_64_v2.rpm;name=x86_64_v2_libutempter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libutempter}"
SRC_URI[x86_64_v2_libutempter.sha256sum] = "be7a1a3d55678b34e4bbf96c1de7feee0e717e519fccdcae9ba262621b0bacc5"

URI_x86_64_v2_libutempter-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libutempter-devel-1.2.1-15.el10.x86_64_v2.rpm;name=x86_64_v2_libutempter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libutempter-devel}"
SRC_URI[x86_64_v2_libutempter-devel.sha256sum] = "4399979a2822c90808acca118832d95fafa73cc4e2fd3b736541bbb10d6cd171"

URI_aarch64_libutempter = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libutempter-1.2.1-15.el10.aarch64.rpm;name=aarch64_libutempter;unpack=0"
SRC_URI:append = " ${URI_aarch64_libutempter}"
SRC_URI[aarch64_libutempter.sha256sum] = "bcfd791e7f2a1addb9ae02efe6cff9c3c6bc0b82a14393e9f3eb5eebe673c977"

URI_aarch64_libutempter-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libutempter-devel-1.2.1-15.el10.aarch64.rpm;name=aarch64_libutempter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libutempter-devel}"
SRC_URI[aarch64_libutempter-devel.sha256sum] = "f562287829d5b9a39e564ee167dec03f1e12dd6442e1aee7035d4f31a0da273b"

RDEPENDS:libutempter = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:libutempter-devel = " \
 libutempter \
 "
