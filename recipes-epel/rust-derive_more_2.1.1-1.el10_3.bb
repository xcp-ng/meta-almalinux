# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive_more"
PV = "2.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-derive_more+add-devel \
 rust-derive_more+add_assign-devel \
 rust-derive_more+as_ref-devel \
 rust-derive_more+constructor-devel \
 rust-derive_more+debug-devel \
 rust-derive_more+default-devel \
 rust-derive_more+deref-devel \
 rust-derive_more+deref_mut-devel \
 rust-derive_more+display-devel \
 rust-derive_more+eq-devel \
 rust-derive_more+error-devel \
 rust-derive_more+from-devel \
 rust-derive_more+from_str-devel \
 rust-derive_more+full-devel \
 rust-derive_more+index-devel \
 rust-derive_more+index_mut-devel \
 rust-derive_more+into-devel \
 rust-derive_more+into_iterator-devel \
 rust-derive_more+is_variant-devel \
 rust-derive_more+mul-devel \
 rust-derive_more+mul_assign-devel \
 rust-derive_more+not-devel \
 rust-derive_more+std-devel \
 rust-derive_more+sum-devel \
 rust-derive_more+testing-helpers-devel \
 rust-derive_more+try_from-devel \
 rust-derive_more+try_into-devel \
 rust-derive_more+try_unwrap-devel \
 rust-derive_more+unwrap-devel \
 rust-derive_more-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive_more-2.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a723bf9b83d825de595b8a0c7cdd8d303e6f24141be48d990beab85457dcd62b"

URI_x86_64_v2_rust-derive_more+add-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+add-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+add-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+add-devel}"
SRC_URI[x86_64_v2_rust-derive_more+add-devel.sha256sum] = "73698519ff74866260bd1cb50a183b48edfdb1ad8ad624613907f63bb9b4d55b"

URI_x86_64_v2_rust-derive_more+add_assign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+add_assign-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+add_assign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+add_assign-devel}"
SRC_URI[x86_64_v2_rust-derive_more+add_assign-devel.sha256sum] = "e6fb8a3c2b47f833af965e1217364609dc3863a32e5f9227069712ababe62798"

URI_x86_64_v2_rust-derive_more+as_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+as_ref-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+as_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+as_ref-devel}"
SRC_URI[x86_64_v2_rust-derive_more+as_ref-devel.sha256sum] = "cfe5ea7078fa9a2d7715ce8931d8de87b5720917c0e419ae2aa9589704fc32dd"

URI_x86_64_v2_rust-derive_more+constructor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+constructor-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+constructor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+constructor-devel}"
SRC_URI[x86_64_v2_rust-derive_more+constructor-devel.sha256sum] = "7f6586e58321fe19c0266a0381091fe5a003a8aed5ac9bbbac592f881a3fca72"

URI_x86_64_v2_rust-derive_more+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+debug-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+debug-devel}"
SRC_URI[x86_64_v2_rust-derive_more+debug-devel.sha256sum] = "8a03cd061a446cb610bcee9930f674b18b81bcada801c83847e2a8b5f95f5f54"

URI_x86_64_v2_rust-derive_more+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+default-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+default-devel}"
SRC_URI[x86_64_v2_rust-derive_more+default-devel.sha256sum] = "3003ee1529b019876c940687f43acb5b1cbdd38fdc7a8460ff496c5cff95e536"

URI_x86_64_v2_rust-derive_more+deref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+deref-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+deref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+deref-devel}"
SRC_URI[x86_64_v2_rust-derive_more+deref-devel.sha256sum] = "29f7f9b4a1e316b9c0f6acee2d50b4f98eef297a24dd47c5e73eeac573b8548c"

URI_x86_64_v2_rust-derive_more+deref_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+deref_mut-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+deref_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+deref_mut-devel}"
SRC_URI[x86_64_v2_rust-derive_more+deref_mut-devel.sha256sum] = "117fc68f28136fc147950edf1cf310f15f25e6c3cadeab90ea1f200fb4aced75"

URI_x86_64_v2_rust-derive_more+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+display-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+display-devel}"
SRC_URI[x86_64_v2_rust-derive_more+display-devel.sha256sum] = "ecb62e9256a4499fcd0dac4aac4b61300f7beaa26435bba257a881ba8cce02c8"

URI_x86_64_v2_rust-derive_more+eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+eq-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+eq-devel}"
SRC_URI[x86_64_v2_rust-derive_more+eq-devel.sha256sum] = "ffa6db8dc93129f6546dbdec02c8a7d7792961593dff1b5e37f2e37826d0a552"

URI_x86_64_v2_rust-derive_more+error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+error-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+error-devel}"
SRC_URI[x86_64_v2_rust-derive_more+error-devel.sha256sum] = "15b20788b294f331289e53f4370cf334d8ca92f429dd75be5e91ae516da48d3c"

URI_x86_64_v2_rust-derive_more+from-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+from-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+from-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+from-devel}"
SRC_URI[x86_64_v2_rust-derive_more+from-devel.sha256sum] = "00f38fc9a69c5723af95f3819f895fe3307a9fd75a2ef21ffbd50ba93ac01416"

URI_x86_64_v2_rust-derive_more+from_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+from_str-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+from_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+from_str-devel}"
SRC_URI[x86_64_v2_rust-derive_more+from_str-devel.sha256sum] = "6415bb531ac62d5ea988bffeebdbf08839cab42c7d969cf7d7a50c2b865414f6"

URI_x86_64_v2_rust-derive_more+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+full-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+full-devel}"
SRC_URI[x86_64_v2_rust-derive_more+full-devel.sha256sum] = "f44a2d9bef6aeca3357358e5c8726ca73b40520bd3adeaf579005a1dc2ab410d"

URI_x86_64_v2_rust-derive_more+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+index-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+index-devel}"
SRC_URI[x86_64_v2_rust-derive_more+index-devel.sha256sum] = "5975307eda9e82ef364de40b6ed3fbe53e30853d24588f23a285d66023ffba7d"

URI_x86_64_v2_rust-derive_more+index_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+index_mut-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+index_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+index_mut-devel}"
SRC_URI[x86_64_v2_rust-derive_more+index_mut-devel.sha256sum] = "acf5c614ad725c982afa232e8c87a6de086cd405e49046c4404e342d5433256e"

URI_x86_64_v2_rust-derive_more+into-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+into-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+into-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+into-devel}"
SRC_URI[x86_64_v2_rust-derive_more+into-devel.sha256sum] = "95df9ff8a05e4fdda6fae239e411a818ea7fffc44bb572609ba1e999b9872121"

URI_x86_64_v2_rust-derive_more+into_iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+into_iterator-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+into_iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+into_iterator-devel}"
SRC_URI[x86_64_v2_rust-derive_more+into_iterator-devel.sha256sum] = "ef1c933ec68b5012c1127e5e8e8092a6baf0d37bc9ac522536eb6b8817f03054"

URI_x86_64_v2_rust-derive_more+is_variant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+is_variant-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+is_variant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+is_variant-devel}"
SRC_URI[x86_64_v2_rust-derive_more+is_variant-devel.sha256sum] = "4a50aa074ec7105e57c9d5b971f7b267ced9870c9d3bad9d06e574e012cf06e0"

URI_x86_64_v2_rust-derive_more+mul-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+mul-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+mul-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+mul-devel}"
SRC_URI[x86_64_v2_rust-derive_more+mul-devel.sha256sum] = "64cc00c15c2b6b2b6673e554051b39dfec5233ae8c1eaee2a69e18c53576bdea"

URI_x86_64_v2_rust-derive_more+mul_assign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+mul_assign-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+mul_assign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+mul_assign-devel}"
SRC_URI[x86_64_v2_rust-derive_more+mul_assign-devel.sha256sum] = "97f2ccc2118b897377ead7143142ecf97ff68134158f1f856aa64fbe0ac4e10c"

URI_x86_64_v2_rust-derive_more+not-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+not-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+not-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+not-devel}"
SRC_URI[x86_64_v2_rust-derive_more+not-devel.sha256sum] = "92aa3f5a75082caa2de5966f77450210c98ea69f2b11e52361fbfa75a9852ba6"

URI_x86_64_v2_rust-derive_more+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+std-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+std-devel}"
SRC_URI[x86_64_v2_rust-derive_more+std-devel.sha256sum] = "5bf8c41f26ccfa66ce9196b479339f15b0eb963b1664bff4824a0c4791e85b9b"

URI_x86_64_v2_rust-derive_more+sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+sum-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+sum-devel}"
SRC_URI[x86_64_v2_rust-derive_more+sum-devel.sha256sum] = "4c65e315a93a5d260c5d793e1db0e59e3809439f992c879e4fb01c40c1ebd580"

URI_x86_64_v2_rust-derive_more+testing-helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+testing-helpers-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+testing-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+testing-helpers-devel}"
SRC_URI[x86_64_v2_rust-derive_more+testing-helpers-devel.sha256sum] = "2a76ebd6049f648d5dcb327ce93b19b78d00c6b2a63ba83a093a9bbf0f29c7ca"

URI_x86_64_v2_rust-derive_more+try_from-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+try_from-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+try_from-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+try_from-devel}"
SRC_URI[x86_64_v2_rust-derive_more+try_from-devel.sha256sum] = "cfad8f582dc2ba388c055278845519c6acaa7ee5ffeae02382eaabd24af15803"

URI_x86_64_v2_rust-derive_more+try_into-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+try_into-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+try_into-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+try_into-devel}"
SRC_URI[x86_64_v2_rust-derive_more+try_into-devel.sha256sum] = "2ba7e98ded7495819588dc9f8d197395af32198307bd24f22c47f933fb3367ff"

URI_x86_64_v2_rust-derive_more+try_unwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+try_unwrap-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+try_unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+try_unwrap-devel}"
SRC_URI[x86_64_v2_rust-derive_more+try_unwrap-devel.sha256sum] = "8452d5bb06b662e99e45056a011447fe7758053e9b999aaf5cd133a6a3228857"

URI_x86_64_v2_rust-derive_more+unwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more+unwrap-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more+unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more+unwrap-devel}"
SRC_URI[x86_64_v2_rust-derive_more+unwrap-devel.sha256sum] = "3164df338b3fcfd0fc72eae3000642f3d3a94edc1079147acecf8a6bc06b3972"

URI_x86_64_v2_rust-derive_more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-devel}"
SRC_URI[x86_64_v2_rust-derive_more-devel.sha256sum] = "e84b67b8dbcd7da408244ec64f461b4a14309f637f8291675b4c1bc50d9075a1"

URI_aarch64_rust-derive_more+add-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+add-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+add-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+add-devel}"
SRC_URI[aarch64_rust-derive_more+add-devel.sha256sum] = "21fe23891a084ed9f03c97d722fe6509f15d7b1fa59349efbbdc5cf77fac6967"

URI_aarch64_rust-derive_more+add_assign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+add_assign-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+add_assign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+add_assign-devel}"
SRC_URI[aarch64_rust-derive_more+add_assign-devel.sha256sum] = "014eb949e9b15b2a54300a14d1aefa791b523ccd22e3b47d0f10d7310dcde6d7"

URI_aarch64_rust-derive_more+as_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+as_ref-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+as_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+as_ref-devel}"
SRC_URI[aarch64_rust-derive_more+as_ref-devel.sha256sum] = "7a73270e5893a959e731e433419e4357fd7f58b4b3c6221a11ae9e65520cab83"

URI_aarch64_rust-derive_more+constructor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+constructor-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+constructor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+constructor-devel}"
SRC_URI[aarch64_rust-derive_more+constructor-devel.sha256sum] = "2e674cc73d73ae4234b02377991f1a732efa1cf754f1e6e05d9bcd1cd3a76eae"

URI_aarch64_rust-derive_more+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+debug-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+debug-devel}"
SRC_URI[aarch64_rust-derive_more+debug-devel.sha256sum] = "233b1a3ae493a57e565af54b3ddf06fd033e9ce3f21298847ef091c318193d0f"

URI_aarch64_rust-derive_more+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+default-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+default-devel}"
SRC_URI[aarch64_rust-derive_more+default-devel.sha256sum] = "61c42bb3ede6d8c343fea833dff0bee81b0602ccd1cc2eec3fe5a365148b7af6"

URI_aarch64_rust-derive_more+deref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+deref-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+deref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+deref-devel}"
SRC_URI[aarch64_rust-derive_more+deref-devel.sha256sum] = "e3e560be6f80d1327e66f1b65d913ed196e021bc05c25cc08f4452b714503cba"

URI_aarch64_rust-derive_more+deref_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+deref_mut-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+deref_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+deref_mut-devel}"
SRC_URI[aarch64_rust-derive_more+deref_mut-devel.sha256sum] = "02562eb8be9a3aa7b3dce3121215685402d337234d2433197ded7dea68a9fea4"

URI_aarch64_rust-derive_more+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+display-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+display-devel}"
SRC_URI[aarch64_rust-derive_more+display-devel.sha256sum] = "a63dbe35a2966201e72e753a7b79850be3c44ef22f45f9e35a878408053c5010"

URI_aarch64_rust-derive_more+eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+eq-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+eq-devel}"
SRC_URI[aarch64_rust-derive_more+eq-devel.sha256sum] = "e726389b4a152f36212b8b8c28d0788f05bfdfdc64272d1b0c962ed6789a2ff2"

URI_aarch64_rust-derive_more+error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+error-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+error-devel}"
SRC_URI[aarch64_rust-derive_more+error-devel.sha256sum] = "5d02c68a9247e5165662a48a925ebab437d1ca6139d06fd85277314c34c127fb"

URI_aarch64_rust-derive_more+from-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+from-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+from-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+from-devel}"
SRC_URI[aarch64_rust-derive_more+from-devel.sha256sum] = "fd7811e6e91695bdd093baefbac968461c5dcecb97cb3567e93d332c0c1455c5"

URI_aarch64_rust-derive_more+from_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+from_str-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+from_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+from_str-devel}"
SRC_URI[aarch64_rust-derive_more+from_str-devel.sha256sum] = "ed615c828812338c5eb271dca00b2d90b2ba1df6efe737eaaaed04e2ed4a87b9"

URI_aarch64_rust-derive_more+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+full-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+full-devel}"
SRC_URI[aarch64_rust-derive_more+full-devel.sha256sum] = "576dcb074fe03167c9982e61865583fe41d81a3776ff3bfc29d580b4be6c502c"

URI_aarch64_rust-derive_more+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+index-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+index-devel}"
SRC_URI[aarch64_rust-derive_more+index-devel.sha256sum] = "d44da81e79b4a8d023fefe8a5fc3282d169a8789020b8aa047fa237a5ab7facf"

URI_aarch64_rust-derive_more+index_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+index_mut-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+index_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+index_mut-devel}"
SRC_URI[aarch64_rust-derive_more+index_mut-devel.sha256sum] = "c1ed1e3a55366e82b1bacdf373a8ed9864d9bb5d7d8e3e0d5b14c80d1a6d04c8"

URI_aarch64_rust-derive_more+into-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+into-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+into-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+into-devel}"
SRC_URI[aarch64_rust-derive_more+into-devel.sha256sum] = "434b3e6a03b82942ef408c6572fdf675e48cdade3366f9e1e65eac36c4bab03d"

URI_aarch64_rust-derive_more+into_iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+into_iterator-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+into_iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+into_iterator-devel}"
SRC_URI[aarch64_rust-derive_more+into_iterator-devel.sha256sum] = "3676121c9d3b4570d9bfebfb7b2cd53493648e328b78fd72a3582cc2d5dc745b"

URI_aarch64_rust-derive_more+is_variant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+is_variant-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+is_variant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+is_variant-devel}"
SRC_URI[aarch64_rust-derive_more+is_variant-devel.sha256sum] = "ef09de3a644287ec5e03cb27a193f9c60feddc580b8c8a3b56218daa4ccc6ee3"

URI_aarch64_rust-derive_more+mul-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+mul-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+mul-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+mul-devel}"
SRC_URI[aarch64_rust-derive_more+mul-devel.sha256sum] = "a017869d4605a23e040f8b6aefc9532295ebc5f84717ebcc6dd88e75c875360c"

URI_aarch64_rust-derive_more+mul_assign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+mul_assign-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+mul_assign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+mul_assign-devel}"
SRC_URI[aarch64_rust-derive_more+mul_assign-devel.sha256sum] = "db77366992c96314bd80f512cd8ffc82c19b42ac94d8c272d1281b339d2de4ef"

URI_aarch64_rust-derive_more+not-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+not-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+not-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+not-devel}"
SRC_URI[aarch64_rust-derive_more+not-devel.sha256sum] = "72e13dc41cea94928f5273147741c2e78899fc1ec234c2846de869a66faab0c8"

URI_aarch64_rust-derive_more+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+std-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+std-devel}"
SRC_URI[aarch64_rust-derive_more+std-devel.sha256sum] = "b9f1e6b824dadf1ceec9631e3a00fce7608e9379bef48b05dfa9323414f9c005"

URI_aarch64_rust-derive_more+sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+sum-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+sum-devel}"
SRC_URI[aarch64_rust-derive_more+sum-devel.sha256sum] = "575862bc9c3135069bf1839685b15241aec5f891d2388503a0a0726ff0276bd4"

URI_aarch64_rust-derive_more+testing-helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+testing-helpers-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+testing-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+testing-helpers-devel}"
SRC_URI[aarch64_rust-derive_more+testing-helpers-devel.sha256sum] = "dd2f50644dd57d47b86f074fddfa464b2ec897911710f06c6ec060513ebfcc2b"

URI_aarch64_rust-derive_more+try_from-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+try_from-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+try_from-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+try_from-devel}"
SRC_URI[aarch64_rust-derive_more+try_from-devel.sha256sum] = "36c5b3cda18c907eb1ee6f8d7776baf78188bd6ecbf56810a1d3b84f556d0668"

URI_aarch64_rust-derive_more+try_into-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+try_into-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+try_into-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+try_into-devel}"
SRC_URI[aarch64_rust-derive_more+try_into-devel.sha256sum] = "da6c0b4903ca8c80a4906d0e0cd3185002ebeb96caab51132b75fab5fafd1bff"

URI_aarch64_rust-derive_more+try_unwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+try_unwrap-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+try_unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+try_unwrap-devel}"
SRC_URI[aarch64_rust-derive_more+try_unwrap-devel.sha256sum] = "11bac0749248016d8767121f07d736890cf3efdc7d9021ce740d197c5a3330c9"

URI_aarch64_rust-derive_more+unwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more+unwrap-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more+unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more+unwrap-devel}"
SRC_URI[aarch64_rust-derive_more+unwrap-devel.sha256sum] = "01af1b7817542b149264956865f4bc4daea8f7b8a6b32257be5a2dcb230ad43e"

URI_aarch64_rust-derive_more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-devel}"
SRC_URI[aarch64_rust-derive_more-devel.sha256sum] = "89cd0d7a1c06ef29a615bf86b3dbdf9422d478c5df7866ba11ddbf5daa5efb0c"

RDEPENDS:rust-derive_more+add-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+add-devel \
 "
RDEPENDS:rust-derive_more+add_assign-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+add_assign-devel \
 "
RDEPENDS:rust-derive_more+as_ref-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+as_ref-devel \
 "
RDEPENDS:rust-derive_more+constructor-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+constructor-devel \
 "
RDEPENDS:rust-derive_more+debug-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+debug-devel \
 "
RDEPENDS:rust-derive_more+default-devel = " \
 cargo \
 rust-derive_more+std-devel \
 rust-derive_more-devel \
 "
RDEPENDS:rust-derive_more+deref-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+deref-devel \
 "
RDEPENDS:rust-derive_more+deref_mut-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+deref_mut-devel \
 "
RDEPENDS:rust-derive_more+display-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+display-devel \
 "
RDEPENDS:rust-derive_more+eq-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+eq-devel \
 "
RDEPENDS:rust-derive_more+error-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+error-devel \
 "
RDEPENDS:rust-derive_more+from-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+from-devel \
 "
RDEPENDS:rust-derive_more+from_str-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+from_str-devel \
 "
RDEPENDS:rust-derive_more+full-devel = " \
 cargo \
 rust-derive_more+add-devel \
 rust-derive_more+add_assign-devel \
 rust-derive_more+as_ref-devel \
 rust-derive_more+constructor-devel \
 rust-derive_more+debug-devel \
 rust-derive_more+deref-devel \
 rust-derive_more+deref_mut-devel \
 rust-derive_more+display-devel \
 rust-derive_more+eq-devel \
 rust-derive_more+error-devel \
 rust-derive_more+from-devel \
 rust-derive_more+from_str-devel \
 rust-derive_more+index-devel \
 rust-derive_more+index_mut-devel \
 rust-derive_more+into-devel \
 rust-derive_more+into_iterator-devel \
 rust-derive_more+is_variant-devel \
 rust-derive_more+mul-devel \
 rust-derive_more+mul_assign-devel \
 rust-derive_more+not-devel \
 rust-derive_more+sum-devel \
 rust-derive_more+try_from-devel \
 rust-derive_more+try_into-devel \
 rust-derive_more+try_unwrap-devel \
 rust-derive_more+unwrap-devel \
 rust-derive_more-devel \
 "
RDEPENDS:rust-derive_more+index-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+index-devel \
 "
RDEPENDS:rust-derive_more+index_mut-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+index_mut-devel \
 "
RDEPENDS:rust-derive_more+into-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+into-devel \
 "
RDEPENDS:rust-derive_more+into_iterator-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+into_iterator-devel \
 "
RDEPENDS:rust-derive_more+is_variant-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+is_variant-devel \
 "
RDEPENDS:rust-derive_more+mul-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+mul-devel \
 "
RDEPENDS:rust-derive_more+mul_assign-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+mul_assign-devel \
 "
RDEPENDS:rust-derive_more+not-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+not-devel \
 "
RDEPENDS:rust-derive_more+std-devel = " \
 cargo \
 rust-derive_more-devel \
 "
RDEPENDS:rust-derive_more+sum-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+sum-devel \
 "
RDEPENDS:rust-derive_more+testing-helpers-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+testing-helpers-devel \
 rust-rustc_version+default-devel \
 "
RDEPENDS:rust-derive_more+try_from-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+try_from-devel \
 "
RDEPENDS:rust-derive_more+try_into-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+try_into-devel \
 "
RDEPENDS:rust-derive_more+try_unwrap-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+try_unwrap-devel \
 "
RDEPENDS:rust-derive_more+unwrap-devel = " \
 cargo \
 rust-derive_more-devel \
 rust-derive_more-impl+unwrap-devel \
 "
RDEPENDS:rust-derive_more-devel = " \
 cargo \
 rust \
 rust-derive_more-impl+default-devel \
 "
