# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghostwriter"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ghostwriter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghostwriter-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9bf5da7d20c8a6be7d8d11a1ca7f11257e1ea23437708d157638d7eff6a73eca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghostwriter-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghostwriter;unpack=0"
SRC_URI[x86_64_v2_ghostwriter.sha256sum] = "eec419f2c929d26b31f34e03b11a68cf11a3eaf76547f5e689b341b36b1a1aa2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghostwriter-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ghostwriter;unpack=0"
SRC_URI[aarch64_ghostwriter.sha256sum] = "ae015638f95a9d94682079428b581b12aa493f62411a2dff5ac0214ecca57dba"

RDEPENDS:ghostwriter = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
