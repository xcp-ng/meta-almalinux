# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-modemmanager-qt"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-modemmanager-qt \
 kf6-modemmanager-qt-devel \
 kf6-modemmanager-qt-doc \
 kf6-modemmanager-qt-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-modemmanager-qt-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cda622c19fb1d7d3e72bf82e2f036c3a26578e64fe807b7749cfe7de87e73a6a"

URI_x86_64_v2_kf6-modemmanager-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt.sha256sum] = "9ae943fc8d12cd626598a919c4dd5fe65af881a5ce6899b8537d8633969058f5"

URI_x86_64_v2_kf6-modemmanager-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-devel}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-devel.sha256sum] = "85d52e755242a08c391a8f8b09b960598422e45c37a615d43c884a84d83499d6"

URI_x86_64_v2_kf6-modemmanager-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-doc}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-doc.sha256sum] = "059bd00d4ce28507a89d22df32e8597c705fd3bedcb06b1c455f668b23bd3cb0"

URI_x86_64_v2_kf6-modemmanager-qt-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-modemmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-modemmanager-qt-html}"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-html.sha256sum] = "410e8e117e0673c0d270fa9ffba5c64a3af3e2b6257a7bc607b4d0d7547bcb54"

URI_aarch64_kf6-modemmanager-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-modemmanager-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt}"
SRC_URI[aarch64_kf6-modemmanager-qt.sha256sum] = "68d1ad89b91fa5e9a7642e5fd1850d7d8bdd2f1e062b54bd3caae0da730ce4d7"

URI_aarch64_kf6-modemmanager-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-devel}"
SRC_URI[aarch64_kf6-modemmanager-qt-devel.sha256sum] = "189cc5f4274672c7b849f9e47b926f05ce1fb11dcb8595d83ce345b69e70fdd6"

URI_aarch64_kf6-modemmanager-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-doc}"
SRC_URI[aarch64_kf6-modemmanager-qt-doc.sha256sum] = "22d8b1e04212ae2ceb509a6391780c3935e3f4feb253eabfa4e0844fa35e19f3"

URI_aarch64_kf6-modemmanager-qt-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-modemmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-modemmanager-qt-html}"
SRC_URI[aarch64_kf6-modemmanager-qt-html.sha256sum] = "138cb3c50e51f234313879f5ea47b0568c5f4b276ffa0908c76a31eacb059126"

RDEPENDS:kf6-modemmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-modemmanager-qt-devel = " \
 ModemManager-devel \
 cmake-filesystem \
 kf6-modemmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-modemmanager-qt-doc = " \
 "
RDEPENDS:kf6-modemmanager-qt-html = " \
 "
