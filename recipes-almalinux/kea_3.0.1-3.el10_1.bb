# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kea"
PV = "3.0.1"
PR = "3.el10_1"
PACKAGES = " \
 kea \
 kea-doc \
 kea-hooks \
 kea-keama \
 kea-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kea-3.0.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "464950fc4c27fc23786b3fd29b7f634aa432c78b2566b9b2fbf7bb19074e2d21"

URI_x86_64_v2_kea = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kea-3.0.1-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_kea;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea}"
SRC_URI[x86_64_v2_kea.sha256sum] = "828e854553e6757af59160b85c835fd4551a5f3316b621ae83f6720dd490e3d5"

URI_x86_64_v2_kea-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kea-doc-3.0.1-3.el10_1.noarch.rpm;name=x86_64_v2_kea-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-doc}"
SRC_URI[x86_64_v2_kea-doc.sha256sum] = "4dc81e4d6aa7a894bd32969d0ebbcace130f55ef96224eb3be6bce76c2f96035"

URI_x86_64_v2_kea-hooks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kea-hooks-3.0.1-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_kea-hooks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-hooks}"
SRC_URI[x86_64_v2_kea-hooks.sha256sum] = "facb63d351aabe51fa4887aa37bc575b1688216f25620528247f0b8169311dd5"

URI_x86_64_v2_kea-keama = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kea-keama-3.0.1-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_kea-keama;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-keama}"
SRC_URI[x86_64_v2_kea-keama.sha256sum] = "338f293a4a347672d57541bdf2d3350fec650229bdaafee16796df54bc22377f"

URI_x86_64_v2_kea-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kea-libs-3.0.1-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_kea-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kea-libs}"
SRC_URI[x86_64_v2_kea-libs.sha256sum] = "55af4c9b902286534ca353418a26bb16272b3fb51c236e4485f8f4a67d635086"

URI_aarch64_kea = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kea-3.0.1-3.el10_1.aarch64.rpm;name=aarch64_kea;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea}"
SRC_URI[aarch64_kea.sha256sum] = "371a1f35954b907c1142962cabb379379fbe4d194ad94be539df57a7741680e3"

URI_aarch64_kea-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kea-doc-3.0.1-3.el10_1.noarch.rpm;name=aarch64_kea-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-doc}"
SRC_URI[aarch64_kea-doc.sha256sum] = "4dc81e4d6aa7a894bd32969d0ebbcace130f55ef96224eb3be6bce76c2f96035"

URI_aarch64_kea-hooks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kea-hooks-3.0.1-3.el10_1.aarch64.rpm;name=aarch64_kea-hooks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-hooks}"
SRC_URI[aarch64_kea-hooks.sha256sum] = "a511ab5b532cbee385298e8bee5f1f87911f53d7e32a0b43b4022a2ab3e7135c"

URI_aarch64_kea-keama = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kea-keama-3.0.1-3.el10_1.aarch64.rpm;name=aarch64_kea-keama;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-keama}"
SRC_URI[aarch64_kea-keama.sha256sum] = "e80293015759858e8beb309e509789128587ca7aa28eec84722036d550a9ccc1"

URI_aarch64_kea-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kea-libs-3.0.1-3.el10_1.aarch64.rpm;name=aarch64_kea-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kea-libs}"
SRC_URI[aarch64_kea-libs.sha256sum] = "93a6711cb900cf59afd65a75abab8ffc9674ffb67885ef64da9f1dd3a837ef88"

RDEPENDS:kea = " \
 bash \
 glibc \
 kea-libs \
 libgcc \
 libstdc++ \
 openssl-libs \
 python3 \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:kea-doc = " \
 "
RDEPENDS:kea-hooks = " \
 glibc \
 kea-libs \
 krb5-libs \
 libgcc \
 libpq \
 libstdc++ \
 mariadb-connector-c \
 openssl-libs \
 "
RDEPENDS:kea-keama = " \
 glibc \
 "
RDEPENDS:kea-libs = " \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 log4cplus \
 mariadb-connector-c \
 openssl-libs \
 "
