# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit-qt-1"
PV = "0.200.0"
PR = "1.el10_0"
PACKAGES = " \
 polkit-qt5-1 \
 polkit-qt5-1-devel \
 polkit-qt6-1 \
 polkit-qt6-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/polkit-qt-1-0.200.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc4b198cdaf83ffa4fc20f281ed0cbc267b687c5a523df3b47d54fdede7d6974"

URI_x86_64_v2_polkit-qt5-1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt5-1-0.200.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt5-1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt5-1}"
SRC_URI[x86_64_v2_polkit-qt5-1.sha256sum] = "52c44cb44163262bcc6e531d200fa900a138d05e70dc5bbcdcb358040accbf5b"

URI_x86_64_v2_polkit-qt5-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt5-1-devel-0.200.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt5-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt5-1-devel}"
SRC_URI[x86_64_v2_polkit-qt5-1-devel.sha256sum] = "636f07664c55852809f82cd79d57156466357925749b990cf2138bbd1093ee51"

URI_x86_64_v2_polkit-qt6-1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt6-1-0.200.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt6-1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt6-1}"
SRC_URI[x86_64_v2_polkit-qt6-1.sha256sum] = "e21de68e758bf3230ce4bee73b4e74ee5a15c7f32319d0effa4add762e57f189"

URI_x86_64_v2_polkit-qt6-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt6-1-devel-0.200.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt6-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt6-1-devel}"
SRC_URI[x86_64_v2_polkit-qt6-1-devel.sha256sum] = "4fce2bf62776de9dd0ad667b1405a28f80f93c7dc2928cd2d7ebb507dc735a5c"

URI_aarch64_polkit-qt5-1 = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt5-1-0.200.0-1.el10_0.aarch64.rpm;name=aarch64_polkit-qt5-1;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt5-1}"
SRC_URI[aarch64_polkit-qt5-1.sha256sum] = "febe3505fa5c446275d347afe88731651f95b6a1c64330324ec30d84510e83c4"

URI_aarch64_polkit-qt5-1-devel = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt5-1-devel-0.200.0-1.el10_0.aarch64.rpm;name=aarch64_polkit-qt5-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt5-1-devel}"
SRC_URI[aarch64_polkit-qt5-1-devel.sha256sum] = "5d26718264694801cc9fa3865212ce67cec8198680e1983f7307d32b4173a8c5"

URI_aarch64_polkit-qt6-1 = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt6-1-0.200.0-1.el10_0.aarch64.rpm;name=aarch64_polkit-qt6-1;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt6-1}"
SRC_URI[aarch64_polkit-qt6-1.sha256sum] = "9171e685ef4acb89e747871c63fb489c228b0054c9a21a00960718b8ecffd4db"

URI_aarch64_polkit-qt6-1-devel = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt6-1-devel-0.200.0-1.el10_0.aarch64.rpm;name=aarch64_polkit-qt6-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt6-1-devel}"
SRC_URI[aarch64_polkit-qt6-1-devel.sha256sum] = "c02ac48eee3373bda850a7f6c714ac60a2dec7ccfe1864053bb05b4b47724483"

RDEPENDS:polkit-qt5-1 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 polkit-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:polkit-qt5-1-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 polkit-qt5-1 \
 polkit-qt5-1-devel \
 qt5-qtbase-devel \
 "
RDEPENDS:polkit-qt6-1 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 polkit-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:polkit-qt6-1-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 polkit-qt6-1 \
 polkit-qt6-1-devel \
 qt6-qtbase-devel \
 "
