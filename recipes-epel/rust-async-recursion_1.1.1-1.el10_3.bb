# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-recursion"
PV = "1.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-async-recursion+default-devel \
 rust-async-recursion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-recursion-1.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62962b04c71e988236cbd2ebfec83507bff54ee74c87b7c41836985a353501a6"

URI_x86_64_v2_rust-async-recursion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-recursion+default-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-recursion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-recursion+default-devel}"
SRC_URI[x86_64_v2_rust-async-recursion+default-devel.sha256sum] = "d9b53e4cf24be7f6410b1dc62005211bc1f58d0594ca662341533b559cbd26c2"

URI_x86_64_v2_rust-async-recursion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-recursion-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-recursion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-recursion-devel}"
SRC_URI[x86_64_v2_rust-async-recursion-devel.sha256sum] = "d2d71a3392f6c75cc2dbb368b012e21b6a47f6437de18db24a22f1a116044015"

URI_aarch64_rust-async-recursion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-recursion+default-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-async-recursion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-recursion+default-devel}"
SRC_URI[aarch64_rust-async-recursion+default-devel.sha256sum] = "6402aebe4c84190ca9dbe2b3a15388747cfc79f6b3a16a788e0c4fe692e717df"

URI_aarch64_rust-async-recursion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-recursion-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-async-recursion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-recursion-devel}"
SRC_URI[aarch64_rust-async-recursion-devel.sha256sum] = "4ad995e043e9b6ab3603c6265508c77800dc845e4ece0c1074d6ee30e1748066"

RDEPENDS:rust-async-recursion+default-devel = " \
 cargo \
 rust-async-recursion-devel \
 "
RDEPENDS:rust-async-recursion-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2+visit-mut-devel \
 rust-syn2-devel \
 "
