# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-PostgreSQL"
PV = "1.29"
PR = "13.el10_2"
PACKAGES = " \
 perl-Test-PostgreSQL \
 perl-Test-PostgreSQL-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-PostgreSQL-1.29-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86c3dcf355a4abfff58d5e7583badd9d416e2205c98abcc89948c0852e9c68c7"

URI_x86_64_v2_perl-Test-PostgreSQL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-PostgreSQL-1.29-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-PostgreSQL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-PostgreSQL}"
SRC_URI[x86_64_v2_perl-Test-PostgreSQL.sha256sum] = "617a5fc70d9ae0210ed8e649b989fa69111ff04ff4d1eb225e2a080d215dea48"

URI_x86_64_v2_perl-Test-PostgreSQL-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-PostgreSQL-tests-1.29-13.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-PostgreSQL-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-PostgreSQL-tests}"
SRC_URI[x86_64_v2_perl-Test-PostgreSQL-tests.sha256sum] = "e6334bd43c71a269b037b6bb850e8783158c6ae3904537222354e42a6d9a1c4c"

URI_aarch64_perl-Test-PostgreSQL = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-PostgreSQL-1.29-13.el10_2.noarch.rpm;name=aarch64_perl-Test-PostgreSQL;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-PostgreSQL}"
SRC_URI[aarch64_perl-Test-PostgreSQL.sha256sum] = "004f666475a29b28f6fa271f61fa9a3735ee659fd1b026ff079ee02e2763a1f9"

URI_aarch64_perl-Test-PostgreSQL-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-PostgreSQL-tests-1.29-13.el10_2.noarch.rpm;name=aarch64_perl-Test-PostgreSQL-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-PostgreSQL-tests}"
SRC_URI[aarch64_perl-Test-PostgreSQL-tests.sha256sum] = "0b62b37ad6bc79f3ec78b15714479e8196595563d0ed263a326c19bdda64390f"

RDEPENDS:perl-Test-PostgreSQL = " \
 perl-DBD-Pg \
 perl-DBI \
 perl-File-Temp \
 perl-File-Which \
 perl-Function-Parameters \
 perl-Moo \
 perl-POSIX \
 perl-PathTools \
 perl-Tie-Hash-Method \
 perl-Try-Tiny \
 perl-Type-Tiny \
 perl-User-pwent \
 perl-libs \
 postgresql-server \
 "
RDEPENDS:perl-Test-PostgreSQL-tests = " \
 bash \
 perl-DBI \
 perl-File-Temp \
 perl-POSIX \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-PostgreSQL \
 perl-Test-SharedFork \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 "
