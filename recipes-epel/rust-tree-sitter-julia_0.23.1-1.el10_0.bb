# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-julia"
PV = "0.23.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-julia+default-devel \
 rust-tree-sitter-julia-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-julia-0.23.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b1fcc02ecfbfba9a886eb6405c3714a4454eab6735eb394e463d14925d00c5e"

URI_x86_64_v2_rust-tree-sitter-julia+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-julia+default-devel-0.23.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-julia+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-julia+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-julia+default-devel.sha256sum] = "ec7551f40189addf086294a68a21b2fd695efa0c88a6f45e59993ee98dcbbd49"

URI_x86_64_v2_rust-tree-sitter-julia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-julia-devel-0.23.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-julia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-julia-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-julia-devel.sha256sum] = "a4cd576bc39bd7cc83e665400e71b748b27da144476b6a4499442e1babc239e0"

URI_aarch64_rust-tree-sitter-julia+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-julia+default-devel-0.23.1-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-julia+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-julia+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-julia+default-devel.sha256sum] = "e0021fd1777be4159a7916ab84634c7db245e8f3c908a8af1a27db2b2edef872"

URI_aarch64_rust-tree-sitter-julia-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-julia-devel-0.23.1-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-julia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-julia-devel}"
SRC_URI[aarch64_rust-tree-sitter-julia-devel.sha256sum] = "64f99650aaee41cad422c0690ba6ed7eb4210727a57bbb74d7b2f39e8003f737"

RDEPENDS:rust-tree-sitter-julia+default-devel = " \
 cargo \
 rust-tree-sitter-julia-devel \
 "
RDEPENDS:rust-tree-sitter-julia-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
