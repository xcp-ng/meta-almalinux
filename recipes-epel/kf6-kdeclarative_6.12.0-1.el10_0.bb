# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdeclarative"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kdeclarative \
 kf6-kdeclarative-devel \
 kf6-kdeclarative-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdeclarative-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30edae68da409e193b84afcc8de5c630383abda0f7684c846d0917af9a640e4a"

URI_x86_64_v2_kf6-kdeclarative = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative}"
SRC_URI[x86_64_v2_kf6-kdeclarative.sha256sum] = "a738242f57e1ac8c5106c3aeb848753745d20745451675276d0aaa4ff9ec3722"

URI_x86_64_v2_kf6-kdeclarative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-devel}"
SRC_URI[x86_64_v2_kf6-kdeclarative-devel.sha256sum] = "33640682e90ac392e321d7725e28c8068f47fae9a3269d9b0cf4556292528730"

URI_x86_64_v2_kf6-kdeclarative-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdeclarative-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdeclarative-doc}"
SRC_URI[x86_64_v2_kf6-kdeclarative-doc.sha256sum] = "c6593b51e9c2c2a18042950b3550f666d89878247e22db43c65f4662f6907c65"

URI_aarch64_kf6-kdeclarative = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative}"
SRC_URI[aarch64_kf6-kdeclarative.sha256sum] = "b2f37707a4bc8892d24f87003f1f55e36fc2d8987456b94a2f81de74de0286ea"

URI_aarch64_kf6-kdeclarative-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-devel}"
SRC_URI[aarch64_kf6-kdeclarative-devel.sha256sum] = "a24a383a40dfb0c418c187f038217cf558ea252e4d5fdd7f1aaac3edf0403f28"

URI_aarch64_kf6-kdeclarative-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdeclarative-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kdeclarative-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdeclarative-doc}"
SRC_URI[aarch64_kf6-kdeclarative-doc.sha256sum] = "ab852e22894a460072f9ea3723c387a8883a999f1725d3a83bd8ed7946931e70"

RDEPENDS:kf6-kdeclarative = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kdeclarative-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kdeclarative \
 kf6-kpackage-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kdeclarative-doc = " \
 "
