# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdoctools"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kdoctools \
 kf6-kdoctools-devel \
 kf6-kdoctools-doc \
 kf6-kdoctools-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdoctools-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e6243ba69eef854999ad928f7bd3b2ea03e77f51908272f7b7be225eac48d7c"

URI_x86_64_v2_kf6-kdoctools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools}"
SRC_URI[x86_64_v2_kf6-kdoctools.sha256sum] = "7a691afb6ee7f7b43f562dfad683a448b195fa2882de1867906193bdf15b1d90"

URI_x86_64_v2_kf6-kdoctools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools-devel}"
SRC_URI[x86_64_v2_kf6-kdoctools-devel.sha256sum] = "095240870116597517e5c172425f3b410981e9da29718b6cbbf9263e89c09c28"

URI_x86_64_v2_kf6-kdoctools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdoctools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools-doc}"
SRC_URI[x86_64_v2_kf6-kdoctools-doc.sha256sum] = "3eaf8331b62d76d3bd561671678fe6949d55a131de38c33f2b264e94a68037c4"

URI_x86_64_v2_kf6-kdoctools-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdoctools-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools-html}"
SRC_URI[x86_64_v2_kf6-kdoctools-html.sha256sum] = "8ad9562ee3dc205f14d236cc535880eb63e276f50a10641e2916093e708baa2e"

URI_aarch64_kf6-kdoctools = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdoctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools}"
SRC_URI[aarch64_kf6-kdoctools.sha256sum] = "eb558457dc63abc4733e70e06f01e66c80cf2eb1712bae2f67ebec6cf0dfd2fe"

URI_aarch64_kf6-kdoctools-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdoctools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools-devel}"
SRC_URI[aarch64_kf6-kdoctools-devel.sha256sum] = "a1490b293b7ece5210b53283adc04b2ff23765adab0d10c6aa766e11af91b27c"

URI_aarch64_kf6-kdoctools-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdoctools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools-doc}"
SRC_URI[aarch64_kf6-kdoctools-doc.sha256sum] = "a2ed5cd90edfd3a04b9a37c7b85339fad7569f84be27f52e745871f52bd8c01e"

URI_aarch64_kf6-kdoctools-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdoctools-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools-html}"
SRC_URI[aarch64_kf6-kdoctools-html.sha256sum] = "340c761269b93a8a952c925ed32ce429a1bc988bd55f7d099a91ee9f3b05e912"

RDEPENDS:kf6-kdoctools = " \
 docbook-dtds \
 docbook-style-xsl \
 glibc \
 kf6-karchive \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdoctools-devel = " \
 cmake-filesystem \
 kf6-kdoctools \
 perl-Any-URI-Escape \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdoctools-doc = " \
 "
RDEPENDS:kf6-kdoctools-html = " \
 "
