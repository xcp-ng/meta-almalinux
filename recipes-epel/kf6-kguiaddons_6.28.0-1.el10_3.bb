# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kguiaddons"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kguiaddons \
 kf6-kguiaddons-devel \
 kf6-kguiaddons-doc \
 kf6-kguiaddons-html \
 python3-kf6-kguiaddons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kguiaddons-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48d94ccc122952712e1b332d52f7b7b8759d521cbcdb958582f9005ccc903083"

URI_x86_64_v2_kf6-kguiaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons}"
SRC_URI[x86_64_v2_kf6-kguiaddons.sha256sum] = "dbd7aec85ef54e0937c074cf6939f280083a3f27ad311ca4b8120059bc71bebb"

URI_x86_64_v2_kf6-kguiaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons-devel}"
SRC_URI[x86_64_v2_kf6-kguiaddons-devel.sha256sum] = "354825646efdfde91627a252d4eab4d93e901aa72b11a77fa833e70997d49051"

URI_x86_64_v2_kf6-kguiaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kguiaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons-doc}"
SRC_URI[x86_64_v2_kf6-kguiaddons-doc.sha256sum] = "81cf3fbbfbc4c47c9c7e7e72ed5128eeec89a381120d79b9bcda214759d22ad9"

URI_x86_64_v2_kf6-kguiaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kguiaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons-html}"
SRC_URI[x86_64_v2_kf6-kguiaddons-html.sha256sum] = "9ce454690c0a7ab2edc36c6e9da4a4a9cc2a60353c267ac42fed15f43099ee40"

URI_x86_64_v2_python3-kf6-kguiaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kguiaddons-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kguiaddons}"
SRC_URI[x86_64_v2_python3-kf6-kguiaddons.sha256sum] = "6c5255fb9d732666b9fd47f1c096b930e913eebf2036c8360afd61e18039da3d"

URI_aarch64_kf6-kguiaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons}"
SRC_URI[aarch64_kf6-kguiaddons.sha256sum] = "aeeea3d1539512092b3c67a884f7ee0c0de853cee0706646f0f3a10e30e62b23"

URI_aarch64_kf6-kguiaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kguiaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons-devel}"
SRC_URI[aarch64_kf6-kguiaddons-devel.sha256sum] = "a51a61abc321b1fea9d834a29b2167ed11bda2eaf53eac1fff0827ea5661a536"

URI_aarch64_kf6-kguiaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kguiaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons-doc}"
SRC_URI[aarch64_kf6-kguiaddons-doc.sha256sum] = "193719ce3dd8d9c2e7c3ff5f9a9ac86f507ef8a31a8c74e9a2bb62df54982d2e"

URI_aarch64_kf6-kguiaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kguiaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons-html}"
SRC_URI[aarch64_kf6-kguiaddons-html.sha256sum] = "229dd3cb86bcc80da1458e45cfda8c646b2c773887ec5c1cb3e635169f9eaf9b"

URI_aarch64_python3-kf6-kguiaddons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kguiaddons-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kguiaddons}"
SRC_URI[aarch64_python3-kf6-kguiaddons.sha256sum] = "3d761a8156c428d605bf3e068cc09536594897db4cbdf2bd7f2bcfdfba6e976e"

RDEPENDS:kf6-kguiaddons = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kguiaddons-devel = " \
 cmake-filesystem \
 kf6-kguiaddons \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kguiaddons-doc = " \
 "
RDEPENDS:kf6-kguiaddons-html = " \
 "
RDEPENDS:python3-kf6-kguiaddons = " \
 glibc \
 kf6-kguiaddons \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
