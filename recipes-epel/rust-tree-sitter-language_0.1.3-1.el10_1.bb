# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-language"
PV = "0.1.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-language+default-devel \
 rust-tree-sitter-language-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-language-0.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8039f098dea2bcdc323d6df186a71a7e28d6a68440e0113f01bcd4eac09a6cd"

URI_x86_64_v2_rust-tree-sitter-language+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-language+default-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-language+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-language+default-devel.sha256sum] = "8dd5fa2a121364af5174e9a0d9dd57fd7d4096378d38cd6c6d728a0f5576b1e3"

URI_x86_64_v2_rust-tree-sitter-language-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-language-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-language-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-language-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-language-devel.sha256sum] = "d0dd6ee2ca713bc8e85d9ed81bcd56c5a478590d5a2f57209413a90d6f0d8295"

URI_aarch64_rust-tree-sitter-language+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-language+default-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-language+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-language+default-devel.sha256sum] = "df2ca4d1d943fc44a1642348b253627e8abb3730fd432d9c62507395871b6e2e"

URI_aarch64_rust-tree-sitter-language-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-language-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-language-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-language-devel}"
SRC_URI[aarch64_rust-tree-sitter-language-devel.sha256sum] = "c6336a377c9737abf61bcfb459c09078e089a8622f361553fdd490813a605944"

RDEPENDS:rust-tree-sitter-language+default-devel = " \
 cargo \
 rust-tree-sitter-language-devel \
 "
RDEPENDS:rust-tree-sitter-language-devel = " \
 cargo \
 rust \
 "
