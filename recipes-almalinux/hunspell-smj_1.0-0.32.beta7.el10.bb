# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-smj"
PV = "1.0"
PR = "0.32.beta7.el10"
PACKAGES = " \
 hunspell-smj \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-smj-1.0-0.32.beta7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c35e0085bcb2f7cf80e90ef4612b87f5d627b46ee4a8874b03b9b6becd527044"

URI_x86_64_v2_hunspell-smj = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-smj-1.0-0.32.beta7.el10.noarch.rpm;name=x86_64_v2_hunspell-smj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-smj}"
SRC_URI[x86_64_v2_hunspell-smj.sha256sum] = "00a56f1946c38ff7132849686cf48ee6f9616eb259381050ab892a6be56682c1"

URI_aarch64_hunspell-smj = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-smj-1.0-0.32.beta7.el10.noarch.rpm;name=aarch64_hunspell-smj;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-smj}"
SRC_URI[aarch64_hunspell-smj.sha256sum] = "00a56f1946c38ff7132849686cf48ee6f9616eb259381050ab892a6be56682c1"

RDEPENDS:hunspell-smj = " \
 hunspell \
 "
