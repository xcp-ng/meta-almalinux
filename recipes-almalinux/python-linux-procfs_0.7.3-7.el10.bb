# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-linux-procfs"
PV = "0.7.3"
PR = "7.el10"
PACKAGES = " \
 python3-linux-procfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-linux-procfs-0.7.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3345bbf17a6343997de632bae3116434d1eb9bbcfc62944777d43075983d6a2f"

URI_x86_64_v2_python3-linux-procfs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-linux-procfs-0.7.3-7.el10.noarch.rpm;name=x86_64_v2_python3-linux-procfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-linux-procfs}"
SRC_URI[x86_64_v2_python3-linux-procfs.sha256sum] = "d37209f3d86d028969608cd6c8b59ea99f27c7f62f0650f599b92e0f31db748f"

URI_aarch64_python3-linux-procfs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-linux-procfs-0.7.3-7.el10.noarch.rpm;name=aarch64_python3-linux-procfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-linux-procfs}"
SRC_URI[aarch64_python3-linux-procfs.sha256sum] = "d37209f3d86d028969608cd6c8b59ea99f27c7f62f0650f599b92e0f31db748f"

RDEPENDS:python3-linux-procfs = " \
 python3 \
 python3-six \
 "
