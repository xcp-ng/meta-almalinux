# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shigofumi"
PV = "0.9"
PR = "12.el10_0"
PACKAGES = " \
 shigofumi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/shigofumi-0.9-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59e1303b2ef79370d51c85e6cc6ed50097fa0baa2ac63695955549bd110fe6b9"

URI_x86_64_v2_shigofumi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shigofumi-0.9-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_shigofumi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shigofumi}"
SRC_URI[x86_64_v2_shigofumi.sha256sum] = "0e4e19c8f32053c3465292624b25812ecaa1530bfc95f0151414b4ce650d3ea0"

URI_aarch64_shigofumi = "${EPEL_MIRROR}/aarch64/Packages/s/shigofumi-0.9-12.el10_0.aarch64.rpm;name=aarch64_shigofumi;unpack=0"
SRC_URI:append = " ${URI_aarch64_shigofumi}"
SRC_URI[aarch64_shigofumi.sha256sum] = "36ab46403beebc786a2ccd7998609b0e580ac9306a165c2990e721a46fc711ef"

RDEPENDS:shigofumi = " \
 file-libs \
 glibc \
 libconfuse \
 libisds \
 libxml2 \
 readline \
 "
