# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktuberling"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ktuberling \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktuberling-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f02da1a27d18bbbaae81c16669ef9f5ee34c28593a1c79f06f7cb8c2faf769f"

URI_x86_64_v2_ktuberling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktuberling-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktuberling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktuberling}"
SRC_URI[x86_64_v2_ktuberling.sha256sum] = "c05c4b3eefdb639ccd8bc4662996fb0d1c9192f496e976654a8a0ad74b34f142"

URI_aarch64_ktuberling = "${EPEL_MIRROR}/aarch64/Packages/k/ktuberling-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ktuberling;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktuberling}"
SRC_URI[aarch64_ktuberling.sha256sum] = "c3fedb6afc4d06d5c21afc65a91207b2ada16649cfc547210d7685aa44364fff"

RDEPENDS:ktuberling = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
