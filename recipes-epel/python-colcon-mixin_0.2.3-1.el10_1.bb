# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-mixin"
PV = "0.2.3"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-mixin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-mixin-0.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c50addd0063b556196b1cccb73d01ac96f3b3ee2798a2fd8ccb9f9c2e2a107d"

URI_x86_64_v2_python3-colcon-mixin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-mixin-0.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-mixin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-mixin}"
SRC_URI[x86_64_v2_python3-colcon-mixin.sha256sum] = "6ed657d39a3ecebf5a5ec6a09e8503f3cf0cf5498b3b5e0cf6acabad9d481c6b"

URI_aarch64_python3-colcon-mixin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-mixin-0.2.3-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-mixin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-mixin}"
SRC_URI[aarch64_python3-colcon-mixin.sha256sum] = "991c6cd3e5838085d819bb4cbac2b35eb798dff6618cb6d14e4f95ac92dc8db7"

RDEPENDS:python3-colcon-mixin = " \
 python3 \
 python3-colcon-core \
 python3-pyyaml \
 "
