# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "livesys-scripts"
PV = "0.6.4"
PR = "1.el10_0"
PACKAGES = " \
 livesys-scripts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/livesys-scripts-0.6.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "727b23c552d8a3420590d5e297a692cb55794f740c312ac10ca3883d5a7a959a"

URI_x86_64_v2_livesys-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/livesys-scripts-0.6.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_livesys-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_livesys-scripts}"
SRC_URI[x86_64_v2_livesys-scripts.sha256sum] = "cb2094ccddf97407138e81b7f8f6ce44596f682e9d2bac4b0a4c91f679565e87"

URI_aarch64_livesys-scripts = "${EPEL_MIRROR}/aarch64/Packages/l/livesys-scripts-0.6.4-1.el10_0.noarch.rpm;name=aarch64_livesys-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_livesys-scripts}"
SRC_URI[aarch64_livesys-scripts.sha256sum] = "3880f8ab592e119b302bfd9ca04db68bbab46271b46c631017cb31d936e04c53"

RDEPENDS:livesys-scripts = " \
 bash \
 "
