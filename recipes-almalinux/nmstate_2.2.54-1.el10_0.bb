# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmstate"
PV = "2.2.54"
PR = "1.el10_0"
PACKAGES = " \
 nmstate \
 nmstate-devel \
 nmstate-libs \
 nmstate-static \
 python3-libnmstate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nmstate-2.2.54-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9499717c1f1015eb742c47f35bb9a0c34692052d58945f1dff806364c3769aba"

URI_x86_64_v2_nmstate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-2.2.54-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_nmstate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate}"
SRC_URI[x86_64_v2_nmstate.sha256sum] = "c19ac7ccad5b3a7711c34a026ce751ba50553bcf2dc6cf31efa9077289ecd2d1"

URI_x86_64_v2_nmstate-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-devel-2.2.54-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_nmstate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-devel}"
SRC_URI[x86_64_v2_nmstate-devel.sha256sum] = "c552ec44431674f54a42384a24bdf3b6d151d62630f6da6a234c1aebb25c6d99"

URI_x86_64_v2_nmstate-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmstate-libs-2.2.54-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_nmstate-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-libs}"
SRC_URI[x86_64_v2_nmstate-libs.sha256sum] = "5461e05ef4de51e7b17d4fa2136378bede82109b54713485f355ec0c8cfb8622"

URI_x86_64_v2_nmstate-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nmstate-static-2.2.54-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_nmstate-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmstate-static}"
SRC_URI[x86_64_v2_nmstate-static.sha256sum] = "1a21c0fbf18da2dff4d7dcb8518cf4c0bec7d9b2055421937b832083b54f1375"

URI_x86_64_v2_python3-libnmstate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnmstate-2.2.54-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-libnmstate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnmstate}"
SRC_URI[x86_64_v2_python3-libnmstate.sha256sum] = "b68e16982d3528232aaa0b2bb43bb31288e356c682d30c408e8d41acc69f97a1"

URI_aarch64_nmstate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-2.2.54-1.el10_0.aarch64.rpm;name=aarch64_nmstate;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate}"
SRC_URI[aarch64_nmstate.sha256sum] = "6893f817d3fcc8862e2a234f80abde92075d246f822c69bc4bdbadbfd873d31a"

URI_aarch64_nmstate-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-devel-2.2.54-1.el10_0.aarch64.rpm;name=aarch64_nmstate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-devel}"
SRC_URI[aarch64_nmstate-devel.sha256sum] = "5e48eba8f79ca5d6590a22ed7aba17c15f1d350b8e58c4a1605887440f988b27"

URI_aarch64_nmstate-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmstate-libs-2.2.54-1.el10_0.aarch64.rpm;name=aarch64_nmstate-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-libs}"
SRC_URI[aarch64_nmstate-libs.sha256sum] = "8b7d886e779de26a798ec06921d7a0c783ba5fc333c7cd912b4cc428462bae86"

URI_aarch64_nmstate-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nmstate-static-2.2.54-1.el10_0.aarch64.rpm;name=aarch64_nmstate-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmstate-static}"
SRC_URI[aarch64_nmstate-static.sha256sum] = "548faa2d9196d74d199f3b8c26713dc051be76a5f429a2273cb8eb781385867c"

URI_aarch64_python3-libnmstate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnmstate-2.2.54-1.el10_0.aarch64.rpm;name=aarch64_python3-libnmstate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnmstate}"
SRC_URI[aarch64_python3-libnmstate.sha256sum] = "186d3d266cfa0a284a7be69da1c48fc8874ea768fb9d15574c79859be015c381"

RDEPENDS:nmstate = " \
 glibc \
 libgcc \
 nmstate-libs \
 "
RDEPENDS:nmstate-devel = " \
 nmstate-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:nmstate-libs = " \
 glibc \
 libgcc \
 "
RDEPENDS:nmstate-static = " \
 nmstate-devel \
 "
RDEPENDS:python3-libnmstate = " \
 nmstate-libs \
 python3 \
 python3-pyyaml \
 "
