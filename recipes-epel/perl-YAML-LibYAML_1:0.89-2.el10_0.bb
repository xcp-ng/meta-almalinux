# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-YAML-LibYAML"
PE = "1"
PV = "0.89"
PR = "2.el10_0"
PACKAGES = " \
 perl-YAML-LibYAML \
 perl-YAML-LibYAML-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-YAML-LibYAML-0.89-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "051782a28c7ef89941a92d7f3e32f2b736f3a9c979aebc029ef286a6b0684c31"

URI_x86_64_v2_perl-YAML-LibYAML = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-YAML-LibYAML-0.89-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-YAML-LibYAML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-YAML-LibYAML}"
SRC_URI[x86_64_v2_perl-YAML-LibYAML.sha256sum] = "c0c853cd6017543c39c22c3d2b1e913fe74c0e745a4f4ee8714b222f05ff5927"

URI_x86_64_v2_perl-YAML-LibYAML-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-YAML-LibYAML-tests-0.89-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-YAML-LibYAML-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-YAML-LibYAML-tests}"
SRC_URI[x86_64_v2_perl-YAML-LibYAML-tests.sha256sum] = "67677ff2a22c2579d348e1d4f0553389564c2e77c59acd1c8cc7ae38a6814363"

URI_aarch64_perl-YAML-LibYAML = "${EPEL_MIRROR}/aarch64/Packages/p/perl-YAML-LibYAML-0.89-2.el10_0.aarch64.rpm;name=aarch64_perl-YAML-LibYAML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-YAML-LibYAML}"
SRC_URI[aarch64_perl-YAML-LibYAML.sha256sum] = "9e22cdabc0f111a03b7cbd4e70ec87c25fc2c0c860b31487f400da9b5644c03d"

URI_aarch64_perl-YAML-LibYAML-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-YAML-LibYAML-tests-0.89-2.el10_0.aarch64.rpm;name=aarch64_perl-YAML-LibYAML-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-YAML-LibYAML-tests}"
SRC_URI[aarch64_perl-YAML-LibYAML-tests.sha256sum] = "d86504fd3ce29c5cbdb1fa0916a52b1971febb694d3f2153ea26b4c6c05e0d4d"

RDEPENDS:perl-YAML-LibYAML = " \
 glibc \
 libyaml \
 perl-B \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-base \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-YAML-LibYAML-tests = " \
 bash \
 perl-B \
 perl-Devel-Peek \
 perl-Encode \
 perl-File-Path \
 perl-FindBin \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-Test-Base \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tie \
 perl-YAML-LibYAML \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
