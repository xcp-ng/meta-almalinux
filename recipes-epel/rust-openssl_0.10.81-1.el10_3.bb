# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl"
PV = "0.10.81"
PR = "1.el10_3"
PACKAGES = " \
 rust-openssl+bindgen-devel \
 rust-openssl+default-devel \
 rust-openssl+v101-devel \
 rust-openssl+v102-devel \
 rust-openssl+v110-devel \
 rust-openssl+v111-devel \
 rust-openssl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-0.10.81-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65a91bd13adc2c81787ee2d849922bcf53077fd0c49cad30847b3f9662cde880"

URI_x86_64_v2_rust-openssl+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+bindgen-devel-0.10.81-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+bindgen-devel}"
SRC_URI[x86_64_v2_rust-openssl+bindgen-devel.sha256sum] = "871e5bfc1794baed2ad6c10b9a5573b833a16d74673d4fec254a6e1548b0f29b"

URI_x86_64_v2_rust-openssl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+default-devel-0.10.81-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+default-devel}"
SRC_URI[x86_64_v2_rust-openssl+default-devel.sha256sum] = "ce1c754956ccf1fac70f67983ead5c5caf4ef9acf884937e665f8259ffb8c5b1"

URI_x86_64_v2_rust-openssl+v101-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v101-devel-0.10.81-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v101-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v101-devel}"
SRC_URI[x86_64_v2_rust-openssl+v101-devel.sha256sum] = "fe75968c1f8be92058112d4f17624bf06b0a28c60bfbe1d276e332788c428767"

URI_x86_64_v2_rust-openssl+v102-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v102-devel-0.10.81-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v102-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v102-devel}"
SRC_URI[x86_64_v2_rust-openssl+v102-devel.sha256sum] = "1eb47db1e60637e9b0248f1ce0047f3a030717a4c7471e30d8494ee5809fd1e8"

URI_x86_64_v2_rust-openssl+v110-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v110-devel-0.10.81-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v110-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v110-devel}"
SRC_URI[x86_64_v2_rust-openssl+v110-devel.sha256sum] = "73c0cfc695c4bd76c2236934f8cf70c3485942b0e468067509aebe84ad797b65"

URI_x86_64_v2_rust-openssl+v111-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v111-devel-0.10.81-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v111-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v111-devel}"
SRC_URI[x86_64_v2_rust-openssl+v111-devel.sha256sum] = "9241287518b23cf475442686d9596ef81b6a36f2e0bedaea4a141f883746123c"

URI_x86_64_v2_rust-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-devel-0.10.81-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-devel}"
SRC_URI[x86_64_v2_rust-openssl-devel.sha256sum] = "1c8ae50524116460ac9c8fe5e07e8d4cf8c01a1af08c25f2a2f0598b200791a7"

URI_aarch64_rust-openssl+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+bindgen-devel-0.10.81-1.el10_3.noarch.rpm;name=aarch64_rust-openssl+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+bindgen-devel}"
SRC_URI[aarch64_rust-openssl+bindgen-devel.sha256sum] = "71baeaaa89445a0bf430dc8cda324681d9061adc5ac078398a0151c1757a3fbb"

URI_aarch64_rust-openssl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+default-devel-0.10.81-1.el10_3.noarch.rpm;name=aarch64_rust-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+default-devel}"
SRC_URI[aarch64_rust-openssl+default-devel.sha256sum] = "e44d676caea1cdc154bf3e9301e39b1748536a173a4f0c63c8a6d353e370c38e"

URI_aarch64_rust-openssl+v101-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v101-devel-0.10.81-1.el10_3.noarch.rpm;name=aarch64_rust-openssl+v101-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v101-devel}"
SRC_URI[aarch64_rust-openssl+v101-devel.sha256sum] = "aeba84aa1d61c2eb89c1ee4e8f684642d1853bb9b4c97523aef91b05cab3d41c"

URI_aarch64_rust-openssl+v102-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v102-devel-0.10.81-1.el10_3.noarch.rpm;name=aarch64_rust-openssl+v102-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v102-devel}"
SRC_URI[aarch64_rust-openssl+v102-devel.sha256sum] = "0e3202e9495793011d7da1456d16153412e23e039ffb141793d8eb0d458feec6"

URI_aarch64_rust-openssl+v110-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v110-devel-0.10.81-1.el10_3.noarch.rpm;name=aarch64_rust-openssl+v110-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v110-devel}"
SRC_URI[aarch64_rust-openssl+v110-devel.sha256sum] = "531b6ef611fa4734b279d62219b21db094f57cf332d8070a385bcc8aebfddcb4"

URI_aarch64_rust-openssl+v111-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v111-devel-0.10.81-1.el10_3.noarch.rpm;name=aarch64_rust-openssl+v111-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v111-devel}"
SRC_URI[aarch64_rust-openssl+v111-devel.sha256sum] = "c6475dc4f7e430a26308e5f1134dd60f1f6e8a8243a62593486a6c1d90ad6834"

URI_aarch64_rust-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-devel-0.10.81-1.el10_3.noarch.rpm;name=aarch64_rust-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-devel}"
SRC_URI[aarch64_rust-openssl-devel.sha256sum] = "54e5574792ff0c9b17142bf3cc3e89eec8606a668dd25e4b361a6dee5874bdb6"

RDEPENDS:rust-openssl+bindgen-devel = " \
 cargo \
 rust-openssl-devel \
 rust-openssl-sys+bindgen-devel \
 "
RDEPENDS:rust-openssl+default-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v101-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v102-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v110-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v111-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-foreign-types0.3+default-devel \
 rust-libc+default-devel \
 rust-openssl-macros+default-devel \
 rust-openssl-sys+default-devel \
 "
