# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustfix"
PV = "0.9.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustfix+default-devel \
 rust-rustfix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustfix-0.9.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d286a22fbfa0403b9ee097d9732afbe41bd91f85a490d7679646379e471a0fe8"

URI_x86_64_v2_rust-rustfix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix+default-devel-0.9.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfix+default-devel}"
SRC_URI[x86_64_v2_rust-rustfix+default-devel.sha256sum] = "ea3bc58a422211f23a3993c52ed04309c1c4e04c6752093eb19815f7236fc5e7"

URI_x86_64_v2_rust-rustfix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix-devel-0.9.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustfix-devel}"
SRC_URI[x86_64_v2_rust-rustfix-devel.sha256sum] = "84572d163679ba8191b859e1719aefa1dabd294d9b25b4208ea2fb311b6c1be2"

URI_aarch64_rust-rustfix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix+default-devel-0.9.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustfix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfix+default-devel}"
SRC_URI[aarch64_rust-rustfix+default-devel.sha256sum] = "5957fb3653f26212a63951e33dc7ce854e30b2a3066a4a80a5b08dbb3be19337"

URI_aarch64_rust-rustfix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix-devel-0.9.4-1.el10_2.noarch.rpm;name=aarch64_rust-rustfix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustfix-devel}"
SRC_URI[aarch64_rust-rustfix-devel.sha256sum] = "42f30396c99f8d95208df439bee8a6ce4a79e52ccc61fe3fea9f53019b2933bd"

RDEPENDS:rust-rustfix+default-devel = " \
 cargo \
 rust-rustfix-devel \
 "
RDEPENDS:rust-rustfix-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
