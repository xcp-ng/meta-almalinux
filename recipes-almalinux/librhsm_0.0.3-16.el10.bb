# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librhsm"
PV = "0.0.3"
PR = "16.el10"
PACKAGES = " \
 librhsm \
 librhsm-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/librhsm-0.0.3-16.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1487faec3a006f4425b0b8e16d6984ed2b64c97ac2d7569dffd1613ebb387f0f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librhsm-0.0.3-16.el10.x86_64_v2.rpm;name=x86_64_v2_librhsm;unpack=0"
SRC_URI[x86_64_v2_librhsm.sha256sum] = "53fe0ede43d7e84fe427e0fcac36aa50f6b4a9030e26e1b9798a1e193f99df61"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librhsm-devel-0.0.3-16.el10.x86_64_v2.rpm;name=x86_64_v2_librhsm-devel;unpack=0"
SRC_URI[x86_64_v2_librhsm-devel.sha256sum] = "90d840a28222fda3802f6f9b12da70b8bcd1d5b32939560e98eced2fd9cd782f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librhsm-0.0.3-16.el10.aarch64.rpm;name=aarch64_librhsm;unpack=0"
SRC_URI[aarch64_librhsm.sha256sum] = "43ccdcc55677781803e182792b6588e6ce9d43ecdf3f8fde1ee9f071a0f20ab1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librhsm-devel-0.0.3-16.el10.aarch64.rpm;name=aarch64_librhsm-devel;unpack=0"
SRC_URI[aarch64_librhsm-devel.sha256sum] = "2605055672ec82a5f40d6c07196c3c9cbbe99bef9089dafa29813badf35e2b4f"

RDEPENDS:librhsm = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 openssl-libs \
 "
RDEPENDS:librhsm-devel = " \
 glib2-devel \
 json-glib-devel \
 librhsm \
 openssl-devel \
 pkgconf-pkg-config \
 "
