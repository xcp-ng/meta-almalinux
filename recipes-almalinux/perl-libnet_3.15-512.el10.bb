# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-libnet"
PV = "3.15"
PR = "512.el10"
PACKAGES = " \
 perl-libnet \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-libnet-3.15-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aa48d583b12668e662dc64557d0566a493523fc41efa0115aa062ae2ffe8358"

URI_x86_64_v2_perl-libnet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-libnet-3.15-512.el10.noarch.rpm;name=x86_64_v2_perl-libnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-libnet}"
SRC_URI[x86_64_v2_perl-libnet.sha256sum] = "1c7a64f05cf253c039ec909729408925c259d751fa764b47af823a4b5fac0ca1"

URI_aarch64_perl-libnet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-libnet-3.15-512.el10.noarch.rpm;name=aarch64_perl-libnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-libnet}"
SRC_URI[aarch64_perl-libnet.sha256sum] = "1c7a64f05cf253c039ec909729408925c259d751fa764b47af823a4b5fac0ca1"

RDEPENDS:perl-libnet = " \
 perl-Carp \
 perl-Digest-MD5 \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-FileHandle \
 perl-IO \
 perl-IO-Socket-IP \
 perl-POSIX \
 perl-Socket \
 perl-Symbol \
 perl-Time-Local \
 perl-constant \
 perl-libnet \
 perl-libs \
 "
