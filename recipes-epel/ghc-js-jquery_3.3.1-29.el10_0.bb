# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-js-jquery"
PV = "3.3.1"
PR = "29.el10_0"
PACKAGES = " \
 ghc-js-jquery \
 ghc-js-jquery-devel \
 ghc-js-jquery-doc \
 ghc-js-jquery-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-js-jquery-3.3.1-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "806af846a660f8636575c8645f713dc837babbfaf89f84817006885a7a74ebf2"

URI_x86_64_v2_ghc-js-jquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-jquery-3.3.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-jquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-jquery}"
SRC_URI[x86_64_v2_ghc-js-jquery.sha256sum] = "f59e0a101af14f547b185f86cb180c3ad44381c65c219ec2d77981aff7644e39"

URI_x86_64_v2_ghc-js-jquery-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-jquery-devel-3.3.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-jquery-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-jquery-devel}"
SRC_URI[x86_64_v2_ghc-js-jquery-devel.sha256sum] = "8a27b7d97af275bfb00c81865d3fa6f652fced270f04a811598a6467337de2e0"

URI_x86_64_v2_ghc-js-jquery-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-jquery-doc-3.3.1-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-js-jquery-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-jquery-doc}"
SRC_URI[x86_64_v2_ghc-js-jquery-doc.sha256sum] = "63e650ef0fd3f523d947fca929db1e7994ab383d50e91ce1b08db85c88355886"

URI_x86_64_v2_ghc-js-jquery-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-js-jquery-prof-3.3.1-29.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-js-jquery-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-js-jquery-prof}"
SRC_URI[x86_64_v2_ghc-js-jquery-prof.sha256sum] = "b5f1ecc5c9d0837be82787dcc6b2284381261536dcfc9c5b607dcc3b92ac8435"

URI_aarch64_ghc-js-jquery = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-jquery-3.3.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-js-jquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-jquery}"
SRC_URI[aarch64_ghc-js-jquery.sha256sum] = "eb95c10b55748b0d77960fa6a6a5d4abe1165839d0144b0e2a084ffef9f25dbd"

URI_aarch64_ghc-js-jquery-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-jquery-devel-3.3.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-js-jquery-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-jquery-devel}"
SRC_URI[aarch64_ghc-js-jquery-devel.sha256sum] = "37845ce5ab5ae29ac4e1e13e00c9a3166768c8b715fa3e249ac249318c4ffde9"

URI_aarch64_ghc-js-jquery-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-jquery-doc-3.3.1-29.el10_0.noarch.rpm;name=aarch64_ghc-js-jquery-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-jquery-doc}"
SRC_URI[aarch64_ghc-js-jquery-doc.sha256sum] = "a2540766255e7c0b9c9f31b61c467dc394f2d7af108c12861f033bccbd973ad0"

URI_aarch64_ghc-js-jquery-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-js-jquery-prof-3.3.1-29.el10_0.aarch64.rpm;name=aarch64_ghc-js-jquery-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-js-jquery-prof}"
SRC_URI[aarch64_ghc-js-jquery-prof.sha256sum] = "a67eaf0840e2aff2ca1dee54c989011a416d0091b3734ee70f31d36092ff7582"

RDEPENDS:ghc-js-jquery = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-js-jquery-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-js-jquery \
 "
RDEPENDS:ghc-js-jquery-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-js-jquery-prof = " \
 ghc-base-prof \
 ghc-js-jquery-devel \
 "
