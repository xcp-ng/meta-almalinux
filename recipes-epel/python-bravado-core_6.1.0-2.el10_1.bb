# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bravado-core"
PV = "6.1.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-bravado-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-bravado-core-6.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5bc98898ae9b335dc0acca33b548fe74053f52b6073b77a6fb7c7058ada3029"

URI_x86_64_v2_python3-bravado-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bravado-core-6.1.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bravado-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bravado-core}"
SRC_URI[x86_64_v2_python3-bravado-core.sha256sum] = "a445e925af36ad65af2cec04192fc0e5cba2aff033d1f33a15dfdf7c4dd61be8"

URI_aarch64_python3-bravado-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bravado-core-6.1.0-2.el10_1.noarch.rpm;name=aarch64_python3-bravado-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bravado-core}"
SRC_URI[aarch64_python3-bravado-core.sha256sum] = "c2a760cb8c1a73326396039dc87b4afe3662aaebfd3f5ed74d2ba7c7158997f2"

RDEPENDS:python3-bravado-core = " \
 python3 \
 python3-dateutil \
 python3-jsonref \
 python3-jsonschema \
 python3-jsonschema+format \
 python3-msgpack \
 python3-pytz \
 python3-pyyaml \
 python3-requests \
 python3-simplejson \
 python3-six \
 python3-swagger-spec-validator \
 "
