# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "davfs2"
PV = "1.7.0"
PR = "7.el10_0"
PACKAGES = " \
 davfs2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/davfs2-1.7.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea5a3ca8f3cd86c07facd83b48085ab403c0dc7b1cdcea8edeebd74e2d5dd6af"

URI_x86_64_v2_davfs2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/davfs2-1.7.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_davfs2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_davfs2}"
SRC_URI[x86_64_v2_davfs2.sha256sum] = "a2a15cd4ca185b0b8f52232baf2281afc8246f769595157f818cbcc88b51b66e"

URI_aarch64_davfs2 = "${EPEL_MIRROR}/aarch64/Packages/d/davfs2-1.7.0-7.el10_0.aarch64.rpm;name=aarch64_davfs2;unpack=0"
SRC_URI:append = " ${URI_aarch64_davfs2}"
SRC_URI[aarch64_davfs2.sha256sum] = "b74b1686d1dfdeb58b0870e99536997df755ce72ce59da69fa8ab58db9dce325"

RDEPENDS:davfs2 = " \
 bash \
 glibc \
 neon \
 shadow-utils \
 "
