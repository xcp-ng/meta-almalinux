# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lapp"
PV = "0.3.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-lapp+default-devel \
 rust-lapp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lapp-0.3.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03010acc41fa30078f06cb5865a5293225cf715e3cb8abc63339c0de5c5bac4e"

URI_x86_64_v2_rust-lapp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lapp+default-devel-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lapp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lapp+default-devel}"
SRC_URI[x86_64_v2_rust-lapp+default-devel.sha256sum] = "6f0bb0af92a5be2cb13d10c9410d91bc7c1b4491b42aaaddcf37c170b330a613"

URI_x86_64_v2_rust-lapp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lapp-devel-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lapp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lapp-devel}"
SRC_URI[x86_64_v2_rust-lapp-devel.sha256sum] = "918b5d0ad465cc551ce22697e3280e075d4a82859d3a4eb71a98cb6c10619583"

URI_aarch64_rust-lapp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lapp+default-devel-0.3.1-1.el10_3.noarch.rpm;name=aarch64_rust-lapp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lapp+default-devel}"
SRC_URI[aarch64_rust-lapp+default-devel.sha256sum] = "2da108005570dfff3e856c1838c5296e4e84eb2c709e39b9ea6a5a528f726b17"

URI_aarch64_rust-lapp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lapp-devel-0.3.1-1.el10_3.noarch.rpm;name=aarch64_rust-lapp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lapp-devel}"
SRC_URI[aarch64_rust-lapp-devel.sha256sum] = "90dacad2bbe9b5cbab3462480b75b22781aad866c4a7d6ed7d8ac5ca253f267a"

RDEPENDS:rust-lapp+default-devel = " \
 cargo \
 rust-lapp-devel \
 "
RDEPENDS:rust-lapp-devel = " \
 cargo \
 "
