# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-primes"
PV = "0.4.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-primes+default-devel \
 rust-primes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-primes-0.4.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc880e4f43874c7ae326a396e9eda2c35c10ec1d6b572c0d207a883e9b1ff418"

URI_x86_64_v2_rust-primes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primes+default-devel-0.4.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primes+default-devel}"
SRC_URI[x86_64_v2_rust-primes+default-devel.sha256sum] = "60be2d1d0407f6385c0decf92f8555c5b730e5b9d1ce07d2ed4d3bba54d978b6"

URI_x86_64_v2_rust-primes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primes-devel-0.4.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primes-devel}"
SRC_URI[x86_64_v2_rust-primes-devel.sha256sum] = "bb1c99c71a6197086e374dcddbeed6614c18a02b261b060f84d7b72999638d76"

URI_aarch64_rust-primes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primes+default-devel-0.4.0-2.el10_3.noarch.rpm;name=aarch64_rust-primes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primes+default-devel}"
SRC_URI[aarch64_rust-primes+default-devel.sha256sum] = "3398e0c97b754c56d2499ccb0241d5ca6d2f4833307f1cab964cab78ff6e4a03"

URI_aarch64_rust-primes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primes-devel-0.4.0-2.el10_3.noarch.rpm;name=aarch64_rust-primes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primes-devel}"
SRC_URI[aarch64_rust-primes-devel.sha256sum] = "f7d4363b91fab449f06220fc118d3e777ef8706353ae62f62f53a81d128ec2f8"

RDEPENDS:rust-primes+default-devel = " \
 cargo \
 rust-primes-devel \
 "
RDEPENDS:rust-primes-devel = " \
 cargo \
 "
