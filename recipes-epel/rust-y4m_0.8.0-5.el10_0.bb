# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-y4m"
PV = "0.8.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-y4m+default-devel \
 rust-y4m-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-y4m-0.8.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43e984d94a17f66ef289610b1d5bbaf8d0ddb09043bd1550938c6c1af1fcf09e"

URI_x86_64_v2_rust-y4m+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-y4m+default-devel-0.8.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-y4m+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-y4m+default-devel}"
SRC_URI[x86_64_v2_rust-y4m+default-devel.sha256sum] = "a932bf887a44a7910ae840cac54a59e76cd33fada3b01a5e18541d5a356e3689"

URI_x86_64_v2_rust-y4m-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-y4m-devel-0.8.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-y4m-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-y4m-devel}"
SRC_URI[x86_64_v2_rust-y4m-devel.sha256sum] = "328b1e1a7b0640e5252bd3d6c82c41a189b72ae4ef3ee3593baa026e1d6900d1"

URI_aarch64_rust-y4m+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-y4m+default-devel-0.8.0-5.el10_0.noarch.rpm;name=aarch64_rust-y4m+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-y4m+default-devel}"
SRC_URI[aarch64_rust-y4m+default-devel.sha256sum] = "c9911f8faddf3b629f0a22467c3cab751867615a74bdb871e64d7d5454ae37ac"

URI_aarch64_rust-y4m-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-y4m-devel-0.8.0-5.el10_0.noarch.rpm;name=aarch64_rust-y4m-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-y4m-devel}"
SRC_URI[aarch64_rust-y4m-devel.sha256sum] = "dcde089ced2acda12ee102d31eb8ee87439ceb4eef8a813944ca46e62e958440"

RDEPENDS:rust-y4m+default-devel = " \
 cargo \
 rust-y4m-devel \
 "
RDEPENDS:rust-y4m-devel = " \
 cargo \
 "
