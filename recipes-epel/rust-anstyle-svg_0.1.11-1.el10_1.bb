# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-svg"
PV = "0.1.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-anstyle-svg+default-devel \
 rust-anstyle-svg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-svg-0.1.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c04a64f5782bcab4f36e00fed362eec7409fb044d92ac344f8f9c95862cc4f95"

URI_x86_64_v2_rust-anstyle-svg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg+default-devel-0.1.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg+default-devel.sha256sum] = "9f2b7321bd53c2bd4daac780c828b075c3e1887ac8e733690e3da59d6e9686b4"

URI_x86_64_v2_rust-anstyle-svg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg-devel-0.1.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg-devel.sha256sum] = "fcb17f4759327aa1f4dd33a09146804e93385d95478c4c8e60c952b98be69b5c"

URI_aarch64_rust-anstyle-svg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg+default-devel-0.1.11-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-svg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg+default-devel}"
SRC_URI[aarch64_rust-anstyle-svg+default-devel.sha256sum] = "dd4cac4e4a6da95bd36f28779fdfb8d4cb4b7e2202d458517e50a67ac9eafae4"

URI_aarch64_rust-anstyle-svg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg-devel-0.1.11-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-svg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg-devel}"
SRC_URI[aarch64_rust-anstyle-svg-devel.sha256sum] = "eb8d55cc2b5669110e785e8e5e0c9d45d9a6e237dfd81f0b2bc4309ccc56e1fe"

RDEPENDS:rust-anstyle-svg+default-devel = " \
 cargo \
 rust-anstyle-svg-devel \
 "
RDEPENDS:rust-anstyle-svg-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-lossy+default-devel \
 rust-anstyle-parse+default-devel \
 rust-html-escape+default-devel \
 rust-unicode-width+default-devel \
 "
