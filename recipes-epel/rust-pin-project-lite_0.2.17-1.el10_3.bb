# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project-lite"
PV = "0.2.17"
PR = "1.el10_3"
PACKAGES = " \
 rust-pin-project-lite+default-devel \
 rust-pin-project-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-lite-0.2.17-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecb1c14ef35ea3b89c96aa19ef12e6781742fe1675d64a85c9559b315e02af4f"

URI_x86_64_v2_rust-pin-project-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-lite+default-devel-0.2.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-lite+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project-lite+default-devel.sha256sum] = "254cfc9c12b3cdee3dbdf34ede2af3ffab8d669bcdef4e7d1c23cf76f019ef9a"

URI_x86_64_v2_rust-pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-lite-devel-0.2.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-pin-project-lite-devel.sha256sum] = "4440ff7934c71bc1153b98f8084ea1c86851618400104094e84cfd45a86ed6be"

URI_aarch64_rust-pin-project-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-lite+default-devel-0.2.17-1.el10_3.noarch.rpm;name=aarch64_rust-pin-project-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-lite+default-devel}"
SRC_URI[aarch64_rust-pin-project-lite+default-devel.sha256sum] = "2ebefb1c98867e751eb6643f165e255b6a91283f1489a8d137ea3b4d707c6759"

URI_aarch64_rust-pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-lite-devel-0.2.17-1.el10_3.noarch.rpm;name=aarch64_rust-pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-lite-devel}"
SRC_URI[aarch64_rust-pin-project-lite-devel.sha256sum] = "44870e5f5ba732f0455f32ae39826cd7b0c8787ef3934c3b8012067439dc8a6f"

RDEPENDS:rust-pin-project-lite+default-devel = " \
 cargo \
 rust-pin-project-lite-devel \
 "
RDEPENDS:rust-pin-project-lite-devel = " \
 cargo \
 rust \
 "
