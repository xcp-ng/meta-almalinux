# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-notify2"
PV = "0.3.1"
PR = "25.el10_2"
PACKAGES = " \
 python-notify2-doc \
 python3-notify2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-notify2-0.3.1-25.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9e0050312aa0beb8240c8ab45544e057e3452be3a62014c1f7e75491f1cd3fc"

URI_x86_64_v2_python-notify2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-notify2-doc-0.3.1-25.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-notify2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-notify2-doc}"
SRC_URI[x86_64_v2_python-notify2-doc.sha256sum] = "acb66a2105109709051523208a27ac217758f389d2426e3796f137f120bb3c91"

URI_x86_64_v2_python3-notify2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-notify2-0.3.1-25.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-notify2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-notify2}"
SRC_URI[x86_64_v2_python3-notify2.sha256sum] = "f5709a98c299ad7ec04ff1f08659a8633ffb8e86641db5151a24ee1bd804ccd3"

URI_aarch64_python-notify2-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-notify2-doc-0.3.1-25.el10_2.noarch.rpm;name=aarch64_python-notify2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-notify2-doc}"
SRC_URI[aarch64_python-notify2-doc.sha256sum] = "5561a0804aa6180717cfaeefb9a3a39bd3c0adb52a421049ece350f811f591b5"

URI_aarch64_python3-notify2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-notify2-0.3.1-25.el10_2.noarch.rpm;name=aarch64_python3-notify2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-notify2}"
SRC_URI[aarch64_python3-notify2.sha256sum] = "742710983b7e69670f1412ecc6b2b7f0b81d39fed0f4d99667e95a6eb33a8e5a"

RDEPENDS:python-notify2-doc = " \
 "
RDEPENDS:python3-notify2 = " \
 python3 \
 python3-dbus \
 "
