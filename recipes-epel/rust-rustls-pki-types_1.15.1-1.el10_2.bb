# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-pki-types"
PV = "1.15.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-pki-types+web-devel \
 rust-rustls-pki-types-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-pki-types-1.15.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "50f73271fc010c751bd7d16f4229690156bdea645a2da7a03c605141ad40bc2d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+alloc-devel-1.15.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-pki-types+alloc-devel.sha256sum] = "f049d5c960ff1472c103d2e74811460eb13c0bf42df45140fab742c76f81b9dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+default-devel-1.15.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-pki-types+default-devel.sha256sum] = "be60eac96216c220b85a08a2d5589936fd551ed4cf36d37d22fbefaafb278632"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+std-devel-1.15.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-pki-types+std-devel.sha256sum] = "15ca48a307b43ab7322c8a06b2aae5075d416afeadd12b17e3bcae477787e2e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+web-devel-1.15.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-pki-types+web-devel.sha256sum] = "65257abdc893069549c2aeb9c385b5752815075dd6a0e7756107c9a86951aea6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types-devel-1.15.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-pki-types-devel.sha256sum] = "9af71989065cb61f129164b3a2304206447a3b06aed6124cf778921ec1477229"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+alloc-devel-1.15.1-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-pki-types+alloc-devel.sha256sum] = "ab9d06e908033b2f8e261f4aedb2e08e26437f5606f28cfc6960a3f529a7e5d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+default-devel-1.15.1-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-pki-types+default-devel.sha256sum] = "050f7a2b1400a63fff45ab4a20f519b00c4f18b93bc46c690dfdbff6940eb8f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+std-devel-1.15.1-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-pki-types+std-devel.sha256sum] = "d5dd984d97d9d45d0fb3debde0b22d264e2c78eff6400dc8116c2e450c3c9e96"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+web-devel-1.15.1-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-pki-types+web-devel.sha256sum] = "4d8f9e47b369a8ebad8608b9cf3370d41847ab3c865c052a1678fbd6aaa1e482"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types-devel-1.15.1-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-pki-types-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-pki-types-devel.sha256sum] = "49d49dfaad10ba39b6ae6032505e0fe843618a5f5caec776469e74bb815f299a"

RDEPENDS:rust-rustls-pki-types+alloc-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-rustls-pki-types+default-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+std-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+web-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types-devel = " \
 cargo \
 rust \
 "
