# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ftputil"
PV = "5.2.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-ftputil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ftputil-5.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd79fc09752975b1b1f16d7c4b6a1605c8f57137a60c3abad21177c8616b4d73"

URI_x86_64_v2_python3-ftputil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ftputil-5.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ftputil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ftputil}"
SRC_URI[x86_64_v2_python3-ftputil.sha256sum] = "dfff8a6d22e6cbb2d137b32f88e3e5fef651e95c85a41042c1d8e2a6a32e592c"

URI_aarch64_python3-ftputil = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ftputil-5.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-ftputil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ftputil}"
SRC_URI[aarch64_python3-ftputil.sha256sum] = "04d99e45a1873d8a7d35083778694f32baeff0faa7cebba6ea801eaf2473da6b"

RDEPENDS:python3-ftputil = " \
 ftp \
 python3 \
 "
