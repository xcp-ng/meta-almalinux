# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tikv-jemalloc-sys"
PV = "0.7.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemalloc-sys+default-devel \
 rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys+profiling-devel \
 rust-tikv-jemalloc-sys+stats-devel \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tikv-jemalloc-sys-0.7.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f108ed09ab1ef8e1d50cad7bf9e91b7cfec18eace0322ef16bdc04fd0467d93"

URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+background_threads_runtime_support-devel-0.7.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel.sha256sum] = "ba7d1e5e817e451ce64503d85d895148c54e945757a2d93110460aeea17fc3fe"

URI_x86_64_v2_rust-tikv-jemalloc-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+default-devel-0.7.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+default-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+default-devel.sha256sum] = "40a1df5fadccaac0a76378556ca59fed2faff0f4f8e9eb4155c9eb49ac667250"

URI_x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel-0.7.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel.sha256sum] = "b44c087ecada18414e955bf5be1e0dd2eb2786a79c0d8d0c9cc17a7798304e75"

URI_x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+profiling-devel-0.7.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+profiling-devel.sha256sum] = "d7c03888e5e9f9e17d72704a3c97f35c043a26c818f6e65fc72a85a38b161e6b"

URI_x86_64_v2_rust-tikv-jemalloc-sys+stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+stats-devel-0.7.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+stats-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+stats-devel.sha256sum] = "c03356d3bb1214bd933ce4efa49396671c96926b56c8b5a865a97366cf8563d9"

URI_x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel-0.7.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "04d46354051316059e1c89f4b7b11c8130cc2a72e9ebcd5ae0acae63ff04c937"

URI_x86_64_v2_rust-tikv-jemalloc-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemalloc-sys-devel-0.7.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemalloc-sys-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemalloc-sys-devel.sha256sum] = "dd603b7ad1f3611ff5abd0216bb3f21f2db8ca3aa56a3e68665965c2ddd2df30"

URI_aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+background_threads_runtime_support-devel-0.7.1-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+background_threads_runtime_support-devel.sha256sum] = "c22f0d24be775183fc4384f32f777fd359cad5ac5be7de9a5fd50f2f483d27ab"

URI_aarch64_rust-tikv-jemalloc-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+default-devel-0.7.1-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+default-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+default-devel.sha256sum] = "42d2dd19bd863a08c862e7158660fae864bd5a5b8544442271e9ca4d1a259a94"

URI_aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel-0.7.1-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel.sha256sum] = "458fb58ee815ae6ed54cc5ea3ebcb7a95ce4496cbb3a5eb18f52e01ec9cdd11b"

URI_aarch64_rust-tikv-jemalloc-sys+profiling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+profiling-devel-0.7.1-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+profiling-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+profiling-devel.sha256sum] = "c814c98a6a79bb397669c6ee456c5c994a0da7c49490ed28726b43abd3ba6f07"

URI_aarch64_rust-tikv-jemalloc-sys+stats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+stats-devel-0.7.1-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+stats-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+stats-devel.sha256sum] = "fbb7f5e197a8be80acb00afaebb0a5f1d6531c426479c80dc5a63fab9bba9dc9"

URI_aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel-0.7.1-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "103132fdace1c13b322b234cab0e1ca74f7baf657f95a38bf7e6ec096145704c"

URI_aarch64_rust-tikv-jemalloc-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemalloc-sys-devel-0.7.1-1.el10_3.noarch.rpm;name=aarch64_rust-tikv-jemalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemalloc-sys-devel}"
SRC_URI[aarch64_rust-tikv-jemalloc-sys-devel.sha256sum] = "99fbaf1db83aaa932d48ed2d42b7ff0705bda83554d598dedfd996789f364157"

RDEPENDS:rust-tikv-jemalloc-sys+background_threads_runtime_support-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+default-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+profiling-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+stats-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys-devel \
 "
RDEPENDS:rust-tikv-jemalloc-sys-devel = " \
 cargo \
 jemalloc-devel \
 rust \
 rust-cc+default-devel \
 rust-libc-devel \
 "
