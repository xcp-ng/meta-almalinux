# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wireless-regdb"
PV = "2024.01.23"
PR = "3.el10"
PACKAGES = " \
 wireless-regdb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/wireless-regdb-2024.01.23-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9c27aa0971ca30940d054d4fa9f70da5348ee7c1b601f84efea50a05939ef50"

URI_x86_64_v2_wireless-regdb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/wireless-regdb-2024.01.23-3.el10.noarch.rpm;name=x86_64_v2_wireless-regdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireless-regdb}"
SRC_URI[x86_64_v2_wireless-regdb.sha256sum] = "f80e67246587560bcc793c036992d49d964dd4c461acd0cb129e97ab1ad69099"

URI_aarch64_wireless-regdb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/wireless-regdb-2024.01.23-3.el10.noarch.rpm;name=aarch64_wireless-regdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireless-regdb}"
SRC_URI[aarch64_wireless-regdb.sha256sum] = "f80e67246587560bcc793c036992d49d964dd4c461acd0cb129e97ab1ad69099"

RDEPENDS:wireless-regdb = " \
 bash \
 iw \
 systemd \
 systemd-udev \
 "
