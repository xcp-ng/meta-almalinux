# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerocopy-derive"
PV = "0.8.56"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerocopy-derive+default-devel \
 rust-zerocopy-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerocopy-derive-0.8.56-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aded9e2b283ba0b487a0c30f12425a4e94300c3175ef40fddd5807891232cacf"

URI_x86_64_v2_rust-zerocopy-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive+default-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive+default-devel.sha256sum] = "b4612dbb693b42ee7d8a84b6816ea6c8ed5863af4bb64da12305b9c6bcb6f16e"

URI_x86_64_v2_rust-zerocopy-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerocopy-derive-devel-0.8.56-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerocopy-derive-devel}"
SRC_URI[x86_64_v2_rust-zerocopy-derive-devel.sha256sum] = "29ed8f8c74576ffb287e1bc3c272e8d2dffd58ca0972a22437e88aac1ba225a5"

URI_aarch64_rust-zerocopy-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive+default-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive+default-devel}"
SRC_URI[aarch64_rust-zerocopy-derive+default-devel.sha256sum] = "efd832e4afb1a274756647478d3d118a817241900dda54d485d9410bf543ab11"

URI_aarch64_rust-zerocopy-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerocopy-derive-devel-0.8.56-1.el10_3.noarch.rpm;name=aarch64_rust-zerocopy-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerocopy-derive-devel}"
SRC_URI[aarch64_rust-zerocopy-derive-devel.sha256sum] = "b5c179a01683a50945b79fa5728cbd8276033909192f371bb85970438ae6fcd3"

RDEPENDS:rust-zerocopy-derive+default-devel = " \
 cargo \
 rust-zerocopy-derive-devel \
 "
RDEPENDS:rust-zerocopy-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
