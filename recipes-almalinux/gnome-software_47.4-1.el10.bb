# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-software"
PV = "47.4"
PR = "1.el10"
PACKAGES = " \
 gnome-software \
 gnome-software-devel \
 gnome-software-fedora-langpacks \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-software-47.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fd9c7af3002c5dff7909767397a3a6dccb7715ccc213cc4d0cf44e25142346f"

URI_x86_64_v2_gnome-software = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-software-47.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-software;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-software}"
SRC_URI[x86_64_v2_gnome-software.sha256sum] = "351f5d2e1c4e3bc0187968c30e1fa8c3bd0ba1efe478852d38ec187afea470d0"

URI_x86_64_v2_gnome-software-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-software-devel-47.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-software-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-software-devel}"
SRC_URI[x86_64_v2_gnome-software-devel.sha256sum] = "27eabccf32760d75810f61236957f620df553c567442a45520283b23120b4390"

URI_x86_64_v2_gnome-software-fedora-langpacks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-software-fedora-langpacks-47.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-software-fedora-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-software-fedora-langpacks}"
SRC_URI[x86_64_v2_gnome-software-fedora-langpacks.sha256sum] = "66be37a8df3c39494e0fc3d86f4bef7ff8f4d7675bcaa0349d3ab260897c4c11"

URI_aarch64_gnome-software = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-software-47.4-1.el10.aarch64.rpm;name=aarch64_gnome-software;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-software}"
SRC_URI[aarch64_gnome-software.sha256sum] = "eebac7fa420c9e98e08b1cd25043271e57c10edaca60b0c356c01c65a59e0033"

URI_aarch64_gnome-software-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-software-devel-47.4-1.el10.aarch64.rpm;name=aarch64_gnome-software-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-software-devel}"
SRC_URI[aarch64_gnome-software-devel.sha256sum] = "ff1dfa43080757b224f29e06262ae2e6cf2925d1b9372229958ecbb1345751b1"

URI_aarch64_gnome-software-fedora-langpacks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-software-fedora-langpacks-47.4-1.el10.aarch64.rpm;name=aarch64_gnome-software-fedora-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-software-fedora-langpacks}"
SRC_URI[aarch64_gnome-software-fedora-langpacks.sha256sum] = "8d230d6eb70c1b5163b6ff541f64b831ef89a340fa56e6098866b2769fee3a30"

RDEPENDS:gnome-software = " \
 PackageKit-glib \
 appstream \
 appstream-data \
 flatpak \
 flatpak-libs \
 fwupd \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-menus \
 gsettings-desktop-schemas \
 gtk4 \
 iso-codes \
 json-glib \
 libadwaita \
 libgcc \
 libgudev \
 librsvg2 \
 libsoup3 \
 libxmlb \
 ostree-libs \
 pango \
 polkit-libs \
 "
RDEPENDS:gnome-software-devel = " \
 appstream-devel \
 glib2-devel \
 gnome-software \
 gtk4-devel \
 json-glib-devel \
 libsoup3-devel \
 libxmlb-devel \
 pkgconf-pkg-config \
 polkit-devel \
 sysprof-capture-devel \
 "
RDEPENDS:gnome-software-fedora-langpacks = " \
 glib2 \
 glibc \
 gnome-software \
 libgcc \
 "
