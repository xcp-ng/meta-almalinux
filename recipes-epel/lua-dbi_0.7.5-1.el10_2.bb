# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-dbi"
PV = "0.7.5"
PR = "1.el10_2"
PACKAGES = " \
 lua-dbi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-dbi-0.7.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7ade188664142da2cc016a9929da63afa111542f423e90a96aba3c73b4d6bf6"

URI_x86_64_v2_lua-dbi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-dbi-0.7.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-dbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-dbi}"
SRC_URI[x86_64_v2_lua-dbi.sha256sum] = "6a4bba4124628ec672e8d331822a6f9dc9c8034a970695f58e68bfd62c570c7f"

URI_aarch64_lua-dbi = "${EPEL_MIRROR}/aarch64/Packages/l/lua-dbi-0.7.5-1.el10_2.aarch64.rpm;name=aarch64_lua-dbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-dbi}"
SRC_URI[aarch64_lua-dbi.sha256sum] = "c34127680cbe8456a82371109b0b372636a896c32069919744c7adc653080e54"

RDEPENDS:lua-dbi = " \
 glibc \
 libpq \
 lua-libs \
 mariadb-connector-c \
 sqlite-libs \
 "
