# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-terminal_size"
PV = "0.4.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-terminal_size+default-devel \
 rust-terminal_size-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-terminal_size-0.4.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d4f38434656a970b6c7157a5106232827065519e30aa372069b0985c3c30bcb"

URI_x86_64_v2_rust-terminal_size+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size+default-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size+default-devel}"
SRC_URI[x86_64_v2_rust-terminal_size+default-devel.sha256sum] = "6d1446cc9dee26307650ec1c1738d78f7a834876d40d4bd8f5b63eb409a04188"

URI_x86_64_v2_rust-terminal_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size-devel}"
SRC_URI[x86_64_v2_rust-terminal_size-devel.sha256sum] = "d0ac760d479ed333ff2903442513d415939e33c8e951522873560c2bd4fe78a0"

URI_aarch64_rust-terminal_size+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size+default-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-terminal_size+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size+default-devel}"
SRC_URI[aarch64_rust-terminal_size+default-devel.sha256sum] = "b3d91895e526c49ef11670d442102b417f9ac33f91db633ebbc216057e6893c7"

URI_aarch64_rust-terminal_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size-devel}"
SRC_URI[aarch64_rust-terminal_size-devel.sha256sum] = "e4020184e18d09da013b39131df2498c521f1ee8ce49ff48fe59f06af43ca28b"

RDEPENDS:rust-terminal_size+default-devel = " \
 cargo \
 rust-terminal_size-devel \
 "
RDEPENDS:rust-terminal_size-devel = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+termios-devel \
 "
