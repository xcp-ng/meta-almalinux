# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemmodels"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kitemmodels \
 kf6-kitemmodels-devel \
 kf6-kitemmodels-doc \
 kf6-kitemmodels-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemmodels-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "393059f568a486a56aab6fab7dbf8b9566f8ee7be5fa4ee191a23d0035a8fc44"

URI_x86_64_v2_kf6-kitemmodels = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels}"
SRC_URI[x86_64_v2_kf6-kitemmodels.sha256sum] = "d37a2fd8979b9dc7e9a89d012d0dfd34d2630a186f7efa6f99cceb068f3b1c47"

URI_x86_64_v2_kf6-kitemmodels-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemmodels-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-devel}"
SRC_URI[x86_64_v2_kf6-kitemmodels-devel.sha256sum] = "0aa22ee1b89a2d869a3ca143ea6d64ad48590b2258f1d37262c393729fadaf97"

URI_x86_64_v2_kf6-kitemmodels-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemmodels-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-doc}"
SRC_URI[x86_64_v2_kf6-kitemmodels-doc.sha256sum] = "e397e00bb0d147dc1ca363415fbbb29b8c203d2321781e132910eabad4d74a98"

URI_x86_64_v2_kf6-kitemmodels-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemmodels-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemmodels-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemmodels-html}"
SRC_URI[x86_64_v2_kf6-kitemmodels-html.sha256sum] = "d94f2905217a93a5d312e09c8571d0a221ab9418901ae0682786a4bd09368ed4"

URI_aarch64_kf6-kitemmodels = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kitemmodels;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels}"
SRC_URI[aarch64_kf6-kitemmodels.sha256sum] = "bccae11bf0a807a34c4722c675708dac979afa8b0240822ecb48fde23f584379"

URI_aarch64_kf6-kitemmodels-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kitemmodels-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-devel}"
SRC_URI[aarch64_kf6-kitemmodels-devel.sha256sum] = "aad140a4ded91640a8f21ced08a4032c32217a362009139c03498bb25a9128b3"

URI_aarch64_kf6-kitemmodels-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kitemmodels-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-doc}"
SRC_URI[aarch64_kf6-kitemmodels-doc.sha256sum] = "5d17dcb23f4dbe25963aecb3b4c3ad0c481db2ad4858f2106a91e2902f00328a"

URI_aarch64_kf6-kitemmodels-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemmodels-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kitemmodels-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemmodels-html}"
SRC_URI[aarch64_kf6-kitemmodels-html.sha256sum] = "c473b0f5c96c785f793dbab750f6405a171203c776fd37db6205b6508e206440"

RDEPENDS:kf6-kitemmodels = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kitemmodels-devel = " \
 cmake-filesystem \
 kf6-kitemmodels \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kitemmodels-doc = " \
 "
RDEPENDS:kf6-kitemmodels-html = " \
 "
