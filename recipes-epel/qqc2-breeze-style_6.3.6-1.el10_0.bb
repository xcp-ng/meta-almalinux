# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qqc2-breeze-style"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 qqc2-breeze-style \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qqc2-breeze-style-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f7d1ee20414b2524695adddc511c00b3bf498c827fe84d762c3e52b34e15951"

URI_x86_64_v2_qqc2-breeze-style = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qqc2-breeze-style-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qqc2-breeze-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qqc2-breeze-style}"
SRC_URI[x86_64_v2_qqc2-breeze-style.sha256sum] = "01c5c1f14c9a582d390e3ba33c67ef49784fc9cbadcdc91ab9809abd8e35e3ab"

URI_aarch64_qqc2-breeze-style = "${EPEL_MIRROR}/aarch64/Packages/q/qqc2-breeze-style-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_qqc2-breeze-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_qqc2-breeze-style}"
SRC_URI[aarch64_qqc2-breeze-style.sha256sum] = "5e8a3b83937b4811244483106efd8e2f44af2e67c6189c40dd9a1e3580d5bf7f"

RDEPENDS:qqc2-breeze-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kquickcharts \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
