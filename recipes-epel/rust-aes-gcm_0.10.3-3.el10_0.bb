# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aes-gcm"
PV = "0.10.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-aes-gcm+aes-devel \
 rust-aes-gcm+alloc-devel \
 rust-aes-gcm+arrayvec-devel \
 rust-aes-gcm+default-devel \
 rust-aes-gcm+getrandom-devel \
 rust-aes-gcm+heapless-devel \
 rust-aes-gcm+rand_core-devel \
 rust-aes-gcm+std-devel \
 rust-aes-gcm+stream-devel \
 rust-aes-gcm+zeroize-devel \
 rust-aes-gcm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aes-gcm-0.10.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3ac6026d690a9b0bb9e425c88b9f46a3ea48642b588d23426ec57b16c2580ae"

URI_x86_64_v2_rust-aes-gcm+aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+aes-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+aes-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+aes-devel.sha256sum] = "9739471d2c589293fd50eee83557218798e32ac8baff9fb604ecb0ba45a6a5a2"

URI_x86_64_v2_rust-aes-gcm+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+alloc-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+alloc-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+alloc-devel.sha256sum] = "d38d938b09897ab025ebf230d4877ce5dc545411e6a83f68f94554f43be03c7f"

URI_x86_64_v2_rust-aes-gcm+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+arrayvec-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+arrayvec-devel.sha256sum] = "97151bdfa54af9875856e50bdbcf9dc012e1f18ad71fb8e3ef3407d55b85dce2"

URI_x86_64_v2_rust-aes-gcm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+default-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+default-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+default-devel.sha256sum] = "9118f3445e0c88c936ca6cf983667b2a9d50a225774d931c3ac1d31beba03f38"

URI_x86_64_v2_rust-aes-gcm+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+getrandom-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+getrandom-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+getrandom-devel.sha256sum] = "adc83fc0a8d23655540fb542891eb5b7683280dee608d70c15f5f9a14d83f9b5"

URI_x86_64_v2_rust-aes-gcm+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+heapless-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+heapless-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+heapless-devel.sha256sum] = "53eb496318c8b0667731a5e6b604c398001ee9bf0ebbb64ae4c94dd669664db5"

URI_x86_64_v2_rust-aes-gcm+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+rand_core-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+rand_core-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+rand_core-devel.sha256sum] = "b9eff2b7f9cb19587988ff0012c48f88676741819e57fd825c88396704dee213"

URI_x86_64_v2_rust-aes-gcm+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+std-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+std-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+std-devel.sha256sum] = "c3b7000bcbcefabafb997692a260a5072f466bda2a696a7bbc5a732eb960ceee"

URI_x86_64_v2_rust-aes-gcm+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+stream-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+stream-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+stream-devel.sha256sum] = "46224baf18e7286d2aee0f5e6ae588d302505a7d08ad3f45ef3c11e72d950d52"

URI_x86_64_v2_rust-aes-gcm+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm+zeroize-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm+zeroize-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm+zeroize-devel.sha256sum] = "a7edc41376e1acc08fdd9d07e677c4de7adf598ba753dfe28bde8754e02ac91a"

URI_x86_64_v2_rust-aes-gcm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-gcm-devel-0.10.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-gcm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-gcm-devel}"
SRC_URI[x86_64_v2_rust-aes-gcm-devel.sha256sum] = "7580de257d489ee7adc9c33c43966995037c1b827c64987f74d5b78f4e66151c"

URI_aarch64_rust-aes-gcm+aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+aes-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+aes-devel}"
SRC_URI[aarch64_rust-aes-gcm+aes-devel.sha256sum] = "ad62a075a26c52a6f7964965ca7d67e55d0288deb4d55863ca5168079107bdb5"

URI_aarch64_rust-aes-gcm+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+alloc-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+alloc-devel}"
SRC_URI[aarch64_rust-aes-gcm+alloc-devel.sha256sum] = "954eaf7fc1c9a8db6996dd828353b793da3e3c5cf8a1cb6b90c066a254cad7bb"

URI_aarch64_rust-aes-gcm+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+arrayvec-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+arrayvec-devel}"
SRC_URI[aarch64_rust-aes-gcm+arrayvec-devel.sha256sum] = "b42fae8996a1c44a820da5e25fe167705f393f86ad83fe955ee28dd59984b2e5"

URI_aarch64_rust-aes-gcm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+default-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+default-devel}"
SRC_URI[aarch64_rust-aes-gcm+default-devel.sha256sum] = "b4b62d20d80f9a32e50700bf399f3d143cb007fe99f83b47be462431e5375cf1"

URI_aarch64_rust-aes-gcm+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+getrandom-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+getrandom-devel}"
SRC_URI[aarch64_rust-aes-gcm+getrandom-devel.sha256sum] = "d3100a3d0a0dd6b1dcd24d607b6b0ebbcc91eeaa51bca3ac4b1be5e8320b9d34"

URI_aarch64_rust-aes-gcm+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+heapless-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+heapless-devel}"
SRC_URI[aarch64_rust-aes-gcm+heapless-devel.sha256sum] = "f53e2f65f02b5798b706fee6c5c66755a0d992f2a732655314a072626e512d56"

URI_aarch64_rust-aes-gcm+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+rand_core-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+rand_core-devel}"
SRC_URI[aarch64_rust-aes-gcm+rand_core-devel.sha256sum] = "440a2ff01e5a20d10d76b785058754524d222d3d1cb1488ff77013d7c133baf7"

URI_aarch64_rust-aes-gcm+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+std-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+std-devel}"
SRC_URI[aarch64_rust-aes-gcm+std-devel.sha256sum] = "eef3d3bc7f9548e0b46ab9e86a00f51d917c53d9c1763db72c4f4a3b9f092945"

URI_aarch64_rust-aes-gcm+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+stream-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+stream-devel}"
SRC_URI[aarch64_rust-aes-gcm+stream-devel.sha256sum] = "d89ce3a20433f5037cbe82a4d00169a4884fe4ad268a51a634bc2e6637a994ee"

URI_aarch64_rust-aes-gcm+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm+zeroize-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm+zeroize-devel}"
SRC_URI[aarch64_rust-aes-gcm+zeroize-devel.sha256sum] = "481c23c7cb145069f2618ef1ba29b88e57c220550866e273ba0c875fecda6911"

URI_aarch64_rust-aes-gcm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-gcm-devel-0.10.3-3.el10_0.noarch.rpm;name=aarch64_rust-aes-gcm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-gcm-devel}"
SRC_URI[aarch64_rust-aes-gcm-devel.sha256sum] = "48a824330e0487e1fd3f4e521ef1cce2d9761300ce01f255581b3fd8bab19182"

RDEPENDS:rust-aes-gcm+aes-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-aes-gcm-devel \
 "
RDEPENDS:rust-aes-gcm+alloc-devel = " \
 cargo \
 rust-aead+alloc-devel \
 rust-aes-gcm-devel \
 "
RDEPENDS:rust-aes-gcm+arrayvec-devel = " \
 cargo \
 rust-aead+arrayvec-devel \
 rust-aes-gcm-devel \
 "
RDEPENDS:rust-aes-gcm+default-devel = " \
 cargo \
 rust-aes-gcm+aes-devel \
 rust-aes-gcm+alloc-devel \
 rust-aes-gcm+getrandom-devel \
 rust-aes-gcm-devel \
 "
RDEPENDS:rust-aes-gcm+getrandom-devel = " \
 cargo \
 rust-aead+getrandom-devel \
 rust-aes-gcm+rand_core-devel \
 rust-aes-gcm-devel \
 "
RDEPENDS:rust-aes-gcm+heapless-devel = " \
 cargo \
 rust-aead+heapless-devel \
 rust-aes-gcm-devel \
 "
RDEPENDS:rust-aes-gcm+rand_core-devel = " \
 cargo \
 rust-aead+rand_core-devel \
 rust-aes-gcm-devel \
 "
RDEPENDS:rust-aes-gcm+std-devel = " \
 cargo \
 rust-aead+std-devel \
 rust-aes-gcm+alloc-devel \
 rust-aes-gcm-devel \
 "
RDEPENDS:rust-aes-gcm+stream-devel = " \
 cargo \
 rust-aead+stream-devel \
 rust-aes-gcm-devel \
 "
RDEPENDS:rust-aes-gcm+zeroize-devel = " \
 cargo \
 rust-aes-gcm-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-aes-gcm-devel = " \
 cargo \
 rust \
 rust-aead-devel \
 rust-cipher0.4+default-devel \
 rust-ctr+default-devel \
 rust-ghash-devel \
 rust-subtle-devel \
 "
