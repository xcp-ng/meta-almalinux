# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sushy"
PV = "5.10.1"
PR = "1.el10_3"
PACKAGES = " \
 python-sushy-doc \
 python3-sushy \
 python3-sushy-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-sushy-5.10.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5fc01cb320f77fd18d518ed8a6aa71d81c785656f50c8e06bcbeec5341518987"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-sushy-doc-5.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-sushy-doc;unpack=0"
SRC_URI[x86_64_v2_python-sushy-doc.sha256sum] = "58b539ec3f8e09da5d92aa86c5aede8651b474aa8e8b18ee7179612e043c7789"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sushy-5.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sushy;unpack=0"
SRC_URI[x86_64_v2_python3-sushy.sha256sum] = "69a78dea6b5136c15bbd422b855a7a1b905e09edd0e19c5da0e062b7062e7d29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sushy-tests-5.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sushy-tests;unpack=0"
SRC_URI[x86_64_v2_python3-sushy-tests.sha256sum] = "9e1972c5c0b4fa886cd2ebd21c8bc7815ae23164f93297da02110b28551f538c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-sushy-doc-5.10.1-1.el10_3.noarch.rpm;name=aarch64_python-sushy-doc;unpack=0"
SRC_URI[aarch64_python-sushy-doc.sha256sum] = "1a2164bcdfbefdf3426e828fb92bcf911093fd445d05eca124e31941b0dc0c7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-sushy-5.10.1-1.el10_3.noarch.rpm;name=aarch64_python3-sushy;unpack=0"
SRC_URI[aarch64_python3-sushy.sha256sum] = "24cf203d612b4330d4c8a5f4a4e5ca9ef725cd30248ea9b0bd17f6163dc36d8e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-sushy-tests-5.10.1-1.el10_3.noarch.rpm;name=aarch64_python3-sushy-tests;unpack=0"
SRC_URI[aarch64_python3-sushy-tests.sha256sum] = "a5a342e8a14d3567231fb52ef2430a357a9470d885a4e9b04d63859e4da8073c"

RDEPENDS:python-sushy-doc = " \
 "
RDEPENDS:python3-sushy = " \
 python3 \
 python3-dateutil \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 "
RDEPENDS:python3-sushy-tests = " \
 python3 \
 python3-sushy \
 "
