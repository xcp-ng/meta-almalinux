# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_tail"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_tail+default-devel \
 rust-uu_tail-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-uu_tail-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fbf4dd7f28ebbe272d2a7b0a1bf0b54040a1f341d32c7eba686a01babe9c8f26"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tail+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tail+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uu_tail+default-devel.sha256sum] = "029208ca60da2478ecc016bdab3e669c0dec02a7ffd53c2df9ea0b172a44100a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tail-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tail-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uu_tail-devel.sha256sum] = "d7650c34cbe8c638dda6a06720b590349d046ac7b89e519e4f02d1ceaa39835a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tail+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tail+default-devel;unpack=0"
SRC_URI[aarch64_rust-uu_tail+default-devel.sha256sum] = "7a22bd3fb057a29e58c16a29444ec1dc642fb796f395238944696d0d334db538"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tail-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tail-devel;unpack=0"
SRC_URI[aarch64_rust-uu_tail-devel.sha256sum] = "12e468d5b36517bab4aaa42234313110151b689a82f89841d36a835067adf576"

RDEPENDS:rust-uu_tail+default-devel = " \
 cargo \
 rust-uu_tail-devel \
 "
RDEPENDS:rust-uu_tail-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-memchr+default-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30-devel \
 rust-notify+default-devel \
 rust-same-file+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 rust-uucore+parser-size-devel \
 rust-uucore+signals-devel \
 "
