# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-16-gcc"
PV = "16.2.1"
PR = "1.2.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 gcc-toolset-16-gcc \
 gcc-toolset-16-gcc-c++ \
 gcc-toolset-16-gcc-gfortran \
 gcc-toolset-16-gcc-plugin-annobin \
 gcc-toolset-16-gcc-plugin-devel \
 gcc-toolset-16-libasan-devel \
 gcc-toolset-16-libatomic-devel \
 gcc-toolset-16-libgccjit \
 gcc-toolset-16-libgccjit-devel \
 gcc-toolset-16-libgdiagnostics-devel \
 gcc-toolset-16-libitm-devel \
 gcc-toolset-16-liblsan-devel \
 gcc-toolset-16-libquadmath-devel \
 gcc-toolset-16-libstdc++-devel \
 gcc-toolset-16-libstdc++-docs \
 gcc-toolset-16-libtsan-devel \
 gcc-toolset-16-libubsan-devel \
 gcc-toolset-16-offload-nvptx \
 libgdiagnostics \
"
PACKAGES:aarch64 = " \
 gcc-toolset-16-gcc \
 gcc-toolset-16-gcc-c++ \
 gcc-toolset-16-gcc-gfortran \
 gcc-toolset-16-gcc-plugin-annobin \
 gcc-toolset-16-gcc-plugin-devel \
 gcc-toolset-16-libasan-devel \
 gcc-toolset-16-libatomic-devel \
 gcc-toolset-16-libgccjit \
 gcc-toolset-16-libgccjit-devel \
 gcc-toolset-16-libgdiagnostics-devel \
 gcc-toolset-16-libitm-devel \
 gcc-toolset-16-liblsan-devel \
 gcc-toolset-16-libstdc++-devel \
 gcc-toolset-16-libstdc++-docs \
 gcc-toolset-16-libtsan-devel \
 gcc-toolset-16-libubsan-devel \
 libgdiagnostics \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-16-gcc-16.2.1-1.2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1ac2bb507a37e181406715e660c979a7aae84a47a5286e261e6e0a44fc52d5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-gcc-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-gcc;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-gcc.sha256sum] = "cea75418be52c2c27a0d14bff921ac31dcf866ec6fcb8ce7aaf1c3adcd275dc7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-gcc-c++-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-gcc-c++;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-gcc-c++.sha256sum] = "d08267e83811e76169b448e3e4160c14ba933d193db87a4c6990533e60775943"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-gcc-gfortran-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-gcc-gfortran;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-gcc-gfortran.sha256sum] = "9bec4864402536e3b39b5b4afcd0f8e89af9351847c2a626f059e69c7ff4f37e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-gcc-plugin-annobin-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-gcc-plugin-annobin;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-gcc-plugin-annobin.sha256sum] = "fb3a8da33da14c593cc43b1574037711d7f95f962c6ed128c686c365c281f92f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-gcc-plugin-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-gcc-plugin-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-gcc-plugin-devel.sha256sum] = "48026a9ca35c0c8defa4933cef9b8d7d3ff8200b340542a6cd314337622f55ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libasan-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libasan-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libasan-devel.sha256sum] = "6b6d2399261a0033342adfbb569029bed3c26b34bba02bf0af483bb7794a0e55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libatomic-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libatomic-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libatomic-devel.sha256sum] = "117f5cc9d8d3a63e33a5127456a785c9edc6835fb7d61f485fd064a1e0d5bc6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libgccjit-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libgccjit;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libgccjit.sha256sum] = "9896bc807ef5daa1b95354ed25423109eb78b66e0187796a087ca515f600c2aa"
RPROVIDES:gcc-toolset-16-libgccjit:append:x86_64_v2 = " virtual/libgccjit.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libgccjit-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libgccjit-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libgccjit-devel.sha256sum] = "7e217e8cedd6c35dfbf53d6522fafd6dbfcf550f48da611b37453ea4f41789f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libgdiagnostics-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libgdiagnostics-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libgdiagnostics-devel.sha256sum] = "96155d1449c4c071b70030ea3d5e949b3840192c2c64d2ad6b4ec0caad6a1a43"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libitm-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libitm-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libitm-devel.sha256sum] = "6b60a60bd38ffcce519116864f17f7ec500f3d0bfc8bf3b62e8aba997398a8b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-liblsan-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-liblsan-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-liblsan-devel.sha256sum] = "594d5b85a2d07c209b5cdc0565ec7ea21297e2cbedd6ea6c212ec60cfcf7e9a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libquadmath-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libquadmath-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libquadmath-devel.sha256sum] = "b696cbd38f08d745a5dfd9217b4ecf9524fb6a3deb8fe863d16b4c2dee1e3863"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libstdc++-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libstdc++-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libstdc++-devel.sha256sum] = "01c785880e9fe689057b6620cc47cb67d8b2d998213a94df6f83e5c5b92e82df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libstdc++-docs-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libstdc++-docs;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libstdc++-docs.sha256sum] = "dfd09ec628316e100b91709e3d6322452f0e45dac690befd538f802267776368"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libtsan-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libtsan-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libtsan-devel.sha256sum] = "b6c93e1a0846ce1001fbdec8fa0c6d925504483097301664b25eb291de139726"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-libubsan-devel-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-libubsan-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-libubsan-devel.sha256sum] = "5b29ac50707eb79bc2e81491f9cc27cc39f3c0873fc82f86214ae19375828d93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-offload-nvptx-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-offload-nvptx;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-offload-nvptx.sha256sum] = "cd051ea9e61ade47e44992babac657d4a79ff69cb1677df3f3e1215f5517a0a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgdiagnostics-16.2.1-1.2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libgdiagnostics;unpack=0"
SRC_URI[x86_64_v2_libgdiagnostics.sha256sum] = "028726412d9044554c7d8b12ceb43846318f996197e9a34641f13cae5a8feabc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-gcc-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-gcc;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-gcc.sha256sum] = "8c32f006c7a7b8e935616025ef2257418f080efccb2d5b4895d01232c881b985"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-gcc-c++-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-gcc-c++;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-gcc-c++.sha256sum] = "a9959dfa7c989827f9e2c395cd88143064b0df0f77f78b1778d0f442c3acd3a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-gcc-gfortran-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-gcc-gfortran;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-gcc-gfortran.sha256sum] = "f3f31940ad6fadf714851c6fe914900b530cd422549048a34f124ec5132b5dd9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-gcc-plugin-annobin-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-gcc-plugin-annobin;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-gcc-plugin-annobin.sha256sum] = "56de8b7bbe33974ce1d71f26e17938371e2bcc7eb9b250ec20c2f5ff5022ed0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-gcc-plugin-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-gcc-plugin-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-gcc-plugin-devel.sha256sum] = "1dee9f038798f20dfd7e53c62aede469f1ab1077ce41586fbc77012246f38392"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libasan-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libasan-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libasan-devel.sha256sum] = "7bece8eac8c3e989c3f8fa84b982e1f7b028c8146cbe986229a2ad220cf1bb8b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libatomic-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libatomic-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libatomic-devel.sha256sum] = "806709571474502812205cdf80e739dac9d1784c009580ca0bf09c6332163dcb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libgccjit-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libgccjit;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libgccjit.sha256sum] = "d23f7dd5f4cbba5c05a04fcff462546f9c5f0d9c1fd4beaf2deb9cbdef40f129"
RPROVIDES:gcc-toolset-16-libgccjit:append:aarch64 = " virtual/libgccjit.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libgccjit-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libgccjit-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libgccjit-devel.sha256sum] = "1783aa107e42c99df43acfa6632c4483cde0744e96fe9e16e07face6b5460934"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libgdiagnostics-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libgdiagnostics-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libgdiagnostics-devel.sha256sum] = "ceefd8065d0afb9ab77d8e327f0f8b291f752cb27473bdfb1b870d95fdb9882e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libitm-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libitm-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libitm-devel.sha256sum] = "30ddb1ef21bd511865ba2eee5156b1446af15965c3d1801878fa4b91a1773af1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-liblsan-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-liblsan-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-liblsan-devel.sha256sum] = "fdb16482dbd2ba8de6fead657d6f03d338e376345ba23a7b038b4380ac20c5bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libstdc++-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libstdc++-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libstdc++-devel.sha256sum] = "dd0dea30cf7dde45c597e3abaad0d26e960d228d8c1905684c79118eca142e86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libstdc++-docs-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libstdc++-docs;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libstdc++-docs.sha256sum] = "ae0f1e0fd1485d075826f4cdd4041dcba9702b1f3c4996ea29a394d69c26c59f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libtsan-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libtsan-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libtsan-devel.sha256sum] = "b75ad13ca32f2bcfcf6e5e63a50c538634ef377dabf8cffeeb2f2abfb4ad2bec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-libubsan-devel-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-libubsan-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-libubsan-devel.sha256sum] = "2ccb2960acdf89538e54115aaf63180435860761741d8103d0900ca8ccd7ce98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgdiagnostics-16.2.1-1.2.el10.alma.1.aarch64.rpm;name=aarch64_libgdiagnostics;unpack=0"
SRC_URI[aarch64_libgdiagnostics.sha256sum] = "73861094738f9ccd845ca462f44f46624d22d298b2f5a9978ccb4829e53c6b4a"

RDEPENDS:gcc-toolset-16-gcc:x86_64_v2 = " \
 bash \
 gcc-toolset-16-binutils \
 gcc-toolset-16-libatomic-devel \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-16-gcc:aarch64 = " \
 gcc-toolset-16-binutils \
 gcc-toolset-16-libatomic-devel \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-16-gcc-c++ = " \
 gcc-toolset-16-gcc \
 gcc-toolset-16-libstdc++-devel \
 glibc \
 gmp \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-16-gcc-gfortran:x86_64_v2 = " \
 bash \
 gcc-toolset-16-gcc \
 gcc-toolset-16-libquadmath-devel \
 glibc \
 gmp \
 info \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-16-gcc-gfortran:aarch64 = " \
 bash \
 gcc-toolset-16-gcc \
 glibc \
 gmp \
 info \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-16-gcc-plugin-annobin = " \
 gcc-toolset-16-gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gcc-toolset-16-gcc-plugin-devel = " \
 gcc-toolset-16-gcc \
 glibc \
 gmp-devel \
 libmpc-devel \
 mpfr-devel \
 "
RDEPENDS:gcc-toolset-16-libasan-devel = " \
 libasan \
 "
RDEPENDS:gcc-toolset-16-libatomic-devel = " \
 libatomic \
 "
RDEPENDS:gcc-toolset-16-libgccjit = " \
 gcc-toolset-16-gcc \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-16-libgccjit-devel = " \
 gcc-toolset-16-libgccjit \
 "
RDEPENDS:gcc-toolset-16-libgdiagnostics-devel = " \
 libgdiagnostics \
 "
RDEPENDS:gcc-toolset-16-libitm-devel = " \
 gcc-toolset-16-gcc \
 libitm \
 "
RDEPENDS:gcc-toolset-16-liblsan-devel = " \
 liblsan \
 "
RDEPENDS:gcc-toolset-16-libquadmath-devel = " \
 gcc-toolset-16-gcc \
 libquadmath \
 "
RDEPENDS:gcc-toolset-16-libstdc++-devel = " \
 libstdc++ \
 "
RDEPENDS:gcc-toolset-16-libstdc++-docs = " \
 "
RDEPENDS:gcc-toolset-16-libtsan-devel = " \
 libtsan \
 "
RDEPENDS:gcc-toolset-16-libubsan-devel = " \
 libubsan \
 "
RDEPENDS:gcc-toolset-16-offload-nvptx = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-nvptx \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:libgdiagnostics = " \
 glibc \
 "
