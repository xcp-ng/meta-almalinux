# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ogdi"
PV = "4.1.1"
PR = "3.el10_0"
PACKAGES = " \
 ogdi \
 ogdi-devel \
 ogdi-tcl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/ogdi-4.1.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b13d709d47f5ae1597f72986ed1d702350407423b6842012f13560ebd9e7415"

URI_x86_64_v2_ogdi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ogdi-4.1.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ogdi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ogdi}"
SRC_URI[x86_64_v2_ogdi.sha256sum] = "3c8f0f2a67090373ab1e17dd4604ea6c0e5b4f5e343a9298f00d1412dff95c5b"

URI_x86_64_v2_ogdi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ogdi-devel-4.1.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ogdi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ogdi-devel}"
SRC_URI[x86_64_v2_ogdi-devel.sha256sum] = "2480870d668c1ecfc56e83f9b6403bced78b5123993c329961c4f78b953170ae"

URI_x86_64_v2_ogdi-tcl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ogdi-tcl-4.1.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ogdi-tcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ogdi-tcl}"
SRC_URI[x86_64_v2_ogdi-tcl.sha256sum] = "e37c2f37036664398bf8b02a534aa28c4b39d9933b5c6fd179c1de27c9bb91a9"

URI_aarch64_ogdi = "${EPEL_MIRROR}/aarch64/Packages/o/ogdi-4.1.1-3.el10_0.aarch64.rpm;name=aarch64_ogdi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ogdi}"
SRC_URI[aarch64_ogdi.sha256sum] = "dc26acdcb6f3087e4fceb6d9b74eda6cd8e79c733623c1b9dd3b9e4a0ab35e20"

URI_aarch64_ogdi-devel = "${EPEL_MIRROR}/aarch64/Packages/o/ogdi-devel-4.1.1-3.el10_0.aarch64.rpm;name=aarch64_ogdi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ogdi-devel}"
SRC_URI[aarch64_ogdi-devel.sha256sum] = "082a9326b9d6f75f6f15cb9e359716a5b822eb1dc3b0eb5e39da7080cf3789a1"

URI_aarch64_ogdi-tcl = "${EPEL_MIRROR}/aarch64/Packages/o/ogdi-tcl-4.1.1-3.el10_0.aarch64.rpm;name=aarch64_ogdi-tcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ogdi-tcl}"
SRC_URI[aarch64_ogdi-tcl.sha256sum] = "11822d9465920a250573136474ada884a6119d6b5794286a315dc2f193847def"

RDEPENDS:ogdi = " \
 expat \
 glibc \
 libtirpc \
 zlib-ng-compat \
 "
RDEPENDS:ogdi-devel = " \
 bash \
 expat-devel \
 ogdi \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:ogdi-tcl = " \
 glibc \
 ogdi \
 tcl \
 "
