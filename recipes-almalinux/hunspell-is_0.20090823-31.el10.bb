# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-is"
PV = "0.20090823"
PR = "31.el10"
PACKAGES = " \
 hunspell-is \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-is-0.20090823-31.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ff4956ce508ca5fd659a359344ad54d5d127766e5bf3fe95c616ceeefa0b276a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-is-0.20090823-31.el10.noarch.rpm;name=x86_64_v2_hunspell-is;unpack=0"
SRC_URI[x86_64_v2_hunspell-is.sha256sum] = "8cc1ddac05e29cf69c52554ef6f204d4996eec14c101c062522bf684eb5425cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-is-0.20090823-31.el10.noarch.rpm;name=aarch64_hunspell-is;unpack=0"
SRC_URI[aarch64_hunspell-is.sha256sum] = "8cc1ddac05e29cf69c52554ef6f204d4996eec14c101c062522bf684eb5425cc"

RDEPENDS:hunspell-is = " \
 hunspell-filesystem \
 "
