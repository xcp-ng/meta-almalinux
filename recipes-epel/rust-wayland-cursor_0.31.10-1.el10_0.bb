# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-cursor"
PV = "0.31.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-wayland-cursor+default-devel \
 rust-wayland-cursor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-cursor-0.31.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "783e277b1c3745ac542b0676a6d514c28517fd7a769059e586291e05bb7f212f"

URI_x86_64_v2_rust-wayland-cursor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-cursor+default-devel-0.31.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-cursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-cursor+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-cursor+default-devel.sha256sum] = "841bf3c96a65d2a96499327d9e5f096c9b853205a1c08576df493f9339f6ecf2"

URI_x86_64_v2_rust-wayland-cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-cursor-devel-0.31.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-cursor-devel}"
SRC_URI[x86_64_v2_rust-wayland-cursor-devel.sha256sum] = "5c12d80a52f7fa49cb395c99891523dd8a6921fb0131c25dc3e0e71cec77ec12"

URI_aarch64_rust-wayland-cursor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-cursor+default-devel-0.31.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-cursor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-cursor+default-devel}"
SRC_URI[aarch64_rust-wayland-cursor+default-devel.sha256sum] = "9f8fe9ab63ea81232eac2e7b3456b1a836f4bd4d5f8a8c4878398e00bf20444f"

URI_aarch64_rust-wayland-cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-cursor-devel-0.31.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-cursor-devel}"
SRC_URI[aarch64_rust-wayland-cursor-devel.sha256sum] = "6146b76fc4e28e0eca188524c768ce6ebd3302c39310c0291cab60f1077aecdd"

RDEPENDS:rust-wayland-cursor+default-devel = " \
 cargo \
 rust-wayland-cursor-devel \
 "
RDEPENDS:rust-wayland-cursor-devel = " \
 cargo \
 rust \
 rust-rustix+default-devel \
 rust-rustix+shm-devel \
 rust-wayland-client+default-devel \
 rust-xcursor+default-devel \
 "
