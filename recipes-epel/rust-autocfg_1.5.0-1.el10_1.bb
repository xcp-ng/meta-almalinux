# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-autocfg"
PV = "1.5.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-autocfg+default-devel \
 rust-autocfg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-autocfg-1.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d1052e595f25c7525568d0c1e444238c68f2a3e9f01ef6097db14807fe4a8f4"

URI_x86_64_v2_rust-autocfg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-autocfg+default-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-autocfg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-autocfg+default-devel}"
SRC_URI[x86_64_v2_rust-autocfg+default-devel.sha256sum] = "abc4942b9a19c372969596349dca69a261b386e425445f93d236dbb5d83e0688"

URI_x86_64_v2_rust-autocfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-autocfg-devel-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-autocfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-autocfg-devel}"
SRC_URI[x86_64_v2_rust-autocfg-devel.sha256sum] = "f01bcc24ce2b9dbc16e5dad917797acca1cf8ebcb3d58a0b06ae4f79eea7299c"

URI_aarch64_rust-autocfg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-autocfg+default-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-autocfg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-autocfg+default-devel}"
SRC_URI[aarch64_rust-autocfg+default-devel.sha256sum] = "5a31958bb1d82f05f42bba507bda839003ae57db7f89a87e7c703c6e0ce82670"

URI_aarch64_rust-autocfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-autocfg-devel-1.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-autocfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-autocfg-devel}"
SRC_URI[aarch64_rust-autocfg-devel.sha256sum] = "331ab56d7f6b4f2c2541870e064f58716f385cab717dd8d16277f9c13274bb79"

RDEPENDS:rust-autocfg+default-devel = " \
 cargo \
 rust-autocfg-devel \
 "
RDEPENDS:rust-autocfg-devel = " \
 bash \
 cargo \
 rust \
 "
