# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-search"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 akonadi-search \
 akonadi-search-devel \
 akonadi-search-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-search-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44d696cc14fe3f1d27afd6427f176149cd9dd3f68b0d200846dba54c862aaf14"

URI_x86_64_v2_akonadi-search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search}"
SRC_URI[x86_64_v2_akonadi-search.sha256sum] = "95e5795bec88196aa62b6bd9daf030869937b5b6dc4353d2f333dd5d9d22158f"

URI_x86_64_v2_akonadi-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search-devel}"
SRC_URI[x86_64_v2_akonadi-search-devel.sha256sum] = "0dc8db575a7e7a0bc3a2cb8b15f4be9abe0534a42796e1849a412118ab0db4ec"

URI_x86_64_v2_akonadi-search-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-search-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-search-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-search-doc}"
SRC_URI[x86_64_v2_akonadi-search-doc.sha256sum] = "23a7c8c2eac227541bc2721e7786cc7be44624fc803e02ccf366e5c060410043"

URI_aarch64_akonadi-search = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-search;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search}"
SRC_URI[aarch64_akonadi-search.sha256sum] = "6f62448dbdbbd82984b595c03e8eb1d17aa58f0073542c10f27cf2bcb8d24b70"

URI_aarch64_akonadi-search-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search-devel}"
SRC_URI[aarch64_akonadi-search-devel.sha256sum] = "b360b6a9b3649bb61cf13d5df022b3dc95f28acf3c04a74d6b67674797ce2af7"

URI_aarch64_akonadi-search-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-search-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_akonadi-search-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-search-doc}"
SRC_URI[aarch64_akonadi-search-doc.sha256sum] = "4ee221634e516d73b55117290dbf8e18a631024f1f8636dbbb40f0f704e61025"

RDEPENDS:akonadi-search = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-krunner \
 kf6-kwidgetsaddons \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 xapian-core-libs \
 "
RDEPENDS:akonadi-search-devel = " \
 akonadi-mime-devel \
 akonadi-search \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 kmime-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:akonadi-search-doc = " \
 "
