# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-no-overview"
PV = "49"
PR = "1.el10"
PACKAGES = " \
 gnome-shell-extension-no-overview \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/gnome-shell-extension-no-overview-49-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "522cb27224e03129088aee685db7889222767d6fe05ea0f19023774ca0c28be2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-shell-extension-no-overview-49-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-no-overview;unpack=0"
SRC_URI[x86_64_v2_gnome-shell-extension-no-overview.sha256sum] = "e5ca86b5d88ae3ed403a71904ea7ea3fe6d8b9e9fee712d50c4798b98518ed74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-shell-extension-no-overview-49-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-no-overview;unpack=0"
SRC_URI[aarch64_gnome-shell-extension-no-overview.sha256sum] = "e5ca86b5d88ae3ed403a71904ea7ea3fe6d8b9e9fee712d50c4798b98518ed74"

RDEPENDS:gnome-shell-extension-no-overview = " \
 "
