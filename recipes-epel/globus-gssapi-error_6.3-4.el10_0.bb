# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gssapi-error"
PV = "6.3"
PR = "4.el10_0"
PACKAGES = " \
 globus-gssapi-error \
 globus-gssapi-error-devel \
 globus-gssapi-error-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gssapi-error-6.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "470f7e7341837437135a0b19f07e33c76ce2047235441aad342d2e853b379969"

URI_x86_64_v2_globus-gssapi-error = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gssapi-error-6.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gssapi-error;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gssapi-error}"
SRC_URI[x86_64_v2_globus-gssapi-error.sha256sum] = "884d5cc2c2c3d54575b9fae39d9600dd4adddafe59caa966d847f3f9d7ee792d"

URI_x86_64_v2_globus-gssapi-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gssapi-error-devel-6.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gssapi-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gssapi-error-devel}"
SRC_URI[x86_64_v2_globus-gssapi-error-devel.sha256sum] = "725ce6d93758cd309838fd0dd318ccc3451ed0173766f04792aa4b7c3e677b86"

URI_x86_64_v2_globus-gssapi-error-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gssapi-error-doc-6.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gssapi-error-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gssapi-error-doc}"
SRC_URI[x86_64_v2_globus-gssapi-error-doc.sha256sum] = "5de8c4c6334dd648c34a7973ba65e6875c8b0221ee0139f8d14346b8651465d7"

URI_aarch64_globus-gssapi-error = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gssapi-error-6.3-4.el10_0.aarch64.rpm;name=aarch64_globus-gssapi-error;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gssapi-error}"
SRC_URI[aarch64_globus-gssapi-error.sha256sum] = "763ed8c96d8b7f5f7d1e8c23de00a7c4d28fccee24ca58bbdce6b6ebd949e02a"

URI_aarch64_globus-gssapi-error-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gssapi-error-devel-6.3-4.el10_0.aarch64.rpm;name=aarch64_globus-gssapi-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gssapi-error-devel}"
SRC_URI[aarch64_globus-gssapi-error-devel.sha256sum] = "5de36946ef36a5c583e96470225e0b02b37cf98eff5bb6e04c05b4b84d96e808"

URI_aarch64_globus-gssapi-error-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gssapi-error-doc-6.3-4.el10_0.noarch.rpm;name=aarch64_globus-gssapi-error-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gssapi-error-doc}"
SRC_URI[aarch64_globus-gssapi-error-doc.sha256sum] = "30bfb9a290cda6dc9ed88221512af9d1beb2504c73ec044d97e10ce34b08b2ba"

RDEPENDS:globus-gssapi-error = " \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 "
RDEPENDS:globus-gssapi-error-devel = " \
 globus-common-devel \
 globus-gss-assist-devel \
 globus-gssapi-error \
 globus-gssapi-gsi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gssapi-error-doc = " \
 "
