# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openspecfun"
PV = "0.5.3"
PR = "22.el10_1"
PACKAGES = " \
 openspecfun \
 openspecfun-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openspecfun-0.5.3-22.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63d125074e69f01daa3da74aa1c0b1dd0035ccdf1211d4c1c0e99aac0db3420e"

URI_x86_64_v2_openspecfun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openspecfun-0.5.3-22.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openspecfun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openspecfun}"
SRC_URI[x86_64_v2_openspecfun.sha256sum] = "2f4126fbf847b17720cb20d1910e541b62a99a8f2f42046c1e7592da085e89b7"

URI_x86_64_v2_openspecfun-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openspecfun-devel-0.5.3-22.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openspecfun-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openspecfun-devel}"
SRC_URI[x86_64_v2_openspecfun-devel.sha256sum] = "3f72572c048c087f6bafddae145ee8d9c800e9ebef4966b12d69c4280aa76725"

URI_aarch64_openspecfun = "${EPEL_MIRROR}/aarch64/Packages/o/openspecfun-0.5.3-22.el10_1.aarch64.rpm;name=aarch64_openspecfun;unpack=0"
SRC_URI:append = " ${URI_aarch64_openspecfun}"
SRC_URI[aarch64_openspecfun.sha256sum] = "5fc21a9f74129be0de0d3f9a053513819f69bf5733c55c376b0ee6ae093542a9"

URI_aarch64_openspecfun-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openspecfun-devel-0.5.3-22.el10_1.aarch64.rpm;name=aarch64_openspecfun-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openspecfun-devel}"
SRC_URI[aarch64_openspecfun-devel.sha256sum] = "7e472e0bd276a9f26f80327aadf1593fe07d22bec854e04f9bd342ec7a35da77"

RDEPENDS:openspecfun = " \
 glibc \
 libgcc \
 libgfortran \
 "
RDEPENDS:openspecfun-devel = " \
 openspecfun \
 "
