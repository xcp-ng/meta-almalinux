# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpkgmanifest"
PV = "0.5.9"
PR = "8.el10_2"
PACKAGES = " \
 libpkgmanifest \
 libpkgmanifest-devel \
 python3-libpkgmanifest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libpkgmanifest-0.5.9-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9274c218511f8e9c103a9d914f5fd945955c86d5c53cb4e17f57138bf603b88f"

URI_x86_64_v2_libpkgmanifest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpkgmanifest-0.5.9-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpkgmanifest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpkgmanifest}"
SRC_URI[x86_64_v2_libpkgmanifest.sha256sum] = "7ab046975ec5dfbb362fac20678dc02cfe11b7367549a66e3e479d4a6a62a5b5"

URI_x86_64_v2_libpkgmanifest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpkgmanifest-devel-0.5.9-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpkgmanifest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpkgmanifest-devel}"
SRC_URI[x86_64_v2_libpkgmanifest-devel.sha256sum] = "7eefd00acd58a4a9595585b9608446f52d8a151edbb002448a9e87e72c030c31"

URI_x86_64_v2_python3-libpkgmanifest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libpkgmanifest-0.5.9-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libpkgmanifest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libpkgmanifest}"
SRC_URI[x86_64_v2_python3-libpkgmanifest.sha256sum] = "d46bb26d401e082031c5c2421af7f518099bff671aac05110c223939152b6d88"

URI_aarch64_libpkgmanifest = "${EPEL_MIRROR}/aarch64/Packages/l/libpkgmanifest-0.5.9-8.el10_2.aarch64.rpm;name=aarch64_libpkgmanifest;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpkgmanifest}"
SRC_URI[aarch64_libpkgmanifest.sha256sum] = "2938c9a8b40a26ec34d76b80d2f2a472d54837d93aa549a7c32332b820b12531"

URI_aarch64_libpkgmanifest-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libpkgmanifest-devel-0.5.9-8.el10_2.aarch64.rpm;name=aarch64_libpkgmanifest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpkgmanifest-devel}"
SRC_URI[aarch64_libpkgmanifest-devel.sha256sum] = "e436f2bc13b11217827bf289971a626981e4d4a097d7ae7ea3d3cae37d0b58a7"

URI_aarch64_python3-libpkgmanifest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libpkgmanifest-0.5.9-8.el10_2.aarch64.rpm;name=aarch64_python3-libpkgmanifest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libpkgmanifest}"
SRC_URI[aarch64_python3-libpkgmanifest.sha256sum] = "4e53d3d149f845feb5e40cc341ed4b72af60dd4a4bb780a99c4e4c977bb2ade3"

RDEPENDS:libpkgmanifest = " \
 glibc \
 libgcc \
 libstdc++ \
 yaml-cpp \
 "
RDEPENDS:libpkgmanifest-devel = " \
 libpkgmanifest \
 pkgconf-pkg-config \
 virtual/pkgconfig_yaml-cpp_ \
 "
RDEPENDS:python3-libpkgmanifest = " \
 glibc \
 libgcc \
 libpkgmanifest \
 libstdc++ \
 python3 \
 python3-libs \
 "
