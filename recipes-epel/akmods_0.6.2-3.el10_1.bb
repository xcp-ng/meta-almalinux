# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akmods"
PV = "0.6.2"
PR = "3.el10_1"
PACKAGES = " \
 akmods \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akmods-0.6.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33f38e157f67b5e5e6f8b9faf22754d607e3ce7c129bd9a2304149af3292c8c8"

URI_x86_64_v2_akmods = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akmods-0.6.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_akmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akmods}"
SRC_URI[x86_64_v2_akmods.sha256sum] = "36ef41c62acba91e048848a2a0af5957137269ae49573a1455fe84ebde6e97d2"

URI_aarch64_akmods = "${EPEL_MIRROR}/aarch64/Packages/a/akmods-0.6.2-3.el10_1.noarch.rpm;name=aarch64_akmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_akmods}"
SRC_URI[aarch64_akmods.sha256sum] = "dd86d5f42c1bfce9697fbff726236f7674e50e1923c12168fb19136d68fed6d4"

RDEPENDS:akmods = " \
 bash \
 bzip2 \
 diffutils \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 grubby \
 gzip \
 kernel-abi-stablelists \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmodtool \
 make \
 openssl \
 rpm-build \
 rpmdevtools \
 sed \
 shadow-utils \
 systemd \
 tar \
 time \
 unzip \
 util-linux \
 util-linux-core \
 virtual/coreutils \
 virtual/kernel-devel-uname-r \
 "
