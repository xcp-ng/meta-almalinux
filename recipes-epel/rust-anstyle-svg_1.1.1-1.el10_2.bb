# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-svg"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-anstyle-svg+default-devel \
 rust-anstyle-svg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-svg-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e529f8c063ac12c84571783587f6abc7bf078b5612d675d86bbeaedbec0b995c"

URI_x86_64_v2_rust-anstyle-svg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg+default-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg+default-devel.sha256sum] = "93c32195916330d6046a17ad292f4136aaaa5909fe44356a43713d3bc68010bc"

URI_x86_64_v2_rust-anstyle-svg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-svg-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-svg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-svg-devel}"
SRC_URI[x86_64_v2_rust-anstyle-svg-devel.sha256sum] = "f7f38d37b437c3cba243cffa388f5d3c7ec0ea582fddcd0117fe2b38e5a86f27"

URI_aarch64_rust-anstyle-svg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg+default-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-svg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg+default-devel}"
SRC_URI[aarch64_rust-anstyle-svg+default-devel.sha256sum] = "35c6cc91c8c7e2f0a78b837df8c0eac0d48d4f70060505227a3389b1169387f1"

URI_aarch64_rust-anstyle-svg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-svg-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-anstyle-svg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-svg-devel}"
SRC_URI[aarch64_rust-anstyle-svg-devel.sha256sum] = "c178f5f46865359f2a043c3bbcacb8bf0309d70f4186f24b873d87873540d673"

RDEPENDS:rust-anstyle-svg+default-devel = " \
 cargo \
 rust-anstyle-svg-devel \
 "
RDEPENDS:rust-anstyle-svg-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-lossy+default-devel \
 rust-anstyle-parse+default-devel \
 rust-html-escape+default-devel \
 rust-unicode-width+default-devel \
 "
