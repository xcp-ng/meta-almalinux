# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smartstring"
PV = "1.0.1"
PR = "8.el10_1"
PACKAGES = " \
 rust-smartstring+arbitrary-devel \
 rust-smartstring+default-devel \
 rust-smartstring+proptest-devel \
 rust-smartstring+serde-devel \
 rust-smartstring+std-devel \
 rust-smartstring+test-devel \
 rust-smartstring-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smartstring-1.0.1-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "156b6556494f921694278e086ac257b4d2ff7559e88b841edc860cf74749b8b3"

URI_x86_64_v2_rust-smartstring+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+arbitrary-devel-1.0.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-smartstring+arbitrary-devel.sha256sum] = "265d76bfca4aa274ccfb59982bc7342cb592e43cfacd5f9ea6abb6cc15a386fe"

URI_x86_64_v2_rust-smartstring+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+default-devel-1.0.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+default-devel}"
SRC_URI[x86_64_v2_rust-smartstring+default-devel.sha256sum] = "df414a966cf126ed5fe44fc380afa967585a8f31be31f5720ae0fef72ef1b100"

URI_x86_64_v2_rust-smartstring+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+proptest-devel-1.0.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+proptest-devel}"
SRC_URI[x86_64_v2_rust-smartstring+proptest-devel.sha256sum] = "68cab6bc61ec4af08ca86d95bba6f485f8ab5bc36d8ed683fd38ccfacb34d4a1"

URI_x86_64_v2_rust-smartstring+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+serde-devel-1.0.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+serde-devel}"
SRC_URI[x86_64_v2_rust-smartstring+serde-devel.sha256sum] = "3ed4fda63911a9bdb9ce2f49ac07e57ff7308bd520900610ff9a21de8984f65d"

URI_x86_64_v2_rust-smartstring+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+std-devel-1.0.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+std-devel}"
SRC_URI[x86_64_v2_rust-smartstring+std-devel.sha256sum] = "6a80d61442feb4e068ff08bc9408f44f59ac4b320070d5c0bebd43c52b0f460d"

URI_x86_64_v2_rust-smartstring+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring+test-devel-1.0.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring+test-devel}"
SRC_URI[x86_64_v2_rust-smartstring+test-devel.sha256sum] = "057c01543705189b02fc3f898aaba4a92e3e72cef72279c904c8397910953b03"

URI_x86_64_v2_rust-smartstring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smartstring-devel-1.0.1-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smartstring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smartstring-devel}"
SRC_URI[x86_64_v2_rust-smartstring-devel.sha256sum] = "9f368766a65faa8e65fc08d5a9b3ecc15d84ed56e7420dd80f0a537335ffde3d"

URI_aarch64_rust-smartstring+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+arbitrary-devel-1.0.1-8.el10_1.noarch.rpm;name=aarch64_rust-smartstring+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+arbitrary-devel}"
SRC_URI[aarch64_rust-smartstring+arbitrary-devel.sha256sum] = "2c6cc3a96dec5ea02faa1b6cd5841a09eb3edf65966d68695280bb48dcb46225"

URI_aarch64_rust-smartstring+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+default-devel-1.0.1-8.el10_1.noarch.rpm;name=aarch64_rust-smartstring+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+default-devel}"
SRC_URI[aarch64_rust-smartstring+default-devel.sha256sum] = "2cdb8d4ad404f53fb0392bfba592820acb933a3c124e48f72ce62a940e283bb7"

URI_aarch64_rust-smartstring+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+proptest-devel-1.0.1-8.el10_1.noarch.rpm;name=aarch64_rust-smartstring+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+proptest-devel}"
SRC_URI[aarch64_rust-smartstring+proptest-devel.sha256sum] = "e53a60d5ca330d102182381e13ee1cd2fc3d6dce1b636249d6ca321bb0e2530c"

URI_aarch64_rust-smartstring+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+serde-devel-1.0.1-8.el10_1.noarch.rpm;name=aarch64_rust-smartstring+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+serde-devel}"
SRC_URI[aarch64_rust-smartstring+serde-devel.sha256sum] = "989476e781ee13df3a4b56e76fd598ab8dcdf619d8d265b5ca9ae88f7ad7db0e"

URI_aarch64_rust-smartstring+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+std-devel-1.0.1-8.el10_1.noarch.rpm;name=aarch64_rust-smartstring+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+std-devel}"
SRC_URI[aarch64_rust-smartstring+std-devel.sha256sum] = "37c199309bd65c4e10775e0f8c2cf92cdd472802d1eebf273a7d5f630a07e1e5"

URI_aarch64_rust-smartstring+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring+test-devel-1.0.1-8.el10_1.noarch.rpm;name=aarch64_rust-smartstring+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring+test-devel}"
SRC_URI[aarch64_rust-smartstring+test-devel.sha256sum] = "ab02243e2b033fbff1de8a5d84e6e1793e5b5b6eaaa096681979282d298f1cb5"

URI_aarch64_rust-smartstring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smartstring-devel-1.0.1-8.el10_1.noarch.rpm;name=aarch64_rust-smartstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smartstring-devel}"
SRC_URI[aarch64_rust-smartstring-devel.sha256sum] = "c5a2e9cd2743c85e7d19fbe5c95de09f75ef8a502dca634ffbb201bf680b2c70"

RDEPENDS:rust-smartstring+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+default-devel = " \
 cargo \
 rust-smartstring+std-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+proptest-devel = " \
 cargo \
 rust-proptest+default-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+std-devel = " \
 cargo \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring+test-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-smartstring+arbitrary-devel \
 rust-smartstring+std-devel \
 rust-smartstring-devel \
 "
RDEPENDS:rust-smartstring-devel = " \
 cargo \
 rust \
 rust-autocfg+default-devel \
 rust-static_assertions+default-devel \
 rust-version_check+default-devel \
 "
