# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontactinterface"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kontactinterface \
 kontactinterface-devel \
 kontactinterface-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kontactinterface-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a672924106a7668c826cddf70604faf850bb5c036791ff969af5c84bb0d21a43"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface;unpack=0"
SRC_URI[x86_64_v2_kontactinterface.sha256sum] = "34daebb3192cd71cbbf4782c2a499af4802007729bf1565aabe1ceb7f8c7d980"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface-devel;unpack=0"
SRC_URI[x86_64_v2_kontactinterface-devel.sha256sum] = "fd592721e0486d8729a50bc71228a5b724a676116f0aff142197d064735b42c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kontactinterface-doc;unpack=0"
SRC_URI[x86_64_v2_kontactinterface-doc.sha256sum] = "20c5d99b8d04ac8ad73b474563c4652fe5d0604bc9fc937271c9197d2fdabf0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kontactinterface;unpack=0"
SRC_URI[aarch64_kontactinterface.sha256sum] = "faa56c60f506f73f2613b73b898716f3465635c67f054896960944d70282eaef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kontactinterface-devel;unpack=0"
SRC_URI[aarch64_kontactinterface-devel.sha256sum] = "06f81717463fd1f0ade9620d0bc3d91574396a593132931d4ac03a779c8251e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kontactinterface-doc;unpack=0"
SRC_URI[aarch64_kontactinterface-doc.sha256sum] = "d691e9e289e24f15d0ec04bd7a904a536e6f5d8b04c8643729226f36bce6e477"

RDEPENDS:kontactinterface = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kontactinterface-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kontactinterface \
 "
RDEPENDS:kontactinterface-doc = " \
 "
