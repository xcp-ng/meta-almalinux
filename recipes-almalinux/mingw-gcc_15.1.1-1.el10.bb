# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-gcc"
PV = "15.1.1"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 mingw32-cpp \
 mingw32-gcc \
 mingw32-gcc-c++ \
 mingw32-libgcc \
 mingw32-libstdc++ \
 mingw64-cpp \
 mingw64-gcc \
 mingw64-gcc-c++ \
 mingw64-libgcc \
 mingw64-libstdc++ \
"
PACKAGES:aarch64 = " \
 mingw32-cpp \
 mingw32-gcc \
 mingw32-gcc-c++ \
 mingw32-libgcc \
 mingw64-cpp \
 mingw64-gcc \
 mingw64-gcc-c++ \
 mingw64-libgcc \
"

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-gcc-15.1.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c516a61ff67d0de8c3747b00c47231c4205d43ddfd203ccf3e26b68da9ad39b5"

URI_x86_64_v2_mingw32-cpp = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-cpp-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-cpp}"
SRC_URI[x86_64_v2_mingw32-cpp.sha256sum] = "70f6eb58039681d153e7ae61b1b523a2829c8938e12226ad41fba33ac3e922c9"

URI_x86_64_v2_mingw32-gcc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-gcc-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-gcc}"
SRC_URI[x86_64_v2_mingw32-gcc.sha256sum] = "2c845fcca44e2ca0e23ccae0e066e1aca40a24c1b5f85f149fbbed6e8d9f7301"

URI_x86_64_v2_mingw32-gcc-c++ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-gcc-c++-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-gcc-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-gcc-c++}"
SRC_URI[x86_64_v2_mingw32-gcc-c++.sha256sum] = "28782cbdf036bd32417a689c09b7366ba49b47f2399c77bc2f47c31029dc425c"

URI_x86_64_v2_mingw32-libgcc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-libgcc-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-libgcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libgcc}"
SRC_URI[x86_64_v2_mingw32-libgcc.sha256sum] = "f7ea28d91a2daaaf0533a083323fead0524dba38b25f7e0816045c8ea57322d1"

URI_x86_64_v2_mingw32-libstdc++ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-libstdc++-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-libstdc++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-libstdc++}"
SRC_URI[x86_64_v2_mingw32-libstdc++.sha256sum] = "9b99778d8d58decf68c313c16ab406a3890901d449c8d5168824bbe7ac6d1ec2"

URI_x86_64_v2_mingw64-cpp = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-cpp-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-cpp}"
SRC_URI[x86_64_v2_mingw64-cpp.sha256sum] = "db2d6cbb362ea053b045c3f97de18241365fd5f3a02fbc72ee7419b4a7e392a8"

URI_x86_64_v2_mingw64-gcc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-gcc-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-gcc}"
SRC_URI[x86_64_v2_mingw64-gcc.sha256sum] = "3bad7a8aae4a1808b0ac38293bc244c8c29e261d6971ee09203f47d6f92804d4"

URI_x86_64_v2_mingw64-gcc-c++ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-gcc-c++-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-gcc-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-gcc-c++}"
SRC_URI[x86_64_v2_mingw64-gcc-c++.sha256sum] = "1a178c5103cf4f3665c324f996ca8841d9f732a45b0463219630deb10fa29dea"

URI_x86_64_v2_mingw64-libgcc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-libgcc-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-libgcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libgcc}"
SRC_URI[x86_64_v2_mingw64-libgcc.sha256sum] = "991ab692353c43a2e8ea6bebd7acb6167accd379415a5dfde987bb654bec8965"

URI_x86_64_v2_mingw64-libstdc++ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-libstdc++-15.1.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-libstdc++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-libstdc++}"
SRC_URI[x86_64_v2_mingw64-libstdc++.sha256sum] = "a6f981e3e383415d27c10e7f59d39cac84055492492de8795fea604bf5b1ff0c"

URI_aarch64_mingw32-cpp = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-cpp-15.1.1-1.el10.aarch64.rpm;name=aarch64_mingw32-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-cpp}"
SRC_URI[aarch64_mingw32-cpp.sha256sum] = "d749c31361798f38c7f23932be5c1f29a164c1f5f317fa8d053e5ba09391d5aa"

URI_aarch64_mingw32-gcc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-gcc-15.1.1-1.el10.aarch64.rpm;name=aarch64_mingw32-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-gcc}"
SRC_URI[aarch64_mingw32-gcc.sha256sum] = "7e14170a6cf4a91d0c321c245de0162ffa03016eaee58f4abc2cc4bee4e45e09"

URI_aarch64_mingw32-gcc-c++ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-gcc-c++-15.1.1-1.el10.aarch64.rpm;name=aarch64_mingw32-gcc-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-gcc-c++}"
SRC_URI[aarch64_mingw32-gcc-c++.sha256sum] = "342ce77e03f3e6694137bb0de38b4687788c645c914cecf79cd755be27daecea"

URI_aarch64_mingw32-libgcc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-libgcc-15.1.1-1.el10.aarch64.rpm;name=aarch64_mingw32-libgcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-libgcc}"
SRC_URI[aarch64_mingw32-libgcc.sha256sum] = "3610e4a1db8af8a54ac2d0b615ee0ae500d4bb477310e44445e3935f5262d30d"

URI_aarch64_mingw64-cpp = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-cpp-15.1.1-1.el10.aarch64.rpm;name=aarch64_mingw64-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-cpp}"
SRC_URI[aarch64_mingw64-cpp.sha256sum] = "6ba9fd6426d3ae6072774ecbcf12213b7ce1fa941ad64e22845d0eb98d348788"

URI_aarch64_mingw64-gcc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-gcc-15.1.1-1.el10.aarch64.rpm;name=aarch64_mingw64-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-gcc}"
SRC_URI[aarch64_mingw64-gcc.sha256sum] = "2301d71d38d5a66dd4d0106186bcab98b8cf7ad17f3ed82e396a5b6f5114fede"

URI_aarch64_mingw64-gcc-c++ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-gcc-c++-15.1.1-1.el10.aarch64.rpm;name=aarch64_mingw64-gcc-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-gcc-c++}"
SRC_URI[aarch64_mingw64-gcc-c++.sha256sum] = "31cb53a73fccec0c2a69abe9394492006c9f527e5d7e8df8b095324840efe32b"

URI_aarch64_mingw64-libgcc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-libgcc-15.1.1-1.el10.aarch64.rpm;name=aarch64_mingw64-libgcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-libgcc}"
SRC_URI[aarch64_mingw64-libgcc.sha256sum] = "43e212880de40fb915f5dc4690c79f8aa7e3e2700f89e5589c74af9a66c68ee3"

RDEPENDS:mingw32-cpp = " \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-filesystem \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw32-gcc = " \
 bash \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-binutils \
 mingw32-cpp \
 mingw32-crt \
 mingw32-headers \
 mingw32-libgcc \
 mingw32-winpthreads-static \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw32-gcc-c++ = " \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw32-gcc \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw32-libgcc = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-winpthreads \
 "
RDEPENDS:mingw32-libstdc++ = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 mingw32-winpthreads \
 "
RDEPENDS:mingw64-cpp = " \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw64-filesystem \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw64-gcc = " \
 bash \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw64-binutils \
 mingw64-cpp \
 mingw64-crt \
 mingw64-headers \
 mingw64-libgcc \
 mingw64-winpthreads-static \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw64-gcc-c++ = " \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 mingw64-gcc \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:mingw64-libgcc = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-winpthreads \
 "
RDEPENDS:mingw64-libstdc++ = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libgcc \
 mingw64-winpthreads \
 "
