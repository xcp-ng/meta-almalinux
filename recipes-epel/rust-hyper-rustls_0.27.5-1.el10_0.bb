# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper-rustls"
PV = "0.27.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-hyper-rustls+default-devel \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+http2-devel \
 rust-hyper-rustls+log-devel \
 rust-hyper-rustls+logging-devel \
 rust-hyper-rustls+native-tokio-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls+webpki-roots-devel \
 rust-hyper-rustls+webpki-tokio-devel \
 rust-hyper-rustls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-rustls-0.27.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "890d1ee4e276f0351300549f6b16bdaa40479724c6f1245eb0a3e4f4803d96f1"

URI_x86_64_v2_rust-hyper-rustls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+default-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+default-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+default-devel.sha256sum] = "9cb85a3fb021bbcfc0d2ba685af6f19416a546f07c7d2813618628f2511b5e73"

URI_x86_64_v2_rust-hyper-rustls+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+http1-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+http1-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+http1-devel.sha256sum] = "670fa333053129d922c05710f7c2083108fec4d6a0c30db2f122b75d25c63feb"

URI_x86_64_v2_rust-hyper-rustls+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+http2-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+http2-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+http2-devel.sha256sum] = "b7e735557f95921b794ed5c581e5c0f2aa03407daa97e1927f779d90601159f4"

URI_x86_64_v2_rust-hyper-rustls+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+log-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+log-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+log-devel.sha256sum] = "f3edd8205d064658dc2ed84e9d6fcc7df454990ce166ec2b5328592b43e3e578"

URI_x86_64_v2_rust-hyper-rustls+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+logging-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+logging-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+logging-devel.sha256sum] = "ef69bbad874727c0a085a993594e8138e5371a7e7d3773dea47afeb074c10d1e"

URI_x86_64_v2_rust-hyper-rustls+native-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+native-tokio-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+native-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+native-tokio-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+native-tokio-devel.sha256sum] = "1b1e0e28ef1159537f5a94e8a58fd458e54ba8a7c7ae2d4cbf10ccf4ecd578ce"

URI_x86_64_v2_rust-hyper-rustls+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+ring-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+ring-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+ring-devel.sha256sum] = "b5f12d3ce4969663a1a7921245c7494517b486fe52205945f7502a63ade9c7d8"

URI_x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+rustls-native-certs-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+rustls-native-certs-devel.sha256sum] = "aaf9c4118d7872879d8abbcd32f4cddc515fe457b8f9e94c1cb76d18338e17e4"

URI_x86_64_v2_rust-hyper-rustls+tls12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+tls12-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+tls12-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+tls12-devel.sha256sum] = "a0cc0e1cc4ad2caa1cd9bcd6100e92ef8c4fd251e0bea4a83817b9b9d7c9300f"

URI_x86_64_v2_rust-hyper-rustls+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+webpki-roots-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+webpki-roots-devel.sha256sum] = "d281bf2ca7a6dc92d5349e4577be4f5cb8b59d6677094121df35e0e7d8c24c75"

URI_x86_64_v2_rust-hyper-rustls+webpki-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls+webpki-tokio-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls+webpki-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls+webpki-tokio-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls+webpki-tokio-devel.sha256sum] = "6ccab1a69004ea839a94c2a54b0d9b9168c9b450118b57674c134de54df916be"

URI_x86_64_v2_rust-hyper-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-rustls-devel-0.27.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-rustls-devel}"
SRC_URI[x86_64_v2_rust-hyper-rustls-devel.sha256sum] = "67c6b1cfcbe97e035b96bb2744c32b177ce00545eb899c3855fbe68942d37848"

URI_aarch64_rust-hyper-rustls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+default-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+default-devel}"
SRC_URI[aarch64_rust-hyper-rustls+default-devel.sha256sum] = "a4edf172524e5dfcedcbfec98e3ac44ecb8eef8c217c1c0e795da4508018a927"

URI_aarch64_rust-hyper-rustls+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+http1-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+http1-devel}"
SRC_URI[aarch64_rust-hyper-rustls+http1-devel.sha256sum] = "5bb685699f9dde930daab35fbd815f530ec840830745af89f7f30b2be634285e"

URI_aarch64_rust-hyper-rustls+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+http2-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+http2-devel}"
SRC_URI[aarch64_rust-hyper-rustls+http2-devel.sha256sum] = "28413b034c4ba7b9a458b9b2bc2f245e5de3ab9f1536174289695e12e1e3a548"

URI_aarch64_rust-hyper-rustls+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+log-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+log-devel}"
SRC_URI[aarch64_rust-hyper-rustls+log-devel.sha256sum] = "cb2c3b9ee22bb9867e605f4a17b17b219edfa038c87462dc6da0fa0050d711de"

URI_aarch64_rust-hyper-rustls+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+logging-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+logging-devel}"
SRC_URI[aarch64_rust-hyper-rustls+logging-devel.sha256sum] = "c1210bb7637364e674d11a0f7d3985ff842d15e651f5f77304eff5d8aa577002"

URI_aarch64_rust-hyper-rustls+native-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+native-tokio-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+native-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+native-tokio-devel}"
SRC_URI[aarch64_rust-hyper-rustls+native-tokio-devel.sha256sum] = "782642e8f7be8a24359157ae4976a948ef35f3ca0d8ce404642947abee526a17"

URI_aarch64_rust-hyper-rustls+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+ring-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+ring-devel}"
SRC_URI[aarch64_rust-hyper-rustls+ring-devel.sha256sum] = "54d80966d89806da31c50e2338bcc7540783a19c6bb497d09d2bf9075629d4e0"

URI_aarch64_rust-hyper-rustls+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+rustls-native-certs-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-hyper-rustls+rustls-native-certs-devel.sha256sum] = "e4930796fbdf259885c1568ab42c4bac013c08d2ba728e2d7fc203e95141928b"

URI_aarch64_rust-hyper-rustls+tls12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+tls12-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+tls12-devel}"
SRC_URI[aarch64_rust-hyper-rustls+tls12-devel.sha256sum] = "d7e9370adff398a8e56937f441abd49581944eb8df322cb77d1c3c3f3b15c904"

URI_aarch64_rust-hyper-rustls+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+webpki-roots-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+webpki-roots-devel}"
SRC_URI[aarch64_rust-hyper-rustls+webpki-roots-devel.sha256sum] = "6398b298139dd9a98db0b7245aa0529c97c2d32f7f9ce4f6de7c2f2f284caee0"

URI_aarch64_rust-hyper-rustls+webpki-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls+webpki-tokio-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls+webpki-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls+webpki-tokio-devel}"
SRC_URI[aarch64_rust-hyper-rustls+webpki-tokio-devel.sha256sum] = "588d3d7fef06ad6f01e1287b85702467dabbad60661d1001ea5f971463ca479c"

URI_aarch64_rust-hyper-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-rustls-devel-0.27.5-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-rustls-devel}"
SRC_URI[aarch64_rust-hyper-rustls-devel.sha256sum] = "37e159719b3b7ba363c316d423b620138f045f01da8154162d24264074e77e77"

RDEPENDS:rust-hyper-rustls+default-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+logging-devel \
 rust-hyper-rustls+native-tokio-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 "
RDEPENDS:rust-hyper-rustls+http1-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-hyper-util+http1-devel \
 "
RDEPENDS:rust-hyper-rustls+http2-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-hyper-util+http2-devel \
 "
RDEPENDS:rust-hyper-rustls+log-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-hyper-rustls+logging-devel = " \
 cargo \
 rust-hyper-rustls+log-devel \
 rust-hyper-rustls-devel \
 rust-rustls+logging-devel \
 rust-tokio-rustls+logging-devel \
 "
RDEPENDS:rust-hyper-rustls+native-tokio-devel = " \
 cargo \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls-devel \
 "
RDEPENDS:rust-hyper-rustls+ring-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls+ring-devel \
 "
RDEPENDS:rust-hyper-rustls+rustls-native-certs-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls-native-certs+default-devel \
 "
RDEPENDS:rust-hyper-rustls+tls12-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-rustls+tls12-devel \
 rust-tokio-rustls+tls12-devel \
 "
RDEPENDS:rust-hyper-rustls+webpki-roots-devel = " \
 cargo \
 rust-hyper-rustls-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-hyper-rustls+webpki-tokio-devel = " \
 cargo \
 rust-hyper-rustls+webpki-roots-devel \
 rust-hyper-rustls-devel \
 "
RDEPENDS:rust-hyper-rustls-devel = " \
 bash \
 cargo \
 rust \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-hyper-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-rustls-devel \
 rust-rustls-pki-types+default-devel \
 rust-tokio+default-devel \
 rust-tokio-rustls-devel \
 rust-tower-service+default-devel \
 "
