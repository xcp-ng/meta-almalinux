# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-syrupy"
PV = "4.9.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-syrupy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-syrupy-4.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40c9374973b715513eed0e2cc8e8b58a2ae77488e4cd4c35acdf4ec7640f4a09"

URI_x86_64_v2_python3-syrupy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-syrupy-4.9.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-syrupy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-syrupy}"
SRC_URI[x86_64_v2_python3-syrupy.sha256sum] = "6a6460d02928951bc923f44ee4f278aa2ebebaefd3327f34c33d9ce26fb9024e"

URI_aarch64_python3-syrupy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-syrupy-4.9.1-1.el10_1.noarch.rpm;name=aarch64_python3-syrupy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-syrupy}"
SRC_URI[aarch64_python3-syrupy.sha256sum] = "4f1ff64de41060c69cddbff4e77ad09ae03942ef947c171589bd7e6948f770ca"

RDEPENDS:python3-syrupy = " \
 python3 \
 python3-pytest \
 "
