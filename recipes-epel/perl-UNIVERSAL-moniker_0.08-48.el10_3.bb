# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-UNIVERSAL-moniker"
PV = "0.08"
PR = "48.el10_3"
PACKAGES = " \
 perl-UNIVERSAL-moniker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-UNIVERSAL-moniker-0.08-48.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dc01b7c7c6be59d13ae4cee5b8af7ae4a190c120ed7809d02ffaa0957bb4f6a"

URI_x86_64_v2_perl-UNIVERSAL-moniker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-UNIVERSAL-moniker-0.08-48.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-UNIVERSAL-moniker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-UNIVERSAL-moniker}"
SRC_URI[x86_64_v2_perl-UNIVERSAL-moniker.sha256sum] = "281d10fe0b19c9e46bb4a334d2e31c30f7013ba5ffb4cdc156b925add321b1a0"

URI_aarch64_perl-UNIVERSAL-moniker = "${EPEL_MIRROR}/aarch64/Packages/p/perl-UNIVERSAL-moniker-0.08-48.el10_3.noarch.rpm;name=aarch64_perl-UNIVERSAL-moniker;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-UNIVERSAL-moniker}"
SRC_URI[aarch64_perl-UNIVERSAL-moniker.sha256sum] = "b89df28e711cb27777025fca799bcee8bf8b18988d9e4892a738d314176149e6"

RDEPENDS:perl-UNIVERSAL-moniker = " \
 perl-libs \
 "
