# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtquickcontrols"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtquickcontrols \
 qt5-qtquickcontrols-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtquickcontrols-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "155b96cb5c7ecec9dd5231eed74944ed73f55ca526baa6ae7c5a2b284c2ba5a9"

URI_x86_64_v2_qt5-qtquickcontrols = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols.sha256sum] = "f05c06c8dbb695d6754ab9951643db8584a6b11ee3fc3e8c2e0645cfb32c0800"

URI_x86_64_v2_qt5-qtquickcontrols-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols-examples}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols-examples.sha256sum] = "2dbef270e6014293068a3f890d79f1975bc43a52065476e6526520e95aa2d6cd"

URI_aarch64_qt5-qtquickcontrols = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtquickcontrols;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols}"
SRC_URI[aarch64_qt5-qtquickcontrols.sha256sum] = "3f4c60bda5b7c11adb01cd740b79f9112ceda2767b675665191c51da137ed0ea"

URI_aarch64_qt5-qtquickcontrols-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtquickcontrols-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols-examples}"
SRC_URI[aarch64_qt5-qtquickcontrols-examples.sha256sum] = "fc9372ab2e0d2ff6bf85036b271b8219aef5e39c629044254a1ea586f95ee51d"

RDEPENDS:qt5-qtquickcontrols = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtquickcontrols-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtquickcontrols \
 "
