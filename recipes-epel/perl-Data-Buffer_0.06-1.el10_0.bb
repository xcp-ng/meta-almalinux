# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Buffer"
PV = "0.06"
PR = "1.el10_0"
PACKAGES = " \
 perl-Data-Buffer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Buffer-0.06-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b11828525cc1ce3fc813b4796f111f92e01d6e344347855737f4b21cf7a7f5a"

URI_x86_64_v2_perl-Data-Buffer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Buffer-0.06-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Buffer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Buffer}"
SRC_URI[x86_64_v2_perl-Data-Buffer.sha256sum] = "3c0b9e165509ad3b58ba3c1ea694737eb16b6bc8c168b0f6f6dc82043537f449"

URI_aarch64_perl-Data-Buffer = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Buffer-0.06-1.el10_0.noarch.rpm;name=aarch64_perl-Data-Buffer;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Buffer}"
SRC_URI[aarch64_perl-Data-Buffer.sha256sum] = "cbcc7d8076baeb2068d23a1ee8c458347941a884b3afbb5f6a7c917f5c32465e"

RDEPENDS:perl-Data-Buffer = " \
 perl-libs \
 perl-vars \
 "
