# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-asa"
PV = "1.04"
PR = "18.el10_0"
PACKAGES = " \
 perl-asa \
 perl-asa-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-asa-1.04-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3ded71c4a1be2c5c7abd10df77f0ec82678a4877b62a2e7761854df8089dfaf"

URI_x86_64_v2_perl-asa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-asa-1.04-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-asa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-asa}"
SRC_URI[x86_64_v2_perl-asa.sha256sum] = "6a7308dc0264ea42f4e2e0c921eb28c0596dbba75a28ec8fb98b087eff5a81f3"

URI_x86_64_v2_perl-asa-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-asa-tests-1.04-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-asa-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-asa-tests}"
SRC_URI[x86_64_v2_perl-asa-tests.sha256sum] = "63d0c1033b05d00174bfb85de8cccc5efd31be88ccabf86cee7a586102934900"

URI_aarch64_perl-asa = "${EPEL_MIRROR}/aarch64/Packages/p/perl-asa-1.04-18.el10_0.noarch.rpm;name=aarch64_perl-asa;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-asa}"
SRC_URI[aarch64_perl-asa.sha256sum] = "25cb7d3dfa0f5915379a3e7b1c907cefa2928cc380e81feea71375353cdfd887"

URI_aarch64_perl-asa-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-asa-tests-1.04-18.el10_0.noarch.rpm;name=aarch64_perl-asa-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-asa-tests}"
SRC_URI[aarch64_perl-asa-tests.sha256sum] = "d6e32acd144ca6c1be2b17915f0e1800ba7a518ad28d915077de38590cb49973"

RDEPENDS:perl-asa = " \
 perl-Carp \
 perl-libs \
 "
RDEPENDS:perl-asa-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-asa \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
