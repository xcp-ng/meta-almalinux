# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Requirements-Dynamic"
PV = "0.003"
PR = "1.el10_2"
PACKAGES = " \
 perl-CPAN-Requirements-Dynamic \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-CPAN-Requirements-Dynamic-0.003-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "69e7573e25e269c2d9daec393db974ffc84652aa05a5a145524ae87772c11cc1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-Requirements-Dynamic-0.003-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-Requirements-Dynamic;unpack=0"
SRC_URI[x86_64_v2_perl-CPAN-Requirements-Dynamic.sha256sum] = "069b88fe031f9ad79903c1cf00fd684129b65a780c62209210f6b40d413cee0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-Requirements-Dynamic-0.003-1.el10_2.noarch.rpm;name=aarch64_perl-CPAN-Requirements-Dynamic;unpack=0"
SRC_URI[aarch64_perl-CPAN-Requirements-Dynamic.sha256sum] = "05cad42a277dff4b0eaf942c3dcf910703dc046e4c2ea78a512d57a52abc8d72"

RDEPENDS:perl-CPAN-Requirements-Dynamic = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Carp \
 perl-ExtUtils-Config \
 perl-ExtUtils-HasCompiler \
 perl-IPC-Cmd \
 perl-Perl-OSType \
 perl-libs \
 "
