# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum0.26"
PV = "0.26.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-strum0.26+default-devel \
 rust-strum0.26+derive-devel \
 rust-strum0.26+phf-devel \
 rust-strum0.26+std-devel \
 rust-strum0.26+strum_macros-devel \
 rust-strum0.26-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum0.26-0.26.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "733be7694480889297c9f3d2ec5ae697a1aee7f5753fbf688244162d1f35ed18"

URI_x86_64_v2_rust-strum0.26+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.26+default-devel-0.26.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.26+default-devel}"
SRC_URI[x86_64_v2_rust-strum0.26+default-devel.sha256sum] = "2930461709ef72626630b053f38b878a580c17a99d4da910ff50ee629b5bf667"

URI_x86_64_v2_rust-strum0.26+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.26+derive-devel-0.26.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.26+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.26+derive-devel}"
SRC_URI[x86_64_v2_rust-strum0.26+derive-devel.sha256sum] = "8f6ac36b0e4d1ba555566b97a4c7956c48c6d06a6b4b5fa354ab580c74ed3666"

URI_x86_64_v2_rust-strum0.26+phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.26+phf-devel-0.26.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.26+phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.26+phf-devel}"
SRC_URI[x86_64_v2_rust-strum0.26+phf-devel.sha256sum] = "8ce37fc30d35c188c91610ca017ec6ab950f93266315a7120b279c28efed1fdc"

URI_x86_64_v2_rust-strum0.26+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.26+std-devel-0.26.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.26+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.26+std-devel}"
SRC_URI[x86_64_v2_rust-strum0.26+std-devel.sha256sum] = "9001348ca86550a378f148f9b30d567da31777706eba15491d36f3cc68a7a6f1"

URI_x86_64_v2_rust-strum0.26+strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.26+strum_macros-devel-0.26.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.26+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.26+strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum0.26+strum_macros-devel.sha256sum] = "9ef4f0b61b1c539e4e2b15941d3f62126e1d4c82d91fc4b5a16a694233e4b827"

URI_x86_64_v2_rust-strum0.26-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.26-devel-0.26.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.26-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.26-devel}"
SRC_URI[x86_64_v2_rust-strum0.26-devel.sha256sum] = "2106ed2826d7ddc6eff7ec976952d42a12bc6901df62b032b8e07a726ba5e369"

URI_aarch64_rust-strum0.26+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.26+default-devel-0.26.3-1.el10_1.noarch.rpm;name=aarch64_rust-strum0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.26+default-devel}"
SRC_URI[aarch64_rust-strum0.26+default-devel.sha256sum] = "facd4ffdc606bb434ffd2ba4c4e5ae0e6686905fd2b43f19b64ba44e78ca51e0"

URI_aarch64_rust-strum0.26+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.26+derive-devel-0.26.3-1.el10_1.noarch.rpm;name=aarch64_rust-strum0.26+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.26+derive-devel}"
SRC_URI[aarch64_rust-strum0.26+derive-devel.sha256sum] = "1ac8180d9566490e4abc36c5ad14390eb074adc8912b5235fbcc3b81232ccfc6"

URI_aarch64_rust-strum0.26+phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.26+phf-devel-0.26.3-1.el10_1.noarch.rpm;name=aarch64_rust-strum0.26+phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.26+phf-devel}"
SRC_URI[aarch64_rust-strum0.26+phf-devel.sha256sum] = "5b576905fe579c1fe525d88431eecd068a142c12472eb25a2e0f4bf58893558d"

URI_aarch64_rust-strum0.26+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.26+std-devel-0.26.3-1.el10_1.noarch.rpm;name=aarch64_rust-strum0.26+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.26+std-devel}"
SRC_URI[aarch64_rust-strum0.26+std-devel.sha256sum] = "ed684377d0361ed2aaadf668046a8c6b4863f512ebb09db921251245cb674199"

URI_aarch64_rust-strum0.26+strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.26+strum_macros-devel-0.26.3-1.el10_1.noarch.rpm;name=aarch64_rust-strum0.26+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.26+strum_macros-devel}"
SRC_URI[aarch64_rust-strum0.26+strum_macros-devel.sha256sum] = "18dd240c541f9cc405492fae3ee24b4e1b099dc03c9cd14b23c5618941065a6c"

URI_aarch64_rust-strum0.26-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.26-devel-0.26.3-1.el10_1.noarch.rpm;name=aarch64_rust-strum0.26-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.26-devel}"
SRC_URI[aarch64_rust-strum0.26-devel.sha256sum] = "1e91eba86592fdf6679f3e930134e77f14c9c1b399ab7a6027b8dfa8156dd905"

RDEPENDS:rust-strum0.26+default-devel = " \
 cargo \
 rust-strum0.26+std-devel \
 rust-strum0.26-devel \
 "
RDEPENDS:rust-strum0.26+derive-devel = " \
 cargo \
 rust-strum0.26+strum_macros-devel \
 rust-strum0.26-devel \
 "
RDEPENDS:rust-strum0.26+phf-devel = " \
 cargo \
 rust-phf0.11+default-devel \
 rust-phf0.11+macros-devel \
 rust-strum0.26-devel \
 "
RDEPENDS:rust-strum0.26+std-devel = " \
 cargo \
 rust-strum0.26-devel \
 "
RDEPENDS:rust-strum0.26+strum_macros-devel = " \
 cargo \
 rust-strum0.26-devel \
 rust-strum_macros0.26+default-devel \
 "
RDEPENDS:rust-strum0.26-devel = " \
 cargo \
 "
