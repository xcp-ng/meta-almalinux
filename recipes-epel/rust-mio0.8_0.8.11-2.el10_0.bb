# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mio0.8"
PV = "0.8.11"
PR = "2.el10_0"
PACKAGES = " \
 rust-mio0.8+default-devel \
 rust-mio0.8+log-devel \
 rust-mio0.8+net-devel \
 rust-mio0.8+os-ext-devel \
 rust-mio0.8+os-poll-devel \
 rust-mio0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mio0.8-0.8.11-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66a57ace3ecf1e4d7832a29b7419f825f87b49d86e910b1eb38a9207e7fb0999"

URI_x86_64_v2_rust-mio0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+default-devel-0.8.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+default-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+default-devel.sha256sum] = "f5e0ff9bb5fb2ad7e0b56c55d8cee5fd3cf1fc78e7f4586097668ee5df5135aa"

URI_x86_64_v2_rust-mio0.8+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+log-devel-0.8.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+log-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+log-devel.sha256sum] = "6844911b82420895d9d4612c4dbe25c8db86cfbf3147206e3bb7fb1e67220016"

URI_x86_64_v2_rust-mio0.8+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+net-devel-0.8.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+net-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+net-devel.sha256sum] = "b778f9989af8841c6f4f8e2330dfdd0a11c05db62966c7d09e1959ae12799f5b"

URI_x86_64_v2_rust-mio0.8+os-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+os-ext-devel-0.8.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+os-ext-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+os-ext-devel.sha256sum] = "bc8f5324344262565068d4c40f53d6c67abbf4e141de6d919ce61288d8e9e453"

URI_x86_64_v2_rust-mio0.8+os-poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+os-poll-devel-0.8.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+os-poll-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+os-poll-devel.sha256sum] = "c1227a01469c5ff93c1a3c62dd13a13eebc74ec70edc92c4f2183ee5f025532c"

URI_x86_64_v2_rust-mio0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8-devel-0.8.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8-devel}"
SRC_URI[x86_64_v2_rust-mio0.8-devel.sha256sum] = "fba50494e2858fffe45c90fca543f16bcee591b8bb6c1aff586b44941f00ae9a"

URI_aarch64_rust-mio0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+default-devel-0.8.11-2.el10_0.noarch.rpm;name=aarch64_rust-mio0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+default-devel}"
SRC_URI[aarch64_rust-mio0.8+default-devel.sha256sum] = "89f03032cc34a63839031f387b5e1ae3f63a1595dc6987debbd0336d426c7fd3"

URI_aarch64_rust-mio0.8+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+log-devel-0.8.11-2.el10_0.noarch.rpm;name=aarch64_rust-mio0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+log-devel}"
SRC_URI[aarch64_rust-mio0.8+log-devel.sha256sum] = "8ae24d4407d0768a807754228dc53fff610da76e07178d4f3e73b71c364f2386"

URI_aarch64_rust-mio0.8+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+net-devel-0.8.11-2.el10_0.noarch.rpm;name=aarch64_rust-mio0.8+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+net-devel}"
SRC_URI[aarch64_rust-mio0.8+net-devel.sha256sum] = "dbf7378c17e606bd21342f414ea10c5d957bdfedc240c6c8e3e49eef28439960"

URI_aarch64_rust-mio0.8+os-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+os-ext-devel-0.8.11-2.el10_0.noarch.rpm;name=aarch64_rust-mio0.8+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+os-ext-devel}"
SRC_URI[aarch64_rust-mio0.8+os-ext-devel.sha256sum] = "69e269ec9d6ad56e18431dbc5c16f6513b5c02a086ade95db1a42c7980ec3b73"

URI_aarch64_rust-mio0.8+os-poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+os-poll-devel-0.8.11-2.el10_0.noarch.rpm;name=aarch64_rust-mio0.8+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+os-poll-devel}"
SRC_URI[aarch64_rust-mio0.8+os-poll-devel.sha256sum] = "06940b5925b56dc91071a7d6a74cac814737bf368b679fed0deb0fb34b596a52"

URI_aarch64_rust-mio0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8-devel-0.8.11-2.el10_0.noarch.rpm;name=aarch64_rust-mio0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8-devel}"
SRC_URI[aarch64_rust-mio0.8-devel.sha256sum] = "05781d70908acba9225603a9af52a1e1c4ef5d7b7a72473b0b29d491100ba4eb"

RDEPENDS:rust-mio0.8+default-devel = " \
 cargo \
 rust-mio0.8+log-devel \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8+net-devel = " \
 cargo \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8+os-ext-devel = " \
 cargo \
 rust-mio0.8+os-poll-devel \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8+os-poll-devel = " \
 cargo \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8-devel = " \
 cargo \
 rust-libc+default-devel \
 "
