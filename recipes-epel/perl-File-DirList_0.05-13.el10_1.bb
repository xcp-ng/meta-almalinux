# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-DirList"
PV = "0.05"
PR = "13.el10_1"
PACKAGES = " \
 perl-File-DirList \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-DirList-0.05-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d42c17fc6846d8ec119df68647ab410f350285deedb5b38b163dca46cb20e53c"

URI_x86_64_v2_perl-File-DirList = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-DirList-0.05-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-DirList;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-DirList}"
SRC_URI[x86_64_v2_perl-File-DirList.sha256sum] = "b74af565eecb549f41faf4e80f517e177f918df235fe1699522f5f870374f4ce"

URI_aarch64_perl-File-DirList = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-DirList-0.05-13.el10_1.noarch.rpm;name=aarch64_perl-File-DirList;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-DirList}"
SRC_URI[aarch64_perl-File-DirList.sha256sum] = "44985fe5e7702d5d27556c10bfc80cf3ec8e952d119aa4d14fe801da6b96a658"

RDEPENDS:perl-File-DirList = " \
 perl-DirHandle \
 perl-Exporter \
 perl-PathTools \
 perl-libs \
 "
