# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pooch"
PV = "1.8.2"
PR = "5.el10_1"
PACKAGES = " \
 python3-pooch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pooch-1.8.2-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "802cbba2220f80142ac747881dd45551ba23b8caad28a93dff02b4e7955b5a45"

URI_x86_64_v2_python3-pooch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pooch-1.8.2-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pooch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pooch}"
SRC_URI[x86_64_v2_python3-pooch.sha256sum] = "fa1582c86441bff7d11fc62cbb5833efaaa4f2fd180b8bc1ab3d994b6002d10b"

URI_aarch64_python3-pooch = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pooch-1.8.2-5.el10_1.noarch.rpm;name=aarch64_python3-pooch;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pooch}"
SRC_URI[aarch64_python3-pooch.sha256sum] = "182af9b2f0f72e3831fe1a17c4bfab7478dc3ee378cec5da4fae3e99adc51a1b"

RDEPENDS:python3-pooch = " \
 python3 \
 python3-packaging \
 python3-platformdirs \
 python3-requests \
 "
