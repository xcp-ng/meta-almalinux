# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxkbcommon"
PV = "1.7.0"
PR = "4.el10"
PACKAGES = " \
 libxkbcommon \
 libxkbcommon-devel \
 libxkbcommon-x11 \
 libxkbcommon-x11-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libxkbcommon-1.7.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c8bc1bc8da618b781d226b3f16666991c42c40484cd63636956c29b7ba00f60"

URI_x86_64_v2_libxkbcommon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxkbcommon-1.7.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_libxkbcommon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxkbcommon}"
SRC_URI[x86_64_v2_libxkbcommon.sha256sum] = "cd7b47d73bb1f9b408df8eace1baa45599c9de049c08f8cd85f897c09ad8b77c"

URI_x86_64_v2_libxkbcommon-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxkbcommon-devel-1.7.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_libxkbcommon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxkbcommon-devel}"
SRC_URI[x86_64_v2_libxkbcommon-devel.sha256sum] = "372f4f17405f70773e67d98b964956f8d06c9b9cf2cfbd8194c496aff09eb47a"

URI_x86_64_v2_libxkbcommon-x11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxkbcommon-x11-1.7.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_libxkbcommon-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxkbcommon-x11}"
SRC_URI[x86_64_v2_libxkbcommon-x11.sha256sum] = "f98f73110a7ea79d0cfa8a7de2509261057b437b509244f0eb35b33ed6e4f1f3"

URI_x86_64_v2_libxkbcommon-x11-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxkbcommon-x11-devel-1.7.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_libxkbcommon-x11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxkbcommon-x11-devel}"
SRC_URI[x86_64_v2_libxkbcommon-x11-devel.sha256sum] = "410bc37e802e1e9e208b287741258feedeec12a98be07a58b26013e2b337b732"

URI_aarch64_libxkbcommon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxkbcommon-1.7.0-4.el10.aarch64.rpm;name=aarch64_libxkbcommon;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxkbcommon}"
SRC_URI[aarch64_libxkbcommon.sha256sum] = "3cf06b8dc99ec8660497a4b9d93b37b69d73ff187162f4e7e84e38fc405d65ee"

URI_aarch64_libxkbcommon-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxkbcommon-devel-1.7.0-4.el10.aarch64.rpm;name=aarch64_libxkbcommon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxkbcommon-devel}"
SRC_URI[aarch64_libxkbcommon-devel.sha256sum] = "d7bccd63fdd233b17a036014d5efa72947c472221f0d963df162f18a824bb478"

URI_aarch64_libxkbcommon-x11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxkbcommon-x11-1.7.0-4.el10.aarch64.rpm;name=aarch64_libxkbcommon-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxkbcommon-x11}"
SRC_URI[aarch64_libxkbcommon-x11.sha256sum] = "0c36ddb5ee805f7b2acbb942b7f998a29b1bcbbda4b52c9fc4c96f54286b6cce"

URI_aarch64_libxkbcommon-x11-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxkbcommon-x11-devel-1.7.0-4.el10.aarch64.rpm;name=aarch64_libxkbcommon-x11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxkbcommon-x11-devel}"
SRC_URI[aarch64_libxkbcommon-x11-devel.sha256sum] = "c8440a89eec80c72cdf2b9ca6f930bc2e22ab63e186dc56bfd1c3d6ed32027ce"

RDEPENDS:libxkbcommon = " \
 glibc \
 libxml2 \
 xkeyboard-config \
 "
RDEPENDS:libxkbcommon-devel = " \
 libxkbcommon \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libxkbcommon-x11 = " \
 glibc \
 libxcb \
 libxkbcommon \
 "
RDEPENDS:libxkbcommon-x11-devel = " \
 libxcb-devel \
 libxkbcommon-devel \
 libxkbcommon-x11 \
 pkgconf-pkg-config \
 "
