# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates2"
PV = "2.1.5"
PR = "4.el10_0"
PACKAGES = " \
 rust-predicates2+default-devel \
 rust-predicates2+diff-devel \
 rust-predicates2+float-cmp-devel \
 rust-predicates2+normalize-line-endings-devel \
 rust-predicates2+regex-devel \
 rust-predicates2+unstable-devel \
 rust-predicates2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates2-2.1.5-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "249ce1403f9c6a9a2997a20315760da56d93ef8a182d60e6519e97a8f142cb98"

URI_x86_64_v2_rust-predicates2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates2+default-devel-2.1.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates2+default-devel}"
SRC_URI[x86_64_v2_rust-predicates2+default-devel.sha256sum] = "fd2b549e6ca765d6a9b9d9b01a54c0d9a4b8e0cbe6b30107c8b28751b69b4360"

URI_x86_64_v2_rust-predicates2+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates2+diff-devel-2.1.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates2+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates2+diff-devel}"
SRC_URI[x86_64_v2_rust-predicates2+diff-devel.sha256sum] = "7ec51cdc9bca1b6f154cc0d69b8bd61454290a3416473b4703e4118df04c2166"

URI_x86_64_v2_rust-predicates2+float-cmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates2+float-cmp-devel-2.1.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates2+float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates2+float-cmp-devel}"
SRC_URI[x86_64_v2_rust-predicates2+float-cmp-devel.sha256sum] = "3717bcf270e3275f15065e6b3bf4efb921f0759cc46259446b078dd74b786a19"

URI_x86_64_v2_rust-predicates2+normalize-line-endings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates2+normalize-line-endings-devel-2.1.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates2+normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates2+normalize-line-endings-devel}"
SRC_URI[x86_64_v2_rust-predicates2+normalize-line-endings-devel.sha256sum] = "6e8bbedf3d008e3568d25500d4f5c691eb71693266d22ad631509a7f2ba7e273"

URI_x86_64_v2_rust-predicates2+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates2+regex-devel-2.1.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates2+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates2+regex-devel}"
SRC_URI[x86_64_v2_rust-predicates2+regex-devel.sha256sum] = "e0b4c2b1732efb4e86b8ab52b37ad5c4dcaa5411635e3dfdcd39a53a678c4d6b"

URI_x86_64_v2_rust-predicates2+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates2+unstable-devel-2.1.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates2+unstable-devel}"
SRC_URI[x86_64_v2_rust-predicates2+unstable-devel.sha256sum] = "ea38509bc8ae80efdc2adc1cc3ed8d9ce9912cda7864a7a53bddb1ca94278aba"

URI_x86_64_v2_rust-predicates2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates2-devel-2.1.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates2-devel}"
SRC_URI[x86_64_v2_rust-predicates2-devel.sha256sum] = "1c953391d442519af39aca9dd3a4d5ab49615ee234bedc9fabee86c5487db60f"

URI_aarch64_rust-predicates2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates2+default-devel-2.1.5-4.el10_0.noarch.rpm;name=aarch64_rust-predicates2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates2+default-devel}"
SRC_URI[aarch64_rust-predicates2+default-devel.sha256sum] = "a0d49e75c0cef34f83ad3640fffcbb0851608ae928d463e90d2fdbda3b7be002"

URI_aarch64_rust-predicates2+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates2+diff-devel-2.1.5-4.el10_0.noarch.rpm;name=aarch64_rust-predicates2+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates2+diff-devel}"
SRC_URI[aarch64_rust-predicates2+diff-devel.sha256sum] = "5b557798980ed0efea6c302ead6b865468fe7d53060e8e798b9c53cc095833f1"

URI_aarch64_rust-predicates2+float-cmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates2+float-cmp-devel-2.1.5-4.el10_0.noarch.rpm;name=aarch64_rust-predicates2+float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates2+float-cmp-devel}"
SRC_URI[aarch64_rust-predicates2+float-cmp-devel.sha256sum] = "433f9a1e90902349debb9110d4cac7793ab297ead4f879d54d9e934bebc4aa76"

URI_aarch64_rust-predicates2+normalize-line-endings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates2+normalize-line-endings-devel-2.1.5-4.el10_0.noarch.rpm;name=aarch64_rust-predicates2+normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates2+normalize-line-endings-devel}"
SRC_URI[aarch64_rust-predicates2+normalize-line-endings-devel.sha256sum] = "2dd16dec15cdcfcee0da6d24b73ecb00c90d81c65d8711f9ff8217df03c3447c"

URI_aarch64_rust-predicates2+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates2+regex-devel-2.1.5-4.el10_0.noarch.rpm;name=aarch64_rust-predicates2+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates2+regex-devel}"
SRC_URI[aarch64_rust-predicates2+regex-devel.sha256sum] = "13344fe4f0e16133c040c520df4a53be5494714bdb325da7c549daafc47a6545"

URI_aarch64_rust-predicates2+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates2+unstable-devel-2.1.5-4.el10_0.noarch.rpm;name=aarch64_rust-predicates2+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates2+unstable-devel}"
SRC_URI[aarch64_rust-predicates2+unstable-devel.sha256sum] = "c9fb2c99b41f6e99df7e9571085e79aa135af327d173ae0873eb0a10164c2ed5"

URI_aarch64_rust-predicates2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates2-devel-2.1.5-4.el10_0.noarch.rpm;name=aarch64_rust-predicates2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates2-devel}"
SRC_URI[aarch64_rust-predicates2-devel.sha256sum] = "dc32997b59fb5770b2855b0f86653944277bdfe8226fdd3624f2afb0cb3ea740"

RDEPENDS:rust-predicates2+default-devel = " \
 cargo \
 rust-predicates2+diff-devel \
 rust-predicates2+float-cmp-devel \
 rust-predicates2+normalize-line-endings-devel \
 rust-predicates2+regex-devel \
 rust-predicates2-devel \
 "
RDEPENDS:rust-predicates2+diff-devel = " \
 cargo \
 rust-difflib+default-devel \
 rust-predicates2-devel \
 "
RDEPENDS:rust-predicates2+float-cmp-devel = " \
 cargo \
 rust-float-cmp0.9+default-devel \
 rust-predicates2-devel \
 "
RDEPENDS:rust-predicates2+normalize-line-endings-devel = " \
 cargo \
 rust-normalize-line-endings+default-devel \
 rust-predicates2-devel \
 "
RDEPENDS:rust-predicates2+regex-devel = " \
 cargo \
 rust-predicates2-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-predicates2+unstable-devel = " \
 cargo \
 rust-predicates2-devel \
 "
RDEPENDS:rust-predicates2-devel = " \
 cargo \
 rust \
 rust-itertools0.10+default-devel \
 rust-predicates-core+default-devel \
 "
