# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-si"
PV = "0.2.1"
PR = "34.el10"
PACKAGES = " \
 hunspell-si \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-si-0.2.1-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f3da04312b189879647a29f78c137c3e229f01d13c487d551e7c7d5fad57b11"

URI_x86_64_v2_hunspell-si = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-si-0.2.1-34.el10.noarch.rpm;name=x86_64_v2_hunspell-si;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-si}"
SRC_URI[x86_64_v2_hunspell-si.sha256sum] = "12504e57114de7018fff775deccece53d5158227310339e00c47d41e5e7b035e"

URI_aarch64_hunspell-si = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-si-0.2.1-34.el10.noarch.rpm;name=aarch64_hunspell-si;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-si}"
SRC_URI[aarch64_hunspell-si.sha256sum] = "12504e57114de7018fff775deccece53d5158227310339e00c47d41e5e7b035e"

RDEPENDS:hunspell-si = " \
 hunspell \
 "
