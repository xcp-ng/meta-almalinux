# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc"
PE = "1"
PV = "3.0.24"
PR = "1.el10_3"
PACKAGES = " \
 vlc \
 vlc-cli \
 vlc-devel \
 vlc-gui-ncurses \
 vlc-gui-qt \
 vlc-gui-skins2 \
 vlc-libs \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pulseaudio \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-all \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vlc-3.0.24-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2f1905cddc6fbf107fce73a4055555a066e9a1a4c2bb152b7c707c3b56f18cb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc;unpack=0"
SRC_URI[x86_64_v2_vlc.sha256sum] = "0ce5f7f5bab22e066f83c5697e144144d302cbf3247b419c365c70425932855f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-cli-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-cli;unpack=0"
SRC_URI[x86_64_v2_vlc-cli.sha256sum] = "d3ab1b32cfc47d5848fc6ef5d5b50597d6666aaabd78c89d3c8920bfb46bb14a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-devel-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-devel;unpack=0"
SRC_URI[x86_64_v2_vlc-devel.sha256sum] = "d01a8e4d5b9d30b2a7838b9475e2cb15bb5fd76a49e630b7e6b6adf4e47444f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-ncurses-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-ncurses;unpack=0"
SRC_URI[x86_64_v2_vlc-gui-ncurses.sha256sum] = "bae01d4d8ef8dba34e8655a5ee8b50647cdbca86f36d21b637665f475146e298"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-qt-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-qt;unpack=0"
SRC_URI[x86_64_v2_vlc-gui-qt.sha256sum] = "7d1a6624a2c19f7c28f1f14b1a01d3e589f7da7c7068bb961ce40e0d03bccdfa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-skins2-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-skins2;unpack=0"
SRC_URI[x86_64_v2_vlc-gui-skins2.sha256sum] = "7a49ce69b51f4bdf3d9e2cdac393f62b3c9655f4ed05909ba384e0151ae672ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-libs-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-libs;unpack=0"
SRC_URI[x86_64_v2_vlc-libs.sha256sum] = "117325813b0d69ac9b5dea5009bed9ec114184778d5b32b0234e83b9869bc3a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ffmpeg-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ffmpeg;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-ffmpeg.sha256sum] = "ae84748cdaf60481076e1aaa38d0a54b8d7d3c615c10bb38d92602c1ce7639c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-fluidsynth-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-fluidsynth;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-fluidsynth.sha256sum] = "0503a2aacbfada51d340676d505e6548b7a89cc2d340168ac7ae234b3c5158a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gnome-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gnome;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-gnome.sha256sum] = "1ae07c4505bf190d14141c188a59268a6ab86e5e01722ca4da04145d5559df9d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gstreamer-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gstreamer;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-gstreamer.sha256sum] = "3f00670c1f9339023c8a0d7008676f05399ad3d7b9fb19b8d2544e7f39abf2b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ieee1394-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ieee1394;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-ieee1394.sha256sum] = "79f89db2cb6db11110060f0f8cb05667d88c0de9e0ba2502a05ef013c9658319"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-jack-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-jack;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-jack.sha256sum] = "265a39fcf13c1a313604b5914204212ca2e2bb746a767976ae65ca4577116011"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-kde-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-kde;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-kde.sha256sum] = "c2cd5dcadcef283004930cb393d40306e1ffad3a176ddddfe022b2d9599f9bad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-lua-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-lua;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-lua.sha256sum] = "a92668f8c0b38674f1b3c9391f935709d253f07ca3f2a3c537b70c1f2643380e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-notify-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-notify;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-notify.sha256sum] = "6f754e27ae6379fe80bb52f160bd9cf4faf4e9e0059f7ef22339f82e24400ad2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-pulseaudio-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-pulseaudio;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-pulseaudio.sha256sum] = "f86c7631d68eff25b7a0d705b55ccb666f7a5f162430b0791a6c4c008c146439"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-samba-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-samba;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-samba.sha256sum] = "579d6178496a2c9e06081e6ce85ded9748cee78e08dee8706cd8cb503f9d16dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-svg-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-svg;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-svg.sha256sum] = "45bd2a59fa5cbef86f65c64afc607fe53c8fc693ae44a9d501edb6c516189562"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-visualization-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-visualization;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-visualization.sha256sum] = "ae779146c074bc0a58dbfe51911dc08babd52b0e9213e6b51ca377fc73261060"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-vnc-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-vnc;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-vnc.sha256sum] = "e6bdec5c634aeb665dea9bc9f43874fef167c2de86795459c3db906386427922"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-all-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-all;unpack=0"
SRC_URI[x86_64_v2_vlc-plugins-all.sha256sum] = "d9cb36d05e9d0782404bbb51538fd6575471bd2d074672d24f50d68eecce8148"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-base-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-base;unpack=0"
SRC_URI[x86_64_v2_vlc-plugins-base.sha256sum] = "bd52d571e8b79b26590931c49d9474b3017828e11d20b14e1f170129de387b25"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-extra-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-extra;unpack=0"
SRC_URI[x86_64_v2_vlc-plugins-extra.sha256sum] = "6d1dde1fb7bfc50cd24b0e321df33d25cac689139bc494e8850426205ddfc425"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-video-out-3.0.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-video-out;unpack=0"
SRC_URI[x86_64_v2_vlc-plugins-video-out.sha256sum] = "cbd625eace8d866801d482648efe393df9566c8dd49d717218d56836c3a145a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc;unpack=0"
SRC_URI[aarch64_vlc.sha256sum] = "0e5214ac11ec496b83b5d20ff5a80124dc63cb9e8bcf7d437f696f6e465c8586"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-cli-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-cli;unpack=0"
SRC_URI[aarch64_vlc-cli.sha256sum] = "98ec08e82be48b34c689cd35de7c3cbafc92117d3c909d8113004ef9a7d10d22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-devel-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-devel;unpack=0"
SRC_URI[aarch64_vlc-devel.sha256sum] = "8ed24b511388bceda4a6378ca8d06826e670e10df3857700484578979c378dc5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-ncurses-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-gui-ncurses;unpack=0"
SRC_URI[aarch64_vlc-gui-ncurses.sha256sum] = "45e3c0e01bc934dc8450386e6abd51d471f7fa55764c68e84283fedcd9819063"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-qt-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-gui-qt;unpack=0"
SRC_URI[aarch64_vlc-gui-qt.sha256sum] = "d7d679d68fd48f7e6447abee9b1b9b7d506681c973a41108dbaaaaae133382d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-skins2-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-gui-skins2;unpack=0"
SRC_URI[aarch64_vlc-gui-skins2.sha256sum] = "ac37b2e761391b5dd328f86008192e873866bc7e1c0e481e2d0aa082a651b8a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-libs-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-libs;unpack=0"
SRC_URI[aarch64_vlc-libs.sha256sum] = "8a5b5cea6357558e7db2418b960fc0bc22efefa0dfec8dd718668eea2dd8984b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ffmpeg-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-ffmpeg;unpack=0"
SRC_URI[aarch64_vlc-plugin-ffmpeg.sha256sum] = "2983bc7a6a81ab67c5db2047f36348d66a5cb17fbe9a67449a165a09a033e326"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-fluidsynth-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-fluidsynth;unpack=0"
SRC_URI[aarch64_vlc-plugin-fluidsynth.sha256sum] = "4079d4d7dda2f4eb43961203a2213b840fd38ec0e830f4e3da67981db0c1f06d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gnome-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-gnome;unpack=0"
SRC_URI[aarch64_vlc-plugin-gnome.sha256sum] = "b9dd3627d716f1d308d65f921827fb253d9b70bd358919d05b111452587ac4b8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gstreamer-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-gstreamer;unpack=0"
SRC_URI[aarch64_vlc-plugin-gstreamer.sha256sum] = "602e82525fd7a6515f2c01032e79860a58565cdd5486045a8e1e4b5d9df71965"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ieee1394-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-ieee1394;unpack=0"
SRC_URI[aarch64_vlc-plugin-ieee1394.sha256sum] = "e74c203f89d54092f03a68b4b24cc5d1e2cc220547cb0f0af2138ff8563e630e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-jack-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-jack;unpack=0"
SRC_URI[aarch64_vlc-plugin-jack.sha256sum] = "815059800e6ae07f05572bd12d169ac96e84c591671003945f95ee239e14917a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-kde-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-kde;unpack=0"
SRC_URI[aarch64_vlc-plugin-kde.sha256sum] = "b27d7cd91583ada4fa8e681132e3da3c7449c08a426cf97ebb63d5bcdc0cd26d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-lua-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-lua;unpack=0"
SRC_URI[aarch64_vlc-plugin-lua.sha256sum] = "f4eff2328ae28aca2644e474e3ae8b86b4fb1055f5c2853114f2acfdeaa8949c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-notify-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-notify;unpack=0"
SRC_URI[aarch64_vlc-plugin-notify.sha256sum] = "2036caf313e769806853c1f79fa15962d2f08bfb31a0e99049bcee72b93848ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-pulseaudio-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-pulseaudio;unpack=0"
SRC_URI[aarch64_vlc-plugin-pulseaudio.sha256sum] = "ed4ed729d184c87b95c74dacbf6a813ad789917bce0e88917810259ebf0e1bf6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-samba-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-samba;unpack=0"
SRC_URI[aarch64_vlc-plugin-samba.sha256sum] = "734ffe03757a0dcfeeabd49441a2bff6909825dd19db70c17d634fc237710def"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-svg-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-svg;unpack=0"
SRC_URI[aarch64_vlc-plugin-svg.sha256sum] = "f05c558c94bb626598439a8f5b4612a4147346bd585493b786e7635312510e75"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-visualization-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-visualization;unpack=0"
SRC_URI[aarch64_vlc-plugin-visualization.sha256sum] = "ee32afffb57ad9c92d7c25fecfbbf52b0296941420a7216738af1cc10ab5e722"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-vnc-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugin-vnc;unpack=0"
SRC_URI[aarch64_vlc-plugin-vnc.sha256sum] = "10bb7db0897c114f7ad72ae468661738d120ceb08534ad3fd720d4c188aa5444"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-all-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugins-all;unpack=0"
SRC_URI[aarch64_vlc-plugins-all.sha256sum] = "49eb1229d01be64234fc56d22002fc82346bf7f356e9ea50c3c44d24a0eae2fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-base-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugins-base;unpack=0"
SRC_URI[aarch64_vlc-plugins-base.sha256sum] = "f1c9e8e9a705f2cbee8181cc4a5838ab84d82c3f9f7e981a1810edab32993866"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-extra-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugins-extra;unpack=0"
SRC_URI[aarch64_vlc-plugins-extra.sha256sum] = "9b9dc680473e79fcefeb6b491d71cac4b1ab6dfc1aaa721ef07c975d069862c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-video-out-3.0.24-1.el10_3.aarch64.rpm;name=aarch64_vlc-plugins-video-out;unpack=0"
SRC_URI[aarch64_vlc-plugins-video-out.sha256sum] = "00212d8e032640d06c257c7347e1fe87a6c7e8e54a66ca594ff4cce255c9079b"

RDEPENDS:vlc = " \
 bash \
 hicolor-icon-theme \
 kde-filesystem \
 vlc-gui-qt \
 "
RDEPENDS:vlc-cli = " \
 bash \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-devel = " \
 pkgconf-pkg-config \
 vlc-libs \
 "
RDEPENDS:vlc-gui-ncurses = " \
 bash \
 glibc \
 ncurses-libs \
 vlc-cli \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-gui-qt = " \
 bash \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 vlc-cli \
 vlc-libs \
 vlc-plugin-lua \
 vlc-plugin-pulseaudio \
 vlc-plugins-base \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-gui-skins2 = " \
 bash \
 freetype \
 fribidi \
 glibc \
 gnu-free-sans-fonts \
 libX11 \
 libXext \
 libXinerama \
 libXpm \
 libgcc \
 libstdc++ \
 vlc-cli \
 vlc-gui-qt \
 vlc-libs \
 "
RDEPENDS:vlc-libs = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libidn2 \
 "
RDEPENDS:vlc-plugin-ffmpeg = " \
 glibc \
 libX11 \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libchromaprint \
 libpostproc-free \
 libswscale-free \
 libva \
 vlc-libs \
 vlc-plugins-base \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-plugin-fluidsynth = " \
 fluidsynth-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gnome = " \
 glib2 \
 glibc \
 libsecret \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-ieee1394 = " \
 glibc \
 libavc1394 \
 libdc1394 \
 libgcc \
 libraw1394 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-jack = " \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-kde = " \
 dbus-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-lua = " \
 glibc \
 libgcc \
 lua-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-notify = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libnotify \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-pulseaudio = " \
 glibc \
 pulseaudio-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-samba = " \
 glibc \
 libsmbclient \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-svg = " \
 cairo \
 glib2 \
 glibc \
 librsvg2 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-visualization = " \
 glibc \
 libglvnd-glx \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-vnc = " \
 glibc \
 libvncserver \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugins-all = " \
 vlc-plugin-bittorrent \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pause-click \
 vlc-plugin-pipewire \
 vlc-plugin-pulseaudio \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-plugins-base = " \
 alsa-lib \
 dbus-libs \
 faad2-libs \
 fdk-aac-free \
 flac-libs \
 glibc \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 libdav1d \
 libgcc \
 libgcrypt \
 libgpg-error \
 libjpeg-turbo \
 libogg \
 libpng \
 librist \
 libshout \
 libstdc++ \
 libtheora \
 libvorbis \
 libvpx \
 libxml2 \
 mpg123-libs \
 opus \
 speex \
 systemd-libs \
 taglib \
 twolame-libs \
 vlc-libs \
 zlib-ng-compat \
 "
RDEPENDS:vlc-plugins-extra:x86_64_v2 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 asdcplib \
 avahi-libs \
 daala-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libgpg-error \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libvpl \
 libxcb \
 lirc-libs \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-extra:aarch64 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 asdcplib \
 avahi-libs \
 daala-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libgpg-error \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libxcb \
 lirc-libs \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-video-out = " \
 glibc \
 libX11 \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libva \
 libwayland-client \
 libwayland-egl \
 libxcb \
 vlc-libs \
 vlc-plugins-base \
 xcb-util-keysyms \
 "
