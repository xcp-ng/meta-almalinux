# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-pki-types"
PV = "1.15.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-rustls-pki-types+web-devel \
 rust-rustls-pki-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-pki-types-1.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7652a7251768051d6dc9450860119b03b20f1c02a4cdb06faa4ee6b742611411"

URI_x86_64_v2_rust-rustls-pki-types+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+alloc-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+alloc-devel.sha256sum] = "3dbcb3ce34fdf2e6aa9bd88e555776bb213965273285aab6a5d50d9af5dcb95e"

URI_x86_64_v2_rust-rustls-pki-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+default-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+default-devel.sha256sum] = "272ba311d827e6912ea21dcdc2059fe64e3f89d9beaade030785e1a4f27bdcec"

URI_x86_64_v2_rust-rustls-pki-types+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+std-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+std-devel.sha256sum] = "224d3e3b3bb8a18da9307636d55a7648abdc7972b0a192b4d33eba56b36ebdf6"

URI_x86_64_v2_rust-rustls-pki-types+web-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types+web-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types+web-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types+web-devel.sha256sum] = "d6f1eb43b029ff31bcdf3e3db69aa9ee70676463c937cb3e7c58de46ad4ef0a6"

URI_x86_64_v2_rust-rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-pki-types-devel-1.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-rustls-pki-types-devel.sha256sum] = "f26c63f5eeafa3d10de436bd3f7571ab50f87250581d31fd377fac5198b1e8e4"

URI_aarch64_rust-rustls-pki-types+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+alloc-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-pki-types+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+alloc-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+alloc-devel.sha256sum] = "46101539d093cad5f21b09e3ad0aef0ba0c9834166831d609c5c6d1dc6b1616e"

URI_aarch64_rust-rustls-pki-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+default-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-pki-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+default-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+default-devel.sha256sum] = "717c4ee8fdadbe6b78417c15d87953f018b4411ec3735758fb70a66e0927df1f"

URI_aarch64_rust-rustls-pki-types+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+std-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-pki-types+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+std-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+std-devel.sha256sum] = "ac17dac771ded59c4cbf2f8ce7e5c157791e6e32020a6cc0ff717d2cab19e09f"

URI_aarch64_rust-rustls-pki-types+web-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types+web-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-pki-types+web-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types+web-devel}"
SRC_URI[aarch64_rust-rustls-pki-types+web-devel.sha256sum] = "23a2e5610127a3909d322628302c392d57cf6c5edc63eb443223e2dc471be441"

URI_aarch64_rust-rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-pki-types-devel-1.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-pki-types-devel}"
SRC_URI[aarch64_rust-rustls-pki-types-devel.sha256sum] = "6f7b38afa583f63e5461eb6cffa05ecc8c5107e94f9e2b36ad983358fffeeb5d"

RDEPENDS:rust-rustls-pki-types+alloc-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-rustls-pki-types+default-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+std-devel = " \
 cargo \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types+web-devel = " \
 cargo \
 rust-rustls-pki-types-devel \
 "
RDEPENDS:rust-rustls-pki-types-devel = " \
 cargo \
 rust \
 "
