# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cairo"
PV = "1.18.2"
PR = "2.el10"
PACKAGES = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 cairo-gobject-devel \
 cairo-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cairo-1.18.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b074e211524b885a6a671ac14789be66064f044940479dc7bc4409770fa81fa"

URI_x86_64_v2_cairo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-1.18.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_cairo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cairo}"
SRC_URI[x86_64_v2_cairo.sha256sum] = "3a0d0d632876f6e74548c7e30aec6ab9ef380cf08c7b8f4c1b2af86a246e7b7f"

URI_x86_64_v2_cairo-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-devel-1.18.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_cairo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cairo-devel}"
SRC_URI[x86_64_v2_cairo-devel.sha256sum] = "6bd361df86f0ff7f46eb4ce609961ac4aaea127aee67a29bf627b86353ffddc1"

URI_x86_64_v2_cairo-gobject = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-gobject-1.18.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_cairo-gobject;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cairo-gobject}"
SRC_URI[x86_64_v2_cairo-gobject.sha256sum] = "90709735093f0be0e723fe35ac1fa5b4be98a7882918fbe4fb741a386ae17be4"

URI_x86_64_v2_cairo-gobject-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-gobject-devel-1.18.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_cairo-gobject-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cairo-gobject-devel}"
SRC_URI[x86_64_v2_cairo-gobject-devel.sha256sum] = "a2567eb6004619dc38359c2af6aa5988b0ef1fa9348a4c6b1e6f0fe6c6166448"

URI_x86_64_v2_cairo-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cairo-tools-1.18.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_cairo-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cairo-tools}"
SRC_URI[x86_64_v2_cairo-tools.sha256sum] = "65af87cc858ac325e8ff589807129ecddf9b3453da62ffedaea0b9d19b1f988b"

URI_aarch64_cairo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-1.18.2-2.el10.aarch64.rpm;name=aarch64_cairo;unpack=0"
SRC_URI:append = " ${URI_aarch64_cairo}"
SRC_URI[aarch64_cairo.sha256sum] = "2d6bcca3f0abbfa2c78cc58afdd2b86940fe22218de4ee9a0d0c45c1be1e3654"

URI_aarch64_cairo-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-devel-1.18.2-2.el10.aarch64.rpm;name=aarch64_cairo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cairo-devel}"
SRC_URI[aarch64_cairo-devel.sha256sum] = "21bdf9db08e66b8351af7aca5a1f9855b7ceab327f1e4c1b4a3a416c3a149b8d"

URI_aarch64_cairo-gobject = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-gobject-1.18.2-2.el10.aarch64.rpm;name=aarch64_cairo-gobject;unpack=0"
SRC_URI:append = " ${URI_aarch64_cairo-gobject}"
SRC_URI[aarch64_cairo-gobject.sha256sum] = "a66d74e302b7f437ee660a803f480deb7371d4e201239fc9ad51fa58b556c676"

URI_aarch64_cairo-gobject-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-gobject-devel-1.18.2-2.el10.aarch64.rpm;name=aarch64_cairo-gobject-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cairo-gobject-devel}"
SRC_URI[aarch64_cairo-gobject-devel.sha256sum] = "7710839df0e4ed6761af19b8ed02b273512ef4d8cac432c6c3673b578a7ea3a9"

URI_aarch64_cairo-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cairo-tools-1.18.2-2.el10.aarch64.rpm;name=aarch64_cairo-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_cairo-tools}"
SRC_URI[aarch64_cairo-tools.sha256sum] = "a085e6b875d9ac5370d25523dc1fd91a3b9567743d8e3eaa10480b0ce9f99298"

RDEPENDS:cairo = " \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXext \
 libXrender \
 libpng \
 libxcb \
 pixman \
 zlib-ng-compat \
 "
RDEPENDS:cairo-devel = " \
 cairo \
 cairo-devel \
 fontconfig-devel \
 freetype-devel \
 libX11-devel \
 libXext-devel \
 libXrender-devel \
 libpng-devel \
 libxcb-devel \
 pixman-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:cairo-gobject = " \
 cairo \
 glib2 \
 glibc \
 "
RDEPENDS:cairo-gobject-devel = " \
 cairo-devel \
 cairo-gobject \
 fontconfig-devel \
 freetype-devel \
 glib2-devel \
 libX11-devel \
 libXext-devel \
 libXrender-devel \
 libpng-devel \
 libxcb-devel \
 pixman-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:cairo-tools = " \
 bash \
 cairo \
 glibc \
 zlib-ng-compat \
 "
