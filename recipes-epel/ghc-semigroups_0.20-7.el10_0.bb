# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-semigroups"
PV = "0.20"
PR = "7.el10_0"
PACKAGES = " \
 ghc-semigroups \
 ghc-semigroups-devel \
 ghc-semigroups-doc \
 ghc-semigroups-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-semigroups-0.20-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71718983e030a1815feb60ec2b14ca548b007308b02d3815a68420e2abfdcef2"

URI_x86_64_v2_ghc-semigroups = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-semigroups-0.20-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-semigroups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-semigroups}"
SRC_URI[x86_64_v2_ghc-semigroups.sha256sum] = "e6ecf81d7e0b463b06ee7e66040aef03b78a68fc85ddf03632f326ec6ee84b54"

URI_x86_64_v2_ghc-semigroups-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-semigroups-devel-0.20-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-semigroups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-semigroups-devel}"
SRC_URI[x86_64_v2_ghc-semigroups-devel.sha256sum] = "920192eedb3a68727add657e8e3cef14ddfe52fd6015367e5e4ee1f7e9c441bc"

URI_x86_64_v2_ghc-semigroups-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-semigroups-doc-0.20-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-semigroups-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-semigroups-doc}"
SRC_URI[x86_64_v2_ghc-semigroups-doc.sha256sum] = "572123c779e0a0abd4f9796914b1867bfa19109c2741c7a77cb2e64696784759"

URI_x86_64_v2_ghc-semigroups-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-semigroups-prof-0.20-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-semigroups-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-semigroups-prof}"
SRC_URI[x86_64_v2_ghc-semigroups-prof.sha256sum] = "52b30b86c7827f3171aa3db36efd2f6204a9c98aa0e704ea3c538af33ce3a4e2"

URI_aarch64_ghc-semigroups = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-semigroups-0.20-7.el10_0.aarch64.rpm;name=aarch64_ghc-semigroups;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-semigroups}"
SRC_URI[aarch64_ghc-semigroups.sha256sum] = "21eb12eb4d0f6a99dc234c4741ad705d67249ae5013e507efbd03f833c0c3599"

URI_aarch64_ghc-semigroups-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-semigroups-devel-0.20-7.el10_0.aarch64.rpm;name=aarch64_ghc-semigroups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-semigroups-devel}"
SRC_URI[aarch64_ghc-semigroups-devel.sha256sum] = "0f46ca1986e0a1b1eea89429020051c3180f88a6185d56247e732549ae70c663"

URI_aarch64_ghc-semigroups-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-semigroups-doc-0.20-7.el10_0.noarch.rpm;name=aarch64_ghc-semigroups-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-semigroups-doc}"
SRC_URI[aarch64_ghc-semigroups-doc.sha256sum] = "a70742577336790ac96686196864f2da889965125cbd78c316e32bbafe0e6a39"

URI_aarch64_ghc-semigroups-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-semigroups-prof-0.20-7.el10_0.aarch64.rpm;name=aarch64_ghc-semigroups-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-semigroups-prof}"
SRC_URI[aarch64_ghc-semigroups-prof.sha256sum] = "0011281dfefe4f0f18f018bda2dc6047cbaa347960538f5c9d1991da947de123"

RDEPENDS:ghc-semigroups = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-semigroups-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-semigroups \
 "
RDEPENDS:ghc-semigroups-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-semigroups-prof = " \
 ghc-base-prof \
 ghc-semigroups-devel \
 "
