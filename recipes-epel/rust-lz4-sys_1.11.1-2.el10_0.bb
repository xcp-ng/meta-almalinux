# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lz4-sys"
PV = "1.11.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-lz4-sys+default-devel \
 rust-lz4-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lz4-sys-1.11.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffb8fe913936101bf3c7777efe80fc952a15d104186625ca0174b4e2d21f5a92"

URI_x86_64_v2_rust-lz4-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lz4-sys+default-devel-1.11.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lz4-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lz4-sys+default-devel}"
SRC_URI[x86_64_v2_rust-lz4-sys+default-devel.sha256sum] = "bb3dcc0cb3cd196ab4f58e98da520510d334d18d7d0d41e51845ed6746b32fd4"

URI_x86_64_v2_rust-lz4-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lz4-sys-devel-1.11.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lz4-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lz4-sys-devel}"
SRC_URI[x86_64_v2_rust-lz4-sys-devel.sha256sum] = "c1f0e23fc6b1a26dd3bf34b3006d230124d81f03f346a2a6c17b02a84f8ca860"

URI_aarch64_rust-lz4-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lz4-sys+default-devel-1.11.1-2.el10_0.noarch.rpm;name=aarch64_rust-lz4-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lz4-sys+default-devel}"
SRC_URI[aarch64_rust-lz4-sys+default-devel.sha256sum] = "a2a17d754c9856f14bb4cf8ad952005b6ab65b4d71e10a25f07fe75a3a4d6824"

URI_aarch64_rust-lz4-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lz4-sys-devel-1.11.1-2.el10_0.noarch.rpm;name=aarch64_rust-lz4-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lz4-sys-devel}"
SRC_URI[aarch64_rust-lz4-sys-devel.sha256sum] = "35dd89c170561f389296a1b686a65462e74756ce3ac84a45199a3ef4a1c3eeab"

RDEPENDS:rust-lz4-sys+default-devel = " \
 cargo \
 rust-lz4-sys-devel \
 "
RDEPENDS:rust-lz4-sys-devel = " \
 cargo \
 lz4-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
