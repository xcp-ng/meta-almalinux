# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pcg-mwc"
PV = "0.2.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-pcg-mwc+default-devel \
 rust-pcg-mwc+serde-devel \
 rust-pcg-mwc+serde1-devel \
 rust-pcg-mwc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pcg-mwc-0.2.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb30fb7f1b1438aeab20e2effceb09eea920c6ed7cd57c2458081edde6a12f6c"

URI_x86_64_v2_rust-pcg-mwc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcg-mwc+default-devel-0.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcg-mwc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcg-mwc+default-devel}"
SRC_URI[x86_64_v2_rust-pcg-mwc+default-devel.sha256sum] = "a6595761e47cc66aed32177a11717e1521caf4e99100d7d10a8078101181506e"

URI_x86_64_v2_rust-pcg-mwc+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcg-mwc+serde-devel-0.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcg-mwc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcg-mwc+serde-devel}"
SRC_URI[x86_64_v2_rust-pcg-mwc+serde-devel.sha256sum] = "2a9005fe5d29dfe22838ada4005b755cc279e21b72410f423cc1735694e4c731"

URI_x86_64_v2_rust-pcg-mwc+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcg-mwc+serde1-devel-0.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcg-mwc+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcg-mwc+serde1-devel}"
SRC_URI[x86_64_v2_rust-pcg-mwc+serde1-devel.sha256sum] = "919260863369d2c1ac568064402dc313de23de62074d9bdcf32c18d67bab3632"

URI_x86_64_v2_rust-pcg-mwc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pcg-mwc-devel-0.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pcg-mwc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pcg-mwc-devel}"
SRC_URI[x86_64_v2_rust-pcg-mwc-devel.sha256sum] = "ce3da23894441f448a36474d9f7087450d119ffc06cb43dca4c6182b8db0f22a"

URI_aarch64_rust-pcg-mwc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcg-mwc+default-devel-0.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-pcg-mwc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcg-mwc+default-devel}"
SRC_URI[aarch64_rust-pcg-mwc+default-devel.sha256sum] = "833b3c7f641589c0d172e9ac0f0d00cd119acc2e1c21844d6cd5cadaf84f4042"

URI_aarch64_rust-pcg-mwc+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcg-mwc+serde-devel-0.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-pcg-mwc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcg-mwc+serde-devel}"
SRC_URI[aarch64_rust-pcg-mwc+serde-devel.sha256sum] = "559c360a8c0255ef7391e2bc6a2b65c0887653c45bd49d57401d7449e0594818"

URI_aarch64_rust-pcg-mwc+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcg-mwc+serde1-devel-0.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-pcg-mwc+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcg-mwc+serde1-devel}"
SRC_URI[aarch64_rust-pcg-mwc+serde1-devel.sha256sum] = "25420f20a1f9536c33bfb0afb41a0077a513d56792d494dd4a7e3736ffd68db5"

URI_aarch64_rust-pcg-mwc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pcg-mwc-devel-0.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-pcg-mwc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pcg-mwc-devel}"
SRC_URI[aarch64_rust-pcg-mwc-devel.sha256sum] = "98b071825ce68d2587f901db7425677a2b87378a412fc6f86e764fd67bddea77"

RDEPENDS:rust-pcg-mwc+default-devel = " \
 cargo \
 rust-pcg-mwc-devel \
 "
RDEPENDS:rust-pcg-mwc+serde-devel = " \
 cargo \
 rust-pcg-mwc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-pcg-mwc+serde1-devel = " \
 cargo \
 rust-pcg-mwc+serde-devel \
 rust-pcg-mwc-devel \
 "
RDEPENDS:rust-pcg-mwc-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
