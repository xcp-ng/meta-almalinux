# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pthreadpool"
PV = "0.0^git20230829.4fe0e1e"
PR = "7.el10_1"
PACKAGES = " \
 pthreadpool \
 pthreadpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pthreadpool-0.0^git20230829.4fe0e1e-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d962f9d2a40a51d337ff186c7b4a47e71fab040fa7749b3aac854f1a3f1e0361"

URI_x86_64_v2_pthreadpool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pthreadpool-0.0^git20230829.4fe0e1e-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pthreadpool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pthreadpool}"
SRC_URI[x86_64_v2_pthreadpool.sha256sum] = "4fa3d4ddb8302b0830850ea63d528e68d2456fe06c6d9f13140592ba2f789ec4"

URI_x86_64_v2_pthreadpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pthreadpool-devel-0.0^git20230829.4fe0e1e-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pthreadpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pthreadpool-devel}"
SRC_URI[x86_64_v2_pthreadpool-devel.sha256sum] = "84879f466a9587ba01d8634d55569f0d1793807c466041d90956a628dfc3949c"

URI_aarch64_pthreadpool = "${EPEL_MIRROR}/aarch64/Packages/p/pthreadpool-0.0^git20230829.4fe0e1e-7.el10_1.aarch64.rpm;name=aarch64_pthreadpool;unpack=0"
SRC_URI:append = " ${URI_aarch64_pthreadpool}"
SRC_URI[aarch64_pthreadpool.sha256sum] = "d056b9725ac22168932b089a0c749ef589149d6463881f980ab279d1d5182047"

URI_aarch64_pthreadpool-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pthreadpool-devel-0.0^git20230829.4fe0e1e-7.el10_1.aarch64.rpm;name=aarch64_pthreadpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pthreadpool-devel}"
SRC_URI[aarch64_pthreadpool-devel.sha256sum] = "e08e63e57c5ba8e37d4ca911889f50ca2a89620eaeec14dfbd6a00ec11d4453c"

RDEPENDS:pthreadpool = " \
 glibc \
 "
RDEPENDS:pthreadpool-devel = " \
 pthreadpool \
 "
