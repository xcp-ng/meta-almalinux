# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-globwalk"
PV = "0.9.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-globwalk+default-devel \
 rust-globwalk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-globwalk-0.9.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "592e73200fc3c6f11bbc7d143e4b275a616c340208ed96478397c5574a9252bb"

URI_x86_64_v2_rust-globwalk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globwalk+default-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globwalk+default-devel}"
SRC_URI[x86_64_v2_rust-globwalk+default-devel.sha256sum] = "1695d733ea1925fc015d241cf5923676415440733d829a7b734425b3114d5421"

URI_x86_64_v2_rust-globwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globwalk-devel-0.9.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globwalk-devel}"
SRC_URI[x86_64_v2_rust-globwalk-devel.sha256sum] = "739fa97a6832714cf77b140e2ae5188d5708563391ba8bbf6367a33f32b330b4"

URI_aarch64_rust-globwalk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globwalk+default-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-globwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globwalk+default-devel}"
SRC_URI[aarch64_rust-globwalk+default-devel.sha256sum] = "c167fa06cfbe52cb836e666cd83ba9bf224ea96b2ce4a5dd01bbf14a9083aea7"

URI_aarch64_rust-globwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globwalk-devel-0.9.1-4.el10_0.noarch.rpm;name=aarch64_rust-globwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globwalk-devel}"
SRC_URI[aarch64_rust-globwalk-devel.sha256sum] = "81f2b32a2e8d5031627fcc997e60be6dc2622a321747efc6d632eb40c15c17a7"

RDEPENDS:rust-globwalk+default-devel = " \
 cargo \
 rust-globwalk-devel \
 "
RDEPENDS:rust-globwalk-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-ignore+default-devel \
 rust-walkdir+default-devel \
 "
