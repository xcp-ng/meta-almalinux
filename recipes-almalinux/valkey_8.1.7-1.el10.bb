# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valkey"
PV = "8.1.7"
PR = "1.el10"
PACKAGES = " \
 valkey \
 valkey-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valkey-8.1.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4844c20d871033379b339f2a52a9e5ffe5286d423e395060037b52973b001d9"

URI_x86_64_v2_valkey = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-8.1.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_valkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valkey}"
SRC_URI[x86_64_v2_valkey.sha256sum] = "e82c111afeb993c6b9e486bb2d46ed36c73eea5df5f5d83dd40e3c5b5c57b454"

URI_x86_64_v2_valkey-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-devel-8.1.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_valkey-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valkey-devel}"
SRC_URI[x86_64_v2_valkey-devel.sha256sum] = "7f2c006214ee568ff605b3d8c88df015e225c9cb16bd03ec3fc014be8060fc8e"

URI_aarch64_valkey = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-8.1.7-1.el10.aarch64.rpm;name=aarch64_valkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_valkey}"
SRC_URI[aarch64_valkey.sha256sum] = "842e49b56a40d267a8e71d549eb8d0090c72edea631cb43f0397790412de0a2d"

URI_aarch64_valkey-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-devel-8.1.7-1.el10.aarch64.rpm;name=aarch64_valkey-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_valkey-devel}"
SRC_URI[aarch64_valkey-devel.sha256sum] = "e0f34bda0c3d79ee97f5c05d385b81ff7c5ad4f7afd2bc9652c8bb5993fe1ef9"

RDEPENDS:valkey = " \
 bash \
 glibc \
 logrotate \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:valkey-devel = " \
 valkey \
 "
