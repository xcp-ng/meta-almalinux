# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs-nodemon"
PV = "3.1.14"
PR = "3.el10"
PACKAGES = " \
 nodejs-nodemon \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs-nodemon-3.1.14-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "287ef8a40974e375013543ea6f17804ab8e4a5c4070bd3f96989110e93b3d46e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-nodemon-3.1.14-3.el10.noarch.rpm;name=x86_64_v2_nodejs-nodemon;unpack=0"
SRC_URI[x86_64_v2_nodejs-nodemon.sha256sum] = "70936575609ecee56f836aee92c4e1003436791077a29c5ec3c6b469eb249d4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-nodemon-3.1.14-3.el10.noarch.rpm;name=aarch64_nodejs-nodemon;unpack=0"
SRC_URI[aarch64_nodejs-nodemon.sha256sum] = "70936575609ecee56f836aee92c4e1003436791077a29c5ec3c6b469eb249d4b"

RDEPENDS:nodejs-nodemon = " \
 virtual/nodejs_engine_ \
 "
