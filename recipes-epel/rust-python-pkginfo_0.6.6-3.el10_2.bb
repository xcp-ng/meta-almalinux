# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-python-pkginfo"
PV = "0.6.6"
PR = "3.el10_2"
PACKAGES = " \
 rust-python-pkginfo+bzip2-devel \
 rust-python-pkginfo+default-devel \
 rust-python-pkginfo+deprecated-formats-devel \
 rust-python-pkginfo+serde-devel \
 rust-python-pkginfo+xz-devel \
 rust-python-pkginfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-python-pkginfo-0.6.6-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8a39a8239272a389c8331086dc4f15a51b45e9922e7a6b178210f6fbb81aea0"

URI_x86_64_v2_rust-python-pkginfo+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+bzip2-devel-0.6.6-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+bzip2-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+bzip2-devel.sha256sum] = "425eb4212c875189ab8e8b240b9c4ea4c0b284116979aeff00aa4bccc3fef23e"

URI_x86_64_v2_rust-python-pkginfo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+default-devel-0.6.6-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+default-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+default-devel.sha256sum] = "2dfa9f7973d8b4f2b28302398c6017063eb0eb403c3c4cf160e481ae00ada387"

URI_x86_64_v2_rust-python-pkginfo+deprecated-formats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+deprecated-formats-devel-0.6.6-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+deprecated-formats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+deprecated-formats-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+deprecated-formats-devel.sha256sum] = "7c10993f85e456bf56020cbbffee3f2e6c068c63668d4979f4b17ef498219741"

URI_x86_64_v2_rust-python-pkginfo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+serde-devel-0.6.6-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+serde-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+serde-devel.sha256sum] = "413ea096150aa126442b086aac6cf6373c58cbf7465138f26b64069f0d7414a7"

URI_x86_64_v2_rust-python-pkginfo+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+xz-devel-0.6.6-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+xz-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+xz-devel.sha256sum] = "568bf34fbe9814ca0665bd24ad9f1ac7cea29e5408cb1a073d7f152eecaae766"

URI_x86_64_v2_rust-python-pkginfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo-devel-0.6.6-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo-devel.sha256sum] = "3ae6b8c2f59b948ecb625e3d649f430a84083b4b5e940f167fca2934df3a745c"

URI_aarch64_rust-python-pkginfo+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+bzip2-devel-0.6.6-3.el10_2.noarch.rpm;name=aarch64_rust-python-pkginfo+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+bzip2-devel}"
SRC_URI[aarch64_rust-python-pkginfo+bzip2-devel.sha256sum] = "45230d624636159adb5336c25446942a33e281143a656ab4a9f0ea6962453421"

URI_aarch64_rust-python-pkginfo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+default-devel-0.6.6-3.el10_2.noarch.rpm;name=aarch64_rust-python-pkginfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+default-devel}"
SRC_URI[aarch64_rust-python-pkginfo+default-devel.sha256sum] = "368a857b6c6a16d2d504ad05b5d0afc7fda05af0533959c5f4373f267d4224ad"

URI_aarch64_rust-python-pkginfo+deprecated-formats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+deprecated-formats-devel-0.6.6-3.el10_2.noarch.rpm;name=aarch64_rust-python-pkginfo+deprecated-formats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+deprecated-formats-devel}"
SRC_URI[aarch64_rust-python-pkginfo+deprecated-formats-devel.sha256sum] = "0a055f6be26e5eab59a55e2a69112d854cc85894beab0e7b250b2d8effe39934"

URI_aarch64_rust-python-pkginfo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+serde-devel-0.6.6-3.el10_2.noarch.rpm;name=aarch64_rust-python-pkginfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+serde-devel}"
SRC_URI[aarch64_rust-python-pkginfo+serde-devel.sha256sum] = "1476ac6dbff62bf78e750983c1c5599f8e5f5ba7b1340e75a526833201e5bf6b"

URI_aarch64_rust-python-pkginfo+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+xz-devel-0.6.6-3.el10_2.noarch.rpm;name=aarch64_rust-python-pkginfo+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+xz-devel}"
SRC_URI[aarch64_rust-python-pkginfo+xz-devel.sha256sum] = "63fd200ec92598a31ea1522f5ee822e07f1e7b5fb8118ee3713b6045807f7920"

URI_aarch64_rust-python-pkginfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo-devel-0.6.6-3.el10_2.noarch.rpm;name=aarch64_rust-python-pkginfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo-devel}"
SRC_URI[aarch64_rust-python-pkginfo-devel.sha256sum] = "23d7233bf1a9bbf9b39ecad56cd3cc2ce4188e337ae6db90f85f22522eb49764"

RDEPENDS:rust-python-pkginfo+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-python-pkginfo-devel \
 "
RDEPENDS:rust-python-pkginfo+default-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 "
RDEPENDS:rust-python-pkginfo+deprecated-formats-devel = " \
 cargo \
 rust-python-pkginfo+bzip2-devel \
 rust-python-pkginfo+xz-devel \
 rust-python-pkginfo-devel \
 virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_8.0.0~ \
 "
RDEPENDS:rust-python-pkginfo+serde-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-python-pkginfo+xz-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-python-pkginfo-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-fs-err+default-devel \
 rust-mailparse+default-devel \
 rust-rfc2047-decoder+default-devel \
 rust-tar+default-devel \
 rust-thiserror+default-devel \
 virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_8.0.0~ \
 virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_8.0.0~ \
 "
