# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtquickcontrols2"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtquickcontrols2 \
 qt5-qtquickcontrols2-devel \
 qt5-qtquickcontrols2-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtquickcontrols2-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b3d89dc4c6ed9bf382014842f7656676bf823a6aaa620190e2740f5e3540750"

URI_x86_64_v2_qt5-qtquickcontrols2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2.sha256sum] = "dc41f40ed7a39f4b3a7b77f5d6d8873a81a45d7ec9d0f79f0906d967dfd72774"

URI_x86_64_v2_qt5-qtquickcontrols2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2-devel}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2-devel.sha256sum] = "2231fd3c2a53c58b0f6d505f1bfa7545aa7288c7e2bc23bf1bfdefc502b2e075"

URI_x86_64_v2_qt5-qtquickcontrols2-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols2-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2-examples}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2-examples.sha256sum] = "c4d52df128008768eab048f06189b88bdae0440f8a7b105880a2cb16a0ea3d94"

URI_aarch64_qt5-qtquickcontrols2 = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtquickcontrols2;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2}"
SRC_URI[aarch64_qt5-qtquickcontrols2.sha256sum] = "b637a31e8a42953eb3396c01d5d8f20bc3583305a722c63b400e6552412f0533"

URI_aarch64_qt5-qtquickcontrols2-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtquickcontrols2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2-devel}"
SRC_URI[aarch64_qt5-qtquickcontrols2-devel.sha256sum] = "a7406251f46955d8f85edb837ce09577009366dc48aa19059c42b92559cd9188"

URI_aarch64_qt5-qtquickcontrols2-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtquickcontrols2-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2-examples}"
SRC_URI[aarch64_qt5-qtquickcontrols2-examples.sha256sum] = "fce7d8c46dbb990d0ce04cf7eb67de6532c08cb4d45f8c1c14e427274375d6eb"

RDEPENDS:qt5-qtquickcontrols2 = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtgraphicaleffects \
 "
RDEPENDS:qt5-qtquickcontrols2-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtquickcontrols2 \
 "
RDEPENDS:qt5-qtquickcontrols2-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtquickcontrols2 \
 "
