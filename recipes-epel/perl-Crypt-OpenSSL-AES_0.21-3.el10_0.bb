# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-AES"
PV = "0.21"
PR = "3.el10_0"
PACKAGES = " \
 perl-Crypt-OpenSSL-AES \
 perl-Crypt-OpenSSL-AES-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-AES-0.21-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f3b3ecc8663019b2e4cdcab7ed220ebd884e0575dcff02d2f2285ab7d8a7443"

URI_x86_64_v2_perl-Crypt-OpenSSL-AES = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-AES-0.21-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-AES;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-AES}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-AES.sha256sum] = "686f2cce317733861b24881d8423f26466f9120935385d14d586e546fbbaea87"

URI_x86_64_v2_perl-Crypt-OpenSSL-AES-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-AES-tests-0.21-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-AES-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-AES-tests}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-AES-tests.sha256sum] = "37dee35a9b3547ec693d46d5a4c17ce21501eac668cd229aa9cd71c49967372c"

URI_aarch64_perl-Crypt-OpenSSL-AES = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-AES-0.21-3.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-AES;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-AES}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-AES.sha256sum] = "a6e42c82685930b297c8eb1cd953e9f0dac943283bb324f6c79ba52392dbd73b"

URI_aarch64_perl-Crypt-OpenSSL-AES-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-AES-tests-0.21-3.el10_0.noarch.rpm;name=aarch64_perl-Crypt-OpenSSL-AES-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-AES-tests}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-AES-tests.sha256sum] = "1e052de6e248b55857228cbfc02e6744ee553a6972e4f0301e777006db512a6a"

RDEPENDS:perl-Crypt-OpenSSL-AES = " \
 glibc \
 openssl-libs \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Crypt-OpenSSL-AES-tests = " \
 bash \
 openssl \
 perl-Crypt-OpenSSL-AES \
 perl-Crypt-OpenSSL-Guess \
 perl-Digest-SHA \
 perl-File-Which \
 perl-MIME-Base64 \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
