# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-bgentry-speakeasy"
PV = "0.1.0"
PR = "18.el10_0"
PACKAGES = " \
 golang-github-bgentry-speakeasy-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-bgentry-speakeasy-0.1.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5d6cb51c5dca77d5133165c305dae20463c047f988d2ee289fee8b201b481a9d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-bgentry-speakeasy-devel-0.1.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-bgentry-speakeasy-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-bgentry-speakeasy-devel.sha256sum] = "4224ba2e3a6fef6e63553b337cfa84bad3fcd530f017ae262e8adeb24c116af2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-bgentry-speakeasy-devel-0.1.0-18.el10_0.noarch.rpm;name=aarch64_golang-github-bgentry-speakeasy-devel;unpack=0"
SRC_URI[aarch64_golang-github-bgentry-speakeasy-devel.sha256sum] = "8540681c33ca560ef45ecadd518c855fb91d324e88eb261248c8a4ee702602a8"

RDEPENDS:golang-github-bgentry-speakeasy-devel = " \
 go-filesystem \
 "
