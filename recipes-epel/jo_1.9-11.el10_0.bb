# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jo"
PV = "1.9"
PR = "11.el10_0"
PACKAGES = " \
 jo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jo-1.9-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "70ea3889514538552bd9994a237d1b37585ed838feaf8b0f79545e5c89e8a21e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jo-1.9-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jo;unpack=0"
SRC_URI[x86_64_v2_jo.sha256sum] = "06dbd7edb98abc7162d4b781f10d393c2496877b86be1c01fd5eaaccbc7c2e36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jo-1.9-11.el10_0.aarch64.rpm;name=aarch64_jo;unpack=0"
SRC_URI[aarch64_jo.sha256sum] = "b467a1c3af575b92141dc5f3805df32c493cf86b4086c232da6d51d1cea00d4f"

RDEPENDS:jo = " \
 glibc \
 "
