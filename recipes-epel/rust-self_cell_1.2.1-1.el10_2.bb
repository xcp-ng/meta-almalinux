# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-self_cell"
PV = "1.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-self_cell+default-devel \
 rust-self_cell+old_rust-devel \
 rust-self_cell+rustversion-devel \
 rust-self_cell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-self_cell-1.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "648b791f4fabab4784b5e3b3c5ef9f41cbda5a6e0f40d1ba9b824e685f2b7889"

URI_x86_64_v2_rust-self_cell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell+default-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-self_cell+default-devel}"
SRC_URI[x86_64_v2_rust-self_cell+default-devel.sha256sum] = "25bc560bb995ea636e70f580ecb0c3bfcc2b0dbe2c79d8510a542eac331d860c"

URI_x86_64_v2_rust-self_cell+old_rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell+old_rust-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell+old_rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-self_cell+old_rust-devel}"
SRC_URI[x86_64_v2_rust-self_cell+old_rust-devel.sha256sum] = "c245c4ef78c2f03a0285ce9030afa3ebf598525164d9e6db3912b9c93bf61ba0"

URI_x86_64_v2_rust-self_cell+rustversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell+rustversion-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-self_cell+rustversion-devel}"
SRC_URI[x86_64_v2_rust-self_cell+rustversion-devel.sha256sum] = "9c89c168632186a575551064aba99ac5f7c3da2f8c899b0e991c061dcf74a308"

URI_x86_64_v2_rust-self_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-self_cell-devel}"
SRC_URI[x86_64_v2_rust-self_cell-devel.sha256sum] = "0b4edd9da3dcdd8b8ddafe995aac86612fc4c5bd756af33ea59c6da61ab73fa5"

URI_aarch64_rust-self_cell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell+default-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-self_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-self_cell+default-devel}"
SRC_URI[aarch64_rust-self_cell+default-devel.sha256sum] = "7a79eacafcbddbfd9dcff3c97278c33115501c38decb7fcce16dfccf0eea8570"

URI_aarch64_rust-self_cell+old_rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell+old_rust-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-self_cell+old_rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-self_cell+old_rust-devel}"
SRC_URI[aarch64_rust-self_cell+old_rust-devel.sha256sum] = "d948f9378e2f350e4fd823985c5c5d12d3618241d7f89a843c883be785979459"

URI_aarch64_rust-self_cell+rustversion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell+rustversion-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-self_cell+rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-self_cell+rustversion-devel}"
SRC_URI[aarch64_rust-self_cell+rustversion-devel.sha256sum] = "a5010c98653367169528679728c810f48d49f2bd879a136101f1aa2ebf0d8c40"

URI_aarch64_rust-self_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-self_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-self_cell-devel}"
SRC_URI[aarch64_rust-self_cell-devel.sha256sum] = "a0f19b3c4f9e3c02d36bbb50b2fd99e5d4bab1cbaa119aeb0a6eb1349154ba60"

RDEPENDS:rust-self_cell+default-devel = " \
 cargo \
 rust-self_cell-devel \
 "
RDEPENDS:rust-self_cell+old_rust-devel = " \
 cargo \
 rust-self_cell+rustversion-devel \
 rust-self_cell-devel \
 "
RDEPENDS:rust-self_cell+rustversion-devel = " \
 cargo \
 rust-rustversion+default-devel \
 rust-self_cell-devel \
 "
RDEPENDS:rust-self_cell-devel = " \
 cargo \
 "
