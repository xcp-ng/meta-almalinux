# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdevelop"
PE = "9"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdevelop \
 kdevelop-devel \
 kdevelop-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdevelop-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e132ba748c517e9959144502c54b267920e4e578601e638e517381503260461"

URI_x86_64_v2_kdevelop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdevelop}"
SRC_URI[x86_64_v2_kdevelop.sha256sum] = "64da6100018ab9492df887768060405688803d329f89e58817d857a34ab7f686"

URI_x86_64_v2_kdevelop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdevelop-devel}"
SRC_URI[x86_64_v2_kdevelop-devel.sha256sum] = "cec7b0a9b91d46d76591463c58eb3cfb4b64ac31e87370c0be820a273d058bf9"

URI_x86_64_v2_kdevelop-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdevelop-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdevelop-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdevelop-libs}"
SRC_URI[x86_64_v2_kdevelop-libs.sha256sum] = "38c5a3fd0c3fcb20579c6d8f4d0f9364d95ce290c571f35e3622a00cd661ef67"

URI_aarch64_kdevelop = "${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdevelop;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdevelop}"
SRC_URI[aarch64_kdevelop.sha256sum] = "3bd08c1780232ae4fa1f80ba01afda29ca6d1dc84c994c05cd07c65751fde29c"

URI_aarch64_kdevelop-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdevelop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdevelop-devel}"
SRC_URI[aarch64_kdevelop-devel.sha256sum] = "537aee0278d7071e7e7983b1af7eece61cdae16210e3d44ffdbc2d53506d3f69"

URI_aarch64_kdevelop-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kdevelop-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdevelop-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdevelop-libs}"
SRC_URI[aarch64_kdevelop-libs.sha256sum] = "7efd0f8b1ee263b487015aee78ac728ba7df7d6f1d96e2fbf42fd179d1da7f1b"

RDEPENDS:kdevelop = " \
 astyle \
 bash \
 cmake \
 cppcheck \
 git \
 glibc \
 kdevelop-libs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 konsole-part \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kdevelop-devel = " \
 cmake-filesystem \
 kdevelop-libs \
 kf6-ktexteditor-devel \
 kf6-threadweaver-devel \
 qt6-qt5compat-devel \
 qt6-qtbase-devel \
 qt6-qtwebengine-devel \
 "
RDEPENDS:kdevelop-libs = " \
 apr \
 apr-util \
 astyle \
 clang-libs \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-krunner \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kf6-threadweaver \
 libgcc \
 libkomparediff2 \
 libksysguard \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 subversion-libs \
 "
