# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ht"
PV = "0.06"
PR = "30.el10"
PACKAGES = " \
 hunspell-ht \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ht-0.06-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3d32b9528f03e70fa82092da1733875d126701a15153c89c739437f39a3a6a4"

URI_x86_64_v2_hunspell-ht = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ht-0.06-30.el10.noarch.rpm;name=x86_64_v2_hunspell-ht;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ht}"
SRC_URI[x86_64_v2_hunspell-ht.sha256sum] = "9fddc506bade75638defd4f8859efd0cbaec378930269e8158014dea7187139f"

URI_aarch64_hunspell-ht = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ht-0.06-30.el10.noarch.rpm;name=aarch64_hunspell-ht;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ht}"
SRC_URI[aarch64_hunspell-ht.sha256sum] = "9fddc506bade75638defd4f8859efd0cbaec378930269e8158014dea7187139f"

RDEPENDS:hunspell-ht = " \
 hunspell-filesystem \
 "
