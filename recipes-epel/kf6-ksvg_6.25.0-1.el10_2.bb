# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ksvg"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-ksvg \
 kf6-ksvg-devel \
 kf6-ksvg-doc \
 kf6-ksvg-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ksvg-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd8159613813d204879993b38a5cc167815cafd4de56cca7f2285a6373ab206e"

URI_x86_64_v2_kf6-ksvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg}"
SRC_URI[x86_64_v2_kf6-ksvg.sha256sum] = "1d846a4ed1638a5d8dbcee000f66943d4fac118f9701bfe18fde8fee21307c12"

URI_x86_64_v2_kf6-ksvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-devel}"
SRC_URI[x86_64_v2_kf6-ksvg-devel.sha256sum] = "2d1f09edbb0b3e06a54905321d4154b384874f46c5658ee70f4f53173f81e0cd"

URI_x86_64_v2_kf6-ksvg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ksvg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-doc}"
SRC_URI[x86_64_v2_kf6-ksvg-doc.sha256sum] = "14604d21823304023a7f1c9fbac9bebf3f4af0c8a89049b124cc6d2c9b475f4e"

URI_x86_64_v2_kf6-ksvg-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ksvg-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-html}"
SRC_URI[x86_64_v2_kf6-ksvg-html.sha256sum] = "3d945fc0339bc45607ca623d7db37d530bba603be643e2f56f1366c7a99323ee"

URI_aarch64_kf6-ksvg = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ksvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg}"
SRC_URI[aarch64_kf6-ksvg.sha256sum] = "1b324b23fb28455543b9a4321da0ddd77d58ca081c6d74fa52653bddefbe438c"

URI_aarch64_kf6-ksvg-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ksvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-devel}"
SRC_URI[aarch64_kf6-ksvg-devel.sha256sum] = "872e5c7cdd89c8759a6055bf513946b53c7cc2fd1df8d1dd309863b58e072f42"

URI_aarch64_kf6-ksvg-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ksvg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-doc}"
SRC_URI[aarch64_kf6-ksvg-doc.sha256sum] = "aeaecd8e9c90a3a620bd30f233e330f2da3f910505ed9264dfa3b36156c526f2"

URI_aarch64_kf6-ksvg-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ksvg-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-html}"
SRC_URI[aarch64_kf6-ksvg-html.sha256sum] = "e1d8fb0d20a7fc05aae735d753921ad7794aac4f128ed5118ba1fdfd513eafb9"

RDEPENDS:kf6-ksvg = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kirigami \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:kf6-ksvg-devel = " \
 cmake-filesystem \
 kf6-ksvg \
 "
RDEPENDS:kf6-ksvg-doc = " \
 "
RDEPENDS:kf6-ksvg-html = " \
 "
