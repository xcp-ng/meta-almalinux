# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kubrick"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kubrick \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kubrick-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c464b1cb359c310fc9c7ca4b6fb5e15f2d50f67597dac38b804f94979aefe39"

URI_x86_64_v2_kubrick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kubrick-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kubrick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kubrick}"
SRC_URI[x86_64_v2_kubrick.sha256sum] = "24b057a080ed1200471f25c7369a5cca926d8f3efd4c3f3441abbe44e2bc5b4b"

URI_aarch64_kubrick = "${EPEL_MIRROR}/aarch64/Packages/k/kubrick-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kubrick;unpack=0"
SRC_URI:append = " ${URI_aarch64_kubrick}"
SRC_URI[aarch64_kubrick.sha256sum] = "cf605b2dd8cf92e2797a6f5e8b2b4bec59091125b48bf1cc1e3f282d08d18a9e"

RDEPENDS:kubrick = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libglvnd-opengl \
 libkdegames \
 libstdc++ \
 mesa-libGLU \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
