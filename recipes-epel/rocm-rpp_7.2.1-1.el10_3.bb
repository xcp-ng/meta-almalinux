# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-rpp"
PV = "7.2.1"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 rocm-rpp \
 rocm-rpp-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-rpp-7.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6c215c4f32cb59d49da3730d231540a57c1b50a58be4b613c114fc45ed33d5c"

URI_x86_64_v2_rocm-rpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rpp-7.2.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-rpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-rpp}"
SRC_URI[x86_64_v2_rocm-rpp.sha256sum] = "e6b07f901ee0a1090f84fcbc70336124a80b8791bb1ab5cf9c37f1d8c7fe5636"

URI_x86_64_v2_rocm-rpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rpp-devel-7.2.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-rpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-rpp-devel}"
SRC_URI[x86_64_v2_rocm-rpp-devel.sha256sum] = "3cea79f662dc9a61ec08d1a34d4953e65c4462d36a40f2765d6b88f8dec66c34"

RDEPENDS:rocm-rpp = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 virtual/libomp.so_VERSION__64bit_ \
 virtual/libomp.so___64bit_ \
 "
RDEPENDS:rocm-rpp-devel = " \
 cmake-filesystem \
 rocm-rpp \
 "
