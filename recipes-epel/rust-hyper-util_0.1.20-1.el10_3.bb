# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper-util"
PV = "0.1.20"
PR = "1.el10_3"
PACKAGES = " \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-pool-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+client-proxy-system-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+full-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+server-graceful-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util+tracing-devel \
 rust-hyper-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-util-0.1.20-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d682cee07ba2ff3a55c96233691e4278a4a23b7bdec2195e83e200186afd9e05"

URI_x86_64_v2_rust-hyper-util+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-devel.sha256sum] = "783dae97421fb23c256702ff63c2da702b0cec10f59d154561bd636e97e65468"

URI_x86_64_v2_rust-hyper-util+client-legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-legacy-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-legacy-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-legacy-devel.sha256sum] = "cb2a45ea611386f48df641d37cf68f97ab3496a154157003a1fcf56d8ae98341"

URI_x86_64_v2_rust-hyper-util+client-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-pool-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-pool-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-pool-devel.sha256sum] = "00b63946a626335d049e44b2640a7f539fd6334389dcd1c4ac2e3f464a31e64a"

URI_x86_64_v2_rust-hyper-util+client-proxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-proxy-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-proxy-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-proxy-devel.sha256sum] = "9553d4e55d33c52ca69cfa06942ffa9e5c2613a863d1f22fe643b4376b06879f"

URI_x86_64_v2_rust-hyper-util+client-proxy-system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-proxy-system-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-proxy-system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-proxy-system-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-proxy-system-devel.sha256sum] = "6f8b74775208f1cce8964a16de5a14edb361333a057e31001377f6797a5db0d8"

URI_x86_64_v2_rust-hyper-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+default-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+default-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+default-devel.sha256sum] = "2fefa50d6ee3b0508d16a436a4a1bdfbc45cf4edd0b4bfb5531744284ebfa0c9"

URI_x86_64_v2_rust-hyper-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+full-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+full-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+full-devel.sha256sum] = "ebe665842bee0f8c1a1dd7d82dd893277f7f816ec2e220cb63a9d4eec2acb8e2"

URI_x86_64_v2_rust-hyper-util+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+http1-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+http1-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+http1-devel.sha256sum] = "678e247e68ae391f7d133d6df3484a6f72347880e71d23284c2194ede07f36a2"

URI_x86_64_v2_rust-hyper-util+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+http2-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+http2-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+http2-devel.sha256sum] = "3de06f7aac31d51ccbd4184882e6d80bf0050a17abe808b2533d495d9508b4be"

URI_x86_64_v2_rust-hyper-util+server-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-auto-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+server-auto-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+server-auto-devel.sha256sum] = "b4b510aeaf3f18dd146cfecc5cf9690b5357ab8f2f751887771ba68042783959"

URI_x86_64_v2_rust-hyper-util+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+server-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+server-devel.sha256sum] = "17f34667c8488e3a1dcbc21e591db7545c179f68de34f2209f2c68fee8edd947"

URI_x86_64_v2_rust-hyper-util+server-graceful-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-graceful-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-graceful-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+server-graceful-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+server-graceful-devel.sha256sum] = "2cd1048f4371d67873d142d3fa9f55f0460fd13ba6af00aff0dc9c3c3de6e80d"

URI_x86_64_v2_rust-hyper-util+service-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+service-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+service-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+service-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+service-devel.sha256sum] = "cf1175a4d52e22eb0f07d69ab0276f747459b58ed41f634ce71b76aee4019ff2"

URI_x86_64_v2_rust-hyper-util+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+tokio-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+tokio-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+tokio-devel.sha256sum] = "8ccc7eb1265c8d45bb688eb1cdc482aec8bf20ba89489fe881167384279d905a"

URI_x86_64_v2_rust-hyper-util+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+tracing-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+tracing-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+tracing-devel.sha256sum] = "3c11b3a6e648adc825821523b97adabf975c6884f30cfb0a42cc57dd312c9d7a"

URI_x86_64_v2_rust-hyper-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util-devel}"
SRC_URI[x86_64_v2_rust-hyper-util-devel.sha256sum] = "6935189ab08dbb76081d7585b9026f103f194c5421c98036f111469d3d8d651f"

URI_aarch64_rust-hyper-util+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-devel}"
SRC_URI[aarch64_rust-hyper-util+client-devel.sha256sum] = "f0c4357e922d9b7c175eae41bcc99f1eeeb2bdfb59bcb79946bb38336b844cf8"

URI_aarch64_rust-hyper-util+client-legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-legacy-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-legacy-devel}"
SRC_URI[aarch64_rust-hyper-util+client-legacy-devel.sha256sum] = "4cbd45a7ebf6dd431b7e49df64053043e9adf1fbc67fddabddf735ca8e573e64"

URI_aarch64_rust-hyper-util+client-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-pool-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-pool-devel}"
SRC_URI[aarch64_rust-hyper-util+client-pool-devel.sha256sum] = "73468b3c96bea31fe358580272ed91b476500800a1e53c0f71261a8d6fe166e8"

URI_aarch64_rust-hyper-util+client-proxy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-proxy-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-proxy-devel}"
SRC_URI[aarch64_rust-hyper-util+client-proxy-devel.sha256sum] = "39511dba14bb9979104c86042897a60d400d574420dff58e4542b2fae98d7675"

URI_aarch64_rust-hyper-util+client-proxy-system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-proxy-system-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+client-proxy-system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-proxy-system-devel}"
SRC_URI[aarch64_rust-hyper-util+client-proxy-system-devel.sha256sum] = "62136bfd1715ded10ed6b629996985017395062b6cc72744e1987138b5862034"

URI_aarch64_rust-hyper-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+default-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+default-devel}"
SRC_URI[aarch64_rust-hyper-util+default-devel.sha256sum] = "fcc35650d05c027530a4ea16eef746d58bfcf93ba69bd75bc2219a48151c268c"

URI_aarch64_rust-hyper-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+full-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+full-devel}"
SRC_URI[aarch64_rust-hyper-util+full-devel.sha256sum] = "9f647f6b5862cb96d966cf9c7f521d4664972fde4431921d3b2150c13609b98a"

URI_aarch64_rust-hyper-util+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+http1-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+http1-devel}"
SRC_URI[aarch64_rust-hyper-util+http1-devel.sha256sum] = "f4c86e48f44826b6a38083340780e55186abe0359066b151ba2da2f51991bf15"

URI_aarch64_rust-hyper-util+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+http2-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+http2-devel}"
SRC_URI[aarch64_rust-hyper-util+http2-devel.sha256sum] = "d64cf613654da26195f40cca5be04c3abead0b1944510e8bb797ac24d7106e64"

URI_aarch64_rust-hyper-util+server-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-auto-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+server-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+server-auto-devel}"
SRC_URI[aarch64_rust-hyper-util+server-auto-devel.sha256sum] = "4d8a59f0e04ee593d89373b555e1692c4abbb7c0c297403d83f5354dd1b8a517"

URI_aarch64_rust-hyper-util+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+server-devel}"
SRC_URI[aarch64_rust-hyper-util+server-devel.sha256sum] = "99f5e6e46f245365b656063618fca790958d5e885df4e54af3bd91ff0fc893c5"

URI_aarch64_rust-hyper-util+server-graceful-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-graceful-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+server-graceful-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+server-graceful-devel}"
SRC_URI[aarch64_rust-hyper-util+server-graceful-devel.sha256sum] = "cc9255501f5b1a04dcd38e4ddc20810389721ef26e31ed513891eddec653aa09"

URI_aarch64_rust-hyper-util+service-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+service-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+service-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+service-devel}"
SRC_URI[aarch64_rust-hyper-util+service-devel.sha256sum] = "3c2fc38ccdd8774491836a5f34c3bf7072a9dc2391c4004c8d7e125fb62a6ec6"

URI_aarch64_rust-hyper-util+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+tokio-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+tokio-devel}"
SRC_URI[aarch64_rust-hyper-util+tokio-devel.sha256sum] = "e66a8dcf0eaae36fff107681bc673ebe2361d8731a8b1cb51d2f79fd32564812"

URI_aarch64_rust-hyper-util+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+tracing-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+tracing-devel}"
SRC_URI[aarch64_rust-hyper-util+tracing-devel.sha256sum] = "31569323a10c53ac589a7db190e10e822c7fb26509ca93a8c533957fa5f4f071"

URI_aarch64_rust-hyper-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util-devel}"
SRC_URI[aarch64_rust-hyper-util-devel.sha256sum] = "9ae8bdfaa9e521bb0450559c73fee82ab8d584df0471a277986cc9ef191044da"

RDEPENDS:rust-hyper-util+client-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-hyper+client-devel \
 rust-hyper-util-devel \
 rust-tokio+net-devel \
 rust-tokio-devel \
 rust-tower-service+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-util+client-legacy-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-libc+default-devel \
 rust-tokio+sync-devel \
 rust-tokio-devel \
 virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~ \
 virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~ \
 "
RDEPENDS:rust-hyper-util+client-pool-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-tower-layer+default-devel \
 "
RDEPENDS:rust-hyper-util+client-proxy-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-ipnet+default-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-hyper-util+client-proxy-system-devel = " \
 cargo \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+default-devel = " \
 cargo \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+full-devel = " \
 cargo \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-pool-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+client-proxy-system-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+server-graceful-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util+tracing-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+http1-devel = " \
 cargo \
 rust-hyper+http1-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+http2-devel = " \
 cargo \
 rust-hyper+http2-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-auto-devel = " \
 cargo \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-devel = " \
 cargo \
 rust-hyper+server-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-graceful-devel = " \
 cargo \
 rust-hyper-util+server-devel \
 rust-hyper-util-devel \
 rust-tokio+sync-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+service-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tower-service+default-devel \
 "
RDEPENDS:rust-hyper-util+tokio-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+tracing-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-hyper+default-devel \
 rust-pin-project-lite+default-devel \
 "
