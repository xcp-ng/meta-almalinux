# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-globset"
PV = "0.4.16"
PR = "1.el10_0"
PACKAGES = " \
 rust-globset+default-devel \
 rust-globset+log-devel \
 rust-globset+serde-devel \
 rust-globset+serde1-devel \
 rust-globset+simd-accel-devel \
 rust-globset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-globset-0.4.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca7e967c03ce0429a2b219fc0256c7b2764f62485b36989e824f81eae6f9648b"

URI_x86_64_v2_rust-globset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+default-devel-0.4.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+default-devel}"
SRC_URI[x86_64_v2_rust-globset+default-devel.sha256sum] = "02ec59bc34bfc00bbf36bd1b995f6b2aa516a4b2abe3786717e5af60206d21c4"

URI_x86_64_v2_rust-globset+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+log-devel-0.4.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+log-devel}"
SRC_URI[x86_64_v2_rust-globset+log-devel.sha256sum] = "0ff0a80f3a6cb6013d9c61ca3d0071bd09fe64fb0083da0d8643850d9382f6fd"

URI_x86_64_v2_rust-globset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+serde-devel-0.4.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+serde-devel}"
SRC_URI[x86_64_v2_rust-globset+serde-devel.sha256sum] = "be4dc3d22f420aa200658e0cc87a8d393ac04946bf9bd1f59ec1d8dee11bb7b1"

URI_x86_64_v2_rust-globset+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+serde1-devel-0.4.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+serde1-devel}"
SRC_URI[x86_64_v2_rust-globset+serde1-devel.sha256sum] = "13771303697196bbf81f620b7561dd098e9bf6721dd631344ecb97e821239b5e"

URI_x86_64_v2_rust-globset+simd-accel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset+simd-accel-devel-0.4.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset+simd-accel-devel}"
SRC_URI[x86_64_v2_rust-globset+simd-accel-devel.sha256sum] = "3840ead92bc39ff5e363d6248d4219b5342419c452fb46ecd3964d4829fc3e79"

URI_x86_64_v2_rust-globset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-globset-devel-0.4.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-globset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-globset-devel}"
SRC_URI[x86_64_v2_rust-globset-devel.sha256sum] = "009b98f55d7c7de1ec4e46f9de29017227603e98821095357793c0dfdf8b9f36"

URI_aarch64_rust-globset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+default-devel-0.4.16-1.el10_0.noarch.rpm;name=aarch64_rust-globset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+default-devel}"
SRC_URI[aarch64_rust-globset+default-devel.sha256sum] = "af9dbf4849c8a7f3b398e2212a11fe53e3d8016d67198266dcd9ecd48a4451b3"

URI_aarch64_rust-globset+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+log-devel-0.4.16-1.el10_0.noarch.rpm;name=aarch64_rust-globset+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+log-devel}"
SRC_URI[aarch64_rust-globset+log-devel.sha256sum] = "a4f423f82a74b73b2539ed9c720e5e4fd4172f4b26cf5c3c6c2854e51c15cb4f"

URI_aarch64_rust-globset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+serde-devel-0.4.16-1.el10_0.noarch.rpm;name=aarch64_rust-globset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+serde-devel}"
SRC_URI[aarch64_rust-globset+serde-devel.sha256sum] = "9ad4ea44a80cd6ed4c65e50ed9590b03eb5fd0ad222fd6cef10f7052333fd6e6"

URI_aarch64_rust-globset+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+serde1-devel-0.4.16-1.el10_0.noarch.rpm;name=aarch64_rust-globset+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+serde1-devel}"
SRC_URI[aarch64_rust-globset+serde1-devel.sha256sum] = "aacfb6055477bc1bb3cc01b87661e094ef76d001ff07504769b410f47621cd17"

URI_aarch64_rust-globset+simd-accel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset+simd-accel-devel-0.4.16-1.el10_0.noarch.rpm;name=aarch64_rust-globset+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset+simd-accel-devel}"
SRC_URI[aarch64_rust-globset+simd-accel-devel.sha256sum] = "c731fbd8674929591a0cd55b51b95296c59763aeea6e4fdcb7679ecc379056c4"

URI_aarch64_rust-globset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-globset-devel-0.4.16-1.el10_0.noarch.rpm;name=aarch64_rust-globset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-globset-devel}"
SRC_URI[aarch64_rust-globset-devel.sha256sum] = "949e64be70cdfc10c952e7b3c6e2b8b0ca1e9dc978e0246e5a76d2e4f61e3cec"

RDEPENDS:rust-globset+default-devel = " \
 cargo \
 rust-globset+log-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+log-devel = " \
 cargo \
 rust-globset-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-globset+serde-devel = " \
 cargo \
 rust-globset-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-globset+serde1-devel = " \
 cargo \
 rust-globset+serde-devel \
 rust-globset-devel \
 "
RDEPENDS:rust-globset+simd-accel-devel = " \
 cargo \
 rust-globset-devel \
 "
RDEPENDS:rust-globset-devel = " \
 cargo \
 rust-aho-corasick+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax-devel \
 "
