# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "PackageKit"
PV = "1.2.8"
PR = "8.el10"
PACKAGES = " \
 PackageKit \
 PackageKit-command-not-found \
 PackageKit-glib \
 PackageKit-glib-devel \
 PackageKit-gstreamer-plugin \
 PackageKit-gtk3-module \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/PackageKit-1.2.8-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d14e23b2a4b99c1e7b8a74f31c66fe02d3a07ec473220fb0838e8dbd07cdcca8"

URI_x86_64_v2_PackageKit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-1.2.8-8.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit}"
SRC_URI[x86_64_v2_PackageKit.sha256sum] = "85e774a13c7739689e9b29fac4a87567f9fe3f4ee274d6d6bfb46584641b1b39"

URI_x86_64_v2_PackageKit-command-not-found = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-command-not-found-1.2.8-8.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-command-not-found;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-command-not-found}"
SRC_URI[x86_64_v2_PackageKit-command-not-found.sha256sum] = "a4b5a86162d7935a29a246cb3c2a7898612d9c7dbe2ed4a06808b6ad1efb5dcb"

URI_x86_64_v2_PackageKit-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-glib-1.2.8-8.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-glib}"
SRC_URI[x86_64_v2_PackageKit-glib.sha256sum] = "d02bec87760d868d12cecc7f365f996eec8e951a2e18d1244a9d8396ac5709c8"

URI_x86_64_v2_PackageKit-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/PackageKit-glib-devel-1.2.8-8.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-glib-devel}"
SRC_URI[x86_64_v2_PackageKit-glib-devel.sha256sum] = "ba0ddc689ce73be115786f9b5e44a05a36177751ca26bb7395d32144647bc374"

URI_x86_64_v2_PackageKit-gstreamer-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-gstreamer-plugin-1.2.8-8.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-gstreamer-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-gstreamer-plugin}"
SRC_URI[x86_64_v2_PackageKit-gstreamer-plugin.sha256sum] = "ebd3cb9fd835b03050e7a5f9bbe1ec59384b21ab3552e95000b7397bfb51bf8f"

URI_x86_64_v2_PackageKit-gtk3-module = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/PackageKit-gtk3-module-1.2.8-8.el10.x86_64_v2.rpm;name=x86_64_v2_PackageKit-gtk3-module;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_PackageKit-gtk3-module}"
SRC_URI[x86_64_v2_PackageKit-gtk3-module.sha256sum] = "db7cc84354d9aad1f46bcb7d3697c04a64ce02f20abafba7b045cea220f4844b"

URI_aarch64_PackageKit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-1.2.8-8.el10.aarch64.rpm;name=aarch64_PackageKit;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit}"
SRC_URI[aarch64_PackageKit.sha256sum] = "12abb983317b8b29606604387be9835926cd92c2153632b599cee946d4bc802c"

URI_aarch64_PackageKit-command-not-found = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-command-not-found-1.2.8-8.el10.aarch64.rpm;name=aarch64_PackageKit-command-not-found;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-command-not-found}"
SRC_URI[aarch64_PackageKit-command-not-found.sha256sum] = "85f160106bd028b7d720662ad82d706952481c8e0c23ce188753401e8dc19a50"

URI_aarch64_PackageKit-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-glib-1.2.8-8.el10.aarch64.rpm;name=aarch64_PackageKit-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-glib}"
SRC_URI[aarch64_PackageKit-glib.sha256sum] = "ca2ca28e332989fd168c910cf4838ff844969b3679b6a9e1300b24d9656f145f"

URI_aarch64_PackageKit-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/PackageKit-glib-devel-1.2.8-8.el10.aarch64.rpm;name=aarch64_PackageKit-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-glib-devel}"
SRC_URI[aarch64_PackageKit-glib-devel.sha256sum] = "1e8a092b3bd1d96800fa7bcb06feac761266e678546141cbc1c898e699b422e7"

URI_aarch64_PackageKit-gstreamer-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-gstreamer-plugin-1.2.8-8.el10.aarch64.rpm;name=aarch64_PackageKit-gstreamer-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-gstreamer-plugin}"
SRC_URI[aarch64_PackageKit-gstreamer-plugin.sha256sum] = "16b4e4d529a38eb299be3f4c34400b7674f61f6efdc121d60278e34531eff428"

URI_aarch64_PackageKit-gtk3-module = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/PackageKit-gtk3-module-1.2.8-8.el10.aarch64.rpm;name=aarch64_PackageKit-gtk3-module;unpack=0"
SRC_URI:append = " ${URI_aarch64_PackageKit-gtk3-module}"
SRC_URI[aarch64_PackageKit-gtk3-module.sha256sum] = "63a56c994328784b8b702b5b457f0641b7d7f8780b70b6dc00eed9a615a51e62"

RDEPENDS:PackageKit = " \
 PackageKit-glib \
 appstream \
 bash \
 glib2 \
 glibc \
 libdnf \
 libgcc \
 polkit-libs \
 python3 \
 rpm-libs \
 shared-mime-info \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:PackageKit-command-not-found = " \
 PackageKit \
 PackageKit-glib \
 bash \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:PackageKit-glib = " \
 dbus \
 glib2 \
 glibc \
 gobject-introspection \
 libgcc \
 "
RDEPENDS:PackageKit-glib-devel = " \
 PackageKit-glib \
 dbus-devel \
 glib2-devel \
 pkgconf-pkg-config \
 sqlite-devel \
 "
RDEPENDS:PackageKit-gstreamer-plugin = " \
 PackageKit-glib \
 glib2 \
 glibc \
 gstreamer1 \
 libgcc \
 "
RDEPENDS:PackageKit-gtk3-module = " \
 PackageKit-glib \
 fontconfig \
 glib2 \
 glibc \
 libgcc \
 pango \
 "
