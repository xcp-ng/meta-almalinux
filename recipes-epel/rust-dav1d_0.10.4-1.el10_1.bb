# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dav1d"
PV = "0.10.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-dav1d+default-devel \
 rust-dav1d-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dav1d-0.10.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8e539ee197a77321b31300f823132a4cc6d2ef367666c76f89e369356c5fdb1"

URI_x86_64_v2_rust-dav1d+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dav1d+default-devel-0.10.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dav1d+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dav1d+default-devel}"
SRC_URI[x86_64_v2_rust-dav1d+default-devel.sha256sum] = "f414bf1778a93b93495dd547ae9875510d23148f0035db397bda11b2f52e98e9"

URI_x86_64_v2_rust-dav1d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dav1d-devel-0.10.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dav1d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dav1d-devel}"
SRC_URI[x86_64_v2_rust-dav1d-devel.sha256sum] = "89d02c98a086e93a6b74f6eecd2b853c5a8df74892099aa83b417c514881ff38"

URI_aarch64_rust-dav1d+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dav1d+default-devel-0.10.4-1.el10_1.noarch.rpm;name=aarch64_rust-dav1d+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dav1d+default-devel}"
SRC_URI[aarch64_rust-dav1d+default-devel.sha256sum] = "a03bdbc6a61cdb0b71e665679d9768cf09c8d0a15a58a30d2d40840ea4423a35"

URI_aarch64_rust-dav1d-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dav1d-devel-0.10.4-1.el10_1.noarch.rpm;name=aarch64_rust-dav1d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dav1d-devel}"
SRC_URI[aarch64_rust-dav1d-devel.sha256sum] = "a0d734479099b167ef02e859f520e9444df03da7e83c0cebf820a0803607930c"

RDEPENDS:rust-dav1d+default-devel = " \
 cargo \
 rust-dav1d-devel \
 "
RDEPENDS:rust-dav1d-devel = " \
 cargo \
 rust-av-data+default-devel \
 rust-bitflags+default-devel \
 rust-dav1d-sys+default-devel \
 rust-static_assertions+default-devel \
 "
