# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project-internal"
PV = "1.1.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-pin-project-internal+default-devel \
 rust-pin-project-internal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-internal-1.1.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be7b9fa4a2543d56d8fcd4da239214830ef06ddfc3db5a67dbde10a2a8fb5af8"

URI_x86_64_v2_rust-pin-project-internal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-internal+default-devel-1.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-internal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-internal+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project-internal+default-devel.sha256sum] = "0bf8311d5be7438e5118a6ce615694e17abf3524f5cacaba3ece3229b5deae8e"

URI_x86_64_v2_rust-pin-project-internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-internal-devel-1.1.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-internal-devel}"
SRC_URI[x86_64_v2_rust-pin-project-internal-devel.sha256sum] = "fa579af1ae6c93c2367d2a7d6d04ef7a14d10deaf2b436e3bc5ec8fa7da4ac91"

URI_aarch64_rust-pin-project-internal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-internal+default-devel-1.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-pin-project-internal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-internal+default-devel}"
SRC_URI[aarch64_rust-pin-project-internal+default-devel.sha256sum] = "a742036b640443370470556c1cabb6ca3037e06700e2e74d87d6653fe57230c6"

URI_aarch64_rust-pin-project-internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-internal-devel-1.1.10-1.el10_0.noarch.rpm;name=aarch64_rust-pin-project-internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-internal-devel}"
SRC_URI[aarch64_rust-pin-project-internal-devel.sha256sum] = "5d7023f141d29c1b45730e3056c69de6f387a6302861a3505234c22a123dcc55"

RDEPENDS:rust-pin-project-internal+default-devel = " \
 cargo \
 rust-pin-project-internal-devel \
 "
RDEPENDS:rust-pin-project-internal-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
