# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbox-importer"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 mbox-importer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbox-importer-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf3a9beaea3362163bcf4e34ce8f9dcbe9bd7dbc632a6900df522db381ea62e9"

URI_x86_64_v2_mbox-importer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbox-importer-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbox-importer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbox-importer}"
SRC_URI[x86_64_v2_mbox-importer.sha256sum] = "a30284f936940a282d3e23047d5486c3fc0065b85a1b55bd0f4cd313505bdd46"

URI_aarch64_mbox-importer = "${EPEL_MIRROR}/aarch64/Packages/m/mbox-importer-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_mbox-importer;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbox-importer}"
SRC_URI[aarch64_mbox-importer.sha256sum] = "7deecdf51dfe18328f3fe346a7f28457a5e4a21405920fab73a42676f44ccaca"

RDEPENDS:mbox-importer = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
