# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Requires"
PV = "0.11"
PR = "16.el10"
PACKAGES = " \
 perl-Test-Requires \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Test-Requires-0.11-16.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0f2e415fb0de29e7386c6719f87da85a02bedba00ed4996a3204885153c3d04d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Test-Requires-0.11-16.el10.noarch.rpm;name=x86_64_v2_perl-Test-Requires;unpack=0"
SRC_URI[x86_64_v2_perl-Test-Requires.sha256sum] = "ba88b3c910268a7c0679d41a6b1d63f1754f888df1956881fabeb6c2d26c95f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Test-Requires-0.11-16.el10.noarch.rpm;name=aarch64_perl-Test-Requires;unpack=0"
SRC_URI[aarch64_perl-Test-Requires.sha256sum] = "ba88b3c910268a7c0679d41a6b1d63f1754f888df1956881fabeb6c2d26c95f8"

RDEPENDS:perl-Test-Requires = " \
 perl-Test-Simple \
 perl-base \
 perl-libs \
 "
