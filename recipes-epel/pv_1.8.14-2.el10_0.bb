# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pv"
PV = "1.8.14"
PR = "2.el10_0"
PACKAGES = " \
 pv \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pv-1.8.14-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6de6f2af6652550a099f4fac6273e5821457e529abeef7b6853ff5b979d8e297"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pv-1.8.14-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pv;unpack=0"
SRC_URI[x86_64_v2_pv.sha256sum] = "d4ade4f0c95642c650b2904226f29567760a26bd16517098cf2e2336f5011f36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pv-1.8.14-2.el10_0.aarch64.rpm;name=aarch64_pv;unpack=0"
SRC_URI[aarch64_pv.sha256sum] = "d1181498f42614bcbe39b3293b7dfe27b736b30082c20a67d883dde00c611307"

RDEPENDS:pv = " \
 glibc \
 "
