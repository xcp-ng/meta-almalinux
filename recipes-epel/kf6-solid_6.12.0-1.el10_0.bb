# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-solid"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-solid \
 kf6-solid-devel \
 kf6-solid-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-solid-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f651e0e094792a34b243f48ca02faa8850f0973f84afe6f5a2b9c96264b9182"

URI_x86_64_v2_kf6-solid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid}"
SRC_URI[x86_64_v2_kf6-solid.sha256sum] = "e48d3a88a38fe835405b16ec9d49bee8b89e3e34bfc8835e35767adc5380536d"

URI_x86_64_v2_kf6-solid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-devel}"
SRC_URI[x86_64_v2_kf6-solid-devel.sha256sum] = "020478f2ac13eac77d1f7f9d5e01407b41b25e5ee893d68375dc3e33219ee1b6"

URI_x86_64_v2_kf6-solid-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-solid-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-doc}"
SRC_URI[x86_64_v2_kf6-solid-doc.sha256sum] = "36dfedc4fe6ac14e1fda032037aeaa0dab937b8f5d2734e72154cea9456739b8"

URI_aarch64_kf6-solid = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-solid;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid}"
SRC_URI[aarch64_kf6-solid.sha256sum] = "4614e4907d22a273c63830234471927242d2fa9b0e22a8234ac9abb948d6dbbc"

URI_aarch64_kf6-solid-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-solid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-devel}"
SRC_URI[aarch64_kf6-solid-devel.sha256sum] = "476ce96285137cec30ceb6900687ecd6e21ba99a023bb0ded63617f41e198db1"

URI_aarch64_kf6-solid-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-solid-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-doc}"
SRC_URI[aarch64_kf6-solid-doc.sha256sum] = "a57c34a58aa251b1929e913166d9b2b0d2227fd997bc2f0b21ff7163371ee276"

RDEPENDS:kf6-solid = " \
 glibc \
 kf6-filesystem \
 libimobiledevice \
 libmount \
 libplist \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
RDEPENDS:kf6-solid-devel = " \
 cmake-filesystem \
 kf6-solid \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-solid-doc = " \
 "
