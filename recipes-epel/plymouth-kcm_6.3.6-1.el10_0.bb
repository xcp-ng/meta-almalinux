# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-kcm"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plymouth-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plymouth-kcm-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06bfb107cc56975d4a2145c0dd309a32f9fade7ec01768bb64e4b57f0b83e98f"

URI_x86_64_v2_plymouth-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-kcm-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plymouth-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-kcm}"
SRC_URI[x86_64_v2_plymouth-kcm.sha256sum] = "16a22d739d98a0974524642c69d4c8a266029915c7d1d465397b08a3af84256a"

URI_aarch64_plymouth-kcm = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-kcm-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plymouth-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-kcm}"
SRC_URI[aarch64_plymouth-kcm.sha256sum] = "3c7b94a25d5510596b22be1f3f40aa44931691e0f23ef55bd1d2ea700b317189"

RDEPENDS:plymouth-kcm = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knewstuff \
 libstdc++ \
 plymouth \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
