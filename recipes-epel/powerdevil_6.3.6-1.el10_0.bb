# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerdevil"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 powerdevil \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/powerdevil-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "582c4ed40aad948d86402969a5f2a736205d22c2353d6b51a200bf1629c656d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerdevil-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerdevil;unpack=0"
SRC_URI[x86_64_v2_powerdevil.sha256sum] = "f155ca7b4a46134c1a027400258244c465ed5e1c84c971c576ebd4e3118bdf65"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/powerdevil-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_powerdevil;unpack=0"
SRC_URI[aarch64_powerdevil.sha256sum] = "660a2530256cb53fad45858fc62d196e5dd1e9c471416a6ae5f118fa4e4ffc87"

RDEPENDS:powerdevil = " \
 ddcutil \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kirigami \
 kf6-knotifications \
 kf6-krunner \
 kf6-kservice \
 kf6-kxmlgui \
 kf6-solid \
 libddcutil \
 libkscreen \
 libkworkspace6 \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 systemd-libs \
 "
