# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khelpcenter"
PE = "1"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 khelpcenter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khelpcenter-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "446ba16cbc6da13bd022fb67f9eda7cbfc9e42b674f5cf27ebcc8b769848d44f"

URI_x86_64_v2_khelpcenter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khelpcenter-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khelpcenter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khelpcenter}"
SRC_URI[x86_64_v2_khelpcenter.sha256sum] = "6f862972db887b0911d1ebe2887126937988e13985604059f0b6ac6b13477126"

URI_aarch64_khelpcenter = "${EPEL_MIRROR}/aarch64/Packages/k/khelpcenter-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_khelpcenter;unpack=0"
SRC_URI:append = " ${URI_aarch64_khelpcenter}"
SRC_URI[aarch64_khelpcenter.sha256sum] = "3675531f2f1aaf443545015c40d142d66f6618023823dbd82a41cf0558ec03fa"

RDEPENDS:khelpcenter = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdoctools \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 libxml2 \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 xapian-core-libs \
 "
