# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-mpi-benchmarks"
PV = "2021.8"
PR = "9.el10_3"
PACKAGES = " \
 intel-mpi-benchmarks-license \
 intel-mpi-benchmarks-mpich \
 intel-mpi-benchmarks-openmpi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-mpi-benchmarks-2021.8-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b37dfd74a0d4dae2785e652e38ccb92bdbcd4a372a6a5a5768d062bee279eef2"

URI_x86_64_v2_intel-mpi-benchmarks-license = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-mpi-benchmarks-license-2021.8-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_intel-mpi-benchmarks-license;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-mpi-benchmarks-license}"
SRC_URI[x86_64_v2_intel-mpi-benchmarks-license.sha256sum] = "acfd5414114e8a03199790b3592afbad6a133c45b6821912a87a12f8c0534797"

URI_x86_64_v2_intel-mpi-benchmarks-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-mpi-benchmarks-mpich-2021.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-mpi-benchmarks-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-mpi-benchmarks-mpich}"
SRC_URI[x86_64_v2_intel-mpi-benchmarks-mpich.sha256sum] = "56d503ec76ba900f8f2c50863ee9b58a9f1b3fd32f52764bfaba3202266ce247"

URI_x86_64_v2_intel-mpi-benchmarks-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-mpi-benchmarks-openmpi-2021.8-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-mpi-benchmarks-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-mpi-benchmarks-openmpi}"
SRC_URI[x86_64_v2_intel-mpi-benchmarks-openmpi.sha256sum] = "2310fcfc5fd7e4d2f30b1c123213a11258dd15dfc425eaa4a770ddef4e0c224b"

URI_aarch64_intel-mpi-benchmarks-license = "${EPEL_MIRROR}/aarch64/Packages/i/intel-mpi-benchmarks-license-2021.8-9.el10_3.noarch.rpm;name=aarch64_intel-mpi-benchmarks-license;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-mpi-benchmarks-license}"
SRC_URI[aarch64_intel-mpi-benchmarks-license.sha256sum] = "edfff31768c00c0c43f79963fb7aaea8d0cad52952e5f7a256d6e357ce9cea9b"

URI_aarch64_intel-mpi-benchmarks-mpich = "${EPEL_MIRROR}/aarch64/Packages/i/intel-mpi-benchmarks-mpich-2021.8-9.el10_3.aarch64.rpm;name=aarch64_intel-mpi-benchmarks-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-mpi-benchmarks-mpich}"
SRC_URI[aarch64_intel-mpi-benchmarks-mpich.sha256sum] = "58890c0682abfc688d6d70764157213a1b3dcd054f16d3787ac9ed13eac22ecb"

URI_aarch64_intel-mpi-benchmarks-openmpi = "${EPEL_MIRROR}/aarch64/Packages/i/intel-mpi-benchmarks-openmpi-2021.8-9.el10_3.aarch64.rpm;name=aarch64_intel-mpi-benchmarks-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-mpi-benchmarks-openmpi}"
SRC_URI[aarch64_intel-mpi-benchmarks-openmpi.sha256sum] = "91cbd50aaf5d22c30209d7cfcc960d939d5a960d491c11d5554bf74e77566455"

RDEPENDS:intel-mpi-benchmarks-license = " \
 "
RDEPENDS:intel-mpi-benchmarks-mpich = " \
 glibc \
 intel-mpi-benchmarks-license \
 libgcc \
 libgomp \
 libstdc++ \
 mpich \
 "
RDEPENDS:intel-mpi-benchmarks-openmpi = " \
 glibc \
 intel-mpi-benchmarks-license \
 libgcc \
 libgomp \
 libstdc++ \
 openmpi \
 "
