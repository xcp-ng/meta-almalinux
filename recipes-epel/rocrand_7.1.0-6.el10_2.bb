# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocrand"
PV = "7.1.0"
PR = "6.el10_2"
PACKAGES:x86_64_v2 = " \
 rocrand \
 rocrand-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocrand-7.1.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69221f9de963eb022473d6d2bc031b124963e821223e245bb596adc3a7840047"

URI_x86_64_v2_rocrand = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocrand-7.1.0-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocrand;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocrand}"
SRC_URI[x86_64_v2_rocrand.sha256sum] = "9678892cadec6e4beb7071ab513263d7a210e44f4e02520984ac4eb0a81aed89"

URI_x86_64_v2_rocrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocrand-devel-7.1.0-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocrand-devel}"
SRC_URI[x86_64_v2_rocrand-devel.sha256sum] = "7d14961d0c134f2c2a58dd895bb09a7fb7033d317860f32541303eeba65556f6"

RDEPENDS:rocrand = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:rocrand-devel = " \
 cmake-filesystem \
 rocrand \
 "
