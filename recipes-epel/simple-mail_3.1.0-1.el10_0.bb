# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "simple-mail"
PV = "3.1.0"
PR = "1.el10_0"
PACKAGES = " \
 simple-mail \
 simple-mail-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/simple-mail-3.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b6501852f4f13bd987a874287e6624d1f056febc21f2cd98522877e12ec7168"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simple-mail-3.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simple-mail;unpack=0"
SRC_URI[x86_64_v2_simple-mail.sha256sum] = "1219b0ce77d9222410a566a3c5c00b326c50136c7fabb190f09ee407da522a9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simple-mail-devel-3.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simple-mail-devel;unpack=0"
SRC_URI[x86_64_v2_simple-mail-devel.sha256sum] = "2b5d86a3ddb3fd2ff50a5edc5b675be4fb66854a0ade002508b2060e06f8525f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/simple-mail-3.1.0-1.el10_0.aarch64.rpm;name=aarch64_simple-mail;unpack=0"
SRC_URI[aarch64_simple-mail.sha256sum] = "89554df8e48f29d81e0b7c09402bbb8308424551aa767e42e2a3a5c471b1a550"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/simple-mail-devel-3.1.0-1.el10_0.aarch64.rpm;name=aarch64_simple-mail-devel;unpack=0"
SRC_URI[aarch64_simple-mail-devel.sha256sum] = "08983286a6155c333b12827336fcb55e27a30cb9417c39e2902ff7ba291fb164"

RDEPENDS:simple-mail = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:simple-mail-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 simple-mail \
 "
