# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_calendar"
PV = "2.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_calendar+alloc-devel \
 rust-icu_calendar+compiled_data-devel \
 rust-icu_calendar+datagen-devel \
 rust-icu_calendar+default-devel \
 rust-icu_calendar+ixdtf-devel \
 rust-icu_calendar+logging-devel \
 rust-icu_calendar+serde-devel \
 rust-icu_calendar+unstable-devel \
 rust-icu_calendar+unstable_chrono_0_4-devel \
 rust-icu_calendar+unstable_jiff_0_2-devel \
 rust-icu_calendar+unstable_time_0_3-devel \
 rust-icu_calendar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_calendar-2.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24fbd0bfc49f016d6b8cd6116c1965ebba000acefe2134007771325a7fd90d8d"

URI_x86_64_v2_rust-icu_calendar+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+alloc-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+alloc-devel.sha256sum] = "23a74f0a9a7f586ae2f11f0448fbf27a6ba5d9164779918769a1530003e46ac1"

URI_x86_64_v2_rust-icu_calendar+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+compiled_data-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+compiled_data-devel.sha256sum] = "c90ff94d2a16167181726a3ff94026a2e1d25e9da2d8adf7cacd79e0b193b293"

URI_x86_64_v2_rust-icu_calendar+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+datagen-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+datagen-devel.sha256sum] = "e0dc450f6226c6d2ee9580217585dd457c77ef4da1af3852edba3e586d0176ad"

URI_x86_64_v2_rust-icu_calendar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+default-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+default-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+default-devel.sha256sum] = "3e75c76c9b216a5b9edc3e02491db3471714d46f9a08512df8abcb57ca8aa305"

URI_x86_64_v2_rust-icu_calendar+ixdtf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+ixdtf-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+ixdtf-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+ixdtf-devel.sha256sum] = "ed38324eec0216dc8a299d6e0703c94059cb4c1970c66c5b33bd518f47e8f299"

URI_x86_64_v2_rust-icu_calendar+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+logging-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+logging-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+logging-devel.sha256sum] = "60ee7b1c5876b3a1d543ac61e6a77c46ed5a9755ae190feb68a4e7d924e80b5a"

URI_x86_64_v2_rust-icu_calendar+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+serde-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+serde-devel.sha256sum] = "060168d2a812584edaa24f7c31644682b612c7f48c25cf1fa3c9bac796320d83"

URI_x86_64_v2_rust-icu_calendar+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+unstable-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+unstable-devel.sha256sum] = "633152caf6aa76278703171b239912f1ad5f657e6612f3c8efc153f318611797"

URI_x86_64_v2_rust-icu_calendar+unstable_chrono_0_4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+unstable_chrono_0_4-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+unstable_chrono_0_4-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+unstable_chrono_0_4-devel.sha256sum] = "ebcc4619d4bde8deb5192a4ced401058378af22a02c90dd0632e8a1c425a15b9"

URI_x86_64_v2_rust-icu_calendar+unstable_jiff_0_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+unstable_jiff_0_2-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+unstable_jiff_0_2-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+unstable_jiff_0_2-devel.sha256sum] = "970c4c391cc90e073abab1b97f73ae0aad957b5b6193d9115f8c070a4dc9303e"

URI_x86_64_v2_rust-icu_calendar+unstable_time_0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar+unstable_time_0_3-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar+unstable_time_0_3-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar+unstable_time_0_3-devel.sha256sum] = "1375ec462b12e77f55b8da6617e47caaa741052ee9586e9ee17a45003dcfa60b"

URI_x86_64_v2_rust-icu_calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_calendar-devel-2.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_calendar-devel}"
SRC_URI[x86_64_v2_rust-icu_calendar-devel.sha256sum] = "92fc205bba54d3af1b9ccdf7b7161806dbb2faf5b75a221ba378c2d9864647be"

URI_aarch64_rust-icu_calendar+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+alloc-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+alloc-devel}"
SRC_URI[aarch64_rust-icu_calendar+alloc-devel.sha256sum] = "f0d32702372ff4e7d0cbf3f1e517e73909ea4c512f85ac063405672d01853d1f"

URI_aarch64_rust-icu_calendar+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+compiled_data-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_calendar+compiled_data-devel.sha256sum] = "de22913861834f24cb34364e5f8ed9b9c75c139e4558eab968c16099ea2beb64"

URI_aarch64_rust-icu_calendar+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+datagen-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+datagen-devel}"
SRC_URI[aarch64_rust-icu_calendar+datagen-devel.sha256sum] = "4a85608ec504825fdb33e8b218c71b90fb9fe88ba0a15929c1eb7d5b66c5edf1"

URI_aarch64_rust-icu_calendar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+default-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+default-devel}"
SRC_URI[aarch64_rust-icu_calendar+default-devel.sha256sum] = "86dfc571fd932618325260e63fddd0d6611787fd339fbfb8950bcfb7479f6ea5"

URI_aarch64_rust-icu_calendar+ixdtf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+ixdtf-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+ixdtf-devel}"
SRC_URI[aarch64_rust-icu_calendar+ixdtf-devel.sha256sum] = "ba1284b98751f2b8837f0923c67670ceefe3965f833c61db7496297ff6dc424b"

URI_aarch64_rust-icu_calendar+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+logging-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+logging-devel}"
SRC_URI[aarch64_rust-icu_calendar+logging-devel.sha256sum] = "e67fbb3479127034f27b3648189d37db2cfdfedc8e4ead4798b5b79106d78384"

URI_aarch64_rust-icu_calendar+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+serde-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+serde-devel}"
SRC_URI[aarch64_rust-icu_calendar+serde-devel.sha256sum] = "2a0801f7c37d8da6cfd16d558cd65acab9447c98427926505a206a09e8524d2f"

URI_aarch64_rust-icu_calendar+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+unstable-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+unstable-devel}"
SRC_URI[aarch64_rust-icu_calendar+unstable-devel.sha256sum] = "33dbdade19a19a6c82b732403fd7ed8e7b40fdf5b68f3568e85367af6728fe8e"

URI_aarch64_rust-icu_calendar+unstable_chrono_0_4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+unstable_chrono_0_4-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+unstable_chrono_0_4-devel}"
SRC_URI[aarch64_rust-icu_calendar+unstable_chrono_0_4-devel.sha256sum] = "aa2f549925077bc50fadaa152792d97fc84825603879ed2eafa76ffa031ae2cf"

URI_aarch64_rust-icu_calendar+unstable_jiff_0_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+unstable_jiff_0_2-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+unstable_jiff_0_2-devel}"
SRC_URI[aarch64_rust-icu_calendar+unstable_jiff_0_2-devel.sha256sum] = "29bfaa86cac45010d8dc3337ac2c89ee22bd2ef2058bad4480ab3a6cf5bafee9"

URI_aarch64_rust-icu_calendar+unstable_time_0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar+unstable_time_0_3-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar+unstable_time_0_3-devel}"
SRC_URI[aarch64_rust-icu_calendar+unstable_time_0_3-devel.sha256sum] = "f011c207dba235a149f1cb55a9a8b1b4573755d8444228e582f922a1eb3997d9"

URI_aarch64_rust-icu_calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_calendar-devel-2.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-icu_calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_calendar-devel}"
SRC_URI[aarch64_rust-icu_calendar-devel.sha256sum] = "34a55206ba843988c077e9ee6e553afdd3bc3d3e26b03e342ffcf42ab347f12a"

RDEPENDS:rust-icu_calendar+alloc-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-icu_locale_core+alloc-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-tinystr+alloc-devel \
 "
RDEPENDS:rust-icu_calendar+compiled_data-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-icu_calendar_data-devel \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_calendar+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_calendar+alloc-devel \
 rust-icu_calendar+serde-devel \
 rust-icu_calendar-devel \
 rust-icu_provider+export-devel \
 rust-tinystr+databake-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_calendar+default-devel = " \
 cargo \
 rust-icu_calendar+compiled_data-devel \
 rust-icu_calendar+ixdtf-devel \
 rust-icu_calendar-devel \
 "
RDEPENDS:rust-icu_calendar+ixdtf-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-icu_calendar+logging-devel = " \
 cargo \
 rust-calendrical_calculations+logging-devel \
 rust-icu_calendar-devel \
 "
RDEPENDS:rust-icu_calendar+serde-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-icu_provider+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-tinystr+serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_calendar+unstable-devel = " \
 cargo \
 rust-icu_calendar-devel \
 "
RDEPENDS:rust-icu_calendar+unstable_chrono_0_4-devel = " \
 cargo \
 rust-chrono-devel \
 rust-icu_calendar-devel \
 "
RDEPENDS:rust-icu_calendar+unstable_jiff_0_2-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-icu_calendar+unstable_time_0_3-devel = " \
 cargo \
 rust-icu_calendar-devel \
 rust-time-devel \
 "
RDEPENDS:rust-icu_calendar-devel = " \
 cargo \
 rust \
 rust-calendrical_calculations-devel \
 rust-displaydoc-devel \
 rust-icu_locale_core-devel \
 rust-icu_provider-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 rust-zerovec+derive-devel \
 rust-zerovec-devel \
 "
