# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-vault"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-vault \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-vault-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2b91892d2a6629b0821ef3dd8c938df13455e1d8719742cea9737be3f4990d3"

URI_x86_64_v2_plasma-vault = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-vault-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-vault;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-vault}"
SRC_URI[x86_64_v2_plasma-vault.sha256sum] = "8dda1e069d23a245a6644c6394498eb127768c031595af4d5c41ab99bc2cedf7"

URI_aarch64_plasma-vault = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-vault-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-vault;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-vault}"
SRC_URI[aarch64_plasma-vault.sha256sum] = "f772e51cf5e804db63c04c1fbc4c65a46740d5acccac4b00bf38099f981549ae"

RDEPENDS:plasma-vault = " \
 glibc \
 gocryptfs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libgcc \
 libksysguard \
 libplasma \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
