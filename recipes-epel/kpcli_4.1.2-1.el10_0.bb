# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpcli"
PV = "4.1.2"
PR = "1.el10_0"
PACKAGES = " \
 kpcli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpcli-4.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7749d0624ff9e435c3630c041e5b244650c18a082f96da6e62109d91524727c2"

URI_x86_64_v2_kpcli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpcli-4.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kpcli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpcli}"
SRC_URI[x86_64_v2_kpcli.sha256sum] = "8d98ae4e47f0ee8a06316bf59df7d773c03aeb91fad1ddd858d754057a4f1179"

URI_aarch64_kpcli = "${EPEL_MIRROR}/aarch64/Packages/k/kpcli-4.1.2-1.el10_0.noarch.rpm;name=aarch64_kpcli;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpcli}"
SRC_URI[aarch64_kpcli.sha256sum] = "775d9c9a850f1e2e8ae9da446a7de894e6fcd434601195294be3f24c405c2aad"

RDEPENDS:kpcli = " \
 perl-Capture-Tiny \
 perl-Carp \
 perl-Clone \
 perl-Crypt-Rijndael \
 perl-Data-Dumper \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Encode \
 perl-English \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-KeePass \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Module-Loaded \
 perl-POSIX \
 perl-PathTools \
 perl-Sort-Naturally \
 perl-Term-ANSIColor \
 perl-Term-ReadLine \
 perl-Term-ReadLine-Gnu \
 perl-Term-ShellUI \
 perl-TermReadKey \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-Time-Piece \
 perl-XML-Parser \
 perl-constant \
 perl-diagnostics \
 perl-interpreter \
 perl-libs \
 perl-subs \
 perl-version \
 "
