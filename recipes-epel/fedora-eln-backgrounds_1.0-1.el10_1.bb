# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-eln-backgrounds"
PV = "1.0"
PR = "1.el10_1"
PACKAGES = " \
 fedora-eln-backgrounds \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fedora-eln-backgrounds-1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9dd55ba15f622673b90032ffa3ad28c64efc5ee2e989591b8be63503ee8404c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-eln-backgrounds-1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-eln-backgrounds;unpack=0"
SRC_URI[x86_64_v2_fedora-eln-backgrounds.sha256sum] = "1a4d1b251a80a6607f0dd8f3847f89aff3927e98b95afc4d6c86c51452d5c0d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fedora-eln-backgrounds-1.0-1.el10_1.noarch.rpm;name=aarch64_fedora-eln-backgrounds;unpack=0"
SRC_URI[aarch64_fedora-eln-backgrounds.sha256sum] = "10e82fbde4d0d96a256ea70eb829c36a340bc9b724280cd7bae84c5734262ac3"

RDEPENDS:fedora-eln-backgrounds = " \
 "
