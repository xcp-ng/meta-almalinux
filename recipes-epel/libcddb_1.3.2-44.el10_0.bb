# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcddb"
PV = "1.3.2"
PR = "44.el10_0"
PACKAGES = " \
 libcddb \
 libcddb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcddb-1.3.2-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fcbe8b9b7b91f7e3cf1a14ec72c3f3d24f17cb00e1b673865524d042abf01cc"

URI_x86_64_v2_libcddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcddb-1.3.2-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcddb}"
SRC_URI[x86_64_v2_libcddb.sha256sum] = "79e225a7a5576315c46b3bcf219b8dc4919b8a965371ca5f01d1897cc468cfdb"

URI_x86_64_v2_libcddb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcddb-devel-1.3.2-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcddb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcddb-devel}"
SRC_URI[x86_64_v2_libcddb-devel.sha256sum] = "cc6c3486bb38085389c137477b8232021b6518859fa32a72515d4cc41c692fe9"

URI_aarch64_libcddb = "${EPEL_MIRROR}/aarch64/Packages/l/libcddb-1.3.2-44.el10_0.aarch64.rpm;name=aarch64_libcddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcddb}"
SRC_URI[aarch64_libcddb.sha256sum] = "f18c64cd2142bedaa6a79f9ed75dc00f7f7866d01b3acc22e13fd4b8a2321fab"

URI_aarch64_libcddb-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcddb-devel-1.3.2-44.el10_0.aarch64.rpm;name=aarch64_libcddb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcddb-devel}"
SRC_URI[aarch64_libcddb-devel.sha256sum] = "a92315d87788fa385fb04f94dbe0bb38384c14b88b88104ba40237f1867cee4d"

RDEPENDS:libcddb = " \
 glibc \
 libcdio \
 "
RDEPENDS:libcddb-devel = " \
 libcddb \
 pkgconf-pkg-config \
 "
