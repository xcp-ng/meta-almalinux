# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sasl-xoauth2"
PV = "0.27"
PR = "1.el10_2"
PACKAGES = " \
 sasl-xoauth2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sasl-xoauth2-0.27-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "054a920f461d69a954cf63364d72948c94770f0289f924d982157d4e522e8986"

URI_x86_64_v2_sasl-xoauth2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sasl-xoauth2-0.27-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sasl-xoauth2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sasl-xoauth2}"
SRC_URI[x86_64_v2_sasl-xoauth2.sha256sum] = "92542aba16b45a74bcdc9e210a64949eb536d0f92b31bbef7b8a8c7b5eab9233"

URI_aarch64_sasl-xoauth2 = "${EPEL_MIRROR}/aarch64/Packages/s/sasl-xoauth2-0.27-1.el10_2.aarch64.rpm;name=aarch64_sasl-xoauth2;unpack=0"
SRC_URI:append = " ${URI_aarch64_sasl-xoauth2}"
SRC_URI[aarch64_sasl-xoauth2.sha256sum] = "9feef912d61ce8ddbdfebe8e59fccf053e05ba095bc3b36b5d0cf111049ddfcc"

RDEPENDS:sasl-xoauth2 = " \
 cyrus-sasl-lib \
 glibc \
 jsoncpp \
 libgcc \
 libstdc++ \
 python3 \
 python3-msal \
 virtual/libcurl.so.4___64bit_ \
 "
