# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "makedumpfile"
PV = "1.7.8"
PR = "2.el10"
PACKAGES = " \
 makedumpfile \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/makedumpfile-1.7.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1f120c8b95437d0502489c55fe0b8464b8b917c1a0cc391b0f4d6ca4301f1ac9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/makedumpfile-1.7.8-2.el10.x86_64_v2.rpm;name=x86_64_v2_makedumpfile;unpack=0"
SRC_URI[x86_64_v2_makedumpfile.sha256sum] = "4adefcb657caa5ab3efef70eebe531cc2fd320fd3cc7df3ff7155fbc154233d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/makedumpfile-1.7.8-2.el10.aarch64.rpm;name=aarch64_makedumpfile;unpack=0"
SRC_URI[aarch64_makedumpfile.sha256sum] = "2be65b0d5c49f2c7e72e4db491dc4dec96331b46425c1c3538ffcd17a33e87dc"

RDEPENDS:makedumpfile = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libgcc \
 libzstd \
 lzo \
 ncurses-libs \
 snappy \
 zlib-ng-compat \
 "
