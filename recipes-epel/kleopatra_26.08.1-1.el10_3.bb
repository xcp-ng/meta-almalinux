# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kleopatra"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kleopatra \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kleopatra-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e5a8b5ccc995d2ef2ca88613f43ee37d9f2ebb3293843f587e6fd0275aa45f9f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kleopatra-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kleopatra;unpack=0"
SRC_URI[x86_64_v2_kleopatra.sha256sum] = "a630ab83636114160cced055cc28cac0131713fef81e264a2f9ed9e4cdf36f7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kleopatra-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kleopatra;unpack=0"
SRC_URI[aarch64_kleopatra.sha256sum] = "cf333c18c970530b0e4c94fde50a7b39cdc3897b839c2e27cb139e3b897d2269"

RDEPENDS:kleopatra = " \
 akonadi-mime \
 glibc \
 gnupg2 \
 gnupg2-smime \
 gpgme2pp \
 kdsingleapplication-qt6 \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kitemmodels \
 kf6-kmime \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 libassuan \
 libgcc \
 libgpg-error \
 libkleo \
 libstdc++ \
 mimetreeparser \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
