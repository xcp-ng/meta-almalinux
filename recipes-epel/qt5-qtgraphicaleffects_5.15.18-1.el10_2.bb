# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtgraphicaleffects"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtgraphicaleffects \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtgraphicaleffects-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "432e83b557818021b8f542303ed04d0ce81e27af47c3619b6a76a297fb1e8fdb"

URI_x86_64_v2_qt5-qtgraphicaleffects = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgraphicaleffects-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgraphicaleffects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgraphicaleffects}"
SRC_URI[x86_64_v2_qt5-qtgraphicaleffects.sha256sum] = "0c345fd48ecece7712a4b70d442b14fc8955f6f4cdd7946d61a4c06eefde27d1"

URI_aarch64_qt5-qtgraphicaleffects = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgraphicaleffects-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtgraphicaleffects;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgraphicaleffects}"
SRC_URI[aarch64_qt5-qtgraphicaleffects.sha256sum] = "7445fc67bf1b677df208739e0ea611eacb92bd166bee8f5e40a1703f2af0c971"

RDEPENDS:qt5-qtgraphicaleffects = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
