# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksieve"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libksieve \
 libksieve-devel \
 libksieve-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libksieve-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a0f0a88263ed1b6be3fa6e4e0248594972c298db11a025b06aba8dc510f870ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksieve;unpack=0"
SRC_URI[x86_64_v2_libksieve.sha256sum] = "5edf5d2710e8dfde58814331eec5ceb5300cbcdf55e42a73e9dfaa46f6822546"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksieve-devel;unpack=0"
SRC_URI[x86_64_v2_libksieve-devel.sha256sum] = "794d5fe03872a1e97d82f1a7831cecd50217988cf8f4ed7dea031cbb2ea50e07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksieve-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libksieve-doc;unpack=0"
SRC_URI[x86_64_v2_libksieve-doc.sha256sum] = "52813a1f69b42ef3e565f7992ae99963a203db6f34b278eabb3bf08eb5680697"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libksieve-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libksieve;unpack=0"
SRC_URI[aarch64_libksieve.sha256sum] = "abb752124250c25ac8dbdc72f3a4760329ee0a4a4309e43544bd484c5a72f357"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libksieve-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libksieve-devel;unpack=0"
SRC_URI[aarch64_libksieve-devel.sha256sum] = "f42dd86f4a01aa5ee3adadc102c325d68605f7d112df8b92662608b789ed0405"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libksieve-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_libksieve-doc;unpack=0"
SRC_URI[aarch64_libksieve-doc.sha256sum] = "2a779ec3c61b0a35713e249f50b814a80c120936cf77e0c091b6e376f0a5ad66"

RDEPENDS:libksieve = " \
 cyrus-sasl-lib \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kmime \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kidentitymanagement \
 ktextaddons-qt6 \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:libksieve-devel = " \
 cmake-filesystem \
 kf6-syntax-highlighting-devel \
 libksieve \
 "
RDEPENDS:libksieve-doc = " \
 "
