# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-cmd"
PV = "1.0.200"
PR = "1.el10_3"
PACKAGES = " \
 cxxbridge \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-cmd-1.0.200-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1817535883195c9435b17b021cb2354fc409d0c014f90d104ee99da76baca363"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cxxbridge-1.0.200-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cxxbridge;unpack=0"
SRC_URI[x86_64_v2_cxxbridge.sha256sum] = "9cee97e9f6b5557159df309285ada1fc9e5a777654a4b4cc999e46beb52282a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cxxbridge-1.0.200-1.el10_3.aarch64.rpm;name=aarch64_cxxbridge;unpack=0"
SRC_URI[aarch64_cxxbridge.sha256sum] = "67fbf587001282cba7a46aa9be341cd38abebc2e0e481fabba0482f1c3815c63"

RDEPENDS:cxxbridge = " \
 glibc \
 libgcc \
 "
