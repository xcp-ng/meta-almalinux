# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-either"
PV = "1.15.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-either+default-devel \
 rust-either+serde-devel \
 rust-either+std-devel \
 rust-either+use_std-devel \
 rust-either-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-either-1.15.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "402583042b66008db36538566cd5825737a2757d2f265d72fd2a8c4f4c0f3193"

URI_x86_64_v2_rust-either+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+default-devel-1.15.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+default-devel}"
SRC_URI[x86_64_v2_rust-either+default-devel.sha256sum] = "0d5ae7edaa027a40f53ec4e6c55ef21d4c9b0d0ef02714ea692f6a858e8d37fe"

URI_x86_64_v2_rust-either+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+serde-devel-1.15.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+serde-devel}"
SRC_URI[x86_64_v2_rust-either+serde-devel.sha256sum] = "2f9e4fd1a8b772830f635825202809cdb14e00d86ca38dcfefba2513cfb283d8"

URI_x86_64_v2_rust-either+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+std-devel-1.15.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+std-devel}"
SRC_URI[x86_64_v2_rust-either+std-devel.sha256sum] = "5d450a9620f41215643b5f9f6dcaddc780cac01f189bb7876014ad29da6c3d11"

URI_x86_64_v2_rust-either+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either+use_std-devel-1.15.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either+use_std-devel}"
SRC_URI[x86_64_v2_rust-either+use_std-devel.sha256sum] = "94fe78594a11c6a96637efa1d5069f66a003e5ec3a636bbb5b2b14f2d5dcae6f"

URI_x86_64_v2_rust-either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-either-devel-1.15.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-either-devel}"
SRC_URI[x86_64_v2_rust-either-devel.sha256sum] = "6105de80f62865d46546916504f2a44a0c1528f92a76419cc1a1d29ef6780c5e"

URI_aarch64_rust-either+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+default-devel-1.15.0-1.el10_1.noarch.rpm;name=aarch64_rust-either+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+default-devel}"
SRC_URI[aarch64_rust-either+default-devel.sha256sum] = "8ec4654cfe33f12e4325ba7ab6520554efe9fa9038eb588e2abe33a01ffb12a9"

URI_aarch64_rust-either+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+serde-devel-1.15.0-1.el10_1.noarch.rpm;name=aarch64_rust-either+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+serde-devel}"
SRC_URI[aarch64_rust-either+serde-devel.sha256sum] = "f8dcb41c69e6253763e90c2ad244c0f4a0b802a3d82acd675d683955de217298"

URI_aarch64_rust-either+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+std-devel-1.15.0-1.el10_1.noarch.rpm;name=aarch64_rust-either+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+std-devel}"
SRC_URI[aarch64_rust-either+std-devel.sha256sum] = "d98c53c9266a2e4340be8dc4e2b50f35dc84ebf1a11ff53f75f352e2a7f6c51d"

URI_aarch64_rust-either+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either+use_std-devel-1.15.0-1.el10_1.noarch.rpm;name=aarch64_rust-either+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either+use_std-devel}"
SRC_URI[aarch64_rust-either+use_std-devel.sha256sum] = "6c60d091b6613773c6ab9c3fb43695aa06fe4512b8da7fb606b0ba76f6ce0b41"

URI_aarch64_rust-either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-either-devel-1.15.0-1.el10_1.noarch.rpm;name=aarch64_rust-either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-either-devel}"
SRC_URI[aarch64_rust-either-devel.sha256sum] = "2a865decfd9dfc3c19700e9cdcd28e166166a7cbdbe058f8b383708199a8e108"

RDEPENDS:rust-either+default-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either+serde-devel = " \
 cargo \
 rust-either-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-either+std-devel = " \
 cargo \
 rust-either-devel \
 "
RDEPENDS:rust-either+use_std-devel = " \
 cargo \
 rust-either+std-devel \
 rust-either-devel \
 "
RDEPENDS:rust-either-devel = " \
 cargo \
 rust \
 "
