# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-oklog-run"
PV = "1.1.0"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-oklog-run-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-oklog-run-1.1.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e92438b053b2002c151048c1875d28a1ed8dc693c1bb106af266825393e733d"

URI_x86_64_v2_golang-github-oklog-run-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-oklog-run-devel-1.1.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-oklog-run-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-oklog-run-devel}"
SRC_URI[x86_64_v2_golang-github-oklog-run-devel.sha256sum] = "5061d7db38d5580c1135f5c32f5650bfdf1d7b86238e717ea0150d8d41578b28"

URI_aarch64_golang-github-oklog-run-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-oklog-run-devel-1.1.0-16.el10_0.noarch.rpm;name=aarch64_golang-github-oklog-run-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-oklog-run-devel}"
SRC_URI[aarch64_golang-github-oklog-run-devel.sha256sum] = "5d7998e1389a1178f028755ea1fd82f8c7b6d2af161a70f711579ad0178ca7c4"

RDEPENDS:golang-github-oklog-run-devel = " \
 go-filesystem \
 "
