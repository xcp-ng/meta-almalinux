# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wmctrl"
PV = "1.07"
PR = "38.el10_0"
PACKAGES = " \
 wmctrl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wmctrl-1.07-38.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e368163f3f05144d7421be5a732d10691b32bb4f8e2cfcec6fed9df8604ca2ac"

URI_x86_64_v2_wmctrl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wmctrl-1.07-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wmctrl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wmctrl}"
SRC_URI[x86_64_v2_wmctrl.sha256sum] = "05bfeaa20e730106f06bd8e733a5d3238a53e85a8ee1cc88d68d36d2c72ceefb"

URI_aarch64_wmctrl = "${EPEL_MIRROR}/aarch64/Packages/w/wmctrl-1.07-38.el10_0.aarch64.rpm;name=aarch64_wmctrl;unpack=0"
SRC_URI:append = " ${URI_aarch64_wmctrl}"
SRC_URI[aarch64_wmctrl.sha256sum] = "5fd7d7ac3c0aa4f4ef0e27e990e5333a0f63f0ff17a6c322af20ed24fd7d179d"

RDEPENDS:wmctrl = " \
 glib2 \
 glibc \
 libX11 \
 libXmu \
 "
