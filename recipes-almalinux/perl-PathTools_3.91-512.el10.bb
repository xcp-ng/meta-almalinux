# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PathTools"
PV = "3.91"
PR = "512.el10"
PACKAGES = " \
 perl-PathTools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/perl-PathTools-3.91-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a88e6c4296928f41deacae4678e7b7c481e3a11392c3196e027273775e1633ca"

URI_x86_64_v2_perl-PathTools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/perl-PathTools-3.91-512.el10.x86_64_v2.rpm;name=x86_64_v2_perl-PathTools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PathTools}"
SRC_URI[x86_64_v2_perl-PathTools.sha256sum] = "7b5d53498f02c865a0860814c45f7fb9806bebd6aba1f0922315d7e233a72924"

URI_aarch64_perl-PathTools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/perl-PathTools-3.91-512.el10.aarch64.rpm;name=aarch64_perl-PathTools;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PathTools}"
SRC_URI[aarch64_perl-PathTools.sha256sum] = "4f96faa1b89613df3f31a70c23d6db5abd738767ebaa80cfa879b8b2b196f8c2"

RDEPENDS:perl-PathTools = " \
 glibc \
 perl-Carp \
 perl-Errno \
 perl-Exporter \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 "
