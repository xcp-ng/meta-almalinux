# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Gtk3"
PV = "0.038"
PR = "18.el10_0"
PACKAGES = " \
 perl-Gtk3 \
 perl-Gtk3-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Gtk3-0.038-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1e5b48414dad44418eeb89ce24458ea9bd2cbf47fb2a787fa03698b2b438f0d"

URI_x86_64_v2_perl-Gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-0.038-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3}"
SRC_URI[x86_64_v2_perl-Gtk3.sha256sum] = "6defdbc922e9cb130f02b5197addda4258012101b768d93b5907b8ff3417dbbf"

URI_x86_64_v2_perl-Gtk3-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-tests-0.038-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-tests}"
SRC_URI[x86_64_v2_perl-Gtk3-tests.sha256sum] = "74cb1facf5cd8f53f5b95ee8abec483d4d298f9b8f1512ca4219b95762432ebf"

URI_aarch64_perl-Gtk3 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-0.038-18.el10_0.noarch.rpm;name=aarch64_perl-Gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3}"
SRC_URI[aarch64_perl-Gtk3.sha256sum] = "f28020925bc97c83781ade4f9f167b3921df9c77e4bc20f456ab1583322e3e5e"

URI_aarch64_perl-Gtk3-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-tests-0.038-18.el10_0.noarch.rpm;name=aarch64_perl-Gtk3-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-tests}"
SRC_URI[aarch64_perl-Gtk3-tests.sha256sum] = "db5843807ef1e384988925252f278d2756856b005ca00a19e0add2f656216068"

RDEPENDS:perl-Gtk3 = " \
 gtk3 \
 perl-Cairo-GObject \
 perl-Carp \
 perl-Exporter \
 perl-Glib-Object-Introspection \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Gtk3-tests = " \
 bash \
 gdk-pixbuf2-modules-extra \
 mutter \
 perl-Encode \
 perl-File-Temp \
 perl-Glib \
 perl-Gtk3 \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-constant \
 perl-interpreter \
 perl-libs \
 xwayland-run \
 "
