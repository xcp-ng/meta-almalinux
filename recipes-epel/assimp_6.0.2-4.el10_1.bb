# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "assimp"
PV = "6.0.2"
PR = "4.el10_1"
PACKAGES = " \
 assimp \
 assimp-devel \
 assimp-doc \
 python3-assimp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/assimp-6.0.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dad5233d5c2ec489aeb6e37282eae1a6d928670f1c2a827fb7e7d6cfd72eb2f7"

URI_x86_64_v2_assimp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/assimp-6.0.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_assimp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_assimp}"
SRC_URI[x86_64_v2_assimp.sha256sum] = "1520e2698d130a13e204250ee709b0ac04f4368ebaa3afa103f46994fc5233ea"

URI_x86_64_v2_assimp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/assimp-devel-6.0.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_assimp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_assimp-devel}"
SRC_URI[x86_64_v2_assimp-devel.sha256sum] = "40967848b873ffb2a73e97bdc9d41de7127e7249fbe869cd24bf8f23a9025f87"

URI_x86_64_v2_assimp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/assimp-doc-6.0.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_assimp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_assimp-doc}"
SRC_URI[x86_64_v2_assimp-doc.sha256sum] = "07e7c1a28ef52ac0478e8fe8680d3f8fed7230db2aa15ed8aaa1e8ac8ffad0c9"

URI_x86_64_v2_python3-assimp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-assimp-6.0.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-assimp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-assimp}"
SRC_URI[x86_64_v2_python3-assimp.sha256sum] = "fcbb9a16ee2d13b6fd1cd0adf5eabc84b9bc8e80b1258f0944a1b04d859a238c"

URI_aarch64_assimp = "${EPEL_MIRROR}/aarch64/Packages/a/assimp-6.0.2-4.el10_1.aarch64.rpm;name=aarch64_assimp;unpack=0"
SRC_URI:append = " ${URI_aarch64_assimp}"
SRC_URI[aarch64_assimp.sha256sum] = "36392ce2b160d948e407b2799a989ed2b059fcb622e0955d2353384f8364a940"

URI_aarch64_assimp-devel = "${EPEL_MIRROR}/aarch64/Packages/a/assimp-devel-6.0.2-4.el10_1.aarch64.rpm;name=aarch64_assimp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_assimp-devel}"
SRC_URI[aarch64_assimp-devel.sha256sum] = "eb2f725bf85a916758732b12a72673010725c28b63b074ba4d65d0eab779b748"

URI_aarch64_assimp-doc = "${EPEL_MIRROR}/aarch64/Packages/a/assimp-doc-6.0.2-4.el10_1.noarch.rpm;name=aarch64_assimp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_assimp-doc}"
SRC_URI[aarch64_assimp-doc.sha256sum] = "55d41435178f3bcb09e62cc261a40ce85e9eddf811e752f852c4d456edac6d38"

URI_aarch64_python3-assimp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-assimp-6.0.2-4.el10_1.noarch.rpm;name=aarch64_python3-assimp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-assimp}"
SRC_URI[aarch64_python3-assimp.sha256sum] = "4425e8c491d6dc49a6f64c8a2ff8cf056f5148914366a4217f29a75fa822622c"

RDEPENDS:assimp = " \
 glibc \
 libgcc \
 libstdc++ \
 poly2tri \
 pugixml \
 zlib-ng-compat \
 "
RDEPENDS:assimp-devel = " \
 assimp \
 cmake-filesystem \
 pkgconf-pkg-config \
 poly2tri-devel \
 pugixml-devel \
 "
RDEPENDS:assimp-doc = " \
 "
RDEPENDS:python3-assimp = " \
 assimp \
 python3 \
 "
