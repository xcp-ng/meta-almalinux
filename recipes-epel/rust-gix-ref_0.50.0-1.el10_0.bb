# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-ref"
PV = "0.50.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-ref+default-devel \
 rust-gix-ref+document-features-devel \
 rust-gix-ref+serde-devel \
 rust-gix-ref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-ref-0.50.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66961298fa929897e397d81ba2ea953fc8a0a6b21aae4b0da216635bc9e0cd28"

URI_x86_64_v2_rust-gix-ref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+default-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+default-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+default-devel.sha256sum] = "0762adadb39b75939085b7980d1149ea040275c354e93f97417defa367c4d18f"

URI_x86_64_v2_rust-gix-ref+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+document-features-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+document-features-devel.sha256sum] = "a63e64820a836d4df7d2e47a13cced44ea3a41ccf8ba628e957a8c7ab234c12d"

URI_x86_64_v2_rust-gix-ref+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+serde-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+serde-devel.sha256sum] = "b3a3db77fa835fb8bdc1f70fb4ebabbdacc7a95452414407b5dc6045fe1d4ab7"

URI_x86_64_v2_rust-gix-ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref-devel-0.50.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref-devel}"
SRC_URI[x86_64_v2_rust-gix-ref-devel.sha256sum] = "833d6d61634417c5807314f583f444702c061d530206569e19134a1375705db9"

URI_aarch64_rust-gix-ref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+default-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+default-devel}"
SRC_URI[aarch64_rust-gix-ref+default-devel.sha256sum] = "96e9c51a22065b6631474e3a7b2a9e3f36957e7b1ca6a808366f6b3405cc4220"

URI_aarch64_rust-gix-ref+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+document-features-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-ref+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+document-features-devel}"
SRC_URI[aarch64_rust-gix-ref+document-features-devel.sha256sum] = "55a87082f647299b280f8596ea77457cfb6417b61b5b06a248a2b843618b8fe8"

URI_aarch64_rust-gix-ref+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+serde-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-ref+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+serde-devel}"
SRC_URI[aarch64_rust-gix-ref+serde-devel.sha256sum] = "d0b30e5f2d9821fe36a02964b521839bd7696815a574463cfe191ee3bf532992"

URI_aarch64_rust-gix-ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref-devel-0.50.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref-devel}"
SRC_URI[aarch64_rust-gix-ref-devel.sha256sum] = "906e64548dde36b0247ea2b208cd76f6f9b915679f4a1272846ea5e867c96a9b"

RDEPENDS:rust-gix-ref+default-devel = " \
 cargo \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+serde-devel = " \
 cargo \
 rust-gix-actor+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-ref-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-ref-devel = " \
 cargo \
 rust \
 rust-gix-actor+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-tempfile-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-memmap2+default-devel \
 rust-thiserror+default-devel \
 rust-winnow0.6+default-devel \
 rust-winnow0.6+simd-devel \
 "
