# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-OAuth"
PV = "0.33"
PR = "2.el10_2"
PACKAGES = " \
 perl-Net-OAuth \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Net-OAuth-0.33-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "424384df3fac0f9be8d43dec470c7f493ea6c8a894c48d120ff42c32c8c22c2c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-OAuth-0.33-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-OAuth;unpack=0"
SRC_URI[x86_64_v2_perl-Net-OAuth.sha256sum] = "4c3b862e0e158740274280756525040881c32410860403fe1c23103e21f75310"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-OAuth-0.33-2.el10_2.noarch.rpm;name=aarch64_perl-Net-OAuth;unpack=0"
SRC_URI[aarch64_perl-Net-OAuth.sha256sum] = "a2e7ef2b5a71d7c5ddd522409d165f3280ac7b08c6886e5e5013cc6bfd5e846c"

RDEPENDS:perl-Net-OAuth = " \
 perl-Carp \
 perl-Class-Accessor \
 perl-Class-Data-Inheritable \
 perl-Crypt-SysRandom \
 perl-Digest-SHA \
 perl-MIME-Base64 \
 perl-Net-OAuth \
 perl-URI \
 perl-base \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 "
