# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dirty-equals"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-dirty-equals \
 python3-dirty-equals+pydantic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dirty-equals-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4180ab4bf15e4274b73d847c57447c54ac14ab5f57dee582e28259eb6072565"

URI_x86_64_v2_python3-dirty-equals = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dirty-equals-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dirty-equals;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dirty-equals}"
SRC_URI[x86_64_v2_python3-dirty-equals.sha256sum] = "87d4f02d1c7ab1b043d601828f60dd9913299811a87e5eaa32613c19826f894b"

URI_x86_64_v2_python3-dirty-equals+pydantic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dirty-equals+pydantic-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dirty-equals+pydantic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dirty-equals+pydantic}"
SRC_URI[x86_64_v2_python3-dirty-equals+pydantic.sha256sum] = "ee6cd990883e3f8f5e7727fd05cb430e211d5214ffd3f587cc495ffaeb0dde52"

URI_aarch64_python3-dirty-equals = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dirty-equals-0.9.0-1.el10_0.noarch.rpm;name=aarch64_python3-dirty-equals;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dirty-equals}"
SRC_URI[aarch64_python3-dirty-equals.sha256sum] = "2741ca6b83fe01a383a1ad933ae2696c380326d3e1b0b4e68e2746981e8bf0e4"

URI_aarch64_python3-dirty-equals+pydantic = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dirty-equals+pydantic-0.9.0-1.el10_0.noarch.rpm;name=aarch64_python3-dirty-equals+pydantic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dirty-equals+pydantic}"
SRC_URI[aarch64_python3-dirty-equals+pydantic.sha256sum] = "14fcecd15702d39d43bd8a0c65387cfeef98171c7e9b74ab7de94cc369fee441"

RDEPENDS:python3-dirty-equals = " \
 python3 \
 "
RDEPENDS:python3-dirty-equals+pydantic = " \
 python3 \
 python3-dirty-equals \
 python3-pydantic \
 "
