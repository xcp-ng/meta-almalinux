# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-AnyEvent-XSPromises"
PV = "0.006"
PR = "2.el10_1"
PACKAGES = " \
 perl-AnyEvent-XSPromises \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-AnyEvent-XSPromises-0.006-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "118463baf7562ebb5a32a32be59011b4ca6b7e542baa14d3e641d126b8bf01b7"

URI_x86_64_v2_perl-AnyEvent-XSPromises = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-AnyEvent-XSPromises-0.006-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-AnyEvent-XSPromises;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-AnyEvent-XSPromises}"
SRC_URI[x86_64_v2_perl-AnyEvent-XSPromises.sha256sum] = "d2617d4513c4c22298e8f34a5d71837939f707061f2f44e71e1605396a332f1a"

URI_aarch64_perl-AnyEvent-XSPromises = "${EPEL_MIRROR}/aarch64/Packages/p/perl-AnyEvent-XSPromises-0.006-2.el10_1.aarch64.rpm;name=aarch64_perl-AnyEvent-XSPromises;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-AnyEvent-XSPromises}"
SRC_URI[aarch64_perl-AnyEvent-XSPromises.sha256sum] = "1f1b760e176b19a87dbe3218d8e188026fa515b37e8e05896233691c8a5fd58c"

RDEPENDS:perl-AnyEvent-XSPromises = " \
 glibc \
 perl-AnyEvent \
 perl-AnyEvent-XSPromises \
 perl-Exporter \
 perl-libs \
 "
