# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-xml0.31"
PV = "0.31.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-quick-xml0.31+arbitrary-devel \
 rust-quick-xml0.31+async-tokio-devel \
 rust-quick-xml0.31+default-devel \
 rust-quick-xml0.31+document-features-devel \
 rust-quick-xml0.31+encoding-devel \
 rust-quick-xml0.31+encoding_rs-devel \
 rust-quick-xml0.31+escape-html-devel \
 rust-quick-xml0.31+overlapped-lists-devel \
 rust-quick-xml0.31+serde-devel \
 rust-quick-xml0.31+serde-types-devel \
 rust-quick-xml0.31+serialize-devel \
 rust-quick-xml0.31+tokio-devel \
 rust-quick-xml0.31-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-xml0.31-0.31.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abb79027ee43079a4077e9263ecde4b567a53084680dd962246ab34aeb85585d"

URI_x86_64_v2_rust-quick-xml0.31+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+arbitrary-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+arbitrary-devel.sha256sum] = "bf8f524da887268c54b339df8e8958eae85d6eb2107bf3873e4e2036b951957c"

URI_x86_64_v2_rust-quick-xml0.31+async-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+async-tokio-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+async-tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+async-tokio-devel.sha256sum] = "b1dadd6a50d5415a15979fbfb3c8dfe156070262c4fbb6c56eed53996831dc14"

URI_x86_64_v2_rust-quick-xml0.31+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+default-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+default-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+default-devel.sha256sum] = "b53d86949cfa435639362f95e037b7c38eb9d5c292ddf166c4881b00e85ed999"

URI_x86_64_v2_rust-quick-xml0.31+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+document-features-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+document-features-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+document-features-devel.sha256sum] = "47470bd9d009e80c34329dc3a4c70a9954638f2fc154f4ba00ae21aa400958b8"

URI_x86_64_v2_rust-quick-xml0.31+encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+encoding-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+encoding-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+encoding-devel.sha256sum] = "f502dc6cc7d4dd2905c7e75908f1076dc859c70d204c9b75ff99fc3c53b85ca0"

URI_x86_64_v2_rust-quick-xml0.31+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+encoding_rs-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+encoding_rs-devel.sha256sum] = "5a2526128befb5b5614bca0aded8123e4591f5191c745c3df2000c8e5b21f5b0"

URI_x86_64_v2_rust-quick-xml0.31+escape-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+escape-html-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+escape-html-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+escape-html-devel.sha256sum] = "8fddbff68063f45e4bc7c0860678b1471265d07aefb422f280f588067ec87c98"

URI_x86_64_v2_rust-quick-xml0.31+overlapped-lists-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+overlapped-lists-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+overlapped-lists-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+overlapped-lists-devel.sha256sum] = "2a3b1dbe3c0afb67507417816db02bfe5df57ff13e25de14dfd12df4684d7740"

URI_x86_64_v2_rust-quick-xml0.31+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+serde-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+serde-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+serde-devel.sha256sum] = "a220e62e0a48362991c9cefe744e4e44f97ec7c7eeb31c4504ffda7986da20ae"

URI_x86_64_v2_rust-quick-xml0.31+serde-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+serde-types-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+serde-types-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+serde-types-devel.sha256sum] = "85c24802382ba35ca1a90a6079e8e262b46c860fa4ee6b95e8660610afb666a7"

URI_x86_64_v2_rust-quick-xml0.31+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+serialize-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+serialize-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+serialize-devel.sha256sum] = "e85e3486dc0c80f7492e5d32a00c900407f90a633af662aacf41f594188dca5a"

URI_x86_64_v2_rust-quick-xml0.31+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31+tokio-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31+tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31+tokio-devel.sha256sum] = "574b88c1a275cf557d91298b96ef835e458439529985dc5d9e365a63c7ffa88c"

URI_x86_64_v2_rust-quick-xml0.31-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml0.31-devel-0.31.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml0.31-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml0.31-devel}"
SRC_URI[x86_64_v2_rust-quick-xml0.31-devel.sha256sum] = "6f2c8467362d710d9e7fbf609de2de4eea16090cad68edabbe30688dcf122a6b"

URI_aarch64_rust-quick-xml0.31+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+arbitrary-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+arbitrary-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+arbitrary-devel.sha256sum] = "79d27c1310bb228b927cd9dd008d88ca75d99c1ad00f7521b10f31876a4a189b"

URI_aarch64_rust-quick-xml0.31+async-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+async-tokio-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+async-tokio-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+async-tokio-devel.sha256sum] = "861ef60cf9bd18fa4472277940b21028f124c93e8f98759ea9affe099ce06582"

URI_aarch64_rust-quick-xml0.31+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+default-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+default-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+default-devel.sha256sum] = "93dc40707d7b92a7b7be49887bccc56d4456fb26254163f4c26466f777b5628f"

URI_aarch64_rust-quick-xml0.31+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+document-features-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+document-features-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+document-features-devel.sha256sum] = "887540ef705a8cbc0f057ed14eb20a85eef34592fe1204e6731e3d1086b59b7e"

URI_aarch64_rust-quick-xml0.31+encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+encoding-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+encoding-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+encoding-devel.sha256sum] = "91999ccd168d62ef439da89104abcfc56542b598e48f99000f0b5fefba1b46bf"

URI_aarch64_rust-quick-xml0.31+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+encoding_rs-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+encoding_rs-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+encoding_rs-devel.sha256sum] = "2566ab36b834614e8b496a13ac530feb7b9e3e0d1136299579af95b3a0343673"

URI_aarch64_rust-quick-xml0.31+escape-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+escape-html-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+escape-html-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+escape-html-devel.sha256sum] = "1af01b8535a0c99eb1d5c20c66c5b06062e631cdd2b85b145e0bfb8c98f0a8e7"

URI_aarch64_rust-quick-xml0.31+overlapped-lists-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+overlapped-lists-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+overlapped-lists-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+overlapped-lists-devel.sha256sum] = "6b5937c814dd12172ff756e4b18f5583477766be97199eed7a78cbcf0718425a"

URI_aarch64_rust-quick-xml0.31+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+serde-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+serde-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+serde-devel.sha256sum] = "6fa224f326a3a7f48a9a1f57f5650ed77a27a69b6a990e8b0578e51176e578a5"

URI_aarch64_rust-quick-xml0.31+serde-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+serde-types-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+serde-types-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+serde-types-devel.sha256sum] = "d534c95129e196e2fd464972a28ea2cdf1510a6211c1969cb94fa8c3f7a68c9a"

URI_aarch64_rust-quick-xml0.31+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+serialize-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+serialize-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+serialize-devel.sha256sum] = "3522189f70edb424c09c1cc441ebde6e26ba9efbbac55d22f2f32b388193c54c"

URI_aarch64_rust-quick-xml0.31+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31+tokio-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31+tokio-devel}"
SRC_URI[aarch64_rust-quick-xml0.31+tokio-devel.sha256sum] = "0d3fff3f571e91d0520fe3f9bfbfdc94eb44e906162c60be91a78b05b6ba72c5"

URI_aarch64_rust-quick-xml0.31-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml0.31-devel-0.31.0-2.el10_0.noarch.rpm;name=aarch64_rust-quick-xml0.31-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml0.31-devel}"
SRC_URI[aarch64_rust-quick-xml0.31-devel.sha256sum] = "d34463a15d921b7c4c1221bd0014be78263be66dad1630a6d541d8d768085e6a"

RDEPENDS:rust-quick-xml0.31+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-quick-xml0.31-devel \
 "
RDEPENDS:rust-quick-xml0.31+async-tokio-devel = " \
 cargo \
 rust-quick-xml0.31+tokio-devel \
 rust-quick-xml0.31-devel \
 "
RDEPENDS:rust-quick-xml0.31+default-devel = " \
 cargo \
 rust-quick-xml0.31-devel \
 "
RDEPENDS:rust-quick-xml0.31+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-quick-xml0.31-devel \
 "
RDEPENDS:rust-quick-xml0.31+encoding-devel = " \
 cargo \
 rust-quick-xml0.31+encoding_rs-devel \
 rust-quick-xml0.31-devel \
 "
RDEPENDS:rust-quick-xml0.31+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-quick-xml0.31-devel \
 "
RDEPENDS:rust-quick-xml0.31+escape-html-devel = " \
 cargo \
 rust-quick-xml0.31-devel \
 "
RDEPENDS:rust-quick-xml0.31+overlapped-lists-devel = " \
 cargo \
 rust-quick-xml0.31-devel \
 "
RDEPENDS:rust-quick-xml0.31+serde-devel = " \
 cargo \
 rust-quick-xml0.31-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-quick-xml0.31+serde-types-devel = " \
 cargo \
 rust-quick-xml0.31-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-quick-xml0.31+serialize-devel = " \
 cargo \
 rust-quick-xml0.31+serde-devel \
 rust-quick-xml0.31-devel \
 "
RDEPENDS:rust-quick-xml0.31+tokio-devel = " \
 cargo \
 rust-quick-xml0.31-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-quick-xml0.31-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 "
