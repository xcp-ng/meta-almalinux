# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "curl"
PV = "8.9.1"
PR = "5.el10"
PACKAGES = " \
 curl \
 libcurl \
 libcurl-devel \
 libcurl-minimal \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/curl-8.9.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d9a28a59d3a56b8e693f2266b8804952e5f2ca8f7d6135dccd7036bc6865a05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/curl-8.9.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_curl;unpack=0"
SRC_URI[x86_64_v2_curl.sha256sum] = "65001d56c0a370fc1f869dd2c090a9a974fe233a5fad79fdb42cf517e0471a01"
RPROVIDES:curl:append:x86_64_v2 = " virtual/wget_or_curl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcurl-8.9.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_libcurl;unpack=0"
SRC_URI[x86_64_v2_libcurl.sha256sum] = "4de03600c9f4ec32c900f6928f334a4f1e7dce968f848dbfb599c3e14ff13ea4"
RPROVIDES:libcurl:append:x86_64_v2 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2 virtual/libcurl_x86-64__eq_8.9.1-5.el10 virtual/libcurl_x86-64__ge_7.29.0 virtual/libcurl_x86-64__ge_7.52.0 virtual/libcurl_x86-64__ge_8.9.1 virtual/libcurl_x86-64__ge_8.9.1-5.el10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcurl-devel-8.9.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_libcurl-devel;unpack=0"
SRC_URI[x86_64_v2_libcurl-devel.sha256sum] = "665add4d0b3bc1958e659ba99557d63c1ffad29596ab6e69ab82f23d39ec6fc8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcurl-minimal-8.9.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_libcurl-minimal;unpack=0"
SRC_URI[x86_64_v2_libcurl-minimal.sha256sum] = "5a87882ca63640d2f20eba459109d97f2b930a5767225b7b1af97c3d5875e1f8"
RPROVIDES:libcurl-minimal:append:x86_64_v2 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2 virtual/libcurl_x86-64__eq_8.9.1-5.el10 virtual/libcurl_x86-64__ge_7.29.0 virtual/libcurl_x86-64__ge_7.52.0 virtual/libcurl_x86-64__ge_8.9.1 virtual/libcurl_x86-64__ge_8.9.1-5.el10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/curl-8.9.1-5.el10.aarch64.rpm;name=aarch64_curl;unpack=0"
SRC_URI[aarch64_curl.sha256sum] = "0ddfd0a2a9e717ea6210ab04d0fc955c0f488ecbb5d8215fe48d2def9ee3ce53"
RPROVIDES:curl:append:aarch64 = " virtual/wget_or_curl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcurl-8.9.1-5.el10.aarch64.rpm;name=aarch64_libcurl;unpack=0"
SRC_URI[aarch64_libcurl.sha256sum] = "175021a232eddeba36e86b0d827663565ab568b9a21be85d8f866610c9c11000"
RPROVIDES:libcurl:append:aarch64 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_aarch-64__eq_8.9.1-5.el10 virtual/libcurl_aarch-64__ge_7.29.0 virtual/libcurl_aarch-64__ge_7.52.0 virtual/libcurl_aarch-64__ge_8.9.1 virtual/libcurl_aarch-64__ge_8.9.1-5.el10 virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcurl-devel-8.9.1-5.el10.aarch64.rpm;name=aarch64_libcurl-devel;unpack=0"
SRC_URI[aarch64_libcurl-devel.sha256sum] = "ed572be34bf88417b21b2cb0af5c4ead11fab97c9dc625920ed2667d990f8eb9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcurl-minimal-8.9.1-5.el10.aarch64.rpm;name=aarch64_libcurl-minimal;unpack=0"
SRC_URI[aarch64_libcurl-minimal.sha256sum] = "82c0b08c40a55175f80cd3caa04030ecefc8ecb1b407fc2d327d473e2a254957"
RPROVIDES:libcurl-minimal:append:aarch64 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_aarch-64__eq_8.9.1-5.el10 virtual/libcurl_aarch-64__ge_7.29.0 virtual/libcurl_aarch-64__ge_7.52.0 virtual/libcurl_aarch-64__ge_8.9.1 virtual/libcurl_aarch-64__ge_8.9.1-5.el10 virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2"

RDEPENDS:curl:x86_64_v2 = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_8.9.1-5.el10 \
"
RDEPENDS:curl:aarch64 = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_8.9.1-5.el10 \
"
RDEPENDS:libcurl = " \
 glibc \
 krb5-libs \
 libbrotli \
 libidn2 \
 libnghttp2 \
 libpsl \
 libssh \
 openldap \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libcurl-devel:x86_64_v2 = " \
 bash \
 brotli-devel \
 libidn2-devel \
 libnghttp2-devel \
 libpsl-devel \
 libssh-devel \
 openssl-devel \
 pkgconf-pkg-config \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__eq_8.9.1-5.el10 \
 zlib-ng-compat-devel \
"
RDEPENDS:libcurl-devel:aarch64 = " \
 bash \
 brotli-devel \
 libidn2-devel \
 libnghttp2-devel \
 libpsl-devel \
 libssh-devel \
 openssl-devel \
 pkgconf-pkg-config \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__eq_8.9.1-5.el10 \
 zlib-ng-compat-devel \
"
RDEPENDS:libcurl-minimal = " \
 glibc \
 krb5-libs \
 libidn2 \
 libnghttp2 \
 openssl-libs \
 zlib-ng-compat \
 "
