# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Negotiate"
PV = "6.01"
PR = "40.el10"
PACKAGES = " \
 perl-HTTP-Negotiate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-HTTP-Negotiate-6.01-40.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37413b7ef5dffb3f5947c1129a0de4229b30d9f0d570e3731c5929cf513e2e49"

URI_x86_64_v2_perl-HTTP-Negotiate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-HTTP-Negotiate-6.01-40.el10.noarch.rpm;name=x86_64_v2_perl-HTTP-Negotiate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Negotiate}"
SRC_URI[x86_64_v2_perl-HTTP-Negotiate.sha256sum] = "c5dcb5682b97dd66e5f10e842c0115f8d83de15dbf0e709f066a25d20d2a8800"

URI_aarch64_perl-HTTP-Negotiate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-HTTP-Negotiate-6.01-40.el10.noarch.rpm;name=aarch64_perl-HTTP-Negotiate;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Negotiate}"
SRC_URI[aarch64_perl-HTTP-Negotiate.sha256sum] = "c5dcb5682b97dd66e5f10e842c0115f8d83de15dbf0e709f066a25d20d2a8800"

RDEPENDS:perl-HTTP-Negotiate = " \
 perl-Exporter \
 perl-HTTP-Message \
 perl-libs \
 "
