# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rb_libtorrent"
PV = "2.0.10"
PR = "4.el10_0"
PACKAGES = " \
 rb_libtorrent \
 rb_libtorrent-devel \
 rb_libtorrent-examples \
 rb_libtorrent-python3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rb_libtorrent-2.0.10-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a47a3d49482e2e2fbded8e71768deca8f3bb052ef11af85f08c251fb10cf01c6"

URI_x86_64_v2_rb_libtorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rb_libtorrent-2.0.10-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rb_libtorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rb_libtorrent}"
SRC_URI[x86_64_v2_rb_libtorrent.sha256sum] = "e20c50669031b7f5487b3cf1920d083e7536026eb010868931aa4203f55469d9"

URI_x86_64_v2_rb_libtorrent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rb_libtorrent-devel-2.0.10-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rb_libtorrent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rb_libtorrent-devel}"
SRC_URI[x86_64_v2_rb_libtorrent-devel.sha256sum] = "7ea831fe6857192399f726ab65865fd96966ac2683d778c006829108826ce708"

URI_x86_64_v2_rb_libtorrent-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rb_libtorrent-examples-2.0.10-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rb_libtorrent-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rb_libtorrent-examples}"
SRC_URI[x86_64_v2_rb_libtorrent-examples.sha256sum] = "17ed33fceb5669b215f9c806a523a271fd9db83e0976074945dce6ee1c5564e7"

URI_x86_64_v2_rb_libtorrent-python3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rb_libtorrent-python3-2.0.10-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rb_libtorrent-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rb_libtorrent-python3}"
SRC_URI[x86_64_v2_rb_libtorrent-python3.sha256sum] = "7b9b6b88183e950f68a2f9efe4ac3a183628e3bca6be6771bf5c5b05e9e61747"

URI_aarch64_rb_libtorrent = "${EPEL_MIRROR}/aarch64/Packages/r/rb_libtorrent-2.0.10-4.el10_0.aarch64.rpm;name=aarch64_rb_libtorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_rb_libtorrent}"
SRC_URI[aarch64_rb_libtorrent.sha256sum] = "d13a66851d76246592387d832a85f59047d1d1ff72ade49e0346b0a6ecf1acc7"

URI_aarch64_rb_libtorrent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rb_libtorrent-devel-2.0.10-4.el10_0.aarch64.rpm;name=aarch64_rb_libtorrent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rb_libtorrent-devel}"
SRC_URI[aarch64_rb_libtorrent-devel.sha256sum] = "0a5dcdf705f51f0c8e83b67ee7d56d8cd22eb5ad59544a01168d14a2d6b11b70"

URI_aarch64_rb_libtorrent-examples = "${EPEL_MIRROR}/aarch64/Packages/r/rb_libtorrent-examples-2.0.10-4.el10_0.aarch64.rpm;name=aarch64_rb_libtorrent-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_rb_libtorrent-examples}"
SRC_URI[aarch64_rb_libtorrent-examples.sha256sum] = "d6087ff54bdcc0c2282dd2176f323871b0c56807ec63a1718eb514e7eb4230d0"

URI_aarch64_rb_libtorrent-python3 = "${EPEL_MIRROR}/aarch64/Packages/r/rb_libtorrent-python3-2.0.10-4.el10_0.aarch64.rpm;name=aarch64_rb_libtorrent-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_rb_libtorrent-python3}"
SRC_URI[aarch64_rb_libtorrent-python3.sha256sum] = "8e0820951f3e47330ae7bd17f4c3adc6bafc6df60c2fe98872d94880d7cc39cd"

RDEPENDS:rb_libtorrent = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:rb_libtorrent-devel = " \
 boost-devel \
 cmake-filesystem \
 openssl-devel \
 pkgconf-pkg-config \
 rb_libtorrent \
 "
RDEPENDS:rb_libtorrent-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 rb_libtorrent \
 "
RDEPENDS:rb_libtorrent-python3 = " \
 boost-python3 \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 python3 \
 rb_libtorrent \
 "
