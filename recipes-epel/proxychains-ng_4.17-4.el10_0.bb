# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "proxychains-ng"
PV = "4.17"
PR = "4.el10_0"
PACKAGES = " \
 proxychains-ng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/proxychains-ng-4.17-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d499b8729f040a2320173380718d8b2d3ecbca29917fe1ab57863797d64d8309"

URI_x86_64_v2_proxychains-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proxychains-ng-4.17-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proxychains-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proxychains-ng}"
SRC_URI[x86_64_v2_proxychains-ng.sha256sum] = "cde6b7479173205f67e7fe68f6f6884c011718e3861d8eabe90e2b3c3efc5201"

URI_aarch64_proxychains-ng = "${EPEL_MIRROR}/aarch64/Packages/p/proxychains-ng-4.17-4.el10_0.aarch64.rpm;name=aarch64_proxychains-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_proxychains-ng}"
SRC_URI[aarch64_proxychains-ng.sha256sum] = "d66819f16f5142cf4afb5b7e79fc3896a42604b69f446f7f8af3b583363f9f8e"

RDEPENDS:proxychains-ng = " \
 glibc \
 "
