# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_spanned"
PV = "0.6.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-serde_spanned-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_spanned-0.6.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5db4b95ba217aa9591c00d19c4781a478cb1f527ad3e913759abbd97e9ce849"

URI_x86_64_v2_rust-serde_spanned+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+default-devel-0.6.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+default-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+default-devel.sha256sum] = "417d9739f595ecd29a9c08b10943c00c88cf20cc86d2cd2ec2bb0e8b00f0265e"

URI_x86_64_v2_rust-serde_spanned+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+serde-devel-0.6.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+serde-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+serde-devel.sha256sum] = "71db33e58d6427f3628e251ba5587f106623908354bf139f65c36103a943434a"

URI_x86_64_v2_rust-serde_spanned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned-devel-0.6.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned-devel.sha256sum] = "78a49a7169b6f38ec76c92a73182b24e4065da2be2417428c6ada809e15d14c2"

URI_aarch64_rust-serde_spanned+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+default-devel-0.6.9-1.el10_0.noarch.rpm;name=aarch64_rust-serde_spanned+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+default-devel}"
SRC_URI[aarch64_rust-serde_spanned+default-devel.sha256sum] = "ececbea420f6255b97d02ba6a42c66e4748d6603b8c682d1c3622c59624192cc"

URI_aarch64_rust-serde_spanned+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+serde-devel-0.6.9-1.el10_0.noarch.rpm;name=aarch64_rust-serde_spanned+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+serde-devel}"
SRC_URI[aarch64_rust-serde_spanned+serde-devel.sha256sum] = "3f18dc1eb38adc9ff2f24a5fba6715d69f11e8c7eb0be33444a3fdb25d7ce9af"

URI_aarch64_rust-serde_spanned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned-devel-0.6.9-1.el10_0.noarch.rpm;name=aarch64_rust-serde_spanned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned-devel}"
SRC_URI[aarch64_rust-serde_spanned-devel.sha256sum] = "94c82ff8b2923ff84aeaaabf89574b4433675ab6516a620e7438c30a76540814"

RDEPENDS:rust-serde_spanned+default-devel = " \
 cargo \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned-devel = " \
 cargo \
 rust \
 "
