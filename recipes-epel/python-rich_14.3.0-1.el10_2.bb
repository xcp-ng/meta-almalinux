# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rich"
PV = "14.3.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-rich \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-rich-14.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "733aeb8bfc98b26ca40370e7589b30e2aec04cfb1548866e7e25fa1d06e4fd8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rich-14.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rich;unpack=0"
SRC_URI[x86_64_v2_python3-rich.sha256sum] = "28b2c4c47aa44ef6e95acbfe426ed7cac6ca38e99759005eea325460e17e7dfa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-rich-14.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-rich;unpack=0"
SRC_URI[aarch64_python3-rich.sha256sum] = "8d7a3e7560677c39f970114a9e6bbf509461c9390cfc6a2c7f4a40345d8281f9"

RDEPENDS:python3-rich = " \
 python3 \
 python3-markdown-it-py \
 python3-pygments \
 "
