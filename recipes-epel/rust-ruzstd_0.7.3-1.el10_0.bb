# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ruzstd"
PV = "0.7.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-ruzstd+default-devel \
 rust-ruzstd+hash-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ruzstd-0.7.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5493e54098dc998d091429bab1c19792901f0dd3fc17df66b99763c586c8dfea"

URI_x86_64_v2_rust-ruzstd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+default-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+default-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+default-devel.sha256sum] = "db5db00ba9877e2fd5aa6322e52eb11f25fa40ce68c2e72bca0d2f0a7dd12b85"

URI_x86_64_v2_rust-ruzstd+hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+hash-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+hash-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+hash-devel.sha256sum] = "e0178c5aed5e69da21c2234d8c351697b0688f26d994a7b94e6edca84d848a81"

URI_x86_64_v2_rust-ruzstd+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd+std-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd+std-devel}"
SRC_URI[x86_64_v2_rust-ruzstd+std-devel.sha256sum] = "7d7212b8932bbcbe1473241976889dc0e70990c9e7ff9286e0af4802300c24d7"

URI_x86_64_v2_rust-ruzstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ruzstd-devel-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ruzstd-devel}"
SRC_URI[x86_64_v2_rust-ruzstd-devel.sha256sum] = "b51fc8325135e2b21d414f8bd2c84e83d14b35f3ec7d243487bff4b8c0de6d4a"

URI_aarch64_rust-ruzstd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+default-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-ruzstd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+default-devel}"
SRC_URI[aarch64_rust-ruzstd+default-devel.sha256sum] = "5fc6e4921e6d4d4e79c346807c9011bd7e95d93b6e7bf46c06f6ebad8678962e"

URI_aarch64_rust-ruzstd+hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+hash-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-ruzstd+hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+hash-devel}"
SRC_URI[aarch64_rust-ruzstd+hash-devel.sha256sum] = "df38ea0fb629e32a39742c273d2d57f93d857ddfb466ff32e89e7804801ae051"

URI_aarch64_rust-ruzstd+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd+std-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-ruzstd+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd+std-devel}"
SRC_URI[aarch64_rust-ruzstd+std-devel.sha256sum] = "d13ca4d43888ab52e941149bd0f24776ffbc366f61b618696d253f2f581d830c"

URI_aarch64_rust-ruzstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ruzstd-devel-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-ruzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ruzstd-devel}"
SRC_URI[aarch64_rust-ruzstd-devel.sha256sum] = "03c6d0f427db3b916b3c1dbec5d464bc32293fc29e6b9beefbd9f20ef71e42fc"

RDEPENDS:rust-ruzstd+default-devel = " \
 cargo \
 rust-ruzstd+hash-devel \
 rust-ruzstd+std-devel \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd+hash-devel = " \
 cargo \
 rust-ruzstd-devel \
 rust-twox-hash1-devel \
 "
RDEPENDS:rust-ruzstd+std-devel = " \
 cargo \
 rust-ruzstd-devel \
 "
RDEPENDS:rust-ruzstd-devel = " \
 cargo \
 "
