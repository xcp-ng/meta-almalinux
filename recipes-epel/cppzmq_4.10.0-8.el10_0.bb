# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cppzmq"
PV = "4.10.0"
PR = "8.el10_0"
PACKAGES = " \
 cppzmq-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cppzmq-4.10.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c458c0f6115483f7edb9334ad70aa893e07ca37236d12d96e0426ba120bcea8"

URI_x86_64_v2_cppzmq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppzmq-devel-4.10.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppzmq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppzmq-devel}"
SRC_URI[x86_64_v2_cppzmq-devel.sha256sum] = "75aa8af021099c46cf789ca3957de938ea6a77130ffe40a4ed91b9672fd2d49d"

URI_aarch64_cppzmq-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cppzmq-devel-4.10.0-8.el10_0.aarch64.rpm;name=aarch64_cppzmq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppzmq-devel}"
SRC_URI[aarch64_cppzmq-devel.sha256sum] = "27103c4eedf0f79f7673b29bc0c1d4d4178c623f9be29f15e79ef9a96add847e"

RDEPENDS:cppzmq-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 zeromq-devel \
 "
