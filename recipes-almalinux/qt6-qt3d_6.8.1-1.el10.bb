# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qt3d"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qt3d \
 qt6-qt3d-devel \
 qt6-qt3d-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qt3d-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30e2417f14bb548c67d3c19376af04315fcd13821551c9946063c80cdc7b5abc"

URI_x86_64_v2_qt6-qt3d = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt3d-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt3d}"
SRC_URI[x86_64_v2_qt6-qt3d.sha256sum] = "015e8c8e5bf9bb3abadfc65462de4adeddb26732c8bd14146844a053ffe4955c"

URI_x86_64_v2_qt6-qt3d-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt3d-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt3d-devel}"
SRC_URI[x86_64_v2_qt6-qt3d-devel.sha256sum] = "ccbd4c778686acfc1cc7add63291f4e0e37910fd097e3a892bdd2a7559d1e3b5"

URI_x86_64_v2_qt6-qt3d-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qt3d-examples-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt3d-examples}"
SRC_URI[x86_64_v2_qt6-qt3d-examples.sha256sum] = "6ba7d583f21c174f6b2c90e9fce157b8a788bb8a3eb2032834ac31f9a716fce4"

URI_aarch64_qt6-qt3d = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt3d-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qt3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt3d}"
SRC_URI[aarch64_qt6-qt3d.sha256sum] = "12a747c59cdf944edf705d3d5cdab4b0df7d8de1e286decb410c231ce780c7aa"

URI_aarch64_qt6-qt3d-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt3d-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt3d-devel}"
SRC_URI[aarch64_qt6-qt3d-devel.sha256sum] = "e11c1b9995148f760eefd4fc7cf36f48f03c438ddbe6e45e9c5c3040b9ea4fc6"

URI_aarch64_qt6-qt3d-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qt3d-examples-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt3d-examples}"
SRC_URI[aarch64_qt6-qt3d-examples.sha256sum] = "97ffbe2c1191bfec127f1d298242abbd450c4a055f590c78766155d50caef7b1"

RDEPENDS:qt6-qt3d = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtimageformats \
 qt6-qtshadertools \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qt3d-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qt3d \
 qt6-qt3d-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qt3d-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qt3d \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
