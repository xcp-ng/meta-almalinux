# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcli"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 tomcli \
 tomcli+tomli \
"
PACKAGES:aarch64 = " \
 tomcli \
 tomcli+all \
 tomcli+tomli \
 tomcli+tomlkit \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tomcli-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e9f915528257a8eb7912ba0620ed1b7ea53932ce85298be52c8da769d019018a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomcli-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_tomcli;unpack=0"
SRC_URI[x86_64_v2_tomcli.sha256sum] = "c9a13e6b172e3887fb3d59215f6e9052d2efe02ef7f42d28f479b7b8c8e610ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomcli+tomli-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_tomcli+tomli;unpack=0"
SRC_URI[x86_64_v2_tomcli+tomli.sha256sum] = "b6158b2248dd265a4cc0029fa170cc23ec2d0649917c01898502b1dc0f40a218"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tomcli-0.9.0-1.el10_0.noarch.rpm;name=aarch64_tomcli;unpack=0"
SRC_URI[aarch64_tomcli.sha256sum] = "2b5bba753fc46a7bb11afb7ae40a5b44dd4620e4dd457161944082490eda1a05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tomcli+all-0.9.0-1.el10_0.noarch.rpm;name=aarch64_tomcli+all;unpack=0"
SRC_URI[aarch64_tomcli+all.sha256sum] = "9d38baac87b3fd0173eea3ee3312842488774d8674260473ef1507dd9020d66c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tomcli+tomli-0.9.0-1.el10_0.noarch.rpm;name=aarch64_tomcli+tomli;unpack=0"
SRC_URI[aarch64_tomcli+tomli.sha256sum] = "fe2fc4577897bb97b59d2967377daab94bb61f9c1c3982097128efc75a6f922f"
RPROVIDES:tomcli+tomli:append:aarch64 = " virtual/python3dist_tomcli_tomlkit___or_python3dist_tomcli_tomli__"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tomcli+tomlkit-0.9.0-1.el10_0.noarch.rpm;name=aarch64_tomcli+tomlkit;unpack=0"
SRC_URI[aarch64_tomcli+tomlkit.sha256sum] = "52728c2dcea3113458ca856d35c4aa3b317cb8d16fb1c4c5c331252e44697190"
RPROVIDES:tomcli+tomlkit:append:aarch64 = " virtual/python3dist_tomcli_tomlkit___or_python3dist_tomcli_tomli__"

RDEPENDS:tomcli:x86_64_v2 = " \
 python3 \
 python3-click \
 tomcli+tomli \
"
RDEPENDS:tomcli:aarch64 = " \
 python3 \
 python3-click \
 virtual/python3dist_tomcli_tomlkit___or_python3dist_tomcli_tomli__ \
"
RDEPENDS:tomcli+tomli = " \
 python3 \
 python3-tomli-w \
 tomcli \
 "
RDEPENDS:tomcli+all = " \
 python3 \
 python3-tomlkit \
 tomcli \
 "
RDEPENDS:tomcli+tomlkit = " \
 python3 \
 python3-tomlkit \
 tomcli \
 "
