# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-ascii"
PV = "2.25.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-onefetch-ascii+default-devel \
 rust-onefetch-ascii-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-ascii-2.25.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "80966e1d915b5ae6c962b0b9134bf6c252df33c9c1f7ad5c2579d488adc45f9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-ascii+default-devel-2.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-ascii+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-onefetch-ascii+default-devel.sha256sum] = "6a584f7e70cce72ce408d93211ed997672869adfcd8a752289bb504e66fcddcc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-ascii-devel-2.25.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-ascii-devel;unpack=0"
SRC_URI[x86_64_v2_rust-onefetch-ascii-devel.sha256sum] = "a72341618ae2334a9dc363a6d8d384fce8ab32ac4cb1ae63bde92014b0c427ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-ascii+default-devel-2.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-onefetch-ascii+default-devel;unpack=0"
SRC_URI[aarch64_rust-onefetch-ascii+default-devel.sha256sum] = "811c58b11a9b966dcb780a3d17bc4eea11d70390eeb1dd7deb8bc0912b0deba6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-ascii-devel-2.25.0-1.el10_1.noarch.rpm;name=aarch64_rust-onefetch-ascii-devel;unpack=0"
SRC_URI[aarch64_rust-onefetch-ascii-devel.sha256sum] = "ddcdf4a57178e0124ca75c40bf631a0ab85c2f39c0afe82a9c882e658683294d"

RDEPENDS:rust-onefetch-ascii+default-devel = " \
 cargo \
 rust-onefetch-ascii-devel \
 "
RDEPENDS:rust-onefetch-ascii-devel = " \
 cargo \
 rust-owo-colors+default-devel \
 "
