# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "giflib"
PV = "5.2.1"
PR = "22.el10_1.1"
PACKAGES = " \
 giflib \
 giflib-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/giflib-5.2.1-22.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5552c90c7025b930c037ae0f83fe480c1987e0fe3c65e56c3d1cce43bf1bee9"

URI_x86_64_v2_giflib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/giflib-5.2.1-22.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_giflib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_giflib}"
SRC_URI[x86_64_v2_giflib.sha256sum] = "454faad3fd337c2337226d59edb50512a2cad8fc2ae3eb670ad1f0aa4df39273"

URI_x86_64_v2_giflib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/giflib-devel-5.2.1-22.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_giflib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_giflib-devel}"
SRC_URI[x86_64_v2_giflib-devel.sha256sum] = "d160c65a032f23ed72e1d1b9df0b623581acdee283c51946d8619f0bd21f0fb6"

URI_aarch64_giflib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/giflib-5.2.1-22.el10_1.1.aarch64.rpm;name=aarch64_giflib;unpack=0"
SRC_URI:append = " ${URI_aarch64_giflib}"
SRC_URI[aarch64_giflib.sha256sum] = "893f3a985304eece9b121dbe74a3b199862ee2787ad1de89d6b8e6894f936886"

URI_aarch64_giflib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/giflib-devel-5.2.1-22.el10_1.1.aarch64.rpm;name=aarch64_giflib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_giflib-devel}"
SRC_URI[aarch64_giflib-devel.sha256sum] = "41a509725862b0e2663ca72dfcd7fe295f07913ed93f20d3d20e6c4d0999d900"

RDEPENDS:giflib = " \
 glibc \
 "
RDEPENDS:giflib-devel = " \
 giflib \
 "
