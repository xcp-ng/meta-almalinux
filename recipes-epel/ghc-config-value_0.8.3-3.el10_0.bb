# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-config-value"
PV = "0.8.3"
PR = "3.el10_0"
PACKAGES = " \
 ghc-config-value \
 ghc-config-value-devel \
 ghc-config-value-doc \
 ghc-config-value-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-config-value-0.8.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e4a7e7adde3f0495ec406cdda1846c7a304c32e3410a8e548da92ee3751fb35"

URI_x86_64_v2_ghc-config-value = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-config-value-0.8.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-config-value;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-config-value}"
SRC_URI[x86_64_v2_ghc-config-value.sha256sum] = "6b18190f3cab186f5f6966171239fc6dff5480ec58ce392fae3c8cee58f474af"

URI_x86_64_v2_ghc-config-value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-config-value-devel-0.8.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-config-value-devel}"
SRC_URI[x86_64_v2_ghc-config-value-devel.sha256sum] = "e63ee81cff0222110c22799af667a8dcd2f6d9d6e06654e7e8814dacd9e543b5"

URI_x86_64_v2_ghc-config-value-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-config-value-doc-0.8.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-config-value-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-config-value-doc}"
SRC_URI[x86_64_v2_ghc-config-value-doc.sha256sum] = "1bf6d909c60de569f4721276740e881dfd8bb770018fcbbceeb73905fe41b125"

URI_x86_64_v2_ghc-config-value-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-config-value-prof-0.8.3-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-config-value-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-config-value-prof}"
SRC_URI[x86_64_v2_ghc-config-value-prof.sha256sum] = "b6c695bbd5ffb9abaec23ac2b3e790073d2b083a5a610868b2d2cdde34ed4801"

URI_aarch64_ghc-config-value = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-config-value-0.8.3-3.el10_0.aarch64.rpm;name=aarch64_ghc-config-value;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-config-value}"
SRC_URI[aarch64_ghc-config-value.sha256sum] = "078f8d889a0aacc26c2749e86f5d1f46ff43ef686eb34d6dfb009d6f6864a0e4"

URI_aarch64_ghc-config-value-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-config-value-devel-0.8.3-3.el10_0.aarch64.rpm;name=aarch64_ghc-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-config-value-devel}"
SRC_URI[aarch64_ghc-config-value-devel.sha256sum] = "95eb055396c45a96ebb1f589a768478bcd1e35674fe19ce8a27be1ce82ed06f3"

URI_aarch64_ghc-config-value-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-config-value-doc-0.8.3-3.el10_0.noarch.rpm;name=aarch64_ghc-config-value-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-config-value-doc}"
SRC_URI[aarch64_ghc-config-value-doc.sha256sum] = "193664128d2949244649690e3a5e8d2cdb395cd6f6d830ffabf31e5206d33160"

URI_aarch64_ghc-config-value-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-config-value-prof-0.8.3-3.el10_0.aarch64.rpm;name=aarch64_ghc-config-value-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-config-value-prof}"
SRC_URI[aarch64_ghc-config-value-prof.sha256sum] = "faf8432402c920e97de06d8d5f60e21d92db34035c57407c4e76c5132c94f15d"

RDEPENDS:ghc-config-value = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-config-value-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-config-value \
 ghc-containers-devel \
 ghc-pretty-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-config-value-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-config-value-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-config-value-devel \
 ghc-containers-prof \
 ghc-pretty-prof \
 ghc-text-prof \
 "
