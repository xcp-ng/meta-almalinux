# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "argparse-manpage"
PV = "4.7"
PR = "1.el10_0"
PACKAGES = " \
 argparse-manpage \
 python3-argparse-manpage \
 python3-argparse-manpage+setuptools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/argparse-manpage-4.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8ac547c67754cacc795be3400fecd5ff4505a965fd5b0fb53a3ce119266e119"

URI_x86_64_v2_argparse-manpage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/argparse-manpage-4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_argparse-manpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_argparse-manpage}"
SRC_URI[x86_64_v2_argparse-manpage.sha256sum] = "488946ce6aa33c8ceca90ab6836120a831ef39c216ff5773e80f28cf6f411208"

URI_x86_64_v2_python3-argparse-manpage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-argparse-manpage-4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-argparse-manpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-argparse-manpage}"
SRC_URI[x86_64_v2_python3-argparse-manpage.sha256sum] = "d7804e1a4ecb66ff98dac5e8eca30390a482a39f69453965f0637ab156317dbe"

URI_x86_64_v2_python3-argparse-manpage+setuptools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-argparse-manpage+setuptools-4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-argparse-manpage+setuptools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-argparse-manpage+setuptools}"
SRC_URI[x86_64_v2_python3-argparse-manpage+setuptools.sha256sum] = "9f653339665d5231980750ab98002a32bab14bc1e56a60c1bc88efde92cbbf2b"

URI_aarch64_argparse-manpage = "${EPEL_MIRROR}/aarch64/Packages/a/argparse-manpage-4.7-1.el10_0.noarch.rpm;name=aarch64_argparse-manpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_argparse-manpage}"
SRC_URI[aarch64_argparse-manpage.sha256sum] = "e7e2e3d3e7ef25a8206bcf2bca8dc9bba11271b41386fa7638a9fdb9bffd95bb"

URI_aarch64_python3-argparse-manpage = "${EPEL_MIRROR}/aarch64/Packages/p/python3-argparse-manpage-4.7-1.el10_0.noarch.rpm;name=aarch64_python3-argparse-manpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-argparse-manpage}"
SRC_URI[aarch64_python3-argparse-manpage.sha256sum] = "d80a24ae6cdf38aeba51c3153f2f5ecb543668ab6330bfc72ceff7065b03b0bf"

URI_aarch64_python3-argparse-manpage+setuptools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-argparse-manpage+setuptools-4.7-1.el10_0.noarch.rpm;name=aarch64_python3-argparse-manpage+setuptools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-argparse-manpage+setuptools}"
SRC_URI[aarch64_python3-argparse-manpage+setuptools.sha256sum] = "62d5fe065e866fdc9e653010dc32ffe6195095460b367ffed5987db703823c5e"

RDEPENDS:argparse-manpage = " \
 python3 \
 python3-argparse-manpage \
 "
RDEPENDS:python3-argparse-manpage = " \
 python3 \
 "
RDEPENDS:python3-argparse-manpage+setuptools = " \
 python3 \
 python3-argparse-manpage \
 python3-setuptools \
 "
