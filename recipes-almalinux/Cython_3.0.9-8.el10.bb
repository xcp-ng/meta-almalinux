# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Cython"
PV = "3.0.9"
PR = "8.el10"
PACKAGES = " \
 python3-cython \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/Cython-3.0.9-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3ab4205b143d40ec28fc1b2a96ea1008b648f110e69a140d3031e0f91f169e6"

URI_x86_64_v2_python3-cython = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-cython-3.0.9-8.el10.x86_64_v2.rpm;name=x86_64_v2_python3-cython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cython}"
SRC_URI[x86_64_v2_python3-cython.sha256sum] = "61960466bb2a985cd0119990ed70bce13295fec89322c7be7242187f271fe459"

URI_aarch64_python3-cython = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-cython-3.0.9-8.el10.aarch64.rpm;name=aarch64_python3-cython;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cython}"
SRC_URI[aarch64_python3-cython.sha256sum] = "47ed988205f97a102de1520c1db7083efb74d98997e346521fd7ad17aa449641"

RDEPENDS:python3-cython = " \
 glibc \
 python3 \
 "
