# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam"
PV = "1.6.1"
PR = "9.el10_2.1"
PACKAGES = " \
 pam \
 pam-devel \
 pam-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pam-1.6.1-9.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "28b76efcb9d88ffded24d8e3f78d720b18a105cbab3cb3f8f1d459f17a5bbfca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-1.6.1-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pam;unpack=0"
SRC_URI[x86_64_v2_pam.sha256sum] = "0b49c0ece6dd8e3630ff965ed10bf86fe0a414d4bd10de7b6db840ddc6c618e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam-devel-1.6.1-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pam-devel;unpack=0"
SRC_URI[x86_64_v2_pam-devel.sha256sum] = "129f98931d01ac366ec413def0cbbb003175c13dff2f987dc34c8e7709de2a2c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-libs-1.6.1-9.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_pam-libs;unpack=0"
SRC_URI[x86_64_v2_pam-libs.sha256sum] = "57e6d79dcc831a3503df6edc6b35a542c805b8a3baebffc87864ebbb0e38f4db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-1.6.1-9.el10_2.1.aarch64.rpm;name=aarch64_pam;unpack=0"
SRC_URI[aarch64_pam.sha256sum] = "87b6b37b92e2876faf3c64870fcd55cd9db5d6407bfc1f29c720d4a692012b0f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam-devel-1.6.1-9.el10_2.1.aarch64.rpm;name=aarch64_pam-devel;unpack=0"
SRC_URI[aarch64_pam-devel.sha256sum] = "dc86a5ee281d73f61eaac743fd28b8f3832d495c7ecb4eaa9cea88c9ce923ef1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-libs-1.6.1-9.el10_2.1.aarch64.rpm;name=aarch64_pam-libs;unpack=0"
SRC_URI[aarch64_pam-libs.sha256sum] = "9cf4b0b505363b4c480f5558ed12278a9428e4970d42a52c6267343b418a5676"

RDEPENDS:pam = " \
 audit-libs \
 authselect \
 bash \
 gdbm \
 gdbm-libs \
 glibc \
 libeconf \
 libpwquality \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 setup \
 "
RDEPENDS:pam-devel = " \
 pam-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pam-libs = " \
 audit-libs \
 glibc \
 libeconf \
 "
