# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnutls"
PV = "3.8.10"
PR = "5.el10_2"
PACKAGES = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 gnutls-fips \
 gnutls-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gnutls-3.8.10-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e8cf9917b4b1019ac7b2eed1133d6c341efcd1f5b2ed077a8aafbe41f44a1d64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gnutls-3.8.10-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls;unpack=0"
SRC_URI[x86_64_v2_gnutls.sha256sum] = "a483461a149e1b6afbe03f25417dab5c15d3c65f1ae979015635e28f9fdd6ff9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-c++-3.8.10-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-c++;unpack=0"
SRC_URI[x86_64_v2_gnutls-c++.sha256sum] = "8b4e2a17a2afb35ef04015be26ad0da7a3ecc897118fb8e0e1ed1a0e4e584a81"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-dane-3.8.10-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-dane;unpack=0"
SRC_URI[x86_64_v2_gnutls-dane.sha256sum] = "25c2f1e90a5e8032ff75b1bc7bb123b5274b08906fd6a88032c62768d3688a30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-devel-3.8.10-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-devel;unpack=0"
SRC_URI[x86_64_v2_gnutls-devel.sha256sum] = "235d1a85b1393a78651a977c24b0adb5317cafe475661a45e3752017dee7197d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-fips-3.8.10-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-fips;unpack=0"
SRC_URI[x86_64_v2_gnutls-fips.sha256sum] = "e1aa8c14c21d298c4e211b7cb5e37b9b5ba33c74aee5936ff2fe7c3dc9087c62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnutls-utils-3.8.10-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gnutls-utils;unpack=0"
SRC_URI[x86_64_v2_gnutls-utils.sha256sum] = "bd207ff1ff6a7fe0ee1860691e69aaa3e3bc5eb37c2b8a14c487059cd4e2c515"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gnutls-3.8.10-5.el10_2.aarch64.rpm;name=aarch64_gnutls;unpack=0"
SRC_URI[aarch64_gnutls.sha256sum] = "861e1c575c0dc480a756464933a38b07e9a4dc988049cc2f84e5959040d66a1d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-c++-3.8.10-5.el10_2.aarch64.rpm;name=aarch64_gnutls-c++;unpack=0"
SRC_URI[aarch64_gnutls-c++.sha256sum] = "36566300ce44c9d6bd0e0e0489f76868dcfda625a4aa4b874b3ef0d52e6b1b80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-dane-3.8.10-5.el10_2.aarch64.rpm;name=aarch64_gnutls-dane;unpack=0"
SRC_URI[aarch64_gnutls-dane.sha256sum] = "ba57568230fd5f56fecb5bbacde97b346f9f1b8a32f33015a019498be0cf81b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-devel-3.8.10-5.el10_2.aarch64.rpm;name=aarch64_gnutls-devel;unpack=0"
SRC_URI[aarch64_gnutls-devel.sha256sum] = "e03c909577992e4c16e44d32d76530afa5d922e5005c311648f310483ce02de9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-fips-3.8.10-5.el10_2.aarch64.rpm;name=aarch64_gnutls-fips;unpack=0"
SRC_URI[aarch64_gnutls-fips.sha256sum] = "a3a6846e35365cd67c682047c845ed8082662b88c051701bd42aa05ad5ff5f0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnutls-utils-3.8.10-5.el10_2.aarch64.rpm;name=aarch64_gnutls-utils;unpack=0"
SRC_URI[aarch64_gnutls-utils.sha256sum] = "8e2163282fa45d0cbf4bb775d67b31d73e8ea78f5675903117434231e5fada91"

RDEPENDS:gnutls = " \
 crypto-policies \
 glibc \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 p11-kit-trust \
 "
RDEPENDS:gnutls-c++ = " \
 glibc \
 gnutls \
 libgcc \
 libidn2 \
 libstdc++ \
 libtasn1 \
 libunistring \
 p11-kit \
 "
RDEPENDS:gnutls-dane = " \
 glibc \
 gnutls \
 libidn2 \
 libtasn1 \
 libunistring \
 p11-kit \
 unbound-libs \
 "
RDEPENDS:gnutls-devel = " \
 gnutls \
 gnutls-c++ \
 gnutls-dane \
 gnutls-devel \
 libidn2-devel \
 libtasn1-devel \
 p11-kit-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gnutls-fips = " \
 gnutls \
 "
RDEPENDS:gnutls-utils = " \
 glibc \
 gnutls \
 gnutls-dane \
 libtasn1 \
 "
