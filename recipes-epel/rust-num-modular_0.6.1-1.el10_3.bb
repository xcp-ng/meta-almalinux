# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-modular"
PV = "0.6.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-num-modular+default-devel \
 rust-num-modular+num-bigint-devel \
 rust-num-modular+num-integer-devel \
 rust-num-modular+num-traits-devel \
 rust-num-modular+std-devel \
 rust-num-modular-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-modular-0.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b79d21a64a593de40d1692b7b435c3f970e79bfc8d98b3200be9413375c3a718"

URI_x86_64_v2_rust-num-modular+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-modular+default-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-modular+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-modular+default-devel}"
SRC_URI[x86_64_v2_rust-num-modular+default-devel.sha256sum] = "ad14c565f59148622081e438ef2f4614b3c5c89e1e4a5b007a34d5a757876086"

URI_x86_64_v2_rust-num-modular+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-modular+num-bigint-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-modular+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-modular+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num-modular+num-bigint-devel.sha256sum] = "9264c53fc61954808edb927653734034c439b329b2ddd8b3b1176fc3cc6cf342"

URI_x86_64_v2_rust-num-modular+num-integer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-modular+num-integer-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-modular+num-integer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-modular+num-integer-devel}"
SRC_URI[x86_64_v2_rust-num-modular+num-integer-devel.sha256sum] = "bef00394be19690a5a934062719dd4b1cdbf6ac48fea0da866ab73e06ba060bf"

URI_x86_64_v2_rust-num-modular+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-modular+num-traits-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-modular+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-modular+num-traits-devel}"
SRC_URI[x86_64_v2_rust-num-modular+num-traits-devel.sha256sum] = "6ec4fea6ce088a6c110cb6047d0f491cf84ff50b821901abbbf1f7d6c70c94c7"

URI_x86_64_v2_rust-num-modular+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-modular+std-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-modular+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-modular+std-devel}"
SRC_URI[x86_64_v2_rust-num-modular+std-devel.sha256sum] = "25998fb353f6dfb1d4ee9f19bd7c7172dcb5571386d091b0c03ac7e4d9399d49"

URI_x86_64_v2_rust-num-modular-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-modular-devel-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-modular-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-modular-devel}"
SRC_URI[x86_64_v2_rust-num-modular-devel.sha256sum] = "f64eb69ec9a3fcaf33a681722b2f2359f612c09e082e44ab2339ec9623fba305"

URI_aarch64_rust-num-modular+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-modular+default-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-modular+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-modular+default-devel}"
SRC_URI[aarch64_rust-num-modular+default-devel.sha256sum] = "a39e773aa10b71ae31d8d375bcf7d4fa332cfe37749a5758364f3e01d8364031"

URI_aarch64_rust-num-modular+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-modular+num-bigint-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-modular+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-modular+num-bigint-devel}"
SRC_URI[aarch64_rust-num-modular+num-bigint-devel.sha256sum] = "dade121dab393c2b66270ec55fe7ff7b7101b3db76c45f518b07b1e48a9d4af1"

URI_aarch64_rust-num-modular+num-integer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-modular+num-integer-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-modular+num-integer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-modular+num-integer-devel}"
SRC_URI[aarch64_rust-num-modular+num-integer-devel.sha256sum] = "ff02bf418bb513520451224a86c28f368e533b2d990ceba88cead40506f4e78f"

URI_aarch64_rust-num-modular+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-modular+num-traits-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-modular+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-modular+num-traits-devel}"
SRC_URI[aarch64_rust-num-modular+num-traits-devel.sha256sum] = "0b87dfa3dfc5f3cbba32b58f1745b82c0bd253a7da612275401d2298bf29c70f"

URI_aarch64_rust-num-modular+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-modular+std-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-modular+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-modular+std-devel}"
SRC_URI[aarch64_rust-num-modular+std-devel.sha256sum] = "a0cb2d2ede9dd8899e6c89745fb24bac038363d5c453e5f76a10315adc627bc2"

URI_aarch64_rust-num-modular-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-modular-devel-0.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-num-modular-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-modular-devel}"
SRC_URI[aarch64_rust-num-modular-devel.sha256sum] = "58a9edb29c7a6c48f43bf00a5ba8b06b782ba11ec45a04986442a0a8ff0010db"

RDEPENDS:rust-num-modular+default-devel = " \
 cargo \
 rust-num-modular-devel \
 "
RDEPENDS:rust-num-modular+num-bigint-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-modular-devel \
 "
RDEPENDS:rust-num-modular+num-integer-devel = " \
 cargo \
 rust-num-integer+default-devel \
 rust-num-modular-devel \
 "
RDEPENDS:rust-num-modular+num-traits-devel = " \
 cargo \
 rust-num-modular-devel \
 rust-num-traits+default-devel \
 "
RDEPENDS:rust-num-modular+std-devel = " \
 cargo \
 rust-num-modular-devel \
 "
RDEPENDS:rust-num-modular-devel = " \
 cargo \
 "
