# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-webpki"
PV = "0.103.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki+default-devel \
 rust-rustls-webpki+ring-devel \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-webpki-0.103.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "28fdafdd24f31eadf99cd880dfb4fe83b67e943ff222ef83ee417f9829b04554"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+alloc-devel-0.103.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki+alloc-devel.sha256sum] = "5d47e31095efb945b59e3a34d812d36acd149dbab2d68ad14ec47cf3f45ee2cb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+default-devel-0.103.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki+default-devel.sha256sum] = "04627c4972ac28eb9ffd5ae15885552ad1e15a3a759804b4f15965d2273bff47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+ring-devel-0.103.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki+ring-devel.sha256sum] = "280fe9f5a16afd1d2632f78e589c8307dd4e0dd3328da6fcf726190220297ad9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+std-devel-0.103.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki+std-devel.sha256sum] = "49cb6c86555598f90f7b0ae4de3ef90309d20fb52f235cadec3bde2ec41414cb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki-devel-0.103.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki-devel.sha256sum] = "728a2a20c5c25d4dbb2d68766a11ba106acb138dcec5a4378fd5a294bfcc6e80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+alloc-devel-0.103.15-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki+alloc-devel.sha256sum] = "6b49dfab93e93cbb63f8916860149d2437185008d6fd0f17229cd590d889dc9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+default-devel-0.103.15-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki+default-devel.sha256sum] = "0ec1b24254ce4c7227e2efad9c2c5b84cf0b3efd24d2842fcceeaa31db513d68"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+ring-devel-0.103.15-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki+ring-devel.sha256sum] = "11d23a09a37cab090f7e91c599aa489cb42c725d260d88ec2aca7193c371b58d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+std-devel-0.103.15-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki+std-devel.sha256sum] = "be4cb7a4d6e4e04da83fbc7675b34f821484cb43f22c1e7d30a401500dfbcffe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki-devel-0.103.15-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki-devel.sha256sum] = "2b270ae050fd53b8ff0c2d0d438591207f0a5e7e52e12bdce898c4add0eb4469"

RDEPENDS:rust-rustls-webpki+alloc-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+default-devel = " \
 cargo \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+ring-devel = " \
 cargo \
 rust-ring-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+std-devel = " \
 cargo \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 rust-untrusted+default-devel \
 "
