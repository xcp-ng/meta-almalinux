# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_properties_data"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_properties_data+default-devel \
 rust-icu_properties_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_properties_data-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6769bb4d1c6234c4a23476361fb3585fac55b6246aa736777e16c62d78367df8"

URI_x86_64_v2_rust-icu_properties_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties_data+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_properties_data+default-devel.sha256sum] = "16b03f856543817f0864bbcff88eae6352b11f671409424ac110884a839d21e1"

URI_x86_64_v2_rust-icu_properties_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_properties_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_properties_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_properties_data-devel}"
SRC_URI[x86_64_v2_rust-icu_properties_data-devel.sha256sum] = "f164744e856084c9555f20535584b5750d6cae3966bb5d70d099311f320b8ee7"

URI_aarch64_rust-icu_properties_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties_data+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_properties_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties_data+default-devel}"
SRC_URI[aarch64_rust-icu_properties_data+default-devel.sha256sum] = "3adfe081334a863f9487ac6fb62d36f8361c79b242516fbe6b74d732206e1c0c"

URI_aarch64_rust-icu_properties_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_properties_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_properties_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_properties_data-devel}"
SRC_URI[aarch64_rust-icu_properties_data-devel.sha256sum] = "d15f10963ab891937bce44a63563bda4f3570be5e872948f3b8404399d16ab29"

RDEPENDS:rust-icu_properties_data+default-devel = " \
 cargo \
 rust-icu_properties_data-devel \
 "
RDEPENDS:rust-icu_properties_data-devel = " \
 cargo \
 rust \
 "
