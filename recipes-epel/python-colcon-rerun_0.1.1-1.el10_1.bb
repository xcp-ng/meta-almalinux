# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-rerun"
PV = "0.1.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-rerun \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-rerun-0.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61b33755ff63de7774773e2203c3a4d5aa876750b3cbe82d1d65fe7574593c9f"

URI_x86_64_v2_python3-colcon-rerun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-rerun-0.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-rerun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-rerun}"
SRC_URI[x86_64_v2_python3-colcon-rerun.sha256sum] = "2182390c1b74fbe6b125970dc15b79e82a28c2bf0fad8ad16bb0f6b792e554fc"

URI_aarch64_python3-colcon-rerun = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-rerun-0.1.1-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-rerun;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-rerun}"
SRC_URI[aarch64_python3-colcon-rerun.sha256sum] = "f57dfe898a2a262398af415b0c2da20b9934fd96e0bae8ef23eee974f385d211"

RDEPENDS:python3-colcon-rerun = " \
 python3 \
 python3-colcon-core \
 python3-filelock \
 python3-pyyaml \
 "
