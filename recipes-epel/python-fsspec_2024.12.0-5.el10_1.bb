# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fsspec"
PV = "2024.12.0"
PR = "5.el10_1"
PACKAGES = " \
 python3-fsspec \
 python3-fsspec+arrow \
 python3-fsspec+dask \
 python3-fsspec+entrypoints \
 python3-fsspec+fuse \
 python3-fsspec+gcs \
 python3-fsspec+git \
 python3-fsspec+github \
 python3-fsspec+gs \
 python3-fsspec+hdfs \
 python3-fsspec+http \
 python3-fsspec+libarchive \
 python3-fsspec+sftp \
 python3-fsspec+smb \
 python3-fsspec+ssh \
 python3-fsspec+tqdm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fsspec-2024.12.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e01bbf7ff97cbc3f72a188806a82502cadb0a753aebf4c6e303e64467cd8198b"

URI_x86_64_v2_python3-fsspec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec}"
SRC_URI[x86_64_v2_python3-fsspec.sha256sum] = "0e56c16278e828071fe492ced49bee78357a9d10090c25a076b895ef346925a7"

URI_x86_64_v2_python3-fsspec+arrow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+arrow-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+arrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+arrow}"
SRC_URI[x86_64_v2_python3-fsspec+arrow.sha256sum] = "1d5c3176d94b868e2076c4a03b396222fefda6f12040075701d6e9d2b077719d"

URI_x86_64_v2_python3-fsspec+dask = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+dask-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+dask;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+dask}"
SRC_URI[x86_64_v2_python3-fsspec+dask.sha256sum] = "1a821457f032388225e4de31c1fa3ed67c64aad1661ed919eefa33f94726b516"

URI_x86_64_v2_python3-fsspec+entrypoints = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+entrypoints-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+entrypoints;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+entrypoints}"
SRC_URI[x86_64_v2_python3-fsspec+entrypoints.sha256sum] = "a13f270bd9d69639eba5786f840fe115d72334f8463b0be6852f1ae15b55f052"

URI_x86_64_v2_python3-fsspec+fuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+fuse-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+fuse}"
SRC_URI[x86_64_v2_python3-fsspec+fuse.sha256sum] = "951398a247b9fb66e74d5a7db03d1e4a847765f1cd04744059010f63dbf9d8ea"

URI_x86_64_v2_python3-fsspec+gcs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+gcs-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+gcs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+gcs}"
SRC_URI[x86_64_v2_python3-fsspec+gcs.sha256sum] = "2bad8efb0737401fe36cf8ef8650dd8df7a51af62231d616f3527d186eb4d5e1"

URI_x86_64_v2_python3-fsspec+git = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+git-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+git;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+git}"
SRC_URI[x86_64_v2_python3-fsspec+git.sha256sum] = "676419b1d244f48acfacbd1c6fa203bf44011bb9a00e571715dcdba20359098a"

URI_x86_64_v2_python3-fsspec+github = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+github-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+github;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+github}"
SRC_URI[x86_64_v2_python3-fsspec+github.sha256sum] = "3e824f418ad947307347c45ce95c5c774279b3e017c3499e3e3d8079c5d219b1"

URI_x86_64_v2_python3-fsspec+gs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+gs-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+gs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+gs}"
SRC_URI[x86_64_v2_python3-fsspec+gs.sha256sum] = "92f9696b971fbd0e627733abb33633eca43a56c54d0d705ff7be71ee375cc081"

URI_x86_64_v2_python3-fsspec+hdfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+hdfs-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+hdfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+hdfs}"
SRC_URI[x86_64_v2_python3-fsspec+hdfs.sha256sum] = "1d229843bf3de7007748dd6fecaa02aae41a14adf58e745612c54a606fd4780d"

URI_x86_64_v2_python3-fsspec+http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+http-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+http}"
SRC_URI[x86_64_v2_python3-fsspec+http.sha256sum] = "640401e67e859ae42f84e10825fb9aed6a60db36a29531da0c982d3eedb9e267"

URI_x86_64_v2_python3-fsspec+libarchive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+libarchive-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+libarchive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+libarchive}"
SRC_URI[x86_64_v2_python3-fsspec+libarchive.sha256sum] = "d8eb5cce8ed1242299bf9e6bcef018aa9afe0d91e87fd991e948cbe93f2d3ea1"

URI_x86_64_v2_python3-fsspec+sftp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+sftp-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+sftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+sftp}"
SRC_URI[x86_64_v2_python3-fsspec+sftp.sha256sum] = "f19be378d302a8b2abfc9405e32bd846366d345e93a6993a4145447011c44236"

URI_x86_64_v2_python3-fsspec+smb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+smb-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+smb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+smb}"
SRC_URI[x86_64_v2_python3-fsspec+smb.sha256sum] = "7ef2ed9d198979b27dcdccba325aa287b36dd7eb2d15f7fe32dc746ab91e4ed7"

URI_x86_64_v2_python3-fsspec+ssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+ssh-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+ssh}"
SRC_URI[x86_64_v2_python3-fsspec+ssh.sha256sum] = "686e6e2aa6ce0ec99bee21dd54da469ccc66f34fed50479fb1379bdc09082798"

URI_x86_64_v2_python3-fsspec+tqdm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec+tqdm-2024.12.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec+tqdm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fsspec+tqdm}"
SRC_URI[x86_64_v2_python3-fsspec+tqdm.sha256sum] = "77a82697d174ee10a857d0423f861fdf3fb1089c5f1be4df30d87c85224fea03"

URI_aarch64_python3-fsspec = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec}"
SRC_URI[aarch64_python3-fsspec.sha256sum] = "6d4f0a6de10c08a2cab6bdab25ba0413a65a4c9ded93f0f60fa070817f5544a1"

URI_aarch64_python3-fsspec+arrow = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+arrow-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+arrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+arrow}"
SRC_URI[aarch64_python3-fsspec+arrow.sha256sum] = "fad39ea1d29b29d42660ba72facaad920ea73f453cdb57fda5c360f8c7fcb6ab"

URI_aarch64_python3-fsspec+dask = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+dask-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+dask;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+dask}"
SRC_URI[aarch64_python3-fsspec+dask.sha256sum] = "d448a668155dd645f08559fc5d8a22f678edbf7250804876656434e5e183a1a3"

URI_aarch64_python3-fsspec+entrypoints = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+entrypoints-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+entrypoints;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+entrypoints}"
SRC_URI[aarch64_python3-fsspec+entrypoints.sha256sum] = "2ec88890ef70ef0534de2f3672e042973520ec2c221a080e63178822985e694c"

URI_aarch64_python3-fsspec+fuse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+fuse-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+fuse}"
SRC_URI[aarch64_python3-fsspec+fuse.sha256sum] = "6638dc1ad1166289ce2922fca9f8de43a2278b9e85cbce150312de1f61fe3528"

URI_aarch64_python3-fsspec+gcs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+gcs-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+gcs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+gcs}"
SRC_URI[aarch64_python3-fsspec+gcs.sha256sum] = "eaca77d8c0b7f55cf8a95dcbb83773522267f04b73faea8f5e792192e63511c6"

URI_aarch64_python3-fsspec+git = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+git-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+git;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+git}"
SRC_URI[aarch64_python3-fsspec+git.sha256sum] = "ae020226bc635f365f7fd3cc7dc8bb8c5e956044f3208df7d51585c0880cee0d"

URI_aarch64_python3-fsspec+github = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+github-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+github;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+github}"
SRC_URI[aarch64_python3-fsspec+github.sha256sum] = "0f1c6de19e2c600278a48ad58aacf8087ce27e0e1e8ffeb48aac8da36f8d6d7d"

URI_aarch64_python3-fsspec+gs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+gs-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+gs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+gs}"
SRC_URI[aarch64_python3-fsspec+gs.sha256sum] = "865b209be877b084c395bee6b41e79e3775b48abdf0122dc6b7f2ba2750b31f3"

URI_aarch64_python3-fsspec+hdfs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+hdfs-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+hdfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+hdfs}"
SRC_URI[aarch64_python3-fsspec+hdfs.sha256sum] = "687d168336cb2285af19d850e7f0c1a952715c54b0edc0a0bc61a7495225f945"

URI_aarch64_python3-fsspec+http = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+http-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+http;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+http}"
SRC_URI[aarch64_python3-fsspec+http.sha256sum] = "fbf3e3b050608341add53f6b4fee6c47f701356cdf87a3b5801f15559b5de16d"

URI_aarch64_python3-fsspec+libarchive = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+libarchive-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+libarchive;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+libarchive}"
SRC_URI[aarch64_python3-fsspec+libarchive.sha256sum] = "41df39d33eee0b30d40eda57e5c8d1593a607d41b946df7a47e12973864ef75c"

URI_aarch64_python3-fsspec+sftp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+sftp-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+sftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+sftp}"
SRC_URI[aarch64_python3-fsspec+sftp.sha256sum] = "41fbfda3d97379a0fb5d2729201c24749db509f4180e92b9440523d0db7a74ec"

URI_aarch64_python3-fsspec+smb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+smb-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+smb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+smb}"
SRC_URI[aarch64_python3-fsspec+smb.sha256sum] = "639be16f1d34faee1fe1fee001286a436f688be64b50b826118a4bb762c40581"

URI_aarch64_python3-fsspec+ssh = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+ssh-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+ssh}"
SRC_URI[aarch64_python3-fsspec+ssh.sha256sum] = "25491cbec2a7d8d81e19a94b7644e8abec0293f038e8596c9f13fb444e7f0c90"

URI_aarch64_python3-fsspec+tqdm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec+tqdm-2024.12.0-5.el10_1.noarch.rpm;name=aarch64_python3-fsspec+tqdm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fsspec+tqdm}"
SRC_URI[aarch64_python3-fsspec+tqdm.sha256sum] = "b65a0a8d90914a636f8ed7213814bce29476da24d006bd8f40052c2194241a89"

RDEPENDS:python3-fsspec = " \
 python3 \
 "
RDEPENDS:python3-fsspec+arrow = " \
 python3 \
 python3-fsspec \
 python3-pyarrow \
 "
RDEPENDS:python3-fsspec+dask = " \
 python3 \
 python3-dask \
 python3-distributed \
 python3-fsspec \
 "
RDEPENDS:python3-fsspec+entrypoints = " \
 python3 \
 python3-fsspec \
 "
RDEPENDS:python3-fsspec+fuse = " \
 python3 \
 python3-fsspec \
 python3-fusepy \
 "
RDEPENDS:python3-fsspec+gcs = " \
 python3 \
 python3-fsspec \
 python3-gcsfs \
 "
RDEPENDS:python3-fsspec+git = " \
 python3 \
 python3-fsspec \
 python3-pygit2 \
 "
RDEPENDS:python3-fsspec+github = " \
 python3 \
 python3-fsspec \
 python3-requests \
 "
RDEPENDS:python3-fsspec+gs = " \
 python3 \
 python3-fsspec \
 python3-gcsfs \
 "
RDEPENDS:python3-fsspec+hdfs = " \
 python3 \
 python3-fsspec \
 python3-pyarrow \
 "
RDEPENDS:python3-fsspec+http = " \
 python3 \
 python3-aiohttp \
 python3-fsspec \
 "
RDEPENDS:python3-fsspec+libarchive = " \
 python3 \
 python3-fsspec \
 python3-libarchive-c \
 "
RDEPENDS:python3-fsspec+sftp = " \
 python3 \
 python3-fsspec \
 python3-paramiko \
 "
RDEPENDS:python3-fsspec+smb = " \
 python3 \
 python3-fsspec \
 python3-smbprotocol \
 "
RDEPENDS:python3-fsspec+ssh = " \
 python3 \
 python3-fsspec \
 python3-paramiko \
 "
RDEPENDS:python3-fsspec+tqdm = " \
 python3 \
 python3-fsspec \
 python3-tqdm \
 "
