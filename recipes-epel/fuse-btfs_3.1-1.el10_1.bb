# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fuse-btfs"
PV = "3.1"
PR = "1.el10_1"
PACKAGES = " \
 fuse-btfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fuse-btfs-3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16ae0b1d286b403ed53c51910bb23b78af33bb53c1458d9e2d4e242f8de1dd3f"

URI_x86_64_v2_fuse-btfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fuse-btfs-3.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fuse-btfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fuse-btfs}"
SRC_URI[x86_64_v2_fuse-btfs.sha256sum] = "e5e023312dfd717593754f60bf61bff2d968acbff6f1bef69a11e916fc02d513"

URI_aarch64_fuse-btfs = "${EPEL_MIRROR}/aarch64/Packages/f/fuse-btfs-3.1-1.el10_1.aarch64.rpm;name=aarch64_fuse-btfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_fuse-btfs}"
SRC_URI[aarch64_fuse-btfs.sha256sum] = "e7af88c99ecb706a2bce58174a3b551fd1fafa2f2cf46726ba9647ea3f6161bb"

RDEPENDS:fuse-btfs = " \
 fuse3-libs \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 python3 \
 rb_libtorrent \
 virtual/libcurl.so.4___64bit_ \
 "
