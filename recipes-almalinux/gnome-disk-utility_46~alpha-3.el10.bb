# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-disk-utility"
PV = "46~alpha"
PR = "3.el10"
PACKAGES = " \
 gnome-disk-utility \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-disk-utility-46~alpha-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc682703ce403d448f49b6a9c81a5391f1e9c33abaf1d86cbd6c94ead9af291d"

URI_x86_64_v2_gnome-disk-utility = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-disk-utility-46~alpha-3.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-disk-utility;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-disk-utility}"
SRC_URI[x86_64_v2_gnome-disk-utility.sha256sum] = "25ab9ad6733cb1ac8303b784ca667c317629d91d45c4afef3e06dd40dc6f5b96"

URI_aarch64_gnome-disk-utility = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-disk-utility-46~alpha-3.el10.aarch64.rpm;name=aarch64_gnome-disk-utility;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-disk-utility}"
SRC_URI[aarch64_gnome-disk-utility.sha256sum] = "3ef7b8e9d20aa1185d9f6933854f380405e6ab13c166b924e38a1f3189daf501"

RDEPENDS:gnome-disk-utility = " \
 atk \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libcanberra-gtk3 \
 libdvdread \
 libgcc \
 libhandy \
 libnotify \
 libpwquality \
 libsecret \
 libudisks2 \
 pango \
 systemd-libs \
 udisks2 \
 xz-libs \
 "
