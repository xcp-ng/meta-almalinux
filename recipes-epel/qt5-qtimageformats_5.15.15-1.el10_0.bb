# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtimageformats"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtimageformats \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtimageformats-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ea4fe98671990bce40b78bcf66ba5c92f98d17f6052cd43b0dd74fc5502fe14"

URI_x86_64_v2_qt5-qtimageformats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtimageformats-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtimageformats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtimageformats}"
SRC_URI[x86_64_v2_qt5-qtimageformats.sha256sum] = "035b1f7351b4bbcf584f8092cec5e6b7a131de001f1be2b848ca5cccdaa2acbe"

URI_aarch64_qt5-qtimageformats = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtimageformats-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtimageformats;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtimageformats}"
SRC_URI[aarch64_qt5-qtimageformats.sha256sum] = "142009f9433eeea6d037904e8e5722de758169ae74d5fdc7dd48b091666a52a6"

RDEPENDS:qt5-qtimageformats = " \
 glibc \
 jasper-libs \
 libmng \
 libstdc++ \
 libtiff \
 libwebp \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
