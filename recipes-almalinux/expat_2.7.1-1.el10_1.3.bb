# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "expat"
PV = "2.7.1"
PR = "1.el10_1.3"
PACKAGES = " \
 expat \
 expat-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/expat-2.7.1-1.el10_1.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fcf60c70905ed9f58051d82d0b013e5d1c7ef567330cdfc78e3d78db7d14190"

URI_x86_64_v2_expat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/expat-2.7.1-1.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_expat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_expat}"
SRC_URI[x86_64_v2_expat.sha256sum] = "c6399de42288bbe7d4192fa71d65a1460d97557285cdaa585f77b11cc0f73e9e"

URI_x86_64_v2_expat-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/expat-devel-2.7.1-1.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_expat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_expat-devel}"
SRC_URI[x86_64_v2_expat-devel.sha256sum] = "8d717cc27dfef532f2e1636accf82a24c1758a9adedf1849324ec043886b17ca"

URI_aarch64_expat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/expat-2.7.1-1.el10_1.3.aarch64.rpm;name=aarch64_expat;unpack=0"
SRC_URI:append = " ${URI_aarch64_expat}"
SRC_URI[aarch64_expat.sha256sum] = "0a24d4213be41ee78c714ca79692036d1efab39d7165fba07fde89c1b1238290"

URI_aarch64_expat-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/expat-devel-2.7.1-1.el10_1.3.aarch64.rpm;name=aarch64_expat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_expat-devel}"
SRC_URI[aarch64_expat-devel.sha256sum] = "cbcee89ba564db32d41fd76689b6f2b8e47fd3823e801ef013295e965f148bd6"

RDEPENDS:expat = " \
 glibc \
 "
RDEPENDS:expat-devel = " \
 expat \
 pkgconf-pkg-config \
 "
