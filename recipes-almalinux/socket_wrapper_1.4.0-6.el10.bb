# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "socket_wrapper"
PV = "1.4.0"
PR = "6.el10"
PACKAGES = " \
 socket_wrapper \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/socket_wrapper-1.4.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8db844d30f86154d6bb679e02f856b77914a3f5cc32725ab2f5f69c436e6fa67"

URI_x86_64_v2_socket_wrapper = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/socket_wrapper-1.4.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_socket_wrapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_socket_wrapper}"
SRC_URI[x86_64_v2_socket_wrapper.sha256sum] = "000d6596d442f1b93f7bc14b8698439b4329758a0744788f12b465519d9e9612"

URI_aarch64_socket_wrapper = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/socket_wrapper-1.4.0-6.el10.aarch64.rpm;name=aarch64_socket_wrapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_socket_wrapper}"
SRC_URI[aarch64_socket_wrapper.sha256sum] = "1e41ea77e82da0f48eb5491f090528eacc1e404603a5f148b41f656b9e3735fd"

RDEPENDS:socket_wrapper = " \
 cmake-filesystem \
 glibc \
 pkgconf-pkg-config \
 "
