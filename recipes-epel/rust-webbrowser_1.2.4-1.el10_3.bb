# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-webbrowser"
PV = "1.2.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-webbrowser+default-devel \
 rust-webbrowser+disable-wsl-devel \
 rust-webbrowser+hardened-devel \
 rust-webbrowser-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-webbrowser-1.2.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "59b9ecd585d0c8dd3d15748194d4af8179e20efe58c9be7d82a33cbd03e680b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser+default-devel-1.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-webbrowser+default-devel.sha256sum] = "58786766750a70b23270fd25df8525fe43b2c5d0b8c920118dd5d3a9e1a41c51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser+disable-wsl-devel-1.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser+disable-wsl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-webbrowser+disable-wsl-devel.sha256sum] = "3422f0547fd4e636b8a0017ccab4401887543b489de064aa4d82ab4797a31771"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser+hardened-devel-1.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser+hardened-devel;unpack=0"
SRC_URI[x86_64_v2_rust-webbrowser+hardened-devel.sha256sum] = "d88e1b7e4d956c1a45c4d725eb2d2f630d8c4d85767ca89a559d3d9403751cd2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser-devel-1.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser-devel;unpack=0"
SRC_URI[x86_64_v2_rust-webbrowser-devel.sha256sum] = "9f5509f23333dba0f42a90280d3a90107388c74f1ad196da48820c73d8c7bf90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser+default-devel-1.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-webbrowser+default-devel;unpack=0"
SRC_URI[aarch64_rust-webbrowser+default-devel.sha256sum] = "b9c661427abd35390a77078624e25b05578392ac8293debc64a25a8623494f23"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser+disable-wsl-devel-1.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-webbrowser+disable-wsl-devel;unpack=0"
SRC_URI[aarch64_rust-webbrowser+disable-wsl-devel.sha256sum] = "98afd1b459650eab9f948bd08ec20492ceab009cd39b4f79f34b535ac3e9c209"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser+hardened-devel-1.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-webbrowser+hardened-devel;unpack=0"
SRC_URI[aarch64_rust-webbrowser+hardened-devel.sha256sum] = "5984a7c7a117bbab99113b69b9d0ccbaecf8bd75db12db06bcf00fc00b8bc58a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser-devel-1.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-webbrowser-devel;unpack=0"
SRC_URI[aarch64_rust-webbrowser-devel.sha256sum] = "f704082f89966c95820a57719b88e849ebbe113d362c8fd423a5f6dec1936842"

RDEPENDS:rust-webbrowser+default-devel = " \
 cargo \
 rust-webbrowser-devel \
 "
RDEPENDS:rust-webbrowser+disable-wsl-devel = " \
 cargo \
 rust-webbrowser-devel \
 "
RDEPENDS:rust-webbrowser+hardened-devel = " \
 cargo \
 rust-webbrowser-devel \
 "
RDEPENDS:rust-webbrowser-devel = " \
 cargo \
 rust \
 rust-log-devel \
 rust-url+std-devel \
 rust-url-devel \
 "
