# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustyline14"
PV = "14.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustyline14+case_insensitive_history_search-devel \
 rust-rustyline14+custom-bindings-devel \
 rust-rustyline14+default-devel \
 rust-rustyline14+derive-devel \
 rust-rustyline14+fd-lock-devel \
 rust-rustyline14+home-devel \
 rust-rustyline14+radix_trie-devel \
 rust-rustyline14+regex-devel \
 rust-rustyline14+rusqlite-devel \
 rust-rustyline14+rustyline-derive-devel \
 rust-rustyline14+signal-hook-devel \
 rust-rustyline14+termios-devel \
 rust-rustyline14+with-dirs-devel \
 rust-rustyline14+with-file-history-devel \
 rust-rustyline14+with-sqlite-history-devel \
 rust-rustyline14-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustyline14-14.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dc65b711958c1378a96a70257554fbb9f315e0519124a9efd9da59d8d3f881f"

URI_x86_64_v2_rust-rustyline14+case_insensitive_history_search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+case_insensitive_history_search-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+case_insensitive_history_search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+case_insensitive_history_search-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+case_insensitive_history_search-devel.sha256sum] = "76ba3827042b470c0317b539e8ebf771d2e0b2c65fa2abe32b29bff33e774c09"

URI_x86_64_v2_rust-rustyline14+custom-bindings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+custom-bindings-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+custom-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+custom-bindings-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+custom-bindings-devel.sha256sum] = "5422caec04776bfbcf163ef8824170c83b58d0b209ed578b0526c785aaab6854"

URI_x86_64_v2_rust-rustyline14+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+default-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+default-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+default-devel.sha256sum] = "e39906f83138de609d94ea7023dc64c268394316f069a51bad41a96bfb8d9fde"

URI_x86_64_v2_rust-rustyline14+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+derive-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+derive-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+derive-devel.sha256sum] = "d98fb79ff7309bdef9bf4cf57280c522de9f97d59c1063b63b55278cf249a506"

URI_x86_64_v2_rust-rustyline14+fd-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+fd-lock-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+fd-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+fd-lock-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+fd-lock-devel.sha256sum] = "18a3685bcc4420a69ce364b3097b289a9eb3f08a00af36ac9a1a649a09f997f6"

URI_x86_64_v2_rust-rustyline14+home-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+home-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+home-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+home-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+home-devel.sha256sum] = "c26dbfb2339bc4f976e5e4c0c8d06805e59e916c30ea06009d7d684bb56ff374"

URI_x86_64_v2_rust-rustyline14+radix_trie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+radix_trie-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+radix_trie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+radix_trie-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+radix_trie-devel.sha256sum] = "f41f0bd210ee08f4c3dfe93e67f88e9f3250f4c16fc675fb901d94231d536da8"

URI_x86_64_v2_rust-rustyline14+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+regex-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+regex-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+regex-devel.sha256sum] = "eff0aeff98c6ecc853376128bfe9be541da2ebc464b7bc01c13ffa578b8702f2"

URI_x86_64_v2_rust-rustyline14+rusqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+rusqlite-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+rusqlite-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+rusqlite-devel.sha256sum] = "bf14a7b0a005de1b18bbfbc200a4ace4a07f9b5511c7097fd9819943b9e2d232"

URI_x86_64_v2_rust-rustyline14+rustyline-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+rustyline-derive-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+rustyline-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+rustyline-derive-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+rustyline-derive-devel.sha256sum] = "24447cd7bf5e6e06462270e33b9aa7b83f5d86bce44a5eb7e4f0e2c50fb88760"

URI_x86_64_v2_rust-rustyline14+signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+signal-hook-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+signal-hook-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+signal-hook-devel.sha256sum] = "4a0003a8d00b162d4d19aa6f97cbc959a28202e5facb5dffab6a671f30b84076"

URI_x86_64_v2_rust-rustyline14+termios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+termios-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+termios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+termios-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+termios-devel.sha256sum] = "a91477a994016c1964763338e5a7f26ab6fa82ffba4e1afd0ff57e1fc7712d65"

URI_x86_64_v2_rust-rustyline14+with-dirs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+with-dirs-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+with-dirs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+with-dirs-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+with-dirs-devel.sha256sum] = "581200aed475931188909b406d153cb2d82764731b4ec20b7c06254636c0ee6d"

URI_x86_64_v2_rust-rustyline14+with-file-history-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+with-file-history-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+with-file-history-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+with-file-history-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+with-file-history-devel.sha256sum] = "b4c333a446d56b830e383d6ca53e3b8f3eb5e9e2d8e8444b39d848b6ae4f84ec"

URI_x86_64_v2_rust-rustyline14+with-sqlite-history-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14+with-sqlite-history-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14+with-sqlite-history-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14+with-sqlite-history-devel}"
SRC_URI[x86_64_v2_rust-rustyline14+with-sqlite-history-devel.sha256sum] = "b6704ce85c4ee86d064f28db44f0760decab17896ff85d3d6ba2ebb88532c177"

URI_x86_64_v2_rust-rustyline14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline14-devel-14.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline14-devel}"
SRC_URI[x86_64_v2_rust-rustyline14-devel.sha256sum] = "da455507bd225043a0ce309692d63e6ddc53d4926237947e648b332c283f8407"

URI_aarch64_rust-rustyline14+case_insensitive_history_search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+case_insensitive_history_search-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+case_insensitive_history_search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+case_insensitive_history_search-devel}"
SRC_URI[aarch64_rust-rustyline14+case_insensitive_history_search-devel.sha256sum] = "0702e27e0316d3600ea18d85cacf32861497a8fb852f42fb4ca7186ce71b6fbe"

URI_aarch64_rust-rustyline14+custom-bindings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+custom-bindings-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+custom-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+custom-bindings-devel}"
SRC_URI[aarch64_rust-rustyline14+custom-bindings-devel.sha256sum] = "1f830714995d2c3225408fa616f5aa22e492c8b21259507c7b2be094b804f0fc"

URI_aarch64_rust-rustyline14+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+default-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+default-devel}"
SRC_URI[aarch64_rust-rustyline14+default-devel.sha256sum] = "4c1b64d04edc7e2e599accb5520b031e53ec29b7fbc86467fa739cf1739b61e4"

URI_aarch64_rust-rustyline14+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+derive-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+derive-devel}"
SRC_URI[aarch64_rust-rustyline14+derive-devel.sha256sum] = "aedfc02ba3543faf583013656fdf296ee14da25c62f7d4c659864c583fbf01bb"

URI_aarch64_rust-rustyline14+fd-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+fd-lock-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+fd-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+fd-lock-devel}"
SRC_URI[aarch64_rust-rustyline14+fd-lock-devel.sha256sum] = "7ec13567bda8e22149ac1079ccd56db343f1dbb2a1f6014ad92f704262fb8eed"

URI_aarch64_rust-rustyline14+home-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+home-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+home-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+home-devel}"
SRC_URI[aarch64_rust-rustyline14+home-devel.sha256sum] = "ba49a7cf86861190f29b96c588c71a4223cf69115c162ce2d76789246d6c30c0"

URI_aarch64_rust-rustyline14+radix_trie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+radix_trie-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+radix_trie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+radix_trie-devel}"
SRC_URI[aarch64_rust-rustyline14+radix_trie-devel.sha256sum] = "dc847ff59b7b5d30abb1f9c6c618b9c1d6b34737bec56c1e8889f68b9f4bd29d"

URI_aarch64_rust-rustyline14+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+regex-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+regex-devel}"
SRC_URI[aarch64_rust-rustyline14+regex-devel.sha256sum] = "af963bd727092531a4d254b49238457ba8d6bbbf041604543f442b0191005f62"

URI_aarch64_rust-rustyline14+rusqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+rusqlite-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+rusqlite-devel}"
SRC_URI[aarch64_rust-rustyline14+rusqlite-devel.sha256sum] = "dd2366ded1fb504b15e51b8c36648bcd73288f3373ed7ebc9e0e797b86dae08a"

URI_aarch64_rust-rustyline14+rustyline-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+rustyline-derive-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+rustyline-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+rustyline-derive-devel}"
SRC_URI[aarch64_rust-rustyline14+rustyline-derive-devel.sha256sum] = "eec2f0d044498a1fa5da74ca2ea158ac9ba45bff38a309f55cb17ce98f05bb10"

URI_aarch64_rust-rustyline14+signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+signal-hook-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+signal-hook-devel}"
SRC_URI[aarch64_rust-rustyline14+signal-hook-devel.sha256sum] = "a1227c213ea225f5c1101dadedd43fac33bce396c86b552514775dcdc54ac467"

URI_aarch64_rust-rustyline14+termios-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+termios-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+termios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+termios-devel}"
SRC_URI[aarch64_rust-rustyline14+termios-devel.sha256sum] = "bc0344264ce607d2ef6d4ac35c7a0ed65cc45e9a1c0394cf49cfff47f8d2579e"

URI_aarch64_rust-rustyline14+with-dirs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+with-dirs-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+with-dirs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+with-dirs-devel}"
SRC_URI[aarch64_rust-rustyline14+with-dirs-devel.sha256sum] = "6d3fa82a80e6ecd7f49eac470444194364ab80280bc76feed8a5dea476119cec"

URI_aarch64_rust-rustyline14+with-file-history-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+with-file-history-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+with-file-history-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+with-file-history-devel}"
SRC_URI[aarch64_rust-rustyline14+with-file-history-devel.sha256sum] = "00039752499cdc8adb1eed4aa5050582c8a707a21c3c686b6577ce50f0f25fe0"

URI_aarch64_rust-rustyline14+with-sqlite-history-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14+with-sqlite-history-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14+with-sqlite-history-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14+with-sqlite-history-devel}"
SRC_URI[aarch64_rust-rustyline14+with-sqlite-history-devel.sha256sum] = "3a8caec8080536d9684b4d6a6485c04110bcbdabdcce99771c6cfed8826beea8"

URI_aarch64_rust-rustyline14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline14-devel-14.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline14-devel}"
SRC_URI[aarch64_rust-rustyline14-devel.sha256sum] = "106fc485bcc2e196211293a6c4306bd1ae2cd311ac8683f6af69ed9190abbc04"

RDEPENDS:rust-rustyline14+case_insensitive_history_search-devel = " \
 cargo \
 rust-rustyline14+regex-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+custom-bindings-devel = " \
 cargo \
 rust-rustyline14+radix_trie-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+default-devel = " \
 cargo \
 rust-rustyline14+custom-bindings-devel \
 rust-rustyline14+with-dirs-devel \
 rust-rustyline14+with-file-history-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+derive-devel = " \
 cargo \
 rust-rustyline14+rustyline-derive-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+fd-lock-devel = " \
 cargo \
 rust-fd-lock+default-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+home-devel = " \
 cargo \
 rust-home+default-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+radix_trie-devel = " \
 cargo \
 rust-radix_trie+default-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+rusqlite-devel = " \
 cargo \
 rust-rusqlite0.31+backup-devel \
 rust-rusqlite0.31-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+rustyline-derive-devel = " \
 cargo \
 rust-rustyline-derive0.10+default-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+signal-hook-devel = " \
 cargo \
 rust-rustyline14-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-rustyline14+termios-devel = " \
 cargo \
 rust-rustyline14-devel \
 rust-termios+default-devel \
 "
RDEPENDS:rust-rustyline14+with-dirs-devel = " \
 cargo \
 rust-rustyline14+home-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+with-file-history-devel = " \
 cargo \
 rust-rustyline14+fd-lock-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14+with-sqlite-history-devel = " \
 cargo \
 rust-rustyline14+rusqlite-devel \
 rust-rustyline14-devel \
 "
RDEPENDS:rust-rustyline14-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-nix0.28+fs-devel \
 rust-nix0.28+ioctl-devel \
 rust-nix0.28+poll-devel \
 rust-nix0.28+signal-devel \
 rust-nix0.28+term-devel \
 rust-nix0.28-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 rust-utf8parse+default-devel \
 "
