# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skanlite"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 skanlite \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/skanlite-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9dd76bc94b24523dbe364f3d234b4803978d4b6aee72ca624ac2ded6f871b7a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skanlite-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skanlite;unpack=0"
SRC_URI[x86_64_v2_skanlite.sha256sum] = "facc36a57dbcf4b35e93c4cd30b57ab7c7d5752c3fdec5ed5483a9e8ddefb224"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/skanlite-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_skanlite;unpack=0"
SRC_URI[aarch64_skanlite.sha256sum] = "0257fd98a049bf5911b085c51a09202bfbeb3147fdca4d20523f246f4be41e3b"

RDEPENDS:skanlite = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
