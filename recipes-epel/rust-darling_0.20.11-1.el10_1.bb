# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling"
PV = "0.20.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-darling+default-devel \
 rust-darling+diagnostics-devel \
 rust-darling+suggestions-devel \
 rust-darling-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling-0.20.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d2cf8b31e41c25f82fafc7457d7fb6ebba80cc89daf41627fb063e290576ecb"

URI_x86_64_v2_rust-darling+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+default-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+default-devel}"
SRC_URI[x86_64_v2_rust-darling+default-devel.sha256sum] = "17ccc4471868ebcffe1e762e41f5d5addfc111224b5d3775e77f007373a2a5b2"

URI_x86_64_v2_rust-darling+diagnostics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+diagnostics-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+diagnostics-devel}"
SRC_URI[x86_64_v2_rust-darling+diagnostics-devel.sha256sum] = "f4f5b50a8447109e629cb94e4fcb209cfd58e27a1645c97fdc9428f791887a00"

URI_x86_64_v2_rust-darling+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling+suggestions-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling+suggestions-devel}"
SRC_URI[x86_64_v2_rust-darling+suggestions-devel.sha256sum] = "2f23fbc22cd19d71e482264901378ff9d2ae3a791c11f2fb21573ac930fc72ee"

URI_x86_64_v2_rust-darling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling-devel}"
SRC_URI[x86_64_v2_rust-darling-devel.sha256sum] = "7728c8252c1e5f3a5e92052fae186680179342f7d3888ae0e8e82c2fd45397e3"

URI_aarch64_rust-darling+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+default-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+default-devel}"
SRC_URI[aarch64_rust-darling+default-devel.sha256sum] = "b6fa65755f909bed8cc2f12cba99e8e9b192eb5267e6142ecbb4134bb9dd3ea4"

URI_aarch64_rust-darling+diagnostics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+diagnostics-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling+diagnostics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+diagnostics-devel}"
SRC_URI[aarch64_rust-darling+diagnostics-devel.sha256sum] = "a1c20fa22be21b94d69baf97f1fdf2425e0a733ac709648b63c448cf0605b7f3"

URI_aarch64_rust-darling+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling+suggestions-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling+suggestions-devel}"
SRC_URI[aarch64_rust-darling+suggestions-devel.sha256sum] = "3389c6a3ef942ce89aa9b2149371ba1ec3fd722f517d23ff263ec1cbdab722ca"

URI_aarch64_rust-darling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling-devel}"
SRC_URI[aarch64_rust-darling-devel.sha256sum] = "a910ca6c3bda1cec54b000f1905cf6fa480b2cf707e7a3534f64bb89a236cf3e"

RDEPENDS:rust-darling+default-devel = " \
 cargo \
 rust-darling+suggestions-devel \
 rust-darling-devel \
 "
RDEPENDS:rust-darling+diagnostics-devel = " \
 cargo \
 rust-darling-devel \
 rust-darling_core+diagnostics-devel \
 "
RDEPENDS:rust-darling+suggestions-devel = " \
 cargo \
 rust-darling-devel \
 rust-darling_core+suggestions-devel \
 "
RDEPENDS:rust-darling-devel = " \
 cargo \
 rust \
 rust-darling_core+default-devel \
 rust-darling_macro+default-devel \
 "
