# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-utf-8"
PV = "0.7.6"
PR = "10.el10_0"
PACKAGES = " \
 rust-utf-8+default-devel \
 rust-utf-8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-utf-8-0.7.6-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0876b5d3f3c3f27bfc400ccb6f15e1286e3de149c98dfbe73d926ea44a5a7292"

URI_x86_64_v2_rust-utf-8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf-8+default-devel-0.7.6-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf-8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf-8+default-devel}"
SRC_URI[x86_64_v2_rust-utf-8+default-devel.sha256sum] = "ffaba97425e1cc3708326671ac1a6ff8812de856d3a3bd1dd1fa24bc4e0374a5"

URI_x86_64_v2_rust-utf-8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf-8-devel-0.7.6-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf-8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf-8-devel}"
SRC_URI[x86_64_v2_rust-utf-8-devel.sha256sum] = "477e15c6f066641bb16ce8c075b0770e8055fbfbcf127087953e0faffd094f5e"

URI_aarch64_rust-utf-8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf-8+default-devel-0.7.6-10.el10_0.noarch.rpm;name=aarch64_rust-utf-8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf-8+default-devel}"
SRC_URI[aarch64_rust-utf-8+default-devel.sha256sum] = "41bfbbd9febf6458d5e35e8be22157c73c0dfc0416bcbe813d71b19bc53dc5b4"

URI_aarch64_rust-utf-8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf-8-devel-0.7.6-10.el10_0.noarch.rpm;name=aarch64_rust-utf-8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf-8-devel}"
SRC_URI[aarch64_rust-utf-8-devel.sha256sum] = "5da7bf866dc618e6dc374bea5f734803e4f7486abe6146a713d7fb4cc52208c9"

RDEPENDS:rust-utf-8+default-devel = " \
 cargo \
 rust-utf-8-devel \
 "
RDEPENDS:rust-utf-8-devel = " \
 cargo \
 "
