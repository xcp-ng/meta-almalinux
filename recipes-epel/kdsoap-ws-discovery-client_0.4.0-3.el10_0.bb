# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdsoap-ws-discovery-client"
PV = "0.4.0"
PR = "3.el10_0"
PACKAGES = " \
 kdsoap-ws-discovery-client \
 kdsoap-ws-discovery-client-devel \
 kdsoap-ws-discovery-client-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdsoap-ws-discovery-client-0.4.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5056dee7a3a7914506a61c71ca2eb321ffbff3ed1010d8619ed662ca0803375"

URI_x86_64_v2_kdsoap-ws-discovery-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsoap-ws-discovery-client-0.4.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdsoap-ws-discovery-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsoap-ws-discovery-client}"
SRC_URI[x86_64_v2_kdsoap-ws-discovery-client.sha256sum] = "22545f536a87ca62b48a0819707ed162c77ce99f38fa8e6c13f1bd1f1e8378ae"

URI_x86_64_v2_kdsoap-ws-discovery-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsoap-ws-discovery-client-devel-0.4.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdsoap-ws-discovery-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsoap-ws-discovery-client-devel}"
SRC_URI[x86_64_v2_kdsoap-ws-discovery-client-devel.sha256sum] = "1856447bd4ab454df67fd57115f9a7f093bdaa7cf13c077ace605725e4f4705e"

URI_x86_64_v2_kdsoap-ws-discovery-client-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdsoap-ws-discovery-client-doc-0.4.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kdsoap-ws-discovery-client-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdsoap-ws-discovery-client-doc}"
SRC_URI[x86_64_v2_kdsoap-ws-discovery-client-doc.sha256sum] = "dcf1fdb890384376985fd02ead0b0c1f57d37139da6d36f951c5b26243ebe802"

URI_aarch64_kdsoap-ws-discovery-client = "${EPEL_MIRROR}/aarch64/Packages/k/kdsoap-ws-discovery-client-0.4.0-3.el10_0.aarch64.rpm;name=aarch64_kdsoap-ws-discovery-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsoap-ws-discovery-client}"
SRC_URI[aarch64_kdsoap-ws-discovery-client.sha256sum] = "79f0ae75ccd9995eed6ea3e429365f9bbfe328ae31a00e349495e3c89d8ca95d"

URI_aarch64_kdsoap-ws-discovery-client-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdsoap-ws-discovery-client-devel-0.4.0-3.el10_0.aarch64.rpm;name=aarch64_kdsoap-ws-discovery-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsoap-ws-discovery-client-devel}"
SRC_URI[aarch64_kdsoap-ws-discovery-client-devel.sha256sum] = "77d553ffd6f5625bd6e7ca9099bd45890e4889fd8c6a6430a6cb496bd6b27fee"

URI_aarch64_kdsoap-ws-discovery-client-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kdsoap-ws-discovery-client-doc-0.4.0-3.el10_0.noarch.rpm;name=aarch64_kdsoap-ws-discovery-client-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdsoap-ws-discovery-client-doc}"
SRC_URI[aarch64_kdsoap-ws-discovery-client-doc.sha256sum] = "ae8abc27b6fb71c05ff94e3e04d8bd54d758d6705f09ebcece23dd21f015cb2c"

RDEPENDS:kdsoap-ws-discovery-client = " \
 glibc \
 kdsoap6 \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kdsoap-ws-discovery-client-devel = " \
 cmake-filesystem \
 kdsoap-ws-discovery-client \
 kdsoap6-devel \
 "
RDEPENDS:kdsoap-ws-discovery-client-doc = " \
 "
