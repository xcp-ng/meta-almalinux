# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ossl"
PV = "1.5.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-ossl+default-devel \
 rust-ossl+openssl-sys-devel \
 rust-ossl+ossl320-devel \
 rust-ossl+ossl350-devel \
 rust-ossl+ossl400-devel \
 rust-ossl+rfc9580-devel \
 rust-ossl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ossl-1.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fc5a08c5cb44da65861bb43a6dbd1af99917e614ccba334a439281c43784e19"

URI_x86_64_v2_rust-ossl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+default-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+default-devel}"
SRC_URI[x86_64_v2_rust-ossl+default-devel.sha256sum] = "630d72fc0015aab6d9a31600b29972105393d3cb7ba1ed77c8b7f83894832077"

URI_x86_64_v2_rust-ossl+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+openssl-sys-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-ossl+openssl-sys-devel.sha256sum] = "ab846fb6231aa13f6481c6499852168ea8baac83e94e5fa7c130ff3d97c7f46d"

URI_x86_64_v2_rust-ossl+ossl320-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+ossl320-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+ossl320-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+ossl320-devel}"
SRC_URI[x86_64_v2_rust-ossl+ossl320-devel.sha256sum] = "11b36a7054a5ddd07c472af6229a11aa73d8fda641969a6121ecbfbc9182b910"

URI_x86_64_v2_rust-ossl+ossl350-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+ossl350-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+ossl350-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+ossl350-devel}"
SRC_URI[x86_64_v2_rust-ossl+ossl350-devel.sha256sum] = "1aafa9927e55d12886cb7c25442211ad51fd4d04c778be41f8772247ee8c01b1"

URI_x86_64_v2_rust-ossl+ossl400-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+ossl400-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+ossl400-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+ossl400-devel}"
SRC_URI[x86_64_v2_rust-ossl+ossl400-devel.sha256sum] = "fc4eea0ccfa02136377825e28f3ae1fe66d5c3f7d9bca154ceebb7b7a6288614"

URI_x86_64_v2_rust-ossl+rfc9580-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl+rfc9580-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl+rfc9580-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl+rfc9580-devel}"
SRC_URI[x86_64_v2_rust-ossl+rfc9580-devel.sha256sum] = "3af93f341bc5204a3d7c477d378f9ff6be27ebdf921c3c855ebaf081e5763c3f"

URI_x86_64_v2_rust-ossl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ossl-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ossl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ossl-devel}"
SRC_URI[x86_64_v2_rust-ossl-devel.sha256sum] = "8c05f62f7ff1702f2340a770286969d8cc5cf3a052408a9c7570d9621706a099"

URI_aarch64_rust-ossl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+default-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ossl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+default-devel}"
SRC_URI[aarch64_rust-ossl+default-devel.sha256sum] = "2ac198c7f23ac6899a4328da84c8c824e54aff30fc831d91b2aa38225605c0ea"

URI_aarch64_rust-ossl+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+openssl-sys-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ossl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+openssl-sys-devel}"
SRC_URI[aarch64_rust-ossl+openssl-sys-devel.sha256sum] = "67962da8719d2d533479ffa5e81f2e0260cd2caeb8ba1647fb75eb8dbd3b184c"

URI_aarch64_rust-ossl+ossl320-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+ossl320-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ossl+ossl320-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+ossl320-devel}"
SRC_URI[aarch64_rust-ossl+ossl320-devel.sha256sum] = "5713c4324b6c2a308497437bbe401aa25b87c8e05f38cac351aca3a089b89654"

URI_aarch64_rust-ossl+ossl350-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+ossl350-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ossl+ossl350-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+ossl350-devel}"
SRC_URI[aarch64_rust-ossl+ossl350-devel.sha256sum] = "c691112b1f4839cb5acbbd864088b205036e67db87a1466ab753051ff802c0a5"

URI_aarch64_rust-ossl+ossl400-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+ossl400-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ossl+ossl400-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+ossl400-devel}"
SRC_URI[aarch64_rust-ossl+ossl400-devel.sha256sum] = "fa3ef6b402fe953a3ef93d659c6ad74f9492e343835c158a4575fe1c455a8ae1"

URI_aarch64_rust-ossl+rfc9580-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl+rfc9580-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ossl+rfc9580-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl+rfc9580-devel}"
SRC_URI[aarch64_rust-ossl+rfc9580-devel.sha256sum] = "9162f5030f6edb7598cd0b1ff8cceae742322e28814056c9bd351e143506beba"

URI_aarch64_rust-ossl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ossl-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_rust-ossl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ossl-devel}"
SRC_URI[aarch64_rust-ossl-devel.sha256sum] = "0a4bdf58211de5a7dec150305028edefbbb660e2423e9f44fe3611113653509e"

RDEPENDS:rust-ossl+default-devel = " \
 cargo \
 rust-ossl+openssl-sys-devel \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+openssl-sys-devel = " \
 cargo \
 rust-openssl-sys+bindgen-devel \
 rust-openssl-sys+default-devel \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+ossl320-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+ossl350-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+ossl400-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl+rfc9580-devel = " \
 cargo \
 rust-ossl-devel \
 "
RDEPENDS:rust-ossl-devel = " \
 cargo \
 rust-bindgen+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
