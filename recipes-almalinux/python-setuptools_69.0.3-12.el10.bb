# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-setuptools"
PV = "69.0.3"
PR = "12.el10"
PACKAGES = " \
 python3-setuptools \
 python3-setuptools-wheel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-setuptools-69.0.3-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "561be6ce231c1705a25be9ed279f97ece6bc2416e2bd19ef2bbb2f5a0fb7ebb2"

URI_x86_64_v2_python3-setuptools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-setuptools-69.0.3-12.el10.noarch.rpm;name=x86_64_v2_python3-setuptools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setuptools}"
SRC_URI[x86_64_v2_python3-setuptools.sha256sum] = "501974f6a8c1e5b163f0dc61d42c9599c816519ec208cb2684ade3db97e53cfb"

URI_x86_64_v2_python3-setuptools-wheel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-setuptools-wheel-69.0.3-12.el10.noarch.rpm;name=x86_64_v2_python3-setuptools-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setuptools-wheel}"
SRC_URI[x86_64_v2_python3-setuptools-wheel.sha256sum] = "b3d6aeeeb9d1c29e8abe405c7650e79326f1da1e659a62fbb5de3d89205b537a"

URI_aarch64_python3-setuptools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-setuptools-69.0.3-12.el10.noarch.rpm;name=aarch64_python3-setuptools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setuptools}"
SRC_URI[aarch64_python3-setuptools.sha256sum] = "501974f6a8c1e5b163f0dc61d42c9599c816519ec208cb2684ade3db97e53cfb"

URI_aarch64_python3-setuptools-wheel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-setuptools-wheel-69.0.3-12.el10.noarch.rpm;name=aarch64_python3-setuptools-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setuptools-wheel}"
SRC_URI[aarch64_python3-setuptools-wheel.sha256sum] = "b3d6aeeeb9d1c29e8abe405c7650e79326f1da1e659a62fbb5de3d89205b537a"

RDEPENDS:python3-setuptools = " \
 python3 \
 "
RDEPENDS:python3-setuptools-wheel = " \
 "
