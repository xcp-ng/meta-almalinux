# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curl-sys"
PV = "0.4.84"
PR = "1.el10_1"
PACKAGES = " \
 rust-curl-sys+default-devel \
 rust-curl-sys+http2-devel \
 rust-curl-sys+ntlm-devel \
 rust-curl-sys+openssl-sys-devel \
 rust-curl-sys+poll_7_68_0-devel \
 rust-curl-sys+protocol-ftp-devel \
 rust-curl-sys+spnego-devel \
 rust-curl-sys+ssl-devel \
 rust-curl-sys+upkeep_7_62_0-devel \
 rust-curl-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-curl-sys-0.4.84-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "915bedc859a0b3e55860d3971168b2643d7b1226c8c14719f3281c40e1dac3bb"

URI_x86_64_v2_rust-curl-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+default-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+default-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+default-devel.sha256sum] = "08ec29ea71cde677afb35dbfd361f28d551c8fa1112f70d610bb35e9629aed83"

URI_x86_64_v2_rust-curl-sys+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+http2-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+http2-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+http2-devel.sha256sum] = "817face8c0ae5a8deedbbd70a1569b177443ad7d75459b9993aabf325cd943b7"

URI_x86_64_v2_rust-curl-sys+ntlm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+ntlm-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+ntlm-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+ntlm-devel.sha256sum] = "b22f0460d0d71fb188d2b74f232f81b525dbbf99b75af1ba15f29c4ba0800823"

URI_x86_64_v2_rust-curl-sys+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+openssl-sys-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+openssl-sys-devel.sha256sum] = "652285d9eadd95b233c8260b239ccd157c0a51c5813323cf835fb4479005de62"

URI_x86_64_v2_rust-curl-sys+poll_7_68_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+poll_7_68_0-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+poll_7_68_0-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+poll_7_68_0-devel.sha256sum] = "863d2b865ecc2be1f5bb34a08af4db5c15b2c577b7de68d9b8d6b89837f1e299"

URI_x86_64_v2_rust-curl-sys+protocol-ftp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+protocol-ftp-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+protocol-ftp-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+protocol-ftp-devel.sha256sum] = "5b03dea81667e8d30ffcbe4fdf3db67d29c7244c39c28813b43c0722e8b5bee0"

URI_x86_64_v2_rust-curl-sys+spnego-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+spnego-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+spnego-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+spnego-devel.sha256sum] = "2706ed774898eacf9364e1eae3ccd40ba38e437cf9ec058eb40d80a49f2372cc"

URI_x86_64_v2_rust-curl-sys+ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+ssl-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+ssl-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+ssl-devel.sha256sum] = "958777c16b829f6b53981986188183cf488f53069800821c4d658546b5bf5cc8"

URI_x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+upkeep_7_62_0-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel.sha256sum] = "ef4f993407c7fbeda8e8afed4bfc7a9e20c310b4d692d9ac1d3847f0f70c1909"

URI_x86_64_v2_rust-curl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys-devel-0.4.84-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl-sys-devel.sha256sum] = "cbaaa6605fe89ced8ce3b3095a8fe3b0d07a3e3cb3f1921577382145195b6d6a"

URI_aarch64_rust-curl-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+default-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+default-devel}"
SRC_URI[aarch64_rust-curl-sys+default-devel.sha256sum] = "306d2f95015cfb44d0e18a90b543ad34dd0ceb7dcb910d482524efb4d41de77f"

URI_aarch64_rust-curl-sys+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+http2-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+http2-devel}"
SRC_URI[aarch64_rust-curl-sys+http2-devel.sha256sum] = "3d6d4327847b24abcfcf287f900722443d1b89f2ca1219e12a895485671125b0"

URI_aarch64_rust-curl-sys+ntlm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+ntlm-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+ntlm-devel}"
SRC_URI[aarch64_rust-curl-sys+ntlm-devel.sha256sum] = "3ab3713716e1727281dc5f2b84192079e1210bb16d5ede87eb00941d7d3fadcc"

URI_aarch64_rust-curl-sys+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+openssl-sys-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+openssl-sys-devel}"
SRC_URI[aarch64_rust-curl-sys+openssl-sys-devel.sha256sum] = "36d30135d6ec10e92fcb163ebe949b35c3502e59f24af004798b3bfad5c039cc"

URI_aarch64_rust-curl-sys+poll_7_68_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+poll_7_68_0-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+poll_7_68_0-devel}"
SRC_URI[aarch64_rust-curl-sys+poll_7_68_0-devel.sha256sum] = "bf94462bfebcf71d96671ce7d47c1b4f992c32f3aa79bc64842b62e9b39c22db"

URI_aarch64_rust-curl-sys+protocol-ftp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+protocol-ftp-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+protocol-ftp-devel}"
SRC_URI[aarch64_rust-curl-sys+protocol-ftp-devel.sha256sum] = "ff0fe554c4961b7a1cc62f85e1b0f1e00b794374315f50edab9e2d7ac0dbce69"

URI_aarch64_rust-curl-sys+spnego-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+spnego-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+spnego-devel}"
SRC_URI[aarch64_rust-curl-sys+spnego-devel.sha256sum] = "3a581d8bce56be36506170d1199a708c15a9cef18f3102a3effe823717337eaf"

URI_aarch64_rust-curl-sys+ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+ssl-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+ssl-devel}"
SRC_URI[aarch64_rust-curl-sys+ssl-devel.sha256sum] = "429c8dbd04bb950a794ea37b315d05c879ef8702c9b2740356c86d9abc4357f7"

URI_aarch64_rust-curl-sys+upkeep_7_62_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+upkeep_7_62_0-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+upkeep_7_62_0-devel}"
SRC_URI[aarch64_rust-curl-sys+upkeep_7_62_0-devel.sha256sum] = "a856cafadc167c113c7bd39b86a47190e5bbd5988199a81ea2e4695645ceb760"

URI_aarch64_rust-curl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys-devel-0.4.84-1.el10_1.noarch.rpm;name=aarch64_rust-curl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys-devel}"
SRC_URI[aarch64_rust-curl-sys-devel.sha256sum] = "095a08e2a2f15c59d43ccbecb1165e0c7621aaf8d0f5a24c87eb1c1ee6c5cd05"

RDEPENDS:rust-curl-sys+default-devel = " \
 cargo \
 rust-curl-sys+ssl-devel \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+http2-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+ntlm-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+openssl-sys-devel = " \
 cargo \
 rust-curl-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-curl-sys+poll_7_68_0-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+protocol-ftp-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+spnego-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+ssl-devel = " \
 cargo \
 rust-curl-sys+openssl-sys-devel \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+upkeep_7_62_0-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys-devel = " \
 cargo \
 libcurl-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
