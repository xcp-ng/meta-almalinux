# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zipp"
PV = "3.21.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-zipp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zipp-3.21.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecdcbf8e9d8fd006bc7de7df909c399c1ac1875e788a79b84f9adafcbcf512ce"

URI_x86_64_v2_python3-zipp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zipp-3.21.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zipp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zipp}"
SRC_URI[x86_64_v2_python3-zipp.sha256sum] = "49815288a85a4c243d092fe367a1b7a0a3a5379e7457d856312e2988fde61016"

URI_aarch64_python3-zipp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zipp-3.21.0-1.el10_0.noarch.rpm;name=aarch64_python3-zipp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zipp}"
SRC_URI[aarch64_python3-zipp.sha256sum] = "abc76ef66e98ae69855f764780ee1c52ed5579af5f34bb19faaf4c73b8d1f1df"

RDEPENDS:python3-zipp = " \
 python3 \
 "
