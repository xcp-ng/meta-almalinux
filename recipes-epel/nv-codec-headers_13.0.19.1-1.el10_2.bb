# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nv-codec-headers"
PV = "13.0.19.1"
PR = "1.el10_2"
PACKAGES = " \
 nv-codec-headers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nv-codec-headers-13.0.19.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcba5d17b1ac8dd36e94699c17e4002360c5f70de26b589e921846db12196e79"

URI_x86_64_v2_nv-codec-headers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nv-codec-headers-13.0.19.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nv-codec-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nv-codec-headers}"
SRC_URI[x86_64_v2_nv-codec-headers.sha256sum] = "867718c0477c2bbf7b11ac9ce6a4452554f6b0dbfd96d61318146bf91eaa9814"

URI_aarch64_nv-codec-headers = "${EPEL_MIRROR}/aarch64/Packages/n/nv-codec-headers-13.0.19.1-1.el10_2.noarch.rpm;name=aarch64_nv-codec-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_nv-codec-headers}"
SRC_URI[aarch64_nv-codec-headers.sha256sum] = "6b15bbeb9c0990044bcfc08ba41a584864d0d3e1dfe100168c21f97f8325cfc0"

RDEPENDS:nv-codec-headers = " \
 pkgconf-pkg-config \
 "
