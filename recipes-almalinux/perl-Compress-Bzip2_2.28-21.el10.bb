# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Compress-Bzip2"
PV = "2.28"
PR = "21.el10"
PACKAGES = " \
 perl-Compress-Bzip2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Compress-Bzip2-2.28-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459acab7a24e44a2ca7b242cabff647c5dfc24b6d8fded4884842e9def9054b6"

URI_x86_64_v2_perl-Compress-Bzip2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Compress-Bzip2-2.28-21.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Compress-Bzip2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Compress-Bzip2}"
SRC_URI[x86_64_v2_perl-Compress-Bzip2.sha256sum] = "35d79baa95a15670513365bd03a594adb22ffaa5bb94ea9daf1d8e2c70958109"

URI_aarch64_perl-Compress-Bzip2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Compress-Bzip2-2.28-21.el10.aarch64.rpm;name=aarch64_perl-Compress-Bzip2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Compress-Bzip2}"
SRC_URI[aarch64_perl-Compress-Bzip2.sha256sum] = "383b82b9200c414474525722d71bd7713fdd8207d5241f6759f5395efe14f08e"

RDEPENDS:perl-Compress-Bzip2 = " \
 bzip2-libs \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-Getopt-Std \
 perl-constant \
 perl-libs \
 "
