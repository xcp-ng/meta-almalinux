# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "breeze-gtk"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 breeze-gtk \
 breeze-gtk-common \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/breeze-gtk-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d7d025ec62f26713ed9f1ff92d4363eaca29543d6b653af5c8599d9047f60cd8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk;unpack=0"
SRC_URI[x86_64_v2_breeze-gtk.sha256sum] = "c764b7fd39242e8de7bcc65ef9299d1f83f54e049167d99ee7bb82c058fcbf2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-common-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-common;unpack=0"
SRC_URI[x86_64_v2_breeze-gtk-common.sha256sum] = "30c817fdaa0537a7a81380f26713511191d8613976bb38ee65546229501f3996"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk2-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk2;unpack=0"
SRC_URI[x86_64_v2_breeze-gtk-gtk2.sha256sum] = "a80d3cdf8ade6df225c526c8a6c0301d1806a735420e3b9f45dc3c6c4b40adef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk3-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk3;unpack=0"
SRC_URI[x86_64_v2_breeze-gtk-gtk3.sha256sum] = "a28f00d982c07ea4e69b451460168705a70975e8967122f071d9b9d94e0b9098"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk4-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk4;unpack=0"
SRC_URI[x86_64_v2_breeze-gtk-gtk4.sha256sum] = "8117b1b6b427729c02eed0871a48b2f0b8c22ae01f89a2fec1f85204935ea417"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-6.7.5-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk;unpack=0"
SRC_URI[aarch64_breeze-gtk.sha256sum] = "263032a1187dce3cd7d291c74a2fe8293a2950a5d30cb4e52761e9e2a06d659f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-common-6.7.5-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk-common;unpack=0"
SRC_URI[aarch64_breeze-gtk-common.sha256sum] = "03c4c0abcfb6a77f51fd4d21848417b88f14db5c7f66a181f59dbd7e76b253c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk2-6.7.5-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk-gtk2;unpack=0"
SRC_URI[aarch64_breeze-gtk-gtk2.sha256sum] = "11d8170ba9382b58935b2588af3461c7027e36b8060537c0ada5af938597fa0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk3-6.7.5-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk-gtk3;unpack=0"
SRC_URI[aarch64_breeze-gtk-gtk3.sha256sum] = "706ea366992fcdbe1c7a5afaa6fe6565fb93e394e60f1a9011bad1378a8398fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk4-6.7.5-1.el10_3.noarch.rpm;name=aarch64_breeze-gtk-gtk4;unpack=0"
SRC_URI[aarch64_breeze-gtk-gtk4.sha256sum] = "fdabf79ce570fa8582847b5571189b2d8cb93418eeefe840ecadc31bc8c586d5"

RDEPENDS:breeze-gtk = " \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "
RDEPENDS:breeze-gtk-common = " \
 "
RDEPENDS:breeze-gtk-gtk2 = " \
 breeze-gtk-common \
 gtk2-engines \
 "
RDEPENDS:breeze-gtk-gtk3 = " \
 breeze-gtk-common \
 "
RDEPENDS:breeze-gtk-gtk4 = " \
 breeze-gtk-common \
 "
