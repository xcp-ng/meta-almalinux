# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-elisp"
PV = "1.6.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-elisp+default-devel \
 rust-tree-sitter-elisp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-elisp-1.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61d17c2e01823ab8e29a0dc82a65710d551022a1a8cfc9f5a40fdb286ba01e96"

URI_x86_64_v2_rust-tree-sitter-elisp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elisp+default-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elisp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elisp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elisp+default-devel.sha256sum] = "f0e197532ae315d066dd30e2bec09ecbba1127cbc1c79fe69c0adb42759ced32"

URI_x86_64_v2_rust-tree-sitter-elisp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elisp-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elisp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elisp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elisp-devel.sha256sum] = "17d98308ea404bc898fc11031c3258731e1481f6c26ebf220680591f5cf8928a"

URI_aarch64_rust-tree-sitter-elisp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elisp+default-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-elisp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elisp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-elisp+default-devel.sha256sum] = "b2ba38cc78bfb2b0ca94b866760d6ea7c2aa0b1e152d7637afd57bc639770eaf"

URI_aarch64_rust-tree-sitter-elisp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elisp-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-elisp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elisp-devel}"
SRC_URI[aarch64_rust-tree-sitter-elisp-devel.sha256sum] = "a24a3ae66105eeb366aeff9896348f76d305bb546dd36d3137d87ff9487c7f1f"

RDEPENDS:rust-tree-sitter-elisp+default-devel = " \
 cargo \
 rust-tree-sitter-elisp-devel \
 "
RDEPENDS:rust-tree-sitter-elisp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
