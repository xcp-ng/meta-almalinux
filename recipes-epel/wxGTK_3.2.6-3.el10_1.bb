# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wxGTK"
PV = "3.2.6"
PR = "3.el10_1"
PACKAGES = " \
 wxBase \
 wxBase-devel \
 wxGTK \
 wxGTK-devel \
 wxGTK-docs \
 wxGTK-gl \
 wxGTK-i18n \
 wxGTK-media \
 wxGTK-webview \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/wxGTK-3.2.6-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "48d9ae230dbed53ba2848e1dd8493e1eee14534dbfd0545d16bbbb1240b102fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxBase-3.2.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxBase;unpack=0"
SRC_URI[x86_64_v2_wxBase.sha256sum] = "3fafe65047a5271b41018abe6f082e2b38e278682308d263ac6d5c2815166e8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxBase-devel-3.2.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxBase-devel;unpack=0"
SRC_URI[x86_64_v2_wxBase-devel.sha256sum] = "a2c1f7c71ceb62fef9348e51b3b8c33ca6fa79a84ee9b10f0ba1ca2a631ae3a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-3.2.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK;unpack=0"
SRC_URI[x86_64_v2_wxGTK.sha256sum] = "16ddf6f5e3f3ab3a0227ff95053fdaf9bee60bdfaa250f77c6c77c10c3b72f00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-devel-3.2.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK-devel;unpack=0"
SRC_URI[x86_64_v2_wxGTK-devel.sha256sum] = "6b10bddfe10ea0d7048f8e006054191f95dbe0c2ee01da220dd098e03b1a8556"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-docs-3.2.6-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_wxGTK-docs;unpack=0"
SRC_URI[x86_64_v2_wxGTK-docs.sha256sum] = "8fd2dda9ef7e64840244b93877ea397e5d117dde0e48dc8b48e55e187dde24e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-gl-3.2.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK-gl;unpack=0"
SRC_URI[x86_64_v2_wxGTK-gl.sha256sum] = "1bc691565d709bfea2611f1b99bfe7883d2051e76fd5deddd1f5680fce60b2cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-i18n-3.2.6-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_wxGTK-i18n;unpack=0"
SRC_URI[x86_64_v2_wxGTK-i18n.sha256sum] = "a691a8269201b4930f75441b1de193383e8f12f88f6b579b19610eef16a2cf71"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-media-3.2.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK-media;unpack=0"
SRC_URI[x86_64_v2_wxGTK-media.sha256sum] = "24a44356ac20f9769994fb7c53b1a92f00a67bbdd9e567c200e0303e94c7f12c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wxGTK-webview-3.2.6-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wxGTK-webview;unpack=0"
SRC_URI[x86_64_v2_wxGTK-webview.sha256sum] = "8c53a1d5e588042787f84753985052e3fa1c614aa06c10e4e932986d872d8c5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wxBase-3.2.6-3.el10_1.aarch64.rpm;name=aarch64_wxBase;unpack=0"
SRC_URI[aarch64_wxBase.sha256sum] = "91c780ec1b22913e4475bb53712a3f9bd6d4c157e898153ed2c91eff83536abd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wxBase-devel-3.2.6-3.el10_1.aarch64.rpm;name=aarch64_wxBase-devel;unpack=0"
SRC_URI[aarch64_wxBase-devel.sha256sum] = "c7db3b500c1f281691c9daf84cfc0a43dce5e30f0aa16346b902de9fb6ec2632"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-3.2.6-3.el10_1.aarch64.rpm;name=aarch64_wxGTK;unpack=0"
SRC_URI[aarch64_wxGTK.sha256sum] = "4302bec00ba4376ddea5c99e9de4d943fcd06a9178e503ce981850b91ee8206b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-devel-3.2.6-3.el10_1.aarch64.rpm;name=aarch64_wxGTK-devel;unpack=0"
SRC_URI[aarch64_wxGTK-devel.sha256sum] = "c8490460e36ae04e1489a98f7f4784fc357fad01e90691c459aee7696fa2ab80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-docs-3.2.6-3.el10_1.noarch.rpm;name=aarch64_wxGTK-docs;unpack=0"
SRC_URI[aarch64_wxGTK-docs.sha256sum] = "abe979da8ac1541b530df9c4b4e13eaf3fe0303db979b7c2d6b4fe0f18b95567"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-gl-3.2.6-3.el10_1.aarch64.rpm;name=aarch64_wxGTK-gl;unpack=0"
SRC_URI[aarch64_wxGTK-gl.sha256sum] = "5533f4a18a3c67a931953a73c9947a338800d3f5bb731e70f701da7b9dc56baf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-i18n-3.2.6-3.el10_1.noarch.rpm;name=aarch64_wxGTK-i18n;unpack=0"
SRC_URI[aarch64_wxGTK-i18n.sha256sum] = "59bd67f427164bc1d0f86869232178078fbb336764d8a92a6188707165726b1c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-media-3.2.6-3.el10_1.aarch64.rpm;name=aarch64_wxGTK-media;unpack=0"
SRC_URI[aarch64_wxGTK-media.sha256sum] = "da007923c0e55a5b3fddda1edd82d945b996339fb554d4f81fa2f76988fd9d4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wxGTK-webview-3.2.6-3.el10_1.aarch64.rpm;name=aarch64_wxGTK-webview;unpack=0"
SRC_URI[aarch64_wxGTK-webview.sha256sum] = "3d9ea9cdf948523b134f91ad6aea11abe13c57f0b1655ae058331e9af4749db4"

RDEPENDS:wxBase = " \
 expat \
 glib2 \
 glibc \
 libgcc \
 libsecret \
 libstdc++ \
 pcre2-utf32 \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:wxBase-devel = " \
 alternatives \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 wxBase \
 "
RDEPENDS:wxGTK = " \
 cairo \
 cairo-gobject \
 fontconfig \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libSM \
 libX11 \
 libXtst \
 libgcc \
 libjpeg-turbo \
 libmspack \
 libpng \
 libstdc++ \
 libtiff \
 libxkbcommon \
 pango \
 virtual/libSDL2-2.0.so.0___64bit_ \
 wxBase \
 wxGTK-i18n \
 "
RDEPENDS:wxGTK-devel = " \
 bash \
 gtk3-devel \
 mesa-libGLU-devel \
 wxBase \
 wxBase-devel \
 wxGTK \
 wxGTK-gl \
 wxGTK-media \
 wxGTK-webview \
 "
RDEPENDS:wxGTK-docs = " \
 wxGTK \
 "
RDEPENDS:wxGTK-gl = " \
 glib2 \
 glibc \
 gtk3 \
 libX11 \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 wxBase \
 wxGTK \
 "
RDEPENDS:wxGTK-i18n = " \
 "
RDEPENDS:wxGTK-media = " \
 cairo \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gtk3 \
 libgcc \
 libstdc++ \
 wxBase \
 wxGTK \
 "
RDEPENDS:wxGTK-webview = " \
 glib2 \
 glibc \
 gtk3 \
 javascriptcoregtk4.1 \
 libgcc \
 libstdc++ \
 webkit2gtk4.1 \
 wxBase \
 wxGTK \
 "
