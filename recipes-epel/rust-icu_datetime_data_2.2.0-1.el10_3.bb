# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_datetime_data"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_datetime_data+default-devel \
 rust-icu_datetime_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_datetime_data-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "452b9de088b147eed193135d4dd6ab6f2c780cebd71b78a0dd5e9e0a745426b0"

URI_x86_64_v2_rust-icu_datetime_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime_data+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime_data+default-devel.sha256sum] = "a8d3a40cd1c556a9848f4aaf553cd4416bbb4e9a9fccfac2dc805ca479c34490"

URI_x86_64_v2_rust-icu_datetime_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime_data-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime_data-devel.sha256sum] = "2f29cbb0e8d309b16173658d9baab6243e0cefdfd43dbb5af360ea38c7135b8c"

URI_aarch64_rust-icu_datetime_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime_data+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime_data+default-devel}"
SRC_URI[aarch64_rust-icu_datetime_data+default-devel.sha256sum] = "978d27695c8ef9d7de52d73207bb892fbce3793d95f951d613cb0b7c6dd2f47d"

URI_aarch64_rust-icu_datetime_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_datetime_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime_data-devel}"
SRC_URI[aarch64_rust-icu_datetime_data-devel.sha256sum] = "85cbd68f523765c8c96206ed2936400aa5dca0580159d1fc1700fdceb1d9a780"

RDEPENDS:rust-icu_datetime_data+default-devel = " \
 cargo \
 rust-icu_datetime_data-devel \
 "
RDEPENDS:rust-icu_datetime_data-devel = " \
 cargo \
 rust \
 "
