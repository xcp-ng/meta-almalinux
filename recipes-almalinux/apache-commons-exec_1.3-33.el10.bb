# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-exec"
PV = "1.3"
PR = "33.el10"
PACKAGES = " \
 apache-commons-exec \
 apache-commons-exec-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/apache-commons-exec-1.3-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73ea55790e5abd73343cf1bd252c373760ca838d1b22ce7d87894944ca665afc"

URI_x86_64_v2_apache-commons-exec = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-exec-1.3-33.el10.noarch.rpm;name=x86_64_v2_apache-commons-exec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-exec}"
SRC_URI[x86_64_v2_apache-commons-exec.sha256sum] = "1508cd7c06903579cd35c2ab4e6b6b82e80cb469344cbbcd98cd19c66b30eb32"

URI_x86_64_v2_apache-commons-exec-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-exec-javadoc-1.3-33.el10.noarch.rpm;name=x86_64_v2_apache-commons-exec-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-exec-javadoc}"
SRC_URI[x86_64_v2_apache-commons-exec-javadoc.sha256sum] = "b6681586638181488a8ea20ebae9d349e9da4cf985f60f593df67fe57de637f6"

URI_aarch64_apache-commons-exec = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-exec-1.3-33.el10.noarch.rpm;name=aarch64_apache-commons-exec;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-exec}"
SRC_URI[aarch64_apache-commons-exec.sha256sum] = "1508cd7c06903579cd35c2ab4e6b6b82e80cb469344cbbcd98cd19c66b30eb32"

URI_aarch64_apache-commons-exec-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-exec-javadoc-1.3-33.el10.noarch.rpm;name=aarch64_apache-commons-exec-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-exec-javadoc}"
SRC_URI[aarch64_apache-commons-exec-javadoc.sha256sum] = "b6681586638181488a8ea20ebae9d349e9da4cf985f60f593df67fe57de637f6"

RDEPENDS:apache-commons-exec = " \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-exec-javadoc = " \
 javapackages-filesystem \
 "
