# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-image-webp"
PV = "0.2.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-image-webp+default-devel \
 rust-image-webp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-image-webp-0.2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3603dbb131a74487c6c6d3ad77f79b2ea21ddd822b9fc61484485b3b814f5a2"

URI_x86_64_v2_rust-image-webp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-webp+default-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-webp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-webp+default-devel}"
SRC_URI[x86_64_v2_rust-image-webp+default-devel.sha256sum] = "4096fffb7e289795b1c72946a94c59d34388a9d8ab6cf71e9cdf4be91eb741aa"

URI_x86_64_v2_rust-image-webp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-webp-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-webp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-webp-devel}"
SRC_URI[x86_64_v2_rust-image-webp-devel.sha256sum] = "a698f44dd60c9fd3b0735bbf80b6ad119254051d4a839dc9ce2073d01c49a401"

URI_aarch64_rust-image-webp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-webp+default-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-image-webp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-webp+default-devel}"
SRC_URI[aarch64_rust-image-webp+default-devel.sha256sum] = "8931143c732e1df43890a0bfd0c215652333abb3ef21e90c801b8c00c0653a37"

URI_aarch64_rust-image-webp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-webp-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-image-webp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-webp-devel}"
SRC_URI[aarch64_rust-image-webp-devel.sha256sum] = "dbff8874c8ee7aec1707685222ea3bb40564cdfe570a16516310ff67e873391d"

RDEPENDS:rust-image-webp+default-devel = " \
 cargo \
 rust-image-webp-devel \
 "
RDEPENDS:rust-image-webp-devel = " \
 cargo \
 rust \
 rust-byteorder-lite+default-devel \
 rust-quick-error+default-devel \
 "
