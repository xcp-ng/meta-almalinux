# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-c"
PV = "0.9.32"
PR = "3.el10_0"
PACKAGES = " \
 cargo-c \
 rust-cargo-c+default-devel \
 rust-cargo-c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-c-0.9.32-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05d6bdb26692a9d2ec76f5a4e64fa51d47d083a9b1a35bb33551d9eab1807cce"

URI_x86_64_v2_cargo-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-c-0.9.32-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-c}"
SRC_URI[x86_64_v2_cargo-c.sha256sum] = "92be7e9fdd33ab05d2a2dcb53092f43c3ef16628c4747b510e56c2bc820900df"

URI_x86_64_v2_rust-cargo-c+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-c+default-devel-0.9.32-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-c+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-c+default-devel.sha256sum] = "287cd26f9a4310add93c101e0419c0e467199e1161feb3baaa5ea68dae470fbe"

URI_x86_64_v2_rust-cargo-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-c-devel-0.9.32-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-c-devel}"
SRC_URI[x86_64_v2_rust-cargo-c-devel.sha256sum] = "efee3ac4f6253a21138aeae8cf4cf49ff39e263de9c3dda314911e309a257c18"

URI_aarch64_cargo-c = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-c-0.9.32-3.el10_0.aarch64.rpm;name=aarch64_cargo-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-c}"
SRC_URI[aarch64_cargo-c.sha256sum] = "0b92ccb584e6ea2ebab50b69a5a846e9c6a9ca5794902ae9f069b8f41c17ec87"

URI_aarch64_rust-cargo-c+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-c+default-devel-0.9.32-3.el10_0.noarch.rpm;name=aarch64_rust-cargo-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-c+default-devel}"
SRC_URI[aarch64_rust-cargo-c+default-devel.sha256sum] = "68a60ba02dbebc65bdd23c9515a58b830a3bf246c9a09ddcf93f1ea0f7caa2f9"

URI_aarch64_rust-cargo-c-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-c-devel-0.9.32-3.el10_0.noarch.rpm;name=aarch64_rust-cargo-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-c-devel}"
SRC_URI[aarch64_rust-cargo-c-devel.sha256sum] = "aa2255e779c9a05a863d4f8ed6ba5b3adb674e9b30e247f5257fab64a04c6952"

RDEPENDS:cargo-c = " \
 glibc \
 libgcc \
 libssh2 \
 openssl-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:rust-cargo-c+default-devel = " \
 cargo \
 rust-cargo-c-devel \
 "
RDEPENDS:rust-cargo-c-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-cargo+default-devel \
 rust-cargo-util+default-devel \
 rust-cbindgen0.26-devel \
 rust-cc+default-devel \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-glob+default-devel \
 rust-itertools0.13+default-devel \
 rust-log+default-devel \
 rust-regex+default-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-toml+default-devel \
 "
