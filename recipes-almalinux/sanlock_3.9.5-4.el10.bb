# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sanlock"
PV = "3.9.5"
PR = "4.el10"
PACKAGES = " \
 sanlock \
 sanlock-devel \
 sanlock-lib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sanlock-3.9.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d14ca81bd6d794bf7aafaaf98083656f78acaf7f2584e599853de9a62e81a1f6"

URI_x86_64_v2_sanlock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-3.9.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock}"
SRC_URI[x86_64_v2_sanlock.sha256sum] = "fa870fbbc897701c6020e8ad3f4816d5db20a649fd3a4fe76ccc7bea356b7c08"

URI_x86_64_v2_sanlock-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sanlock-devel-3.9.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock-devel}"
SRC_URI[x86_64_v2_sanlock-devel.sha256sum] = "b6c6fc1f1d5b7265b1581b99eb0f756af6091fbad2de96950bcc9d1698549129"

URI_x86_64_v2_sanlock-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-lib-3.9.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock-lib}"
SRC_URI[x86_64_v2_sanlock-lib.sha256sum] = "048fb32ae6a8fc16db1f09d0b02b5e6722859d2f9993472f2ebecd43db267b7f"

URI_aarch64_sanlock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-3.9.5-4.el10.aarch64.rpm;name=aarch64_sanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock}"
SRC_URI[aarch64_sanlock.sha256sum] = "b66ea3e8be841ebaf563ab999ff30ab557d38d5bdd77e2f632aaf983bf957797"

URI_aarch64_sanlock-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sanlock-devel-3.9.5-4.el10.aarch64.rpm;name=aarch64_sanlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock-devel}"
SRC_URI[aarch64_sanlock-devel.sha256sum] = "23da413db7d927b66ca1c9e5bde3544ca2f3966bebe6773ce8defaf913dbe470"

URI_aarch64_sanlock-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-lib-3.9.5-4.el10.aarch64.rpm;name=aarch64_sanlock-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock-lib}"
SRC_URI[aarch64_sanlock-lib.sha256sum] = "387a4725646afb1fc11ac393245aa9a87b873b4b92438723f3096866bc646138"

RDEPENDS:sanlock = " \
 bash \
 glibc \
 libaio \
 libblkid \
 libuuid \
 sanlock-lib \
 systemd \
 "
RDEPENDS:sanlock-devel = " \
 pkgconf-pkg-config \
 sanlock-lib \
 "
RDEPENDS:sanlock-lib = " \
 glibc \
 libaio \
 libblkid \
 "
