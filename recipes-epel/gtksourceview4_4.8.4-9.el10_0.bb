# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtksourceview4"
PV = "4.8.4"
PR = "9.el10_0"
PACKAGES = " \
 gtksourceview4 \
 gtksourceview4-devel \
 gtksourceview4-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtksourceview4-4.8.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "811bad67acd4b4bc93c732d19f0d794f5e9b29518a9944a36ab9ea17e2c14acc"

URI_x86_64_v2_gtksourceview4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtksourceview4-4.8.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtksourceview4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtksourceview4}"
SRC_URI[x86_64_v2_gtksourceview4.sha256sum] = "eda0a5b8d97d668344c82a2020b06c208b6a56b9f5d793e7b25d2019503472dc"

URI_x86_64_v2_gtksourceview4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtksourceview4-devel-4.8.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtksourceview4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtksourceview4-devel}"
SRC_URI[x86_64_v2_gtksourceview4-devel.sha256sum] = "1903ecf7cd839f0db45d6ab590709300d496845ed6a39fe45124536133277a0d"

URI_x86_64_v2_gtksourceview4-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtksourceview4-tests-4.8.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtksourceview4-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtksourceview4-tests}"
SRC_URI[x86_64_v2_gtksourceview4-tests.sha256sum] = "141b2001861451830a2410a990c216a19af51ba8225a17a26913dd727c88ac09"

URI_aarch64_gtksourceview4 = "${EPEL_MIRROR}/aarch64/Packages/g/gtksourceview4-4.8.4-9.el10_0.aarch64.rpm;name=aarch64_gtksourceview4;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtksourceview4}"
SRC_URI[aarch64_gtksourceview4.sha256sum] = "5c6b12718693f73374db81462121008dc3f1c571d617ed55f1bc5d2213f66244"

URI_aarch64_gtksourceview4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gtksourceview4-devel-4.8.4-9.el10_0.aarch64.rpm;name=aarch64_gtksourceview4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtksourceview4-devel}"
SRC_URI[aarch64_gtksourceview4-devel.sha256sum] = "a5470c9ccfd45ff321cc2328b8e580256af86d2ec9803aacdd02c4e44609d8c2"

URI_aarch64_gtksourceview4-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gtksourceview4-tests-4.8.4-9.el10_0.aarch64.rpm;name=aarch64_gtksourceview4-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtksourceview4-tests}"
SRC_URI[aarch64_gtksourceview4-tests.sha256sum] = "0b5b6936b45a537b2ec5f8cbcd03e16b63168303b8529cd83eae95b1db049086"

RDEPENDS:gtksourceview4 = " \
 atk \
 cairo \
 fribidi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libxml2 \
 pango \
 "
RDEPENDS:gtksourceview4-devel = " \
 fribidi-devel \
 glib2-devel \
 gtk3-devel \
 gtksourceview4 \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gtksourceview4-tests = " \
 cairo \
 fribidi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 gtksourceview4 \
 libxml2 \
 pango \
 "
