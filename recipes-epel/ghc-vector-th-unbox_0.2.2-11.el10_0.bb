# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-vector-th-unbox"
PV = "0.2.2"
PR = "11.el10_0"
PACKAGES = " \
 ghc-vector-th-unbox \
 ghc-vector-th-unbox-devel \
 ghc-vector-th-unbox-doc \
 ghc-vector-th-unbox-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-vector-th-unbox-0.2.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96e4df6582ddf507ce8a7449d3d56090440b9e6ec36b6df6df8af1ce942c01ba"

URI_x86_64_v2_ghc-vector-th-unbox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-th-unbox-0.2.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-th-unbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-th-unbox}"
SRC_URI[x86_64_v2_ghc-vector-th-unbox.sha256sum] = "a0f4eab6251255e97ddd0427392ee7df3063b0280a9ec98a0039126b3feb93d4"

URI_x86_64_v2_ghc-vector-th-unbox-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-th-unbox-devel-0.2.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-th-unbox-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-th-unbox-devel}"
SRC_URI[x86_64_v2_ghc-vector-th-unbox-devel.sha256sum] = "239ad361ff74d1d277b9d44242799a9a28bdfa47492b2d92b597126b73dd5a19"

URI_x86_64_v2_ghc-vector-th-unbox-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-th-unbox-doc-0.2.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-vector-th-unbox-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-th-unbox-doc}"
SRC_URI[x86_64_v2_ghc-vector-th-unbox-doc.sha256sum] = "47fa002927e85ea0e2f55e108d966460b835d2b7197fe85b758b1b13949dc4c8"

URI_x86_64_v2_ghc-vector-th-unbox-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-th-unbox-prof-0.2.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-th-unbox-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-th-unbox-prof}"
SRC_URI[x86_64_v2_ghc-vector-th-unbox-prof.sha256sum] = "5af013d823d4d8520b6a7fb5e8d0ef33141a0a69b62ed84254b3409ccc98855d"

URI_aarch64_ghc-vector-th-unbox = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-th-unbox-0.2.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-vector-th-unbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-th-unbox}"
SRC_URI[aarch64_ghc-vector-th-unbox.sha256sum] = "5f84e31a844f778d793ae07ae9afad5af25255aa18446a59139231f16d112dd8"

URI_aarch64_ghc-vector-th-unbox-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-th-unbox-devel-0.2.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-vector-th-unbox-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-th-unbox-devel}"
SRC_URI[aarch64_ghc-vector-th-unbox-devel.sha256sum] = "3b8c1c934d51fdc9277ecad2d8caa39f2fbbafc1f8d11b13caa9b08ebcf1ef88"

URI_aarch64_ghc-vector-th-unbox-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-th-unbox-doc-0.2.2-11.el10_0.noarch.rpm;name=aarch64_ghc-vector-th-unbox-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-th-unbox-doc}"
SRC_URI[aarch64_ghc-vector-th-unbox-doc.sha256sum] = "311abfa1651f06ecbce6abfe9837c769cd6ef0e4ead7c583fd591c07d58f844f"

URI_aarch64_ghc-vector-th-unbox-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-th-unbox-prof-0.2.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-vector-th-unbox-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-th-unbox-prof}"
SRC_URI[aarch64_ghc-vector-th-unbox-prof.sha256sum] = "fab570d250ee0d42d8c180c470bfd89fff21337f7fd4d664550aaec8e958ef9d"

RDEPENDS:ghc-vector-th-unbox = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-vector-th-unbox-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-template-haskell-devel \
 ghc-vector-devel \
 ghc-vector-th-unbox \
 "
RDEPENDS:ghc-vector-th-unbox-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-vector-th-unbox-prof = " \
 ghc-base-prof \
 ghc-template-haskell-prof \
 ghc-vector-prof \
 ghc-vector-th-unbox-devel \
 "
