# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cairo"
PV = "1.18.2"
PR = "3.el10"
PACKAGES = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 cairo-gobject-devel \
 cairo-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cairo-1.18.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8a6da7b628ca7e6088d664afe8660294e76f7c0bbb6e4be2093a65e0a82ddd82"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-1.18.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_cairo;unpack=0"
SRC_URI[x86_64_v2_cairo.sha256sum] = "9b483f81a142f0147393c64a72e6c662cddf997e6d9de1b966295626387b0e58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-devel-1.18.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_cairo-devel;unpack=0"
SRC_URI[x86_64_v2_cairo-devel.sha256sum] = "c45f1534754b058cfc399fcd878a008b4034e0495e37f9d10c789fc6617926e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-gobject-1.18.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_cairo-gobject;unpack=0"
SRC_URI[x86_64_v2_cairo-gobject.sha256sum] = "b0cd722c050e5c3ecfbc585900f5f0f6f3fd8b49e3c833b11b969e48767d5232"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cairo-gobject-devel-1.18.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_cairo-gobject-devel;unpack=0"
SRC_URI[x86_64_v2_cairo-gobject-devel.sha256sum] = "06c430512eefab913808e4700dc4706b72fc5f9b775b0a773e3f5ec8c0968374"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cairo-tools-1.18.2-3.el10.x86_64_v2.rpm;name=x86_64_v2_cairo-tools;unpack=0"
SRC_URI[x86_64_v2_cairo-tools.sha256sum] = "2b8453c09d43f37ff2751b12abfd120af0c3d5c69fdb379884b86d50efc77b8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-1.18.2-3.el10.aarch64.rpm;name=aarch64_cairo;unpack=0"
SRC_URI[aarch64_cairo.sha256sum] = "e0383c6ad519ad9844c2c2779782e72b9e25ab77b81f7c3b562352cf66eb7d2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-devel-1.18.2-3.el10.aarch64.rpm;name=aarch64_cairo-devel;unpack=0"
SRC_URI[aarch64_cairo-devel.sha256sum] = "ab46597b591feaa9c0d345a0e80d307a7c2e6713d1b7c627cced386c96524bb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-gobject-1.18.2-3.el10.aarch64.rpm;name=aarch64_cairo-gobject;unpack=0"
SRC_URI[aarch64_cairo-gobject.sha256sum] = "085d99d6d092566d5ff23186d006a5d0e0670c1322142d1b139e0b21d9900ea4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cairo-gobject-devel-1.18.2-3.el10.aarch64.rpm;name=aarch64_cairo-gobject-devel;unpack=0"
SRC_URI[aarch64_cairo-gobject-devel.sha256sum] = "c93457ed70e9c07efbe6cb81abba7d8eef7ad4a40b07f90d69ee356f0274dd8b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cairo-tools-1.18.2-3.el10.aarch64.rpm;name=aarch64_cairo-tools;unpack=0"
SRC_URI[aarch64_cairo-tools.sha256sum] = "203f29af88a8204c42f2a5bf82462341ff8890f15d52ead5426a4604ab763789"

RDEPENDS:cairo = " \
 fontconfig \
 freetype \
 glibc \
 libX11 \
 libXext \
 libXrender \
 libpng \
 libxcb \
 pixman \
 zlib-ng-compat \
 "
RDEPENDS:cairo-devel = " \
 cairo \
 cairo-devel \
 fontconfig-devel \
 freetype-devel \
 libX11-devel \
 libXext-devel \
 libXrender-devel \
 libpng-devel \
 libxcb-devel \
 pixman-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:cairo-gobject = " \
 cairo \
 glib2 \
 glibc \
 "
RDEPENDS:cairo-gobject-devel = " \
 cairo-devel \
 cairo-gobject \
 fontconfig-devel \
 freetype-devel \
 glib2-devel \
 libX11-devel \
 libXext-devel \
 libXrender-devel \
 libpng-devel \
 libxcb-devel \
 pixman-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:cairo-tools = " \
 bash \
 cairo \
 glibc \
 zlib-ng-compat \
 "
