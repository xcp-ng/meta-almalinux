# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-ipc"
PV = "57.3.0"
PR = "3.el10_3"
PACKAGES = " \
 rust-arrow-ipc+default-devel \
 rust-arrow-ipc+zstd-devel \
 rust-arrow-ipc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-ipc-57.3.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6d5d5812d381b6b8d321d47f54b3f6a18930bfe7aeb2926db87e6726662ab73"

URI_x86_64_v2_rust-arrow-ipc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-ipc+default-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-ipc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-ipc+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-ipc+default-devel.sha256sum] = "83e038dddb302d80099fb6ad60d83e52843b1b9b98431685101b17088894812d"

URI_x86_64_v2_rust-arrow-ipc+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-ipc+zstd-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-ipc+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-ipc+zstd-devel}"
SRC_URI[x86_64_v2_rust-arrow-ipc+zstd-devel.sha256sum] = "2fc87e1ec256bd782257f7cbadd0bf9f632c99e4f6c54e15d143bfcaf9f020a8"

URI_x86_64_v2_rust-arrow-ipc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-ipc-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-ipc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-ipc-devel}"
SRC_URI[x86_64_v2_rust-arrow-ipc-devel.sha256sum] = "4d8eb2c0298d334f1daffde56d86ceb2b353a4d2f922e0582c34c7132b96b84b"

URI_aarch64_rust-arrow-ipc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-ipc+default-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow-ipc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-ipc+default-devel}"
SRC_URI[aarch64_rust-arrow-ipc+default-devel.sha256sum] = "2ebbecd01d34fb4c39bdbeb89da60539b62ec87a8e1a338a2fa72c9eea69c84b"

URI_aarch64_rust-arrow-ipc+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-ipc+zstd-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow-ipc+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-ipc+zstd-devel}"
SRC_URI[aarch64_rust-arrow-ipc+zstd-devel.sha256sum] = "2a2726dbcf18ac694586b2086bdd1e048e71927c153495b0afb3562c1c0e837d"

URI_aarch64_rust-arrow-ipc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-ipc-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow-ipc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-ipc-devel}"
SRC_URI[aarch64_rust-arrow-ipc-devel.sha256sum] = "7dae0056ee405412467b219827aee76b6f8855656f24530cd13d748f48138a22"

RDEPENDS:rust-arrow-ipc+default-devel = " \
 cargo \
 rust-arrow-ipc-devel \
 "
RDEPENDS:rust-arrow-ipc+zstd-devel = " \
 cargo \
 rust-arrow-ipc-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-arrow-ipc-devel = " \
 cargo \
 rust \
 rust-arrow-array+default-devel \
 rust-arrow-buffer+default-devel \
 rust-arrow-data+default-devel \
 rust-arrow-schema+default-devel \
 rust-arrow-select+default-devel \
 rust-flatbuffers-devel \
 "
