# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linux-firmware"
PV = "20251008"
PR = "15.8.el10_0"
PACKAGES = " \
 amd-gpu-firmware \
 amd-ucode-firmware \
 atheros-firmware \
 brcmfmac-firmware \
 cirrus-audio-firmware \
 dvb-firmware \
 intel-audio-firmware \
 intel-gpu-firmware \
 intel-vsc-firmware \
 iwlegacy-firmware \
 iwlwifi-dvm-firmware \
 iwlwifi-mvm-firmware \
 libertas-firmware \
 linux-firmware \
 linux-firmware-whence \
 mlxsw_spectrum-firmware \
 mrvlprestera-firmware \
 mt7xxx-firmware \
 netronome-firmware \
 nvidia-gpu-firmware \
 nxpwireless-firmware \
 qcom-firmware \
 realtek-firmware \
 tiwilink-firmware \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/linux-firmware-20251008-15.8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3044de9bfc27638cc08a5983240765f2ccad14636a8882323d31f0191a6b3909"

URI_x86_64_v2_amd-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/amd-gpu-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_amd-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amd-gpu-firmware}"
SRC_URI[x86_64_v2_amd-gpu-firmware.sha256sum] = "abd5127e003af822203e6509c39eece4327786c94270178a089fbc9f19ed1edb"

URI_x86_64_v2_amd-ucode-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/amd-ucode-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_amd-ucode-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amd-ucode-firmware}"
SRC_URI[x86_64_v2_amd-ucode-firmware.sha256sum] = "bf8e63ae8cbe6d61fb7cbabc7f585a461a01bfe8d94576822ca66e478a0a3ee4"

URI_x86_64_v2_atheros-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/atheros-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_atheros-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atheros-firmware}"
SRC_URI[x86_64_v2_atheros-firmware.sha256sum] = "a6dd69faab9132430cbcf90d369eaa66f624ef9d77f43004040a591e59a830ab"

URI_x86_64_v2_brcmfmac-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/brcmfmac-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_brcmfmac-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_brcmfmac-firmware}"
SRC_URI[x86_64_v2_brcmfmac-firmware.sha256sum] = "efcacc339533eba146809e2e698340ac87cbf1265c97284fe9630e080bc181a8"

URI_x86_64_v2_cirrus-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cirrus-audio-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_cirrus-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cirrus-audio-firmware}"
SRC_URI[x86_64_v2_cirrus-audio-firmware.sha256sum] = "e08a5e51e2f1613b1362bd0b7b038a3edff327ea42fccc26593ff958c894d8c7"

URI_x86_64_v2_dvb-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dvb-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_dvb-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dvb-firmware}"
SRC_URI[x86_64_v2_dvb-firmware.sha256sum] = "853443162d728ee59d2f68b37eb73a21b501eb59117f371941180bccb4d26bb9"

URI_x86_64_v2_intel-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-audio-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_intel-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-audio-firmware}"
SRC_URI[x86_64_v2_intel-audio-firmware.sha256sum] = "dc7c8f11ce37a32b72a8b68a70ae272e6dd73b6e52a570a2001a9810d36a16b9"

URI_x86_64_v2_intel-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/intel-gpu-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_intel-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gpu-firmware}"
SRC_URI[x86_64_v2_intel-gpu-firmware.sha256sum] = "fb0123329ebc2fb07102293122e3115d6f857a8910cba0f8a9d6c7362bd8e519"

URI_x86_64_v2_intel-vsc-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-vsc-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_intel-vsc-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-vsc-firmware}"
SRC_URI[x86_64_v2_intel-vsc-firmware.sha256sum] = "83289148d1dece06839ad92b7fad99f12a8a38272f248afb98d782b7f9c8cb00"

URI_x86_64_v2_iwlegacy-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlegacy-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_iwlegacy-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwlegacy-firmware}"
SRC_URI[x86_64_v2_iwlegacy-firmware.sha256sum] = "2c915fbc625a34cb8c6bab1ecf085ef1b5e5fc377e5a398e69009fafb2a1dd1b"

URI_x86_64_v2_iwlwifi-dvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-dvm-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_iwlwifi-dvm-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwlwifi-dvm-firmware}"
SRC_URI[x86_64_v2_iwlwifi-dvm-firmware.sha256sum] = "5de42d26e2486696103361683afec3caf93d837e414c2f4af3b0fec8d05f89ec"

URI_x86_64_v2_iwlwifi-mvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwlwifi-mvm-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_iwlwifi-mvm-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwlwifi-mvm-firmware}"
SRC_URI[x86_64_v2_iwlwifi-mvm-firmware.sha256sum] = "9a81d80877f938d9da274eca6d0b128a510549c75e2648a78b46744b70663336"

URI_x86_64_v2_libertas-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libertas-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_libertas-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libertas-firmware}"
SRC_URI[x86_64_v2_libertas-firmware.sha256sum] = "0e9b93f65419dd51ec8c60068c0402c820639a0f1965059a02dc257a5a1ec7b7"

URI_x86_64_v2_linux-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_linux-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linux-firmware}"
SRC_URI[x86_64_v2_linux-firmware.sha256sum] = "2863cd19a648bdb8cb4a974fa734a671beb02d832c889fb3d3d5721d74dd8e8b"

URI_x86_64_v2_linux-firmware-whence = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/linux-firmware-whence-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_linux-firmware-whence;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linux-firmware-whence}"
SRC_URI[x86_64_v2_linux-firmware-whence.sha256sum] = "83d7a70131cc1c9de149c17ffe5c2bff7ef652d869e979f51e0c9be5e7a9ef73"

URI_x86_64_v2_mlxsw_spectrum-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mlxsw_spectrum-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_mlxsw_spectrum-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mlxsw_spectrum-firmware}"
SRC_URI[x86_64_v2_mlxsw_spectrum-firmware.sha256sum] = "d0055924195aa582b73888aa80fbe16898779ac24f72591d57a67fb14d544e01"

URI_x86_64_v2_mrvlprestera-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mrvlprestera-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_mrvlprestera-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrvlprestera-firmware}"
SRC_URI[x86_64_v2_mrvlprestera-firmware.sha256sum] = "8b56b557442c8cb53ce4cb461da031ae20c18c6f66787e9a35df73c46121ffe0"

URI_x86_64_v2_mt7xxx-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mt7xxx-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_mt7xxx-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mt7xxx-firmware}"
SRC_URI[x86_64_v2_mt7xxx-firmware.sha256sum] = "4d630e0febcf00ad4dbea7c628afe55814395705d9fb9e467e095c97ff9a7ed4"

URI_x86_64_v2_netronome-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/netronome-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_netronome-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netronome-firmware}"
SRC_URI[x86_64_v2_netronome-firmware.sha256sum] = "392068aa187226c732903b6ed9c2c1fade2f2e0c7abc811c7d550fbb5d4c2dd8"

URI_x86_64_v2_nvidia-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nvidia-gpu-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_nvidia-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nvidia-gpu-firmware}"
SRC_URI[x86_64_v2_nvidia-gpu-firmware.sha256sum] = "5ec71a637121108abe9a3366a01169e04fe45464f4093603eb94c875b5a9de4c"

URI_x86_64_v2_nxpwireless-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nxpwireless-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_nxpwireless-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxpwireless-firmware}"
SRC_URI[x86_64_v2_nxpwireless-firmware.sha256sum] = "c00d5725f4a7ccb8dceca6c42bf98be0c38848f6e85aa9b7eaad25e14d77d5ac"

URI_x86_64_v2_qcom-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/qcom-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_qcom-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcom-firmware}"
SRC_URI[x86_64_v2_qcom-firmware.sha256sum] = "736aa3d1e3c8427ecb4d5ce0a1fd45946bdfe81ff3bc22f1d25e3e2aac573f02"

URI_x86_64_v2_realtek-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realtek-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_realtek-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_realtek-firmware}"
SRC_URI[x86_64_v2_realtek-firmware.sha256sum] = "2b65e3e0b2a79c6ca191186a396faa3add031d0c993d7c5354a927cfda253f7e"

URI_x86_64_v2_tiwilink-firmware = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tiwilink-firmware-20251008-15.8.el10_0.noarch.rpm;name=x86_64_v2_tiwilink-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tiwilink-firmware}"
SRC_URI[x86_64_v2_tiwilink-firmware.sha256sum] = "928ef584eff5d96fc90ab563d06aab1d9c3e8621df2dd04398c07e8df28ebed7"

URI_aarch64_amd-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/amd-gpu-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_amd-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_amd-gpu-firmware}"
SRC_URI[aarch64_amd-gpu-firmware.sha256sum] = "abd5127e003af822203e6509c39eece4327786c94270178a089fbc9f19ed1edb"

URI_aarch64_amd-ucode-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/amd-ucode-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_amd-ucode-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_amd-ucode-firmware}"
SRC_URI[aarch64_amd-ucode-firmware.sha256sum] = "bf8e63ae8cbe6d61fb7cbabc7f585a461a01bfe8d94576822ca66e478a0a3ee4"

URI_aarch64_atheros-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/atheros-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_atheros-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_atheros-firmware}"
SRC_URI[aarch64_atheros-firmware.sha256sum] = "a6dd69faab9132430cbcf90d369eaa66f624ef9d77f43004040a591e59a830ab"

URI_aarch64_brcmfmac-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/brcmfmac-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_brcmfmac-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_brcmfmac-firmware}"
SRC_URI[aarch64_brcmfmac-firmware.sha256sum] = "efcacc339533eba146809e2e698340ac87cbf1265c97284fe9630e080bc181a8"

URI_aarch64_cirrus-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cirrus-audio-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_cirrus-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_cirrus-audio-firmware}"
SRC_URI[aarch64_cirrus-audio-firmware.sha256sum] = "e08a5e51e2f1613b1362bd0b7b038a3edff327ea42fccc26593ff958c894d8c7"

URI_aarch64_dvb-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dvb-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_dvb-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_dvb-firmware}"
SRC_URI[aarch64_dvb-firmware.sha256sum] = "853443162d728ee59d2f68b37eb73a21b501eb59117f371941180bccb4d26bb9"

URI_aarch64_intel-audio-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-audio-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_intel-audio-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-audio-firmware}"
SRC_URI[aarch64_intel-audio-firmware.sha256sum] = "dc7c8f11ce37a32b72a8b68a70ae272e6dd73b6e52a570a2001a9810d36a16b9"

URI_aarch64_intel-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/intel-gpu-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_intel-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gpu-firmware}"
SRC_URI[aarch64_intel-gpu-firmware.sha256sum] = "fb0123329ebc2fb07102293122e3115d6f857a8910cba0f8a9d6c7362bd8e519"

URI_aarch64_intel-vsc-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/intel-vsc-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_intel-vsc-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-vsc-firmware}"
SRC_URI[aarch64_intel-vsc-firmware.sha256sum] = "83289148d1dece06839ad92b7fad99f12a8a38272f248afb98d782b7f9c8cb00"

URI_aarch64_iwlegacy-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlegacy-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_iwlegacy-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwlegacy-firmware}"
SRC_URI[aarch64_iwlegacy-firmware.sha256sum] = "2c915fbc625a34cb8c6bab1ecf085ef1b5e5fc377e5a398e69009fafb2a1dd1b"

URI_aarch64_iwlwifi-dvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-dvm-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_iwlwifi-dvm-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwlwifi-dvm-firmware}"
SRC_URI[aarch64_iwlwifi-dvm-firmware.sha256sum] = "5de42d26e2486696103361683afec3caf93d837e414c2f4af3b0fec8d05f89ec"

URI_aarch64_iwlwifi-mvm-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwlwifi-mvm-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_iwlwifi-mvm-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwlwifi-mvm-firmware}"
SRC_URI[aarch64_iwlwifi-mvm-firmware.sha256sum] = "9a81d80877f938d9da274eca6d0b128a510549c75e2648a78b46744b70663336"

URI_aarch64_libertas-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libertas-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_libertas-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_libertas-firmware}"
SRC_URI[aarch64_libertas-firmware.sha256sum] = "0e9b93f65419dd51ec8c60068c0402c820639a0f1965059a02dc257a5a1ec7b7"

URI_aarch64_linux-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_linux-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_linux-firmware}"
SRC_URI[aarch64_linux-firmware.sha256sum] = "2863cd19a648bdb8cb4a974fa734a671beb02d832c889fb3d3d5721d74dd8e8b"

URI_aarch64_linux-firmware-whence = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/linux-firmware-whence-20251008-15.8.el10_0.noarch.rpm;name=aarch64_linux-firmware-whence;unpack=0"
SRC_URI:append = " ${URI_aarch64_linux-firmware-whence}"
SRC_URI[aarch64_linux-firmware-whence.sha256sum] = "83d7a70131cc1c9de149c17ffe5c2bff7ef652d869e979f51e0c9be5e7a9ef73"

URI_aarch64_mlxsw_spectrum-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mlxsw_spectrum-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_mlxsw_spectrum-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_mlxsw_spectrum-firmware}"
SRC_URI[aarch64_mlxsw_spectrum-firmware.sha256sum] = "d0055924195aa582b73888aa80fbe16898779ac24f72591d57a67fb14d544e01"

URI_aarch64_mrvlprestera-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mrvlprestera-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_mrvlprestera-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrvlprestera-firmware}"
SRC_URI[aarch64_mrvlprestera-firmware.sha256sum] = "8b56b557442c8cb53ce4cb461da031ae20c18c6f66787e9a35df73c46121ffe0"

URI_aarch64_mt7xxx-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mt7xxx-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_mt7xxx-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_mt7xxx-firmware}"
SRC_URI[aarch64_mt7xxx-firmware.sha256sum] = "4d630e0febcf00ad4dbea7c628afe55814395705d9fb9e467e095c97ff9a7ed4"

URI_aarch64_netronome-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/netronome-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_netronome-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_netronome-firmware}"
SRC_URI[aarch64_netronome-firmware.sha256sum] = "392068aa187226c732903b6ed9c2c1fade2f2e0c7abc811c7d550fbb5d4c2dd8"

URI_aarch64_nvidia-gpu-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nvidia-gpu-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_nvidia-gpu-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_nvidia-gpu-firmware}"
SRC_URI[aarch64_nvidia-gpu-firmware.sha256sum] = "5ec71a637121108abe9a3366a01169e04fe45464f4093603eb94c875b5a9de4c"

URI_aarch64_nxpwireless-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nxpwireless-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_nxpwireless-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxpwireless-firmware}"
SRC_URI[aarch64_nxpwireless-firmware.sha256sum] = "c00d5725f4a7ccb8dceca6c42bf98be0c38848f6e85aa9b7eaad25e14d77d5ac"

URI_aarch64_qcom-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/qcom-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_qcom-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcom-firmware}"
SRC_URI[aarch64_qcom-firmware.sha256sum] = "736aa3d1e3c8427ecb4d5ce0a1fd45946bdfe81ff3bc22f1d25e3e2aac573f02"

URI_aarch64_realtek-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realtek-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_realtek-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_realtek-firmware}"
SRC_URI[aarch64_realtek-firmware.sha256sum] = "2b65e3e0b2a79c6ca191186a396faa3add031d0c993d7c5354a927cfda253f7e"

URI_aarch64_tiwilink-firmware = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tiwilink-firmware-20251008-15.8.el10_0.noarch.rpm;name=aarch64_tiwilink-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_tiwilink-firmware}"
SRC_URI[aarch64_tiwilink-firmware.sha256sum] = "928ef584eff5d96fc90ab563d06aab1d9c3e8621df2dd04398c07e8df28ebed7"

RDEPENDS:amd-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:amd-ucode-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:atheros-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:brcmfmac-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:cirrus-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:dvb-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-audio-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-gpu-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:intel-vsc-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlegacy-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-dvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:iwlwifi-mvm-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:libertas-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:linux-firmware-whence = " \
 "
RDEPENDS:mlxsw_spectrum-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mrvlprestera-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:mt7xxx-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:netronome-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:nvidia-gpu-firmware = " \
 linux-firmware \
 linux-firmware-whence \
 "
RDEPENDS:nxpwireless-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:qcom-firmware = " \
 atheros-firmware \
 linux-firmware-whence \
 "
RDEPENDS:realtek-firmware = " \
 linux-firmware-whence \
 "
RDEPENDS:tiwilink-firmware = " \
 linux-firmware-whence \
 "
