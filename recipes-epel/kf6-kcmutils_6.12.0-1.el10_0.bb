# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcmutils"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kcmutils \
 kf6-kcmutils-devel \
 kf6-kcmutils-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcmutils-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69f7b4d3975c63ed251644086be29d75ab12cb6dbb9b98bc66be1dbddb682d13"

URI_x86_64_v2_kf6-kcmutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils}"
SRC_URI[x86_64_v2_kf6-kcmutils.sha256sum] = "0ce6083e07da105582c32c6a2f0b1d5bc9c0070cbee90c57c4a1fc0996d474e1"

URI_x86_64_v2_kf6-kcmutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-devel}"
SRC_URI[x86_64_v2_kf6-kcmutils-devel.sha256sum] = "49306a71cc2f449d5badcfede807d079b9547b24be8446c2bcd85c929450d965"

URI_x86_64_v2_kf6-kcmutils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcmutils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-doc}"
SRC_URI[x86_64_v2_kf6-kcmutils-doc.sha256sum] = "1234e31492250f0e920f1f98ce8d787b60f6c22d13f90480cf5c81f34e5865d7"

URI_aarch64_kf6-kcmutils = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcmutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils}"
SRC_URI[aarch64_kf6-kcmutils.sha256sum] = "720aad2c083339617bb5049ca435d62b9a42621acba8dc1da7ec6c910ca40c91"

URI_aarch64_kf6-kcmutils-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcmutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-devel}"
SRC_URI[aarch64_kf6-kcmutils-devel.sha256sum] = "264a46d537d054b14ff3c00756546bbb147e878087eedb68d5f1365f3f417128"

URI_aarch64_kf6-kcmutils-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kcmutils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-doc}"
SRC_URI[aarch64_kf6-kcmutils-doc.sha256sum] = "0cb31c5e86ce783c618c22d0cb9e60944122d89443cd7031799c45a5d1706ab3"

RDEPENDS:kf6-kcmutils = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcmutils-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcmutils \
 kf6-kconfigwidgets-devel \
 kf6-kservice-devel \
 qt6-qtbase \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kcmutils-doc = " \
 "
