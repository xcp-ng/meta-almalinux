# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-baloo"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-baloo \
 kf6-baloo-devel \
 kf6-baloo-doc \
 kf6-baloo-file \
 kf6-baloo-html \
 kf6-baloo-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-baloo-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a130f238ba735b2308fcae7bcf7911d0429c6d41fa2e87a7d9e1277a2933b803"

URI_x86_64_v2_kf6-baloo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo}"
SRC_URI[x86_64_v2_kf6-baloo.sha256sum] = "ca990f810890dacbf5379fab385e8ff022e23a14033302d83bd8f5aa02c72b07"

URI_x86_64_v2_kf6-baloo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-devel}"
SRC_URI[x86_64_v2_kf6-baloo-devel.sha256sum] = "a0161a0a3546f26e45e53aafb33f9e8f752cd09ce27b52be4a585a5fc8f2ae5d"

URI_x86_64_v2_kf6-baloo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-baloo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-doc}"
SRC_URI[x86_64_v2_kf6-baloo-doc.sha256sum] = "100ae819197b4e1400a17cd1cc0a60ce8f62b56b89bb8ff9d76420866d2be520"

URI_x86_64_v2_kf6-baloo-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-file-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-file}"
SRC_URI[x86_64_v2_kf6-baloo-file.sha256sum] = "f12c94cc8aa17e88a3b52419b538f2a9c2503127eb3c9d0ba1dabfc20ae63b08"

URI_x86_64_v2_kf6-baloo-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-baloo-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-html}"
SRC_URI[x86_64_v2_kf6-baloo-html.sha256sum] = "4f3e2f7526e945fd54104399641cdcbb7864094601c29466b47e3b9001273f06"

URI_x86_64_v2_kf6-baloo-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-libs-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-libs}"
SRC_URI[x86_64_v2_kf6-baloo-libs.sha256sum] = "6a74f4569fb508ef4600a98a51d3b5159c150bcc4ff7cd83b97caf4b0acf0c41"

URI_aarch64_kf6-baloo = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-baloo;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo}"
SRC_URI[aarch64_kf6-baloo.sha256sum] = "9470a1241adc8fc4435f9ad7d03c477e48d1b80d7a061a2f9adfcb72950a1114"

URI_aarch64_kf6-baloo-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-baloo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-devel}"
SRC_URI[aarch64_kf6-baloo-devel.sha256sum] = "d872283d792b9a7159f517f34ed5065e00146cc10f28ca4eac0827d9e2f11b4f"

URI_aarch64_kf6-baloo-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-baloo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-doc}"
SRC_URI[aarch64_kf6-baloo-doc.sha256sum] = "d91cfdf0d17436740e7c74ff0122e290c7177e25f2148456d288d18c41d8a9ff"

URI_aarch64_kf6-baloo-file = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-file-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-baloo-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-file}"
SRC_URI[aarch64_kf6-baloo-file.sha256sum] = "3dc464dc81a13c229493ca49dc3097d930ecf24b3986853c1f7461b8690869ba"

URI_aarch64_kf6-baloo-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-baloo-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-html}"
SRC_URI[aarch64_kf6-baloo-html.sha256sum] = "703729e18e862ddf322999d03728f0c4f71d98bcf7b53472e0bc9c29552dfee8"

URI_aarch64_kf6-baloo-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-libs-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-baloo-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-libs}"
SRC_URI[aarch64_kf6-baloo-libs.sha256sum] = "29a6a414323b6ac694d697ca106b6e3a9e24ccb3532e8fb80e52b09ee882fb43"

RDEPENDS:kf6-baloo = " \
 glibc \
 kf6-baloo-libs \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-baloo-devel = " \
 cmake-filesystem \
 kf6-baloo-libs \
 kf6-kcoreaddons-devel \
 kf6-kfilemetadata-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-baloo-doc = " \
 "
RDEPENDS:kf6-baloo-file = " \
 glibc \
 kf6-baloo-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kidletime \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-baloo-html = " \
 "
RDEPENDS:kf6-baloo-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-solid \
 libstdc++ \
 lmdb-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
