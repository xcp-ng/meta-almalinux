# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-geomdl"
PV = "5.3.1"
PR = "31.el10_0"
PACKAGES = " \
 python-geomdl-doc \
 python3-geomdl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-geomdl-5.3.1-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9aa5b9a5f7c336faf3be0a65feaa9b85270f13a89376d7e4cfc96cd85635a900"

URI_x86_64_v2_python-geomdl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-geomdl-doc-5.3.1-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-geomdl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-geomdl-doc}"
SRC_URI[x86_64_v2_python-geomdl-doc.sha256sum] = "9f8b81fccca3b1b5a09b2489af335b38b99d4f502eb73fa7c6bf8abe2fbac49e"

URI_x86_64_v2_python3-geomdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-geomdl-5.3.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-geomdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-geomdl}"
SRC_URI[x86_64_v2_python3-geomdl.sha256sum] = "c42bbb574f2f74fd1f4da57c9c7640b82c7d04d64ed6ce4d9ce9b74bdc2709ef"

URI_aarch64_python-geomdl-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-geomdl-doc-5.3.1-31.el10_0.noarch.rpm;name=aarch64_python-geomdl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-geomdl-doc}"
SRC_URI[aarch64_python-geomdl-doc.sha256sum] = "d8da201e403134e9d555c18d62157d526a9b0441b1a7fbc72896eccf750fc1b5"

URI_aarch64_python3-geomdl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-geomdl-5.3.1-31.el10_0.aarch64.rpm;name=aarch64_python3-geomdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-geomdl}"
SRC_URI[aarch64_python3-geomdl.sha256sum] = "f33ddee5fb61ecd058f82461e646e8e56482ce7e8be0d71c220a523b2e7cd5ae"

RDEPENDS:python-geomdl-doc = " \
 "
RDEPENDS:python3-geomdl = " \
 glibc \
 python3 \
 "
