# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-config"
PV = "0.46.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-config+default-devel \
 rust-gix-config+document-features-devel \
 rust-gix-config+serde-devel \
 rust-gix-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-config-0.46.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f300c21efe9ace117c1a255161a9e792a3ab9417cc4d6eb0422e94c567af1184"

URI_x86_64_v2_rust-gix-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+default-devel-0.46.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+default-devel}"
SRC_URI[x86_64_v2_rust-gix-config+default-devel.sha256sum] = "6e9962821e4231860a72a810e0d4d760dd7b5ed81de9db992186e828ea2cf660"

URI_x86_64_v2_rust-gix-config+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+document-features-devel-0.46.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-config+document-features-devel.sha256sum] = "124a06f4f1ddfbc3cb959fc5bda722c76e9513821dd643562f3f0abcdb3f575d"

URI_x86_64_v2_rust-gix-config+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+serde-devel-0.46.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-config+serde-devel.sha256sum] = "ed70f9af00c981a8c0281252506aad5691662f77e07042ae503c9c990da5f6a1"

URI_x86_64_v2_rust-gix-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-devel-0.46.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-devel}"
SRC_URI[x86_64_v2_rust-gix-config-devel.sha256sum] = "4b9fe230bcba09bd6fde93e44b1ab4c3a67e285bb3518353d9f61bbb6e822134"

URI_aarch64_rust-gix-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+default-devel-0.46.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+default-devel}"
SRC_URI[aarch64_rust-gix-config+default-devel.sha256sum] = "1480c6c2858a4f323d2e9e13f7a8dc3db3eb40d14735e17de26db7565a9d3d9b"

URI_aarch64_rust-gix-config+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+document-features-devel-0.46.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-config+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+document-features-devel}"
SRC_URI[aarch64_rust-gix-config+document-features-devel.sha256sum] = "fd0a5440966709edc7b6bc19ddecd6c7572c838b282c892b46ab0e4cf3267c56"

URI_aarch64_rust-gix-config+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+serde-devel-0.46.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-config+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+serde-devel}"
SRC_URI[aarch64_rust-gix-config+serde-devel.sha256sum] = "11a9cf6c97b570f7cd3b09acceb647f23207487217d8cd85ccf55250a05056ec"

URI_aarch64_rust-gix-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-devel-0.46.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-devel}"
SRC_URI[aarch64_rust-gix-config-devel.sha256sum] = "6b88ab10cacd407b2fcf5ef6a9467229fce3a64b0638c92c9c9fd081fddd1be4"

RDEPENDS:rust-gix-config+default-devel = " \
 cargo \
 rust-gix-config-devel \
 "
RDEPENDS:rust-gix-config+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-config-devel \
 "
RDEPENDS:rust-gix-config+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-config-devel \
 rust-gix-config-value+serde-devel \
 rust-gix-glob+serde-devel \
 rust-gix-ref+serde-devel \
 rust-gix-sec+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-config-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-config-value+default-devel \
 rust-gix-features+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-sec+default-devel \
 rust-memchr+default-devel \
 rust-once_cell+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-bom+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
