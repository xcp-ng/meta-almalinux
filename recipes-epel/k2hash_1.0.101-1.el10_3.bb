# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "k2hash"
PV = "1.0.101"
PR = "1.el10_3"
PACKAGES = " \
 k2hash \
 k2hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/k2hash-1.0.101-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "172b640c537417c47f6ebc5bb60a3259e6f6dfe90ea59fce5c118e6663c8c230"

URI_x86_64_v2_k2hash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/k2hash-1.0.101-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_k2hash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_k2hash}"
SRC_URI[x86_64_v2_k2hash.sha256sum] = "af0d9c075f0744061605d0cf9d3aaca66f94c7bc1c76676608fd6d56c98c2721"

URI_x86_64_v2_k2hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/k2hash-devel-1.0.101-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_k2hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_k2hash-devel}"
SRC_URI[x86_64_v2_k2hash-devel.sha256sum] = "9c24b8f7028cfe2fe85bd9cb98e66fe442a9851efb6a0ba94d2a80514daec646"

URI_aarch64_k2hash = "${EPEL_MIRROR}/aarch64/Packages/k/k2hash-1.0.101-1.el10_3.aarch64.rpm;name=aarch64_k2hash;unpack=0"
SRC_URI:append = " ${URI_aarch64_k2hash}"
SRC_URI[aarch64_k2hash.sha256sum] = "1d55f80a91b77374416b88f43e4c90213d3face1358180ae685892fd056c2af6"

URI_aarch64_k2hash-devel = "${EPEL_MIRROR}/aarch64/Packages/k/k2hash-devel-1.0.101-1.el10_3.aarch64.rpm;name=aarch64_k2hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_k2hash-devel}"
SRC_URI[aarch64_k2hash-devel.sha256sum] = "5d075392c8d344b2194ebb8b2f276bfd11e20a4ac3e0e9485b45e17cad2cf68b"

RDEPENDS:k2hash = " \
 bash \
 glibc \
 libfullock \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:k2hash-devel = " \
 k2hash \
 libfullock-devel \
 pkgconf-pkg-config \
 "
