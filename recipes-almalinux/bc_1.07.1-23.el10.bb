# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bc"
PV = "1.07.1"
PR = "23.el10"
PACKAGES = " \
 bc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/bc-1.07.1-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0096ec325c3800dee458fc16db2263424e88e35adb5b0d3588f6ae03e2805243"

URI_x86_64_v2_bc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/bc-1.07.1-23.el10.x86_64_v2.rpm;name=x86_64_v2_bc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bc}"
SRC_URI[x86_64_v2_bc.sha256sum] = "87474f9031cc71575ca89194d41dd17b042845485dd1a76eea8f27f7d9228747"

URI_aarch64_bc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/bc-1.07.1-23.el10.aarch64.rpm;name=aarch64_bc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bc}"
SRC_URI[aarch64_bc.sha256sum] = "ae60a6602eaadb2c78248f419be946acba0dc74bc98878dd7d38ac14413216d6"

RDEPENDS:bc = " \
 glibc \
 readline \
 "
