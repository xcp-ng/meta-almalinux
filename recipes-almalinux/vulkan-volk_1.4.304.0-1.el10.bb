# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-volk"
PV = "1.4.304.0"
PR = "1.el10"
PACKAGES = " \
 vulkan-volk-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-volk-1.4.304.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd475918072347c00ffa994cc499fff0ca835dc6fc170a48a071969d71a68a5a"

URI_x86_64_v2_vulkan-volk-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-volk-devel-1.4.304.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-volk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-volk-devel}"
SRC_URI[x86_64_v2_vulkan-volk-devel.sha256sum] = "e19b8a66a5cf6cfd06d27245c80915aaae9ac4144f63c3571a3b3dbf8da50745"

URI_aarch64_vulkan-volk-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-volk-devel-1.4.304.0-1.el10.aarch64.rpm;name=aarch64_vulkan-volk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-volk-devel}"
SRC_URI[aarch64_vulkan-volk-devel.sha256sum] = "bc7eef492a5cff04fd1909c7a93f50097e3433787bdb4c2638c3b80d6f514a6b"

RDEPENDS:vulkan-volk-devel = " \
 cmake-filesystem \
 vulkan-headers \
 "
