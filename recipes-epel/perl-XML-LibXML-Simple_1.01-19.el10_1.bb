# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-LibXML-Simple"
PV = "1.01"
PR = "19.el10_1"
PACKAGES = " \
 perl-XML-LibXML-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-LibXML-Simple-1.01-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc54197f2e73838915710bbae494c05f55d62e73b04498f2d5c5f255825e41e6"

URI_x86_64_v2_perl-XML-LibXML-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-LibXML-Simple-1.01-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-LibXML-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-LibXML-Simple}"
SRC_URI[x86_64_v2_perl-XML-LibXML-Simple.sha256sum] = "96e4d1d9d4f6afbd7303341ad1220b452268090131060e060fde4ae2626b615e"

URI_aarch64_perl-XML-LibXML-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-LibXML-Simple-1.01-19.el10_1.noarch.rpm;name=aarch64_perl-XML-LibXML-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-LibXML-Simple}"
SRC_URI[aarch64_perl-XML-LibXML-Simple.sha256sum] = "13d770a834e790e5105d6a1144b9102dea011001218941e7479c3cc7ecc74bda"

RDEPENDS:perl-XML-LibXML-Simple = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-XML-LibXML \
 perl-base \
 perl-libs \
 perl-vars \
 "
