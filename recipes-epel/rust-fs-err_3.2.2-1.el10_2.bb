# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fs-err"
PV = "3.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-fs-err+default-devel \
 rust-fs-err+expose_original_error-devel \
 rust-fs-err+tokio-devel \
 rust-fs-err-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fs-err-3.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32340291f64cb0e9f1d5729ca829eac57a64540e8bd11d99ae14d69d0847f553"

URI_x86_64_v2_rust-fs-err+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err+default-devel-3.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err+default-devel}"
SRC_URI[x86_64_v2_rust-fs-err+default-devel.sha256sum] = "5c4f0b3e82fa44d589e1f43ff22db95cc0f538cf2eb1565ad8a8548061dd8e95"

URI_x86_64_v2_rust-fs-err+expose_original_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err+expose_original_error-devel-3.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err+expose_original_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err+expose_original_error-devel}"
SRC_URI[x86_64_v2_rust-fs-err+expose_original_error-devel.sha256sum] = "05712a95141827fd7f7a5aa0a4b9b0005a976d54ab05fce928c086fa84a06f0b"

URI_x86_64_v2_rust-fs-err+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err+tokio-devel-3.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err+tokio-devel}"
SRC_URI[x86_64_v2_rust-fs-err+tokio-devel.sha256sum] = "aff1dd8c7815d76293c1a55b6768ac065abce075d722dbeffb4508e3a22fac6b"

URI_x86_64_v2_rust-fs-err-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err-devel-3.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fs-err-devel}"
SRC_URI[x86_64_v2_rust-fs-err-devel.sha256sum] = "6609ae48041eaec4314e3d7c053a70e17b378cccb16906fe504e0f1d4f50ee85"

URI_aarch64_rust-fs-err+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err+default-devel-3.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-fs-err+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err+default-devel}"
SRC_URI[aarch64_rust-fs-err+default-devel.sha256sum] = "0e56193122b898e4418c1de22b89266afa4a97bfedd9ebd3269e939c788fc3c0"

URI_aarch64_rust-fs-err+expose_original_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err+expose_original_error-devel-3.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-fs-err+expose_original_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err+expose_original_error-devel}"
SRC_URI[aarch64_rust-fs-err+expose_original_error-devel.sha256sum] = "77331aa9286deb9a2f2ab933980703f9838654d7fbbc2e83815373b7dbd8b946"

URI_aarch64_rust-fs-err+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err+tokio-devel-3.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-fs-err+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err+tokio-devel}"
SRC_URI[aarch64_rust-fs-err+tokio-devel.sha256sum] = "c049dc8b3325ad89bd4ac73316b23d3a282c1001c2066d26eda8d69f7a89ea19"

URI_aarch64_rust-fs-err-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err-devel-3.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-fs-err-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fs-err-devel}"
SRC_URI[aarch64_rust-fs-err-devel.sha256sum] = "a9709914762aa4621e3190a875529272e68151aff721fb3e4585ca1ed48c72e4"

RDEPENDS:rust-fs-err+default-devel = " \
 cargo \
 rust-fs-err-devel \
 "
RDEPENDS:rust-fs-err+expose_original_error-devel = " \
 cargo \
 rust-fs-err-devel \
 "
RDEPENDS:rust-fs-err+tokio-devel = " \
 cargo \
 rust-fs-err-devel \
 rust-tokio+fs-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-fs-err-devel = " \
 cargo \
 rust-autocfg+default-devel \
 "
