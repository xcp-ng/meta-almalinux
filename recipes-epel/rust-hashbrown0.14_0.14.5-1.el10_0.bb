# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbrown0.14"
PV = "0.14.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-hashbrown0.14+ahash-devel \
 rust-hashbrown0.14+allocator-api2-devel \
 rust-hashbrown0.14+default-devel \
 rust-hashbrown0.14+equivalent-devel \
 rust-hashbrown0.14+inline-more-devel \
 rust-hashbrown0.14+raw-devel \
 rust-hashbrown0.14+rayon-devel \
 rust-hashbrown0.14+rkyv-devel \
 rust-hashbrown0.14+serde-devel \
 rust-hashbrown0.14-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashbrown0.14-0.14.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45b72c6dab2cefce989bc415653f5785595cf45e2eb0586a9cbd930d669f9440"

URI_x86_64_v2_rust-hashbrown0.14+ahash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14+ahash-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14+ahash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14+ahash-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14+ahash-devel.sha256sum] = "3817dbf1f21f5c8189fae9cace0f7ddd2a1652146e0344a3712f8fef6c181b9b"

URI_x86_64_v2_rust-hashbrown0.14+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14+allocator-api2-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14+allocator-api2-devel.sha256sum] = "b1cc94af85ad747588a6c97ae1b3510aeeb9f20b875583827359a9577016dedf"

URI_x86_64_v2_rust-hashbrown0.14+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14+default-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14+default-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14+default-devel.sha256sum] = "275c56e63beff5317b76f9df97b8a2f6c1d01db82a7419f980e686ebfbf0370d"
RPROVIDES:rust-hashbrown0.14+default-devel:x86_64_v2 = "virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ virtual/crate_hashbrown/default__ge_0.9.0_with_crate_hashbrown/default__lt_0.15.0~"

URI_x86_64_v2_rust-hashbrown0.14+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14+equivalent-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14+equivalent-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14+equivalent-devel.sha256sum] = "8f5882b5c4879cb9f982e30df1acbb6d39dad4cde9691ec1fc051904ade94b00"

URI_x86_64_v2_rust-hashbrown0.14+inline-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14+inline-more-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14+inline-more-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14+inline-more-devel.sha256sum] = "4086e76f30e3f910c39a919a49ae750996ad4da06783a37fbdc392430ad807b4"

URI_x86_64_v2_rust-hashbrown0.14+raw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14+raw-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14+raw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14+raw-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14+raw-devel.sha256sum] = "f1133e511ddb8ed786b98bed3b3b0ff8ab6e55d7aaf1f20dddd4a49e6cd00e77"

URI_x86_64_v2_rust-hashbrown0.14+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14+rayon-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14+rayon-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14+rayon-devel.sha256sum] = "48c9bf33a985a68d322b2d8fc109012c13ac1e242ef36ba8ad4863af64fa350a"

URI_x86_64_v2_rust-hashbrown0.14+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14+rkyv-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14+rkyv-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14+rkyv-devel.sha256sum] = "9b868072c2f163927b82187cb1ca12c249a2dc79a63e7d680eaf1301bd02a176"

URI_x86_64_v2_rust-hashbrown0.14+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14+serde-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14+serde-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14+serde-devel.sha256sum] = "141e389ba6b953b64810c5c1d2eb3834545f186a1605ce367a4123418a624767"

URI_x86_64_v2_rust-hashbrown0.14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.14-devel-0.14.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.14-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.14-devel.sha256sum] = "8c5e32299ff7a21392f8c7f28d52deb998a263e74830cd0019e80a2bab67f8f4"

URI_aarch64_rust-hashbrown0.14+ahash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14+ahash-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14+ahash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14+ahash-devel}"
SRC_URI[aarch64_rust-hashbrown0.14+ahash-devel.sha256sum] = "220f7bd5fc567996db17b0681cd90032c65339e6e7a7e680825b98b6b2057f23"

URI_aarch64_rust-hashbrown0.14+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14+allocator-api2-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14+allocator-api2-devel}"
SRC_URI[aarch64_rust-hashbrown0.14+allocator-api2-devel.sha256sum] = "ebff6714910967057d85a69ace4a3578c3805e33412c0def43d1582a716aa413"

URI_aarch64_rust-hashbrown0.14+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14+default-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14+default-devel}"
SRC_URI[aarch64_rust-hashbrown0.14+default-devel.sha256sum] = "49c3c7998f4c9b4dd85769d048135bd6c9cabafebf5c7d7aca2b80652a9c95a7"
RPROVIDES:rust-hashbrown0.14+default-devel:aarch64 = "virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ virtual/crate_hashbrown/default__ge_0.9.0_with_crate_hashbrown/default__lt_0.15.0~"

URI_aarch64_rust-hashbrown0.14+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14+equivalent-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14+equivalent-devel}"
SRC_URI[aarch64_rust-hashbrown0.14+equivalent-devel.sha256sum] = "88fd83a4b01a63bd3c0089a7e18a2fb60d1cb46bd37e6e97e4da8eac6d464bd4"

URI_aarch64_rust-hashbrown0.14+inline-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14+inline-more-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14+inline-more-devel}"
SRC_URI[aarch64_rust-hashbrown0.14+inline-more-devel.sha256sum] = "00717b3e21369c080eff8c20b250d13e4a7899a282b699c6ac081adca4305e96"

URI_aarch64_rust-hashbrown0.14+raw-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14+raw-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14+raw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14+raw-devel}"
SRC_URI[aarch64_rust-hashbrown0.14+raw-devel.sha256sum] = "8edb43f024020047ad73ca386f9cdceb267a25f3ecace30b262ee43504547ce4"

URI_aarch64_rust-hashbrown0.14+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14+rayon-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14+rayon-devel}"
SRC_URI[aarch64_rust-hashbrown0.14+rayon-devel.sha256sum] = "8669dd654b7ce35d34c4ba561456617b048fad35bf1b3b916ce78fde811075a1"

URI_aarch64_rust-hashbrown0.14+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14+rkyv-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14+rkyv-devel}"
SRC_URI[aarch64_rust-hashbrown0.14+rkyv-devel.sha256sum] = "c13597f74ac4d7ab3f447f1cb760325f796af17f8a38f32ca199dbe9a7148864"

URI_aarch64_rust-hashbrown0.14+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14+serde-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14+serde-devel}"
SRC_URI[aarch64_rust-hashbrown0.14+serde-devel.sha256sum] = "4f88b812a9f7691fdf0a70cc57b37482adbe6901c312d7ff32148f7974b9db70"

URI_aarch64_rust-hashbrown0.14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.14-devel-0.14.5-1.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.14-devel}"
SRC_URI[aarch64_rust-hashbrown0.14-devel.sha256sum] = "a58b671dbcbc8f64ffe02118e857df9524bdee4884c71eb07780c50d18384ba2"

RDEPENDS:rust-hashbrown0.14+ahash-devel = " \
 cargo \
 rust-ahash-devel \
 rust-hashbrown0.14-devel \
 "
RDEPENDS:rust-hashbrown0.14+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2-devel \
 rust-hashbrown0.14-devel \
 "
RDEPENDS:rust-hashbrown0.14+default-devel = " \
 cargo \
 rust-hashbrown0.14+ahash-devel \
 rust-hashbrown0.14+allocator-api2-devel \
 rust-hashbrown0.14+inline-more-devel \
 rust-hashbrown0.14-devel \
 "
RDEPENDS:rust-hashbrown0.14+equivalent-devel = " \
 cargo \
 rust-equivalent-devel \
 rust-hashbrown0.14-devel \
 "
RDEPENDS:rust-hashbrown0.14+inline-more-devel = " \
 cargo \
 rust-hashbrown0.14-devel \
 "
RDEPENDS:rust-hashbrown0.14+raw-devel = " \
 cargo \
 rust-hashbrown0.14-devel \
 "
RDEPENDS:rust-hashbrown0.14+rayon-devel = " \
 cargo \
 rust-hashbrown0.14-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-hashbrown0.14+rkyv-devel = " \
 cargo \
 rust-hashbrown0.14-devel \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-hashbrown0.14+serde-devel = " \
 cargo \
 rust-hashbrown0.14-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashbrown0.14-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ rpm/virtual/crate_hashbrown/default__ge_0.9.0_with_crate_hashbrown/default__lt_0.15.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ rpm/virtual/crate_hashbrown/default__ge_0.9.0_with_crate_hashbrown/default__lt_0.15.0~"
