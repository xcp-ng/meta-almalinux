# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3_0.22"
PV = "0.22.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3_0.22+abi3-devel \
 rust-pyo3_0.22+abi3-py310-devel \
 rust-pyo3_0.22+abi3-py311-devel \
 rust-pyo3_0.22+abi3-py312-devel \
 rust-pyo3_0.22+abi3-py37-devel \
 rust-pyo3_0.22+abi3-py38-devel \
 rust-pyo3_0.22+abi3-py39-devel \
 rust-pyo3_0.22+anyhow-devel \
 rust-pyo3_0.22+auto-initialize-devel \
 rust-pyo3_0.22+chrono-devel \
 rust-pyo3_0.22+chrono-tz-devel \
 rust-pyo3_0.22+default-devel \
 rust-pyo3_0.22+either-devel \
 rust-pyo3_0.22+experimental-async-devel \
 rust-pyo3_0.22+experimental-inspect-devel \
 rust-pyo3_0.22+extension-module-devel \
 rust-pyo3_0.22+eyre-devel \
 rust-pyo3_0.22+full-devel \
 rust-pyo3_0.22+gil-refs-devel \
 rust-pyo3_0.22+hashbrown-devel \
 rust-pyo3_0.22+indexmap-devel \
 rust-pyo3_0.22+indoc-devel \
 rust-pyo3_0.22+inventory-devel \
 rust-pyo3_0.22+macros-devel \
 rust-pyo3_0.22+multiple-pymethods-devel \
 rust-pyo3_0.22+nightly-devel \
 rust-pyo3_0.22+num-bigint-devel \
 rust-pyo3_0.22+num-complex-devel \
 rust-pyo3_0.22+num-rational-devel \
 rust-pyo3_0.22+py-clone-devel \
 rust-pyo3_0.22+pyo3-macros-devel \
 rust-pyo3_0.22+rust_decimal-devel \
 rust-pyo3_0.22+serde-devel \
 rust-pyo3_0.22+smallvec-devel \
 rust-pyo3_0.22+unindent-devel \
 rust-pyo3_0.22-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3_0.22-0.22.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbd8c40c9a271266230c71bff65cf793f49cebf67ee2b6a211c21d7192535340"

URI_x86_64_v2_rust-pyo3_0.22+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+abi3-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+abi3-devel.sha256sum] = "638b8fe3111bcaed0ab551b2218b514978b52cd2cadcddb4f1f6316427a69a7d"

URI_x86_64_v2_rust-pyo3_0.22+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+abi3-py310-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+abi3-py310-devel.sha256sum] = "7fac5bd80d9d05310783dd181642c470be658e86a635f71975e30d316c6b16a8"

URI_x86_64_v2_rust-pyo3_0.22+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+abi3-py311-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+abi3-py311-devel.sha256sum] = "ce64b6321d696afa8d853fe390be569f62760122082e20b9168ee8c1de7d75f7"

URI_x86_64_v2_rust-pyo3_0.22+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+abi3-py312-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+abi3-py312-devel.sha256sum] = "5e7ffa7561cc64f8c1647109331fc541bc3d0db16540f2cfaf00b58c7f099841"

URI_x86_64_v2_rust-pyo3_0.22+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+abi3-py37-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+abi3-py37-devel.sha256sum] = "0a327debaadd04eb9ef09abd6c7515b9c52e1d0c468678e43c67d99228ae0733"

URI_x86_64_v2_rust-pyo3_0.22+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+abi3-py38-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+abi3-py38-devel.sha256sum] = "99b9f4053a3add493b8a32b58d2579b2ec66bd5ae55bd2a87e4da51336c54d29"

URI_x86_64_v2_rust-pyo3_0.22+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+abi3-py39-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+abi3-py39-devel.sha256sum] = "15abe1fc97a5e9d44aff671577474bd8f0494cace840cb04ec832629abc4386b"

URI_x86_64_v2_rust-pyo3_0.22+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+anyhow-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+anyhow-devel.sha256sum] = "ecc63332c4974c87fd008aaf728fabb367bf912e0c2ff4334d9bcd40323ea8e8"

URI_x86_64_v2_rust-pyo3_0.22+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+auto-initialize-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+auto-initialize-devel.sha256sum] = "ebcd1f9b42038e0f837d80be0017d7f3819defa024284f9701a805931b22687e"

URI_x86_64_v2_rust-pyo3_0.22+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+chrono-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+chrono-devel.sha256sum] = "a30fd2bc13a16c53536baf25f2cefbabef3c1380a76d680d9f43b9b3aa110558"

URI_x86_64_v2_rust-pyo3_0.22+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+chrono-tz-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+chrono-tz-devel.sha256sum] = "7dc0c1216221a30ca51357fdb015b91cb3e53fc2bb2cff15c067f14b5f92e0aa"

URI_x86_64_v2_rust-pyo3_0.22+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+default-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+default-devel.sha256sum] = "e2f817a1ba408bf22b61d81c8a8d259a783daafd96ea001ea15e1803ed2bd175"

URI_x86_64_v2_rust-pyo3_0.22+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+either-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+either-devel.sha256sum] = "92c84fd21002c66a1abc6029644434e369c009d52ba561aa38f460bd42f9c5ce"

URI_x86_64_v2_rust-pyo3_0.22+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+experimental-async-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+experimental-async-devel.sha256sum] = "5c0155e9622d771a1a17ddc1d35daf16dba85bea9b3c74af01ce7926b334b302"

URI_x86_64_v2_rust-pyo3_0.22+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+experimental-inspect-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+experimental-inspect-devel.sha256sum] = "aa3596021d40cf939ea7c45317305d9a149a1cbeddb6152c91513d8e9127ea48"

URI_x86_64_v2_rust-pyo3_0.22+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+extension-module-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+extension-module-devel.sha256sum] = "8ab91c1177245724d14ed38211d6a640269bc658949a472f564269d1b1d7c9ec"

URI_x86_64_v2_rust-pyo3_0.22+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+eyre-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+eyre-devel.sha256sum] = "b74504ca9f5387457c4820216e85d585bff54e0b9290e3b5f8b519b08672da7c"

URI_x86_64_v2_rust-pyo3_0.22+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+full-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+full-devel.sha256sum] = "e5acd801792c93bd679e1f5602d33f3417fc6b5bd7f09a792a962a45913c9b6a"

URI_x86_64_v2_rust-pyo3_0.22+gil-refs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+gil-refs-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+gil-refs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+gil-refs-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+gil-refs-devel.sha256sum] = "337b74da0ff7ebc50631c0a774537aaaab4fa4db0f446658c7486c93302275b1"

URI_x86_64_v2_rust-pyo3_0.22+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+hashbrown-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+hashbrown-devel.sha256sum] = "de3625603e53cc34a9a67fa8de727822bb7218d4476e34427620c9563fe5d63f"

URI_x86_64_v2_rust-pyo3_0.22+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+indexmap-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+indexmap-devel.sha256sum] = "23e6eae9b870ca184e02585b6ec172a2586bb5dab084f6d4c5f3d6537db8828b"

URI_x86_64_v2_rust-pyo3_0.22+indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+indoc-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+indoc-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+indoc-devel.sha256sum] = "1304d8781c6a9395cddc283e74e26da8818e15d940df3fa2b87384bdfa118b9e"

URI_x86_64_v2_rust-pyo3_0.22+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+inventory-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+inventory-devel.sha256sum] = "ef353bccc3deaa7ba2d417710ed9e08a83acba47a617be217c7aa1fbb9451b7a"

URI_x86_64_v2_rust-pyo3_0.22+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+macros-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+macros-devel.sha256sum] = "d1fe38193df7aaa24c58668beaaf92fbc66fcee3438b1b71c64c2bc2298274fa"

URI_x86_64_v2_rust-pyo3_0.22+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+multiple-pymethods-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+multiple-pymethods-devel.sha256sum] = "2755b0279464690a1896dd28d125e3b8acf1617259a3b850c5d2a841f15c0fb7"

URI_x86_64_v2_rust-pyo3_0.22+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+nightly-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+nightly-devel.sha256sum] = "083fcfdcf7ffbb1c635bd7dae3ae93d726919316458bfed67f297e8393dac638"

URI_x86_64_v2_rust-pyo3_0.22+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+num-bigint-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+num-bigint-devel.sha256sum] = "d2e367d3cc2c81c0565f7447d61560fc5c73d5de35392f5fa8f932f15bfa9b5e"

URI_x86_64_v2_rust-pyo3_0.22+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+num-complex-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+num-complex-devel.sha256sum] = "a5332ded689bed545c6b4981be2e2a05996a8358c95c30e1f6adb6fbe33d063c"

URI_x86_64_v2_rust-pyo3_0.22+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+num-rational-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+num-rational-devel.sha256sum] = "14466dfe007b925b2180f7008ffd37f585185e7477a7fd835cf73232ac8b4cc0"

URI_x86_64_v2_rust-pyo3_0.22+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+py-clone-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+py-clone-devel.sha256sum] = "245414e7958694f5883d5b8b46905e7db25c57be5e6aebb2c237c8848bca3338"

URI_x86_64_v2_rust-pyo3_0.22+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+pyo3-macros-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+pyo3-macros-devel.sha256sum] = "261cfe9da6db58e47234238d0ba5274d7ef6e961702c931cb628edabf6132935"

URI_x86_64_v2_rust-pyo3_0.22+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+rust_decimal-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+rust_decimal-devel.sha256sum] = "81df63e30c9c1ed3f2d5d90eab0e8be88f84c1495712caa76d538b0c2e08969d"

URI_x86_64_v2_rust-pyo3_0.22+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+serde-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+serde-devel.sha256sum] = "83e8fc65a44bcc678ee60fdf42565725b01388ea3fb99781e452fc26659b7d9a"

URI_x86_64_v2_rust-pyo3_0.22+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+smallvec-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+smallvec-devel.sha256sum] = "b8f3ff5a422a1c172845e9a372aefbb046123226a5f6a8b07e8564b33cf71576"

URI_x86_64_v2_rust-pyo3_0.22+unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22+unindent-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22+unindent-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22+unindent-devel.sha256sum] = "531ba164314aa3127bf7ee2c93b7b44ccc3c79f44a6a64b9551debf7b7eb4030"

URI_x86_64_v2_rust-pyo3_0.22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3_0.22-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3_0.22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3_0.22-devel}"
SRC_URI[x86_64_v2_rust-pyo3_0.22-devel.sha256sum] = "09df7bd872a08806e19214df03ec0486170b6d723da8bbd0101073e2c04ecb6d"

URI_aarch64_rust-pyo3_0.22+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+abi3-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+abi3-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+abi3-devel.sha256sum] = "b34c83dcdf0b4b434b03948f95e301a56400be2aa9041a359caf3ab82985c096"

URI_aarch64_rust-pyo3_0.22+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+abi3-py310-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+abi3-py310-devel.sha256sum] = "aabb2f9bb4d9b968f7d35a8b55bccb2de23854d2c46f57bf6926993c3c64cd2e"

URI_aarch64_rust-pyo3_0.22+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+abi3-py311-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+abi3-py311-devel.sha256sum] = "b30973f8cf1ca47830a5b07d108fa570c1dc2ee21be91046f6b8949554722ba6"

URI_aarch64_rust-pyo3_0.22+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+abi3-py312-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+abi3-py312-devel.sha256sum] = "e8af147d9a3134c185ef82dc6415ec4707a09140d56f2cf11ad8cdb3c516f391"

URI_aarch64_rust-pyo3_0.22+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+abi3-py37-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+abi3-py37-devel.sha256sum] = "3cd9ede932444aa1e6525eb6b53cff42eae9b6be27ed83a6c902cc3fc0989492"

URI_aarch64_rust-pyo3_0.22+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+abi3-py38-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+abi3-py38-devel.sha256sum] = "97ce997ef6c286b888ef3bc86680bc38f2cd66dd250671c24bc6b8dda582859a"

URI_aarch64_rust-pyo3_0.22+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+abi3-py39-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+abi3-py39-devel.sha256sum] = "244d904c1d03a7fabe436089dc4cfc0ecbf36f041f7458d5314c129f00782cc0"

URI_aarch64_rust-pyo3_0.22+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+anyhow-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+anyhow-devel.sha256sum] = "4043fcf9a3e39d55f07de67f4e3fba76b09753d239be8076e59b472c26b454a9"

URI_aarch64_rust-pyo3_0.22+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+auto-initialize-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+auto-initialize-devel.sha256sum] = "b0b856eb965688279eaa5b9d8fd1b20f871f6698d3644058a377510487de98e9"

URI_aarch64_rust-pyo3_0.22+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+chrono-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+chrono-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+chrono-devel.sha256sum] = "948f541e5e92f5dfaa4601d72ab62a8feda2c2b77e996459a8b8969e426558ba"

URI_aarch64_rust-pyo3_0.22+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+chrono-tz-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+chrono-tz-devel.sha256sum] = "2338ef74bb3f3b330ad3cc6a1b9950b1856c2a00f6e5e7a8a394e8410df5e5f6"

URI_aarch64_rust-pyo3_0.22+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+default-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+default-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+default-devel.sha256sum] = "2ec8674a5fd4b057d79946a29054cde55413010406d81df3929f0bf821598c45"

URI_aarch64_rust-pyo3_0.22+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+either-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+either-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+either-devel.sha256sum] = "fef55b2d5a061560da7434433d3fa54dc19e0cc0055514c02467e6e29afb30b6"

URI_aarch64_rust-pyo3_0.22+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+experimental-async-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+experimental-async-devel.sha256sum] = "73e0a0375c504d54752f8d81af08ebc005838f9f02c9d09a9ccd32e1111bd3f8"

URI_aarch64_rust-pyo3_0.22+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+experimental-inspect-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+experimental-inspect-devel.sha256sum] = "ddfb4b2f055ebf811fdd2e045df5e6a761cfe32640a20e3fc127650ca5fc19c9"

URI_aarch64_rust-pyo3_0.22+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+extension-module-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+extension-module-devel.sha256sum] = "a57fefe162789e57742cf3bf877e6c8a7734690103f80bc1cb49e3afb5473378"

URI_aarch64_rust-pyo3_0.22+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+eyre-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+eyre-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+eyre-devel.sha256sum] = "524672e411b386472a57ec7a3985c513f8892e3a14568c268e9f8fae957a4e17"

URI_aarch64_rust-pyo3_0.22+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+full-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+full-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+full-devel.sha256sum] = "61c67265dd7ce3e25297e9bc5b43dbf2adad1642f2ae725ee59d9427df60f84c"

URI_aarch64_rust-pyo3_0.22+gil-refs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+gil-refs-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+gil-refs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+gil-refs-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+gil-refs-devel.sha256sum] = "8cdcf88e1e50bae2071ef81111409ebe0e37cf5cefa9e19a8065e4840f9879d9"

URI_aarch64_rust-pyo3_0.22+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+hashbrown-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+hashbrown-devel.sha256sum] = "0dafde4a76942d7c8ecf2b403b9f96d7682ff329441258d49aab1d4f11d00d0b"

URI_aarch64_rust-pyo3_0.22+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+indexmap-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+indexmap-devel.sha256sum] = "77437df049797431eba59088ea75618403181c322274bcfeabe13db8306409c3"

URI_aarch64_rust-pyo3_0.22+indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+indoc-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+indoc-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+indoc-devel.sha256sum] = "960d5a932c0f24358c798a11eb4ecd44f211a0b079c35c80cfb2bace02f19a9d"

URI_aarch64_rust-pyo3_0.22+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+inventory-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+inventory-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+inventory-devel.sha256sum] = "7e5b9aab04e3eb83275b49e338f3e721a967c14586a552921b4562114dafbee0"

URI_aarch64_rust-pyo3_0.22+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+macros-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+macros-devel.sha256sum] = "1d0a13276f94dba2fdb91f0f69cc2637bc8c514b2906a9ec429d7a4741570927"

URI_aarch64_rust-pyo3_0.22+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+multiple-pymethods-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+multiple-pymethods-devel.sha256sum] = "9ae96e74b0aa2d58daa86ea40c99a296f7db56c2b8a14852fcc0f45db6bfe04e"

URI_aarch64_rust-pyo3_0.22+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+nightly-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+nightly-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+nightly-devel.sha256sum] = "8bc38dcd4a93c122fa0c1d30002adff67b18d91ac043a0d237bd7cc7e2652af0"

URI_aarch64_rust-pyo3_0.22+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+num-bigint-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+num-bigint-devel.sha256sum] = "0724566c1e0ff26f40a381b5a654a4fccc84b31aa8ac0e45844435304ae7a8ce"

URI_aarch64_rust-pyo3_0.22+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+num-complex-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+num-complex-devel.sha256sum] = "1c65dbaa74ef543ae81d46457a515ce26764ea6e7bf4eea60cab6f77e3580818"

URI_aarch64_rust-pyo3_0.22+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+num-rational-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+num-rational-devel.sha256sum] = "00bf528e45f1c3f0cd8a1ed39169d11695a3eec048416cab8a52d831f2319989"

URI_aarch64_rust-pyo3_0.22+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+py-clone-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+py-clone-devel.sha256sum] = "843bb4832e651b42488f015d816e6caaba057b133d752b98b05b58d564416bd5"

URI_aarch64_rust-pyo3_0.22+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+pyo3-macros-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+pyo3-macros-devel.sha256sum] = "ceadd71f9c88756a841f7c7979efb6f1161554c1e9b1c3033b588e4b34091f0f"

URI_aarch64_rust-pyo3_0.22+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+rust_decimal-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+rust_decimal-devel.sha256sum] = "043c43085a5e8d9470b253a431b81cf2e8e5b7fbfe4ec98c7801df37ab2669e4"

URI_aarch64_rust-pyo3_0.22+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+serde-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+serde-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+serde-devel.sha256sum] = "1e5b58a8ff57e2c5a9fd334a504cb35f2a2055f89fb104c9c7b9dace4482eb58"

URI_aarch64_rust-pyo3_0.22+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+smallvec-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+smallvec-devel.sha256sum] = "09993eebe3c189c7bc21c7ca56e01d9672ca18e202771cff8ea45df154de9deb"

URI_aarch64_rust-pyo3_0.22+unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22+unindent-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22+unindent-devel}"
SRC_URI[aarch64_rust-pyo3_0.22+unindent-devel.sha256sum] = "e8bec73c3d3f81bd142c5b5a2abee3be3480bf14799586a33fbeb7d6c446fa3d"

URI_aarch64_rust-pyo3_0.22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3_0.22-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3_0.22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3_0.22-devel}"
SRC_URI[aarch64_rust-pyo3_0.22-devel.sha256sum] = "8a8bbc024662d4ba1b648d99b8a2bfc5bd0c02cf53587b048ea68e1ac3d7b03b"

RDEPENDS:rust-pyo3_0.22+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py310-devel \
 rust-pyo3_0.22+abi3-py311-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py311-devel \
 rust-pyo3_0.22+abi3-py312-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py312-devel \
 rust-pyo3_0.22+abi3-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py37-devel \
 rust-pyo3_0.22+abi3-py38-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py38-devel \
 rust-pyo3_0.22+abi3-py39-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py39-devel \
 rust-pyo3_0.22+abi3-py310-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+auto-initialize-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+default-devel = " \
 cargo \
 rust-pyo3_0.22+macros-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros0.22+default-devel \
 rust-pyo3-macros0.22+experimental-async-devel \
 rust-pyo3_0.22+macros-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+experimental-inspect-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.22+extension-module-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+full-devel = " \
 cargo \
 rust-pyo3_0.22+anyhow-devel \
 rust-pyo3_0.22+chrono-devel \
 rust-pyo3_0.22+chrono-tz-devel \
 rust-pyo3_0.22+either-devel \
 rust-pyo3_0.22+experimental-async-devel \
 rust-pyo3_0.22+experimental-inspect-devel \
 rust-pyo3_0.22+eyre-devel \
 rust-pyo3_0.22+hashbrown-devel \
 rust-pyo3_0.22+indexmap-devel \
 rust-pyo3_0.22+macros-devel \
 rust-pyo3_0.22+num-bigint-devel \
 rust-pyo3_0.22+num-complex-devel \
 rust-pyo3_0.22+num-rational-devel \
 rust-pyo3_0.22+py-clone-devel \
 rust-pyo3_0.22+rust_decimal-devel \
 rust-pyo3_0.22+serde-devel \
 rust-pyo3_0.22+smallvec-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+gil-refs-devel = " \
 cargo \
 rust-pyo3-macros0.22+default-devel \
 rust-pyo3-macros0.22+gil-refs-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+hashbrown-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 virtual/crate_hashbrown/default__ge_0.9.0_with_crate_hashbrown/default__lt_0.15.0~ \
 "
RDEPENDS:rust-pyo3_0.22+indexmap-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~ \
 "
RDEPENDS:rust-pyo3_0.22+indoc-devel = " \
 cargo \
 rust-indoc+default-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+macros-devel = " \
 cargo \
 rust-pyo3_0.22+indoc-devel \
 rust-pyo3_0.22+pyo3-macros-devel \
 rust-pyo3_0.22+unindent-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.22+default-devel \
 rust-pyo3-macros0.22+multiple-pymethods-devel \
 rust-pyo3_0.22+inventory-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+nightly-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+py-clone-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-macros0.22+default-devel \
 rust-pyo3_0.22-devel \
 "
RDEPENDS:rust-pyo3_0.22+rust_decimal-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3_0.22+serde-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3_0.22+smallvec-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3_0.22+unindent-devel = " \
 cargo \
 rust-pyo3_0.22-devel \
 rust-unindent+default-devel \
 "
RDEPENDS:rust-pyo3_0.22-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-memoffset+default-devel \
 rust-once_cell+default-devel \
 rust-portable-atomic+default-devel \
 rust-pyo3-build-config0.22+default-devel \
 rust-pyo3-build-config0.22+resolve-config-devel \
 rust-pyo3-ffi0.22+default-devel \
 "
