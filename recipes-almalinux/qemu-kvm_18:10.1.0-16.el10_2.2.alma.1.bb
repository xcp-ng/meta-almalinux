# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qemu-kvm"
PE = "18"
PV = "10.1.0"
PR = "16.el10_2.2.alma.1"
PACKAGES:x86_64_v2 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"
PACKAGES:aarch64 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qemu-kvm-10.1.0-16.el10_2.2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "048892af3c0a1f281b276d649cb39a8da5ecdf078628b76a6614efa906178896"

URI_x86_64_v2_qemu-guest-agent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-guest-agent-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-guest-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-guest-agent}"
SRC_URI[x86_64_v2_qemu-guest-agent.sha256sum] = "f30f0a2d2e7c2e17185774e462f8826bc982ecb9bb99f71abe6ccd048047c5bd"

URI_x86_64_v2_qemu-img = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-img-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-img;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-img}"
SRC_URI[x86_64_v2_qemu-img.sha256sum] = "1e6010e2073e7bef62b7928ca791e5ad9827539981a2c0bb87be47ce3e733151"

URI_x86_64_v2_qemu-kvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm}"
SRC_URI[x86_64_v2_qemu-kvm.sha256sum] = "fe5eab4b074f3ed95e209c160ab1f4c1fdf6b0094f6afc3038b241ec4cab5358"

URI_x86_64_v2_qemu-kvm-audio-pa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-audio-pa-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-audio-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-audio-pa}"
SRC_URI[x86_64_v2_qemu-kvm-audio-pa.sha256sum] = "ef12f07e7d4e774f21abfc64e7d19cf02e955740f7fe0f464dfd653086194924"

URI_x86_64_v2_qemu-kvm-block-blkio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-blkio-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-blkio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-blkio}"
SRC_URI[x86_64_v2_qemu-kvm-block-blkio.sha256sum] = "b21a2e71fb19823dcb66c1d2cc6cbd2a365e5fca501dd3cfb119eefb7479ed3b"

URI_x86_64_v2_qemu-kvm-block-curl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-curl-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-curl}"
SRC_URI[x86_64_v2_qemu-kvm-block-curl.sha256sum] = "a3e034f137eeac882d62ec0102ac48fb02635d9426c85deddc5b54d7648fd57b"

URI_x86_64_v2_qemu-kvm-block-rbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-rbd-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-rbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-rbd}"
SRC_URI[x86_64_v2_qemu-kvm-block-rbd.sha256sum] = "9f46e06b7af76930e971ae866b55232df1350259fedc0290acaf3a3498208917"

URI_x86_64_v2_qemu-kvm-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-common-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-common}"
SRC_URI[x86_64_v2_qemu-kvm-common.sha256sum] = "0df6dc9fedd65d34d14baf6048f8788c74bf1fdd5bdfd85af94c88bec403be13"

URI_x86_64_v2_qemu-kvm-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-core-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-core}"
SRC_URI[x86_64_v2_qemu-kvm-core.sha256sum] = "6503ee05b3e57cf30df72c5305b7804cce61aebe22dc1f24a6f1960e89ee0e5b"

URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu.sha256sum] = "ed546bc43b48c9bfb4833dcfa6d72654ac1789152389ad3cfcf4bc2237053adf"

URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "3664a950889f76f1688f4ef7271507a17de6968f5175c1f99e2f7fc7c629b708"

URI_x86_64_v2_qemu-kvm-device-display-virtio-vga = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-vga-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-vga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-vga}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-vga.sha256sum] = "b7fae50af7cb1046175c7c365c17b8808f7515ff6c1f2dd70bd888ab28f6d43b"

URI_x86_64_v2_qemu-kvm-device-usb-host = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-host-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-host;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-usb-host}"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-host.sha256sum] = "3f4c9d6dac32ff3804ebcf7bc8e1a6f5a22c6800ce361bd60a97315e5620d96a"

URI_x86_64_v2_qemu-kvm-device-usb-redirect = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-redirect-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-usb-redirect}"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-redirect.sha256sum] = "f48bba104d8901da3d9c3fc79a5bd15b53122a1f203048788c7bf019ac4d7bf5"

URI_x86_64_v2_qemu-kvm-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-docs-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-docs}"
SRC_URI[x86_64_v2_qemu-kvm-docs.sha256sum] = "e68ece1bc966e5a8e9c4a3f45dd435412bf9b6e21ebbb512373182b2ef64877c"

URI_x86_64_v2_qemu-kvm-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-tools-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-tools}"
SRC_URI[x86_64_v2_qemu-kvm-tools.sha256sum] = "d54c4a6ad1b684887d39e2d681bd6426cbf7e39ee22783c5101df1fc306303d9"

URI_x86_64_v2_qemu-kvm-ui-egl-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-egl-headless-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-egl-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-egl-headless}"
SRC_URI[x86_64_v2_qemu-kvm-ui-egl-headless.sha256sum] = "14dd886d3dc4a276c0c74d1c70168a235dffd6f8ad7abf4c723c99d90ed92211"

URI_x86_64_v2_qemu-kvm-ui-opengl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-opengl-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-opengl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-opengl}"
SRC_URI[x86_64_v2_qemu-kvm-ui-opengl.sha256sum] = "041838f4af67fb8460eee05e55f37d7514a0b331d2ca0c980df4038aee98930d"

URI_x86_64_v2_qemu-kvm-ui-spice = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-spice-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-spice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-spice}"
SRC_URI[x86_64_v2_qemu-kvm-ui-spice.sha256sum] = "82a50bcbd797a860350c136fc594c1fc0bdd44d32279567c1649a3588b530aa4"

URI_x86_64_v2_qemu-pr-helper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-pr-helper-10.1.0-16.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-pr-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-pr-helper}"
SRC_URI[x86_64_v2_qemu-pr-helper.sha256sum] = "aad95d8618fd7f9a87c038de89b18a3e027293860bb677e2ac6faa77997fbacc"

URI_aarch64_qemu-guest-agent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-guest-agent-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-guest-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-guest-agent}"
SRC_URI[aarch64_qemu-guest-agent.sha256sum] = "bff2c06a1bb2c275086b99be0a16dff3861cd8da51da46eab8e864b8233bd45f"

URI_aarch64_qemu-img = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-img-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-img;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-img}"
SRC_URI[aarch64_qemu-img.sha256sum] = "e2355e4d5d54a6f72c71d8f7dd6fd5d3d55caf30cc4d0bcdb240f3cdf15e4dff"

URI_aarch64_qemu-kvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm}"
SRC_URI[aarch64_qemu-kvm.sha256sum] = "bb2eb429af2d8ff8969fefbe8ba583b139d997be4bf4adf0419626aa43eb04cc"

URI_aarch64_qemu-kvm-audio-pa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-audio-pa-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-audio-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-audio-pa}"
SRC_URI[aarch64_qemu-kvm-audio-pa.sha256sum] = "f255c4a00afe069e372056242c9399d1a3d2b142d92b03bef9453bfc9e251b43"

URI_aarch64_qemu-kvm-block-blkio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-blkio-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-blkio;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-blkio}"
SRC_URI[aarch64_qemu-kvm-block-blkio.sha256sum] = "95aead15ba0437ea06b39520c9cf569918ab7f7aa178f148298d3ef34b7b548e"

URI_aarch64_qemu-kvm-block-curl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-curl-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-curl}"
SRC_URI[aarch64_qemu-kvm-block-curl.sha256sum] = "95bfb7403bdf2c3c1afcf14f739e79f3d43a83dc439e2f7431269fb3064f21dc"

URI_aarch64_qemu-kvm-block-rbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-rbd-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-rbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-rbd}"
SRC_URI[aarch64_qemu-kvm-block-rbd.sha256sum] = "fa7c6a10b78d4128a1fab3838baf6dc5880b65aaa220aaa99e19a04c7683a23a"

URI_aarch64_qemu-kvm-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-common-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-common}"
SRC_URI[aarch64_qemu-kvm-common.sha256sum] = "8e1c4d02e4f79fa9bb742da371e736af0d26aec88223e08dc756931175ef3dc5"

URI_aarch64_qemu-kvm-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-core-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-core}"
SRC_URI[aarch64_qemu-kvm-core.sha256sum] = "5e98ed8174e4c9208dc9d8650cb1c87641a6c5bf0b0564fd494ee3da1d3d7f58"

URI_aarch64_qemu-kvm-device-display-virtio-gpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-display-virtio-gpu}"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu.sha256sum] = "96a6e0f0f213c26c796b1eaac9b343b48edf2286ecbb2dde380a93a7caeac440"

URI_aarch64_qemu-kvm-device-display-virtio-gpu-pci = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-display-virtio-gpu-pci}"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "477f48b2583a8815712dfe12fa2174b4f0c4dcafc59b52f317275a95e1fa9f7c"

URI_aarch64_qemu-kvm-device-usb-host = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-host-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-host;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-usb-host}"
SRC_URI[aarch64_qemu-kvm-device-usb-host.sha256sum] = "672073e6a6fc2fb238993daf4af78bda7147035b5d47022f75f9db668bea2211"

URI_aarch64_qemu-kvm-device-usb-redirect = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-redirect-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-usb-redirect}"
SRC_URI[aarch64_qemu-kvm-device-usb-redirect.sha256sum] = "5ca2be360e48cfbab470d7e9d13874c0157fe5cf9735d21b6c268971e846725f"

URI_aarch64_qemu-kvm-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-docs-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-docs}"
SRC_URI[aarch64_qemu-kvm-docs.sha256sum] = "82fee6dcc8d21706a4116b84fa7980d05e5e05229fbe4e999247030d959893df"

URI_aarch64_qemu-kvm-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-tools-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-tools}"
SRC_URI[aarch64_qemu-kvm-tools.sha256sum] = "f6f46d7eb670837bf83f79e1aa2b4e4eb0e587c11f2d9c2984a391489238a54e"

URI_aarch64_qemu-kvm-ui-spice = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-ui-spice-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-ui-spice;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-ui-spice}"
SRC_URI[aarch64_qemu-kvm-ui-spice.sha256sum] = "14eb5c3309daf6280f19b8b7627268b9b98fc8be70b1e25f88f454be099c2827"

URI_aarch64_qemu-pr-helper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-pr-helper-10.1.0-16.el10_2.2.alma.1.aarch64.rpm;name=aarch64_qemu-pr-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-pr-helper}"
SRC_URI[aarch64_qemu-pr-helper.sha256sum] = "cb4e1a55a99b10d6d1d92ee802c94dbf5a62a69638e5778eeda2b0ea698236f7"

RDEPENDS:qemu-guest-agent = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 liburing \
 numactl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:qemu-img = " \
 glib2 \
 glibc \
 gnutls \
 libaio \
 libgcc \
 libselinux \
 liburing \
 libzstd \
 numactl-libs \
 zlib-ng-compat \
 "
RDEPENDS:qemu-kvm:x86_64_v2 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm:aarch64 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm-audio-pa = " \
 glibc \
 pulseaudio-libs \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-blkio = " \
 glibc \
 libblkio \
 libgcc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-curl = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-block-rbd = " \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-common:x86_64_v2 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 ipxe-roms-qemu \
 libcap-ng \
 libgcc \
 seabios-bin \
 seavgabios-bin \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-common:aarch64 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 libcap-ng \
 libgcc \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-core:x86_64_v2 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-ovmf \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-core:aarch64 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-aarch64 \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-device-display-virtio-gpu = " \
 glibc \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-display-virtio-gpu-pci = " \
 glibc \
 qemu-kvm-common \
 qemu-kvm-device-display-virtio-gpu \
 "
RDEPENDS:qemu-kvm-device-display-virtio-vga = " \
 glibc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-host = " \
 glibc \
 libusb1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-redirect = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 usbredir \
 "
RDEPENDS:qemu-kvm-docs = " \
 "
RDEPENDS:qemu-kvm-tools = " \
 glib2 \
 glibc \
 libgcc \
 libxkbcommon \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-ui-egl-headless = " \
 glibc \
 libepoxy \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 "
RDEPENDS:qemu-kvm-ui-opengl = " \
 glibc \
 libepoxy \
 libgcc \
 mesa-dri-drivers \
 mesa-libEGL \
 mesa-libGL \
 mesa-libgbm \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-ui-spice:x86_64_v2 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 spice-server \
"
RDEPENDS:qemu-kvm-ui-spice:aarch64 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 spice-server \
"
RDEPENDS:qemu-pr-helper = " \
 device-mapper-multipath-libs \
 glib2 \
 glibc \
 gnutls \
 libcap-ng \
 libgcc \
 liburing \
 numactl-libs \
 systemd-libs \
 "
