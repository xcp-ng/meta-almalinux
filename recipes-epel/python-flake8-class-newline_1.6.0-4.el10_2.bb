# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8-class-newline"
PV = "1.6.0"
PR = "4.el10_2"
PACKAGES = " \
 python3-flake8-class-newline \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-flake8-class-newline-1.6.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f67fcfe28ca217ee968659740c9199a762597657e42cbe8ecaef8d3aae33827"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-class-newline-1.6.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8-class-newline;unpack=0"
SRC_URI[x86_64_v2_python3-flake8-class-newline.sha256sum] = "2729246b14d2403772cc91f2ea9b16d19960d969c9eb31def4bb4519d9a396cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-class-newline-1.6.0-4.el10_2.noarch.rpm;name=aarch64_python3-flake8-class-newline;unpack=0"
SRC_URI[aarch64_python3-flake8-class-newline.sha256sum] = "15780322a7ba9fb4bc67c2a02d674c1d008c0ba149ca98e441a5348b7ca9f90c"

RDEPENDS:python3-flake8-class-newline = " \
 python3 \
 python3-flake8 \
 "
