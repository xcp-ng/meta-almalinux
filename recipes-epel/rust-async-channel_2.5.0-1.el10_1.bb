# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-channel"
PV = "2.5.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-channel+default-devel \
 rust-async-channel+portable-atomic-devel \
 rust-async-channel+std-devel \
 rust-async-channel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-channel-2.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ace56259c7e2bc81c18caf9dd812bb47f38e4d30ce0d86582e8902e64d2983e"

URI_x86_64_v2_rust-async-channel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-channel+default-devel-2.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-channel+default-devel}"
SRC_URI[x86_64_v2_rust-async-channel+default-devel.sha256sum] = "057ac0d4af3adbd13372d009a2b797a642e495399063d5da22b8a7d10a83f0a2"

URI_x86_64_v2_rust-async-channel+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-channel+portable-atomic-devel-2.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-channel+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-channel+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-async-channel+portable-atomic-devel.sha256sum] = "2a3a30d4b2a67aebc12370e421656b37fd92d6248a15e8327da8f36b2576d3ea"

URI_x86_64_v2_rust-async-channel+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-channel+std-devel-2.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-channel+std-devel}"
SRC_URI[x86_64_v2_rust-async-channel+std-devel.sha256sum] = "5371f0b69b571e597a22eeba57e80f4cee5d0e2ffe5942b8607f0a1d87027fe6"

URI_x86_64_v2_rust-async-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-channel-devel-2.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-channel-devel}"
SRC_URI[x86_64_v2_rust-async-channel-devel.sha256sum] = "39548365d42880772db2fb1f611a9e94f68651eff322a694915048cf717c3aa7"

URI_aarch64_rust-async-channel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-channel+default-devel-2.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-channel+default-devel}"
SRC_URI[aarch64_rust-async-channel+default-devel.sha256sum] = "4535fa40cf856010c586049507cbd4fef01515e1a44cf25e88f457bf3c370a80"

URI_aarch64_rust-async-channel+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-channel+portable-atomic-devel-2.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-channel+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-channel+portable-atomic-devel}"
SRC_URI[aarch64_rust-async-channel+portable-atomic-devel.sha256sum] = "70f81660575f82e5ef94a2a19a3853597ee40b35c2383015e81f86ed9509f921"

URI_aarch64_rust-async-channel+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-channel+std-devel-2.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-channel+std-devel}"
SRC_URI[aarch64_rust-async-channel+std-devel.sha256sum] = "f2aacb5d19f3cc70ea5dae64a39ee86a8a79d5da6e14218c8613bd22aff134eb"

URI_aarch64_rust-async-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-channel-devel-2.5.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-channel-devel}"
SRC_URI[aarch64_rust-async-channel-devel.sha256sum] = "287fc263ef80e2caaa6e53150493f9c32b706bf3a01b9172363ac659f7d93125"

RDEPENDS:rust-async-channel+default-devel = " \
 cargo \
 rust-async-channel+std-devel \
 rust-async-channel-devel \
 "
RDEPENDS:rust-async-channel+portable-atomic-devel = " \
 cargo \
 rust-async-channel-devel \
 rust-concurrent-queue+portable-atomic-devel \
 rust-event-listener-strategy+portable-atomic-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-async-channel+std-devel = " \
 cargo \
 rust-async-channel-devel \
 rust-concurrent-queue+std-devel \
 rust-event-listener-strategy+std-devel \
 "
RDEPENDS:rust-async-channel-devel = " \
 cargo \
 rust \
 rust-concurrent-queue-devel \
 rust-event-listener-strategy-devel \
 rust-futures-core-devel \
 rust-pin-project-lite+default-devel \
 "
