# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fmt"
PV = "11.0.2"
PR = "1.el10_0"
PACKAGES = " \
 fmt \
 fmt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fmt-11.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9bb999b971abc8c27d36d30b61c4433577353b9822ba0131cfec502c14e97c2"

URI_x86_64_v2_fmt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fmt-11.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fmt}"
SRC_URI[x86_64_v2_fmt.sha256sum] = "6dbbfb99fb56a190a1318aa387744ca983087d0a1a707d51385d03830d215b0e"

URI_x86_64_v2_fmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fmt-devel-11.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fmt-devel}"
SRC_URI[x86_64_v2_fmt-devel.sha256sum] = "56c7abbca7ee17d5b3cf3d83afaa84fb60f2dacf0c96fbd2e470b9e735bd2b8c"

URI_aarch64_fmt = "${EPEL_MIRROR}/aarch64/Packages/f/fmt-11.0.2-1.el10_0.aarch64.rpm;name=aarch64_fmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_fmt}"
SRC_URI[aarch64_fmt.sha256sum] = "949134527021226492381163c6a11b278df1cc62d0de201af2cc0b3eabb9867f"

URI_aarch64_fmt-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fmt-devel-11.0.2-1.el10_0.aarch64.rpm;name=aarch64_fmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fmt-devel}"
SRC_URI[aarch64_fmt-devel.sha256sum] = "3fa2eb1075d012e3278738d6de6259cc5fa50b02cc80d095600363de848aab8f"

RDEPENDS:fmt = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:fmt-devel = " \
 cmake-filesystem \
 fmt \
 pkgconf-pkg-config \
 "
