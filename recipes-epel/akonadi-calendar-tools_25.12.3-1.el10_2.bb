# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar-tools"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 akonadi-calendar-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-tools-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f74fcb6e4f796b9bc8b92690b5bb3aedd9eea5570c3000cd4e0e30b4b5d696af"

URI_x86_64_v2_akonadi-calendar-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-tools-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-tools}"
SRC_URI[x86_64_v2_akonadi-calendar-tools.sha256sum] = "1d24732dfad918c850281c3d6dec6907b6ac358b7a168c11e0f4eeb35ed3a711"

URI_aarch64_akonadi-calendar-tools = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-tools-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-calendar-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-tools}"
SRC_URI[aarch64_akonadi-calendar-tools.sha256sum] = "95f4a9e585c3ff8aa67d956c710814fc2b39e9c19759f9ef59fcb40fff616130"

RDEPENDS:akonadi-calendar-tools = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kf6-kcalendarcore \
 kf6-kcoreaddons \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
