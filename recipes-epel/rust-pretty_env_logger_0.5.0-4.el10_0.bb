# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pretty_env_logger"
PV = "0.5.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-pretty_env_logger+default-devel \
 rust-pretty_env_logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pretty_env_logger-0.5.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "447b6babfb61a640b397138853b6ad69fc0b0941b1548b8a4e6e4552ff5b2efa"

URI_x86_64_v2_rust-pretty_env_logger+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty_env_logger+default-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty_env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty_env_logger+default-devel}"
SRC_URI[x86_64_v2_rust-pretty_env_logger+default-devel.sha256sum] = "f4b8c3c45798b13ecb26ada7040d3024931f62ad3973648802d59aaf063ff9c7"

URI_x86_64_v2_rust-pretty_env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty_env_logger-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty_env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty_env_logger-devel}"
SRC_URI[x86_64_v2_rust-pretty_env_logger-devel.sha256sum] = "1f7e6da0c34ee0fd1832516a64c25ecee2c11ef5cb1621e44c8082c9f95e46c6"

URI_aarch64_rust-pretty_env_logger+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty_env_logger+default-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-pretty_env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty_env_logger+default-devel}"
SRC_URI[aarch64_rust-pretty_env_logger+default-devel.sha256sum] = "5f05bd3202908c89add4572c1cbe65433327a8ec5e09d197de3b743045fa9c22"

URI_aarch64_rust-pretty_env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty_env_logger-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-pretty_env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty_env_logger-devel}"
SRC_URI[aarch64_rust-pretty_env_logger-devel.sha256sum] = "81afb2600e6f6aebe242eb1b4099e78dd4dff9a33a5645ef0c27bf43f4076f7c"

RDEPENDS:rust-pretty_env_logger+default-devel = " \
 cargo \
 rust-pretty_env_logger-devel \
 "
RDEPENDS:rust-pretty_env_logger-devel = " \
 cargo \
 rust-env_logger0.10+default-devel \
 rust-log+default-devel \
 "
