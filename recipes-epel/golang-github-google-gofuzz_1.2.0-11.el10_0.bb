# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-google-gofuzz"
PV = "1.2.0"
PR = "11.el10_0"
PACKAGES = " \
 golang-github-google-gofuzz-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-google-gofuzz-1.2.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ca502972d16951382885a677641751d4922d123bf0e70fb250f79881d85b83bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-google-gofuzz-devel-1.2.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-google-gofuzz-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-google-gofuzz-devel.sha256sum] = "687e55a112ab87a767da78eb9ae168b6c15ca015e03800165a160f9e388f16bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-gofuzz-devel-1.2.0-11.el10_0.noarch.rpm;name=aarch64_golang-github-google-gofuzz-devel;unpack=0"
SRC_URI[aarch64_golang-github-google-gofuzz-devel.sha256sum] = "6e69d6177e8df90c17e14e9f7a571ff763e1585b83bba793ea3ba39bbb8372bc"

RDEPENDS:golang-github-google-gofuzz-devel = " \
 go-filesystem \
 "
