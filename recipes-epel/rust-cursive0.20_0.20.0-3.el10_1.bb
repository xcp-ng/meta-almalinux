# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive0.20"
PV = "0.20.0"
PR = "3.el10_1"
PACKAGES = " \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20+crossterm-devel \
 rust-cursive0.20+default-devel \
 rust-cursive0.20+doc-cfg-devel \
 rust-cursive0.20+maplit-devel \
 rust-cursive0.20+term_size-devel \
 rust-cursive0.20+termion-backend-devel \
 rust-cursive0.20+termion-devel \
 rust-cursive0.20+toml-devel \
 rust-cursive0.20+unstable_scroll-devel \
 rust-cursive0.20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive0.20-0.20.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "437f810b398cb6b5291cce1daa6e14e0ba113d81acef3486712686303cef4d34"

URI_x86_64_v2_rust-cursive0.20+crossterm-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+crossterm-backend-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+crossterm-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+crossterm-backend-devel.sha256sum] = "87f52bd291cfea0dbb92e856cbdf7898545e320956bd0afcc2388efb338b0ce4"

URI_x86_64_v2_rust-cursive0.20+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+crossterm-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+crossterm-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+crossterm-devel.sha256sum] = "f441b8da1bdde6a6c94206eebe76997a57e5a4ba7643d6d1219605fb280a60ea"

URI_x86_64_v2_rust-cursive0.20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+default-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+default-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+default-devel.sha256sum] = "b38342813c55547bc10794ddeecff20658d6f43688682eaa32894db4193a6413"

URI_x86_64_v2_rust-cursive0.20+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+doc-cfg-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+doc-cfg-devel.sha256sum] = "7c830d2f9faa9c592739f5b18479eab85703e5686d45c559c1cf7bdc96ce5737"

URI_x86_64_v2_rust-cursive0.20+maplit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+maplit-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+maplit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+maplit-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+maplit-devel.sha256sum] = "e202138a85466ff6e8579aea160696944cd33e85f45753021c615baed45bd1a4"

URI_x86_64_v2_rust-cursive0.20+term_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+term_size-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+term_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+term_size-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+term_size-devel.sha256sum] = "9de3cec2c6f098c501dc7ac418a2cfec5503c32dff26a6a13b46d7a7375cd12b"

URI_x86_64_v2_rust-cursive0.20+termion-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+termion-backend-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+termion-backend-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+termion-backend-devel.sha256sum] = "e02116940ede01c83f8e646c33b385a9638e5c3f99b49c50767d7b3aa226cecd"

URI_x86_64_v2_rust-cursive0.20+termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+termion-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+termion-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+termion-devel.sha256sum] = "03f1b42fb809665f1c516b4c4dfc65af2240af80e6905da778df80bcee1fc54f"

URI_x86_64_v2_rust-cursive0.20+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+toml-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+toml-devel.sha256sum] = "ee01bc8a27a88b345e2586566d851f10dda1f0898de8f0d33e02816d00fe5da4"

URI_x86_64_v2_rust-cursive0.20+unstable_scroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20+unstable_scroll-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20+unstable_scroll-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20+unstable_scroll-devel.sha256sum] = "8d6763bb28942568150663be6e716bc87de89002d3269abc285ff0666a3b4ec4"

URI_x86_64_v2_rust-cursive0.20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive0.20-devel-0.20.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive0.20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive0.20-devel}"
SRC_URI[x86_64_v2_rust-cursive0.20-devel.sha256sum] = "fa77481b03c222860f361058b7f6eec055fc98c2d9edb4e31753ccec2d877286"

URI_aarch64_rust-cursive0.20+crossterm-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+crossterm-backend-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+crossterm-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+crossterm-backend-devel}"
SRC_URI[aarch64_rust-cursive0.20+crossterm-backend-devel.sha256sum] = "79fd3a76fab9f86081c554bd45acdf6299f5e4cefdd9a1e132b07fdd00cf6e4d"

URI_aarch64_rust-cursive0.20+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+crossterm-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+crossterm-devel}"
SRC_URI[aarch64_rust-cursive0.20+crossterm-devel.sha256sum] = "cbde5b2246ea24d065d5124ff7e74b000917c1ad0d6151e5fad1cf39f4cf432d"

URI_aarch64_rust-cursive0.20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+default-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+default-devel}"
SRC_URI[aarch64_rust-cursive0.20+default-devel.sha256sum] = "255da9f71702087dba43f481f9aa25a31e140df37c91c3ec91c648d0eb335fa3"

URI_aarch64_rust-cursive0.20+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+doc-cfg-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive0.20+doc-cfg-devel.sha256sum] = "7fd1ee0cc0db3f209ffda726b6ee3d7466c582ec1d4bffb1aceca3f5f4e984af"

URI_aarch64_rust-cursive0.20+maplit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+maplit-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+maplit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+maplit-devel}"
SRC_URI[aarch64_rust-cursive0.20+maplit-devel.sha256sum] = "d2d115b0e60a6c2e9745c1d47ea4ff2cd61b26ffb4c067aaa37c4f9910de40b5"

URI_aarch64_rust-cursive0.20+term_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+term_size-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+term_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+term_size-devel}"
SRC_URI[aarch64_rust-cursive0.20+term_size-devel.sha256sum] = "0978b39d32b510f7e4aeea1998f28c0349502589f795a5ebce9a314646016a33"

URI_aarch64_rust-cursive0.20+termion-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+termion-backend-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+termion-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+termion-backend-devel}"
SRC_URI[aarch64_rust-cursive0.20+termion-backend-devel.sha256sum] = "dc8863d2747af6b834dbc6118e65196412e2599c16c4647109de651887a35c95"

URI_aarch64_rust-cursive0.20+termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+termion-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+termion-devel}"
SRC_URI[aarch64_rust-cursive0.20+termion-devel.sha256sum] = "3dfdfbe1bd00a662bd7ddd41e6f90eed23cbbbc3e0c3089d43ee91ec820ae50d"

URI_aarch64_rust-cursive0.20+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+toml-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+toml-devel}"
SRC_URI[aarch64_rust-cursive0.20+toml-devel.sha256sum] = "6b8407ad0f624f851d2a713aac095c7b8c1d4b80f5d86aa4d7239440d861ed42"

URI_aarch64_rust-cursive0.20+unstable_scroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20+unstable_scroll-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20+unstable_scroll-devel}"
SRC_URI[aarch64_rust-cursive0.20+unstable_scroll-devel.sha256sum] = "d5df60e305acff71eaee234987a348edd5a5f7a0fbd923acab2a946c6f825191"

URI_aarch64_rust-cursive0.20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive0.20-devel-0.20.0-3.el10_1.noarch.rpm;name=aarch64_rust-cursive0.20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive0.20-devel}"
SRC_URI[aarch64_rust-cursive0.20-devel.sha256sum] = "d1c7072e6cc273763c0cf026de5edea9a4f381a76fcf8989751969c8fe4661aa"

RDEPENDS:rust-cursive0.20+crossterm-backend-devel = " \
 cargo \
 rust-cursive0.20+crossterm-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+crossterm-devel = " \
 cargo \
 rust-crossterm0.25+default-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+default-devel = " \
 cargo \
 rust-cursive0.20+crossterm-backend-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+doc-cfg-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-cursive_core0.3+doc-cfg-devel \
 "
RDEPENDS:rust-cursive0.20+maplit-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-maplit+default-devel \
 "
RDEPENDS:rust-cursive0.20+term_size-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-term_size+default-devel \
 "
RDEPENDS:rust-cursive0.20+termion-backend-devel = " \
 cargo \
 rust-cursive0.20+termion-devel \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20+termion-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-termion+default-devel \
 "
RDEPENDS:rust-cursive0.20+toml-devel = " \
 cargo \
 rust-cursive0.20-devel \
 rust-cursive_core0.3+toml-devel \
 "
RDEPENDS:rust-cursive0.20+unstable_scroll-devel = " \
 cargo \
 rust-cursive0.20-devel \
 "
RDEPENDS:rust-cursive0.20-devel = " \
 cargo \
 rust-ahash+default-devel \
 rust-cfg-if+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-cursive_core0.3+default-devel \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-signal-hook+default-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 "
