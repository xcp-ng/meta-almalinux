# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "anaconda"
PV = "40.22.3.26"
PR = "1.el10_0.alma.1"
PACKAGES = " \
 anaconda \
 anaconda-core \
 anaconda-dracut \
 anaconda-gui \
 anaconda-install-env-deps \
 anaconda-install-img-deps \
 anaconda-tui \
 anaconda-widgets \
 anaconda-widgets-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/anaconda-40.22.3.26-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93a029a362cadcb7bccc046d74b6d5892944eb2669b03a4a6ecea61a635cd910"

URI_x86_64_v2_anaconda = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda}"
SRC_URI[x86_64_v2_anaconda.sha256sum] = "9f691e4c0b27d864d62a4af275071023a6f719157676656582abab12d8903991"

URI_x86_64_v2_anaconda-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-core-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-core}"
SRC_URI[x86_64_v2_anaconda-core.sha256sum] = "4e271a00182025350c158579d0546cea0f5b2ba6270742712cc0bc67dac47dff"

URI_x86_64_v2_anaconda-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-dracut-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-dracut}"
SRC_URI[x86_64_v2_anaconda-dracut.sha256sum] = "462163ec13209895a8ee53cfd074a20b14f253ae84fc8ece32b5b1febdda02fa"

URI_x86_64_v2_anaconda-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-gui-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-gui}"
SRC_URI[x86_64_v2_anaconda-gui.sha256sum] = "52c711bb79c311add14c905d1b843f6c02ac92fa0bb0b9d02d12c3af75a5ad8c"

URI_x86_64_v2_anaconda-install-env-deps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-env-deps-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-env-deps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-install-env-deps}"
SRC_URI[x86_64_v2_anaconda-install-env-deps.sha256sum] = "ac5da01ec784dcdea7804edcb07c892ae0135f3e4848657b85c97255279c0705"

URI_x86_64_v2_anaconda-install-img-deps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-img-deps-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-img-deps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-install-img-deps}"
SRC_URI[x86_64_v2_anaconda-install-img-deps.sha256sum] = "19ef0011af893d4782a31cb3f7226047f28790fc55a8a1dffd79edc0009f5e9e"

URI_x86_64_v2_anaconda-tui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-tui-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-tui}"
SRC_URI[x86_64_v2_anaconda-tui.sha256sum] = "f9481d3d12d5af1c468b05618d4e36c8e8968a139af7c9ab60b38a95e02afb20"

URI_x86_64_v2_anaconda-widgets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-widgets-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-widgets}"
SRC_URI[x86_64_v2_anaconda-widgets.sha256sum] = "7f02061d433775c53a335e573fb0a2a7894cb20506a23776426961c354107b1e"

URI_x86_64_v2_anaconda-widgets-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/anaconda-widgets-devel-40.22.3.26-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_anaconda-widgets-devel}"
SRC_URI[x86_64_v2_anaconda-widgets-devel.sha256sum] = "5723b8ec378ff1ec193e32df3969ea1f865edd78098a50fdd32dc3f6c27ba414"

URI_aarch64_anaconda = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-40.22.3.26-1.el10_0.alma.1.aarch64.rpm;name=aarch64_anaconda;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda}"
SRC_URI[aarch64_anaconda.sha256sum] = "497298064c7cfdf37bc56315f60d0735dca793003cb3e8a036126dfb67f5906d"

URI_aarch64_anaconda-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-core-40.22.3.26-1.el10_0.alma.1.aarch64.rpm;name=aarch64_anaconda-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-core}"
SRC_URI[aarch64_anaconda-core.sha256sum] = "0320f4d2a9d14a4c7bb46771fc5c8c07f416144691d51c95f2bbf53a49eba26f"

URI_aarch64_anaconda-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-dracut-40.22.3.26-1.el10_0.alma.1.aarch64.rpm;name=aarch64_anaconda-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-dracut}"
SRC_URI[aarch64_anaconda-dracut.sha256sum] = "cf6cc9ca1aef21d608da65a27386ce9b077272924469c4d5562f202a83fb0315"

URI_aarch64_anaconda-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-gui-40.22.3.26-1.el10_0.alma.1.aarch64.rpm;name=aarch64_anaconda-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-gui}"
SRC_URI[aarch64_anaconda-gui.sha256sum] = "6ea3be4e839be0bac7801d36ecca1fb2af522a38dd2130881a7f5bc2bcb602ba"

URI_aarch64_anaconda-install-env-deps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-env-deps-40.22.3.26-1.el10_0.alma.1.aarch64.rpm;name=aarch64_anaconda-install-env-deps;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-install-env-deps}"
SRC_URI[aarch64_anaconda-install-env-deps.sha256sum] = "09c472911f03b34d15e0a1366e5a7d92d83604438790c3e5b6f3352ccf5221ae"

URI_aarch64_anaconda-install-img-deps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-img-deps-40.22.3.26-1.el10_0.alma.1.aarch64.rpm;name=aarch64_anaconda-install-img-deps;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-install-img-deps}"
SRC_URI[aarch64_anaconda-install-img-deps.sha256sum] = "2e19452fe084cbf1b99469ecae346b1be7886cd8a7297fdadd7f0818864b9343"

URI_aarch64_anaconda-tui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-tui-40.22.3.26-1.el10_0.alma.1.aarch64.rpm;name=aarch64_anaconda-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-tui}"
SRC_URI[aarch64_anaconda-tui.sha256sum] = "3d07aca314225971532f1e4b96baeb220274a3e917ab1e1a97caa188fb711223"

URI_aarch64_anaconda-widgets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-widgets-40.22.3.26-1.el10_0.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-widgets}"
SRC_URI[aarch64_anaconda-widgets.sha256sum] = "52b7e35069d05cc98cafb8d1ecc251bdb933b54895190702b0a8c0b406dc7586"

URI_aarch64_anaconda-widgets-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/anaconda-widgets-devel-40.22.3.26-1.el10_0.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_anaconda-widgets-devel}"
SRC_URI[aarch64_anaconda-widgets-devel.sha256sum] = "ed75f5af427bbfe15225bffa320b380a4b56c0ac553c6d52f058c90feb85a560"

RDEPENDS:anaconda = " \
 anaconda-gui \
 anaconda-tui \
 "
RDEPENDS:anaconda-core = " \
 NetworkManager \
 NetworkManager-libnm \
 anaconda-tui \
 bash \
 chrony \
 cracklib-dicts \
 crypto-policies \
 crypto-policies-scripts \
 dbus-daemon \
 flatpak-libs \
 kbd \
 python3 \
 python3-blivet \
 python3-blockdev \
 python3-dasbus \
 python3-dnf \
 python3-gobject-base \
 python3-kickstart \
 python3-langtable \
 python3-libs \
 python3-libselinux \
 python3-meh \
 python3-pid \
 python3-productmd \
 python3-pwquality \
 python3-pyparted \
 python3-requests \
 python3-requests-file \
 python3-requests-ftp \
 python3-rpm \
 python3-systemd \
 systemd \
 util-linux \
 virtual//usr/bin/date \
 virtual/glibc-langpack-en_or_glibc-all-langpacks \
 "
RDEPENDS:anaconda-dracut = " \
 bash \
 dnsconfd \
 dnsconfd-dracut \
 dracut \
 dracut-live \
 dracut-network \
 glibc \
 iputils \
 libarchive \
 python3 \
 python3-kickstart \
 rpm-libs \
 xz \
 "
RDEPENDS:anaconda-gui = " \
 NetworkManager-wifi \
 adwaita-icon-theme \
 almalinux-logos \
 anaconda-core \
 anaconda-widgets \
 nm-connection-editor \
 python3 \
 python3-iso639 \
 python3-meh-gui \
 python3-xkbregistry \
 tecla \
 "
RDEPENDS:anaconda-install-env-deps = " \
 dosfstools \
 e2fsprogs \
 gdb \
 isomd5sum \
 kexec-tools \
 libblockdev-plugins-all \
 realmd \
 rsync \
 tmux \
 udisks2-iscsi \
 xfsprogs \
 "
RDEPENDS:anaconda-install-img-deps:x86_64_v2 = " \
 anaconda-install-env-deps \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 fcoe-utils \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 python3-pam \
 rpm-ostree \
 skopeo \
 zram-generator \
"
RDEPENDS:anaconda-install-img-deps:aarch64 = " \
 anaconda-install-env-deps \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 python3-pam \
 rpm-ostree \
 skopeo \
 zram-generator \
"
RDEPENDS:anaconda-tui = " \
 anaconda-core \
 python3 \
 python3-simpleline \
 "
RDEPENDS:anaconda-widgets = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 pango \
 python3 \
 "
RDEPENDS:anaconda-widgets-devel = " \
 anaconda-widgets \
 "
