# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vsomeip3"
PV = "3.5.11"
PR = "6.el10_1"
PACKAGES = " \
 vsomeip3 \
 vsomeip3-compat \
 vsomeip3-compat-devel \
 vsomeip3-devel \
 vsomeip3-examples \
 vsomeip3-routingmanager \
 vsomeip3-selinux \
 vsomeip3-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vsomeip3-3.5.11-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d38e6cf43cfb2ba5d6217d7c8a7306957de9faabc2c3980f90c722a2d020f2e"

URI_x86_64_v2_vsomeip3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-3.5.11-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3}"
SRC_URI[x86_64_v2_vsomeip3.sha256sum] = "084c60bdf64d7ed88a43246fca25ce5442c10581707af4dde4f0cff6081c8885"

URI_x86_64_v2_vsomeip3-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-compat-3.5.11-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-compat}"
SRC_URI[x86_64_v2_vsomeip3-compat.sha256sum] = "4a1e9031d03ac23fe014c7f67d5718ac8cebfe9cb6c9364d330f86023751fd46"

URI_x86_64_v2_vsomeip3-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-compat-devel-3.5.11-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-compat-devel}"
SRC_URI[x86_64_v2_vsomeip3-compat-devel.sha256sum] = "c58ef90bdc7bd30f201e191abbdc1d1643cf7321ed05e8a2d5dd2b5ce7b064fd"

URI_x86_64_v2_vsomeip3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-devel-3.5.11-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-devel}"
SRC_URI[x86_64_v2_vsomeip3-devel.sha256sum] = "bf5834e0b40f51dfb688e1cc388417b0a442041708585f9a004ef306cc87812e"

URI_x86_64_v2_vsomeip3-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-examples-3.5.11-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-examples}"
SRC_URI[x86_64_v2_vsomeip3-examples.sha256sum] = "f53159621225fe727c0a0b9d1c5f83def7f721de6fbdba3984f08273e321e8a6"

URI_x86_64_v2_vsomeip3-routingmanager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-routingmanager-3.5.11-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-routingmanager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-routingmanager}"
SRC_URI[x86_64_v2_vsomeip3-routingmanager.sha256sum] = "f2d68abd651a4c5feee92689e49ae9f0458d89f72d0ba16b8ba8aec8abb97fec"

URI_x86_64_v2_vsomeip3-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-selinux-3.5.11-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_vsomeip3-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-selinux}"
SRC_URI[x86_64_v2_vsomeip3-selinux.sha256sum] = "8c881509d20ff6d1b6a666de9d918b6f3d330872bb0e586fdb7a3a13ee103f64"

URI_x86_64_v2_vsomeip3-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-tools-3.5.11-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-tools}"
SRC_URI[x86_64_v2_vsomeip3-tools.sha256sum] = "0ac59992ad5c5c2a6324a5b2113174bc1d5c5b383405fe44b16614d7817165c9"

URI_aarch64_vsomeip3 = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-3.5.11-6.el10_1.aarch64.rpm;name=aarch64_vsomeip3;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3}"
SRC_URI[aarch64_vsomeip3.sha256sum] = "7df1e1f0b9e64430166b4fa70cf42e9aea9708911f79e6721bf3d971502281e8"

URI_aarch64_vsomeip3-compat = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-compat-3.5.11-6.el10_1.aarch64.rpm;name=aarch64_vsomeip3-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-compat}"
SRC_URI[aarch64_vsomeip3-compat.sha256sum] = "c0a1b82a8f4aebe497c9449f1c30136e4cfec1096cd10f611ec64d8e83a33a12"

URI_aarch64_vsomeip3-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-compat-devel-3.5.11-6.el10_1.aarch64.rpm;name=aarch64_vsomeip3-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-compat-devel}"
SRC_URI[aarch64_vsomeip3-compat-devel.sha256sum] = "853673bb649bc38080bc7039c0d4a1a704a15cdc9841ed6c9a902bec4c1df154"

URI_aarch64_vsomeip3-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-devel-3.5.11-6.el10_1.aarch64.rpm;name=aarch64_vsomeip3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-devel}"
SRC_URI[aarch64_vsomeip3-devel.sha256sum] = "d08512d93fb6f043310d596c49d991157e46cddbb6fba47aa6b55203333cbb92"

URI_aarch64_vsomeip3-examples = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-examples-3.5.11-6.el10_1.aarch64.rpm;name=aarch64_vsomeip3-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-examples}"
SRC_URI[aarch64_vsomeip3-examples.sha256sum] = "44b5a35500c24aa74639812ceddad245b3349bf2013ac3b2fee846af3daccef2"

URI_aarch64_vsomeip3-routingmanager = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-routingmanager-3.5.11-6.el10_1.aarch64.rpm;name=aarch64_vsomeip3-routingmanager;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-routingmanager}"
SRC_URI[aarch64_vsomeip3-routingmanager.sha256sum] = "fa16f432e6a975bc34765a0729d46e955e5e38b42ffea0af5b02def6bd034029"

URI_aarch64_vsomeip3-selinux = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-selinux-3.5.11-6.el10_1.noarch.rpm;name=aarch64_vsomeip3-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-selinux}"
SRC_URI[aarch64_vsomeip3-selinux.sha256sum] = "c05e888ec112cabd2facb9c750e363c27c8ae414d52f0f4ca4fd29d718aba50f"

URI_aarch64_vsomeip3-tools = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-tools-3.5.11-6.el10_1.aarch64.rpm;name=aarch64_vsomeip3-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-tools}"
SRC_URI[aarch64_vsomeip3-tools.sha256sum] = "6d29c1ceccaa18c7ef8c6f4fef1ef49ec83d2bfc407cc2d246f4c6e41a1d31bb"

RDEPENDS:vsomeip3 = " \
 boost-filesystem \
 boost-thread \
 dlt-libs \
 glibc \
 libgcc \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:vsomeip3-compat = " \
 glibc \
 libgcc \
 libstdc++ \
 vsomeip3 \
 "
RDEPENDS:vsomeip3-compat-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 vsomeip3-compat \
 "
RDEPENDS:vsomeip3-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 vsomeip3 \
 "
RDEPENDS:vsomeip3-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 vsomeip3 \
 "
RDEPENDS:vsomeip3-routingmanager = " \
 bash \
 dlt-daemon \
 dlt-libs \
 glibc \
 libgcc \
 libstdc++ \
 systemd \
 vsomeip3 \
 "
RDEPENDS:vsomeip3-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.7 \
 "
RDEPENDS:vsomeip3-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 vsomeip3 \
 "
