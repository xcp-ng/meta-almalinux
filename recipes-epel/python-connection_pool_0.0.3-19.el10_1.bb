# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-connection_pool"
PV = "0.0.3"
PR = "19.el10_1"
PACKAGES = " \
 python3-connection-pool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-connection_pool-0.0.3-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52fc45f2e9f67f974c60ce5aa53b966231ef3a0a6812127c5123a532163015af"

URI_x86_64_v2_python3-connection-pool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-connection-pool-0.0.3-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-connection-pool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-connection-pool}"
SRC_URI[x86_64_v2_python3-connection-pool.sha256sum] = "bdb5dcc82ab1cb4f79b6c63c39c72a7f0ed4b7f8244aebe23ab13bf32233fdc1"

URI_aarch64_python3-connection-pool = "${EPEL_MIRROR}/aarch64/Packages/p/python3-connection-pool-0.0.3-19.el10_1.noarch.rpm;name=aarch64_python3-connection-pool;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-connection-pool}"
SRC_URI[aarch64_python3-connection-pool.sha256sum] = "2bec061e708f8b08591e09cfa6fd5cab909f4c785be78e4c91855d1a9aedce26"

RDEPENDS:python3-connection-pool = " \
 python3 \
 "
