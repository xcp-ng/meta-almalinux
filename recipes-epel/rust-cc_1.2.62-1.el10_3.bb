# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cc"
PV = "1.2.62"
PR = "1.el10_3"
PACKAGES = " \
 rust-cc+default-devel \
 rust-cc+jobserver-devel \
 rust-cc+parallel-devel \
 rust-cc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cc-1.2.62-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2df2f3d6e3e11fb4e2eebeb84ea3a3608beb8ae530a35a8aca4902127557361"

URI_x86_64_v2_rust-cc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+default-devel-1.2.62-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+default-devel}"
SRC_URI[x86_64_v2_rust-cc+default-devel.sha256sum] = "b04370de7a1fdeb3541f48a64acd407f8b118f15bf7f2290f64f9f56d59309a8"

URI_x86_64_v2_rust-cc+jobserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+jobserver-devel-1.2.62-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+jobserver-devel}"
SRC_URI[x86_64_v2_rust-cc+jobserver-devel.sha256sum] = "fba9de34d09dce13b99dfb9a4439582b3e7f9e468905609c38c5f31a543c901e"

URI_x86_64_v2_rust-cc+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+parallel-devel-1.2.62-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+parallel-devel}"
SRC_URI[x86_64_v2_rust-cc+parallel-devel.sha256sum] = "7e049c389b369bc84a6076da400cdb45d514e6d0f1572f0fb5ada6c9d8f9c91d"

URI_x86_64_v2_rust-cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc-devel-1.2.62-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc-devel}"
SRC_URI[x86_64_v2_rust-cc-devel.sha256sum] = "7219806db373ea0285502f55bcaa944e87c8d8ddcd0409b9fb2516e21542c827"

URI_aarch64_rust-cc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+default-devel-1.2.62-1.el10_3.noarch.rpm;name=aarch64_rust-cc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+default-devel}"
SRC_URI[aarch64_rust-cc+default-devel.sha256sum] = "8ba77e544a65f82c6e0949c8a4e93f9a85f7b29f5a5894ee342c2f6b9dfb6ed8"

URI_aarch64_rust-cc+jobserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+jobserver-devel-1.2.62-1.el10_3.noarch.rpm;name=aarch64_rust-cc+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+jobserver-devel}"
SRC_URI[aarch64_rust-cc+jobserver-devel.sha256sum] = "491026714a984d4d34712a5489dca17a0a715b3c7680174e02db71fd0bb362ff"

URI_aarch64_rust-cc+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+parallel-devel-1.2.62-1.el10_3.noarch.rpm;name=aarch64_rust-cc+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+parallel-devel}"
SRC_URI[aarch64_rust-cc+parallel-devel.sha256sum] = "659e6de01c3a02f6b29ae7641a859ee5660bd0602b056eb44e56e294c1aaaf64"

URI_aarch64_rust-cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc-devel-1.2.62-1.el10_3.noarch.rpm;name=aarch64_rust-cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc-devel}"
SRC_URI[aarch64_rust-cc-devel.sha256sum] = "ae56a648ad1f1e1841aa23aa6db5f22592c9b9589f329ae34756810818c7415f"

RDEPENDS:rust-cc+default-devel = " \
 cargo \
 rust-cc-devel \
 "
RDEPENDS:rust-cc+jobserver-devel = " \
 cargo \
 rust-cc-devel \
 "
RDEPENDS:rust-cc+parallel-devel = " \
 cargo \
 rust-cc-devel \
 rust-jobserver-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-cc-devel = " \
 cargo \
 gcc \
 gcc-c++ \
 rust \
 rust-find-msvc-tools+default-devel \
 rust-shlex+default-devel \
 "
