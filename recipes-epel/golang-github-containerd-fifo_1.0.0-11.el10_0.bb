# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-containerd-fifo"
PV = "1.0.0"
PR = "11.el10_0"
PACKAGES = " \
 golang-github-containerd-fifo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-containerd-fifo-1.0.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e030af4f2c23520a60cd7d05f0c9686e356b37be9f0da69cea5052c69aee581"

URI_x86_64_v2_golang-github-containerd-fifo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-containerd-fifo-devel-1.0.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-containerd-fifo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-containerd-fifo-devel}"
SRC_URI[x86_64_v2_golang-github-containerd-fifo-devel.sha256sum] = "c7d81cce04b1baa35562cb16f9cabec2ce27535825ce1305b7a486e55a143ba7"

URI_aarch64_golang-github-containerd-fifo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-containerd-fifo-devel-1.0.0-11.el10_0.noarch.rpm;name=aarch64_golang-github-containerd-fifo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-containerd-fifo-devel}"
SRC_URI[aarch64_golang-github-containerd-fifo-devel.sha256sum] = "27707b0feb4def1c1cf3300b3abe6ffb422a3b6b123b7d5450665cff56aea883"

RDEPENDS:golang-github-containerd-fifo-devel = " \
 go-filesystem \
 golang-github-pkg-errors-devel \
 golang-x-sys-devel \
 "
