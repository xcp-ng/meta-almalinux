# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tinycss2"
PV = "1.4.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-tinycss2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tinycss2-1.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c1b3b3ac13a441ea9ead86d00cca232ad6fdc65f44a4cfd8a6d46a7ff2921bf"

URI_x86_64_v2_python3-tinycss2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tinycss2-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tinycss2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tinycss2}"
SRC_URI[x86_64_v2_python3-tinycss2.sha256sum] = "0dcf6daf566553fb68c921e87ab04f7865cb585258002e4afcc64a68393c20c9"

URI_aarch64_python3-tinycss2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tinycss2-1.4.0-1.el10_1.noarch.rpm;name=aarch64_python3-tinycss2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tinycss2}"
SRC_URI[aarch64_python3-tinycss2.sha256sum] = "9e3ffecf9feb27d5e002e7711db9f56282084de61a110c6b57786e241c677393"

RDEPENDS:python3-tinycss2 = " \
 python3 \
 python3-webencodings \
 "
