# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pacman"
PV = "7.0.0"
PR = "5.el10_2"
PACKAGES = " \
 libalpm \
 libalpm-devel \
 pacman \
 pacman-filesystem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pacman-7.0.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fb4d8ab2831f1fab91f64820487cb0688d2e966a07a542ff559be3063625b1c"

URI_x86_64_v2_libalpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libalpm-7.0.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libalpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libalpm}"
SRC_URI[x86_64_v2_libalpm.sha256sum] = "5f2f81617e835ffe628d757667de2865e45b4c85026aab787f5b56c3ace6b224"

URI_x86_64_v2_libalpm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libalpm-devel-7.0.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libalpm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libalpm-devel}"
SRC_URI[x86_64_v2_libalpm-devel.sha256sum] = "50f42a32997b034ef807ae7489787926c88b075da94739232a27ef33ae9f7659"

URI_x86_64_v2_pacman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pacman-7.0.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pacman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacman}"
SRC_URI[x86_64_v2_pacman.sha256sum] = "5d57d8d391b8d0882c4ace5e079393f4fa9571c8a2d872a810284eec6c7d509b"

URI_x86_64_v2_pacman-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pacman-filesystem-7.0.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pacman-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacman-filesystem}"
SRC_URI[x86_64_v2_pacman-filesystem.sha256sum] = "a83d31f1c1d44767e5481b6f040190d44f0ebc6ef939fd00182e86bd3f0e448a"

URI_aarch64_libalpm = "${EPEL_MIRROR}/aarch64/Packages/l/libalpm-7.0.0-5.el10_2.aarch64.rpm;name=aarch64_libalpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libalpm}"
SRC_URI[aarch64_libalpm.sha256sum] = "b907fa1f0f39a7ccf709f765d85931bc9027d142aa78f58fe0514b45f7c8820e"

URI_aarch64_libalpm-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libalpm-devel-7.0.0-5.el10_2.aarch64.rpm;name=aarch64_libalpm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libalpm-devel}"
SRC_URI[aarch64_libalpm-devel.sha256sum] = "c1e11d7c04ddf6695c8aeaf7dc47edc1971e913e5eaa1704a47f115cb321e981"

URI_aarch64_pacman = "${EPEL_MIRROR}/aarch64/Packages/p/pacman-7.0.0-5.el10_2.aarch64.rpm;name=aarch64_pacman;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacman}"
SRC_URI[aarch64_pacman.sha256sum] = "19fde5d8dae5ac86316ff857feb5942fa0c3afe20a3880a6e19e908df708551a"

URI_aarch64_pacman-filesystem = "${EPEL_MIRROR}/aarch64/Packages/p/pacman-filesystem-7.0.0-5.el10_2.noarch.rpm;name=aarch64_pacman-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacman-filesystem}"
SRC_URI[aarch64_pacman-filesystem.sha256sum] = "68f380e92c238a27b151ccbda6ce29a7637f1d5eeb82282bdc6331a0ada35bcc"

RDEPENDS:libalpm = " \
 glibc \
 gpgme \
 libarchive \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libalpm-devel = " \
 libalpm \
 libarchive-devel \
 libcurl-devel \
 openssl-devel \
 virtual/pkgconfig_gpgme__ge_1.12.0 \
 "
RDEPENDS:pacman = " \
 bash \
 bsdtar \
 glibc \
 libalpm \
 libarchive \
 pacman-filesystem \
 "
RDEPENDS:pacman-filesystem = " \
 "
