# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-repo-zdicts"
PV = "2603.1"
PR = "1.el10_1"
PACKAGES = " \
 fedora-repo-zdicts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-repo-zdicts-2603.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4568a7787fbe682a267450af29dbe20ec5c5a8370a5fa6605cc2b95464651b5a"

URI_x86_64_v2_fedora-repo-zdicts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-repo-zdicts-2603.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-repo-zdicts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-repo-zdicts}"
SRC_URI[x86_64_v2_fedora-repo-zdicts.sha256sum] = "946e77930159adb276ce4ead749089e865b092fcaf4731f80184aebc80a3778d"

URI_aarch64_fedora-repo-zdicts = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-repo-zdicts-2603.1-1.el10_1.noarch.rpm;name=aarch64_fedora-repo-zdicts;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-repo-zdicts}"
SRC_URI[aarch64_fedora-repo-zdicts.sha256sum] = "87d77e994b49334bc672c18229072bed66d83ea6aefd4aa15ebaf70942272305"

RDEPENDS:fedora-repo-zdicts = " \
 "
