# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lirc"
PV = "0.10.0"
PR = "49.el10_1"
PACKAGES = " \
 lirc-compat \
 lirc-config \
 lirc-core \
 lirc-devel \
 lirc-disable-kernel-rc \
 lirc-doc \
 lirc-drv-ftdi \
 lirc-drv-portaudio \
 lirc-libs \
 lirc-tools-gui \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lirc-0.10.0-49.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "de531dd85c52f4f1776b4c23dd342779f80942dbc6acad5a0c4c13b48ab40b04"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-compat-0.10.0-49.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-compat;unpack=0"
SRC_URI[x86_64_v2_lirc-compat.sha256sum] = "58a560a4865658f3f57e704a9bcf1407c12dfe021bf6248667bb96cb1a20607b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-config-0.10.0-49.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lirc-config;unpack=0"
SRC_URI[x86_64_v2_lirc-config.sha256sum] = "13c9b8f7ad73152788b4043c0c3a7abf6f6426de681d85d2ee3cae999d6c8e7c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-core-0.10.0-49.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-core;unpack=0"
SRC_URI[x86_64_v2_lirc-core.sha256sum] = "7a35a0208ad0144e6141d4bc4187239e93b9ae5a49ad48934766f25cc495f213"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-devel-0.10.0-49.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-devel;unpack=0"
SRC_URI[x86_64_v2_lirc-devel.sha256sum] = "e182a807b2f2881a98319f4304e4bfed47a21b2df561461409b23f45d2ffbbed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-disable-kernel-rc-0.10.0-49.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lirc-disable-kernel-rc;unpack=0"
SRC_URI[x86_64_v2_lirc-disable-kernel-rc.sha256sum] = "285a7bf5e6066508dc354024a086ea253b1ec98ccecb9ee3fe19aa863628d268"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-doc-0.10.0-49.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lirc-doc;unpack=0"
SRC_URI[x86_64_v2_lirc-doc.sha256sum] = "8c9ccc9325040a3ab1898459421927e9be778435267a4bb00e92efb25284341b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-drv-ftdi-0.10.0-49.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-drv-ftdi;unpack=0"
SRC_URI[x86_64_v2_lirc-drv-ftdi.sha256sum] = "07d345aa080b9a5f1779ad6756801e1f8d1dea4e9d229f135c7115252c3d1d1b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-drv-portaudio-0.10.0-49.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-drv-portaudio;unpack=0"
SRC_URI[x86_64_v2_lirc-drv-portaudio.sha256sum] = "09592628d00de5529c2c3d57cae25b405b748975c150b79ec4c204c6ce43d394"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-libs-0.10.0-49.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-libs;unpack=0"
SRC_URI[x86_64_v2_lirc-libs.sha256sum] = "463fd28a612f8f0b894e96f4352f3d51032b652c31706f5513a1d32e9b47f2b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lirc-tools-gui-0.10.0-49.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lirc-tools-gui;unpack=0"
SRC_URI[x86_64_v2_lirc-tools-gui.sha256sum] = "e5ec3b3c6f6b3429501ac8c1c1cf6d5f6c382c0830bfe51d0433f0eb90c33ff2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-compat-0.10.0-49.el10_1.aarch64.rpm;name=aarch64_lirc-compat;unpack=0"
SRC_URI[aarch64_lirc-compat.sha256sum] = "8ab4ca5d9429f1f8faf6169d31e8ee674801a98d2f2cf7b3532cdee44b693bc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-config-0.10.0-49.el10_1.noarch.rpm;name=aarch64_lirc-config;unpack=0"
SRC_URI[aarch64_lirc-config.sha256sum] = "47fa037b46a62171edb7fe6831a3e57834855c6a218b9db45ad54a32a01ef5da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-core-0.10.0-49.el10_1.aarch64.rpm;name=aarch64_lirc-core;unpack=0"
SRC_URI[aarch64_lirc-core.sha256sum] = "671c48d972395e4c337bcc121e9d5f84a099ffd2d4b4df9ed3b5a99f02921a47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-devel-0.10.0-49.el10_1.aarch64.rpm;name=aarch64_lirc-devel;unpack=0"
SRC_URI[aarch64_lirc-devel.sha256sum] = "514d402299cbb0479635931803040544fd69f3dff6cf1ca28f0480a4be9b2a00"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-disable-kernel-rc-0.10.0-49.el10_1.noarch.rpm;name=aarch64_lirc-disable-kernel-rc;unpack=0"
SRC_URI[aarch64_lirc-disable-kernel-rc.sha256sum] = "bbe1d293f36aa7d5d67fbe0dc01c9df00f5ebc8ad45278e9974a44a31417c2de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-doc-0.10.0-49.el10_1.noarch.rpm;name=aarch64_lirc-doc;unpack=0"
SRC_URI[aarch64_lirc-doc.sha256sum] = "3071ea9c6f8fb17a192f431ea9702e44994e2c62cc226687436e0b3bd0a299eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-drv-ftdi-0.10.0-49.el10_1.aarch64.rpm;name=aarch64_lirc-drv-ftdi;unpack=0"
SRC_URI[aarch64_lirc-drv-ftdi.sha256sum] = "25094d291271111ce45420335a8867dd509ba3bf6d7c976f92c2d4fcf1df70af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-drv-portaudio-0.10.0-49.el10_1.aarch64.rpm;name=aarch64_lirc-drv-portaudio;unpack=0"
SRC_URI[aarch64_lirc-drv-portaudio.sha256sum] = "6ff351263cd60a2db5b74bf1207974141377cb261aa55a1925474e7489dda824"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-libs-0.10.0-49.el10_1.aarch64.rpm;name=aarch64_lirc-libs;unpack=0"
SRC_URI[aarch64_lirc-libs.sha256sum] = "3d0785310755074777b74959cdbc9c93cec1f5cfe982a538dc63401c673745e7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lirc-tools-gui-0.10.0-49.el10_1.aarch64.rpm;name=aarch64_lirc-tools-gui;unpack=0"
SRC_URI[aarch64_lirc-tools-gui.sha256sum] = "03c77ed4dcbdd1a042237825c60c828708e5e6eebbb0b6d0132e5399023cc845"

RDEPENDS:lirc-compat = " \
 lirc-config \
 lirc-core \
 lirc-drv-ftdi \
 lirc-drv-portaudio \
 lirc-tools-gui \
 "
RDEPENDS:lirc-config = " \
 bash \
 gnome-icon-theme \
 lirc-core \
 lirc-doc \
 python3 \
 python3-pyyaml \
 "
RDEPENDS:lirc-core = " \
 alsa-lib \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 libusb-compat-0.1 \
 libusb1 \
 lirc-libs \
 python3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:lirc-devel = " \
 lirc-core \
 lirc-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:lirc-disable-kernel-rc = " \
 lirc-compat \
 "
RDEPENDS:lirc-doc = " \
 "
RDEPENDS:lirc-drv-ftdi = " \
 glibc \
 libftdi \
 libusb-compat-0.1 \
 libusb1 \
 lirc-core \
 lirc-libs \
 systemd-libs \
 "
RDEPENDS:lirc-drv-portaudio = " \
 alsa-lib \
 glibc \
 libusb-compat-0.1 \
 libusb1 \
 lirc-core \
 lirc-libs \
 portaudio \
 systemd-libs \
 "
RDEPENDS:lirc-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libusb-compat-0.1 \
 libusb1 \
 systemd-libs \
 "
RDEPENDS:lirc-tools-gui = " \
 glibc \
 libX11 \
 lirc-core \
 lirc-libs \
 "
