# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-repoquery"
PV = "0.7.4"
PR = "1.el10_0"
PACKAGES = " \
 fedora-repoquery \
 fedora-repoquery-short \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-repoquery-0.7.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8182912188e0198729320de11cde20f52268219827b7df9d44999b37ad86e7b"

URI_x86_64_v2_fedora-repoquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-repoquery-0.7.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fedora-repoquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-repoquery}"
SRC_URI[x86_64_v2_fedora-repoquery.sha256sum] = "61a44c95a8639099e81e7bcfc6ea021be15ee66f7261a80b85fb0d79421ea287"

URI_x86_64_v2_fedora-repoquery-short = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-repoquery-short-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-repoquery-short;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-repoquery-short}"
SRC_URI[x86_64_v2_fedora-repoquery-short.sha256sum] = "5c3c4e6af2f6340d2c1c2148fa2aa0ace021022fbcc1a43372e5b38806850ef3"

URI_aarch64_fedora-repoquery = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-repoquery-0.7.4-1.el10_0.aarch64.rpm;name=aarch64_fedora-repoquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-repoquery}"
SRC_URI[aarch64_fedora-repoquery.sha256sum] = "09d40e832b3b473a2d69a42064fc62bb5e07679b3db4eb25ff795cc359be396c"

URI_aarch64_fedora-repoquery-short = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-repoquery-short-0.7.4-1.el10_0.noarch.rpm;name=aarch64_fedora-repoquery-short;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-repoquery-short}"
SRC_URI[aarch64_fedora-repoquery-short.sha256sum] = "f9de8e99b9bbf2cc5d1d16099ab439e3103a92784c6c4823fff40bfbaf313753"

RDEPENDS:fedora-repoquery = " \
 glibc \
 gmp \
 libffi \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:fedora-repoquery-short = " \
 fedora-repoquery \
 "
