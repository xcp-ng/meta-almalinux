# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-Rijndael"
PV = "1.16"
PR = "14.el10_0"
PACKAGES = " \
 perl-Crypt-Rijndael \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-Rijndael-1.16-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abf81ad7ce6ee85d1f60f87625b07560230a152d7f866bb7f05bcf8f059dfb62"

URI_x86_64_v2_perl-Crypt-Rijndael = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-Rijndael-1.16-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-Rijndael;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-Rijndael}"
SRC_URI[x86_64_v2_perl-Crypt-Rijndael.sha256sum] = "4757a305153f5fb2aa03a72261d5cb07ccf4ec485df74e622ae79d53f5de4638"

URI_aarch64_perl-Crypt-Rijndael = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-Rijndael-1.16-14.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-Rijndael;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-Rijndael}"
SRC_URI[aarch64_perl-Crypt-Rijndael.sha256sum] = "946b452c9c1789a47024df5b73f0759ebb1076aa1bde03eb0bd01ce23c548e0a"

RDEPENDS:perl-Crypt-Rijndael = " \
 glibc \
 perl-libs \
 "
