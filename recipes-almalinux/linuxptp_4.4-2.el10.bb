# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linuxptp"
PV = "4.4"
PR = "2.el10"
PACKAGES = " \
 linuxptp \
 linuxptp-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/linuxptp-4.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35a8e45501bcf7d7e617e89df86b79546d7cfe93f8bb22b090974af30ea368d4"

URI_x86_64_v2_linuxptp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/linuxptp-4.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_linuxptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linuxptp}"
SRC_URI[x86_64_v2_linuxptp.sha256sum] = "5990172190cf994c23787d55335dfd5995baee5366f7078fc5baf818e3de3da8"

URI_x86_64_v2_linuxptp-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/linuxptp-selinux-4.4-2.el10.noarch.rpm;name=x86_64_v2_linuxptp-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linuxptp-selinux}"
SRC_URI[x86_64_v2_linuxptp-selinux.sha256sum] = "7bf71fff2da4c76da8e1002593e23986b65f44ad8caaa8cdd3d2b7212da1e429"

URI_aarch64_linuxptp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/linuxptp-4.4-2.el10.aarch64.rpm;name=aarch64_linuxptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_linuxptp}"
SRC_URI[aarch64_linuxptp.sha256sum] = "0d3ae4beea4a201fb59022cdfe5ca9ed5525283bb22d1e4bdca9d25227931002"

URI_aarch64_linuxptp-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/linuxptp-selinux-4.4-2.el10.noarch.rpm;name=aarch64_linuxptp-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_linuxptp-selinux}"
SRC_URI[aarch64_linuxptp-selinux.sha256sum] = "7bf71fff2da4c76da8e1002593e23986b65f44ad8caaa8cdd3d2b7212da1e429"

RDEPENDS:linuxptp = " \
 bash \
 glibc \
 gnutls \
 linuxptp-selinux \
 systemd \
 "
RDEPENDS:linuxptp-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
