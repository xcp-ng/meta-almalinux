# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-rsc-qr"
PV = "0.2.0"
PR = "19.20230806gitb6857d4.el10_2"
PACKAGES = " \
 golang-rsc-qr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-rsc-qr-0.2.0-19.20230806gitb6857d4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f01ceeb4268d4da86d3041fcf79ee7735086523ff4a6dce0b01e3486bdac5952"

URI_aarch64_golang-rsc-qr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-rsc-qr-devel-0.2.0-19.20230806gitb6857d4.el10_2.noarch.rpm;name=aarch64_golang-rsc-qr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-rsc-qr-devel}"
SRC_URI[aarch64_golang-rsc-qr-devel.sha256sum] = "767d4ae85e8916ff4902a877b08e20ec52fb4fbb49654cf1227de9a71514ed3b"

RDEPENDS:golang-rsc-qr-devel = " \
 go-filesystem \
 qrencode-devel \
 "
