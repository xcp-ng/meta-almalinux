# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "retsnoop"
PV = "0.10.1"
PR = "3.el10_0"
PACKAGES = " \
 retsnoop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/retsnoop-0.10.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a245ec6b35beb844ef50dd5fc3489d5924d3097492fdb9484c7dbc6a18a9c12e"

URI_x86_64_v2_retsnoop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/retsnoop-0.10.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_retsnoop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_retsnoop}"
SRC_URI[x86_64_v2_retsnoop.sha256sum] = "26f7145ce10f3102952dabc941c636c9828cfe8533710c556b52f5e4e033ec97"

URI_aarch64_retsnoop = "${EPEL_MIRROR}/aarch64/Packages/r/retsnoop-0.10.1-3.el10_0.aarch64.rpm;name=aarch64_retsnoop;unpack=0"
SRC_URI:append = " ${URI_aarch64_retsnoop}"
SRC_URI[aarch64_retsnoop.sha256sum] = "cd54df4f41a568bede5137687071b605c9aa183e99874f4c4148caebe4fcce79"

RDEPENDS:retsnoop = " \
 elfutils-libelf \
 glibc \
 zlib-ng-compat \
 "
