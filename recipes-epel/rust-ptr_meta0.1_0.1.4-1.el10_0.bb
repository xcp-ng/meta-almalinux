# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta0.1"
PV = "0.1.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-ptr_meta0.1+default-devel \
 rust-ptr_meta0.1+std-devel \
 rust-ptr_meta0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta0.1-0.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79ac0ed95c81bbc2e26e89bc2d9edb18f8f81931d54e6ceeeb430bcf6e3023d9"

URI_x86_64_v2_rust-ptr_meta0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta0.1+default-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta0.1+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta0.1+default-devel.sha256sum] = "675b72e9357b34604be646ae7c9ebb95edf0da1934c67a2e5fd6ffa97caac3ed"

URI_x86_64_v2_rust-ptr_meta0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta0.1+std-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta0.1+std-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta0.1+std-devel.sha256sum] = "1f898e664c9fff27098033875f88128f2910030d1075be4e59416f081e4c22da"

URI_x86_64_v2_rust-ptr_meta0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta0.1-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta0.1-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta0.1-devel.sha256sum] = "3049fa555dbac76bd1eed33a49bb610bd0dc622ac7a381b494c2c0813dbb36cd"

URI_aarch64_rust-ptr_meta0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta0.1+default-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta0.1+default-devel}"
SRC_URI[aarch64_rust-ptr_meta0.1+default-devel.sha256sum] = "b8e878dc283473c774cd4377091a7ff81558c5656814497c1349798924339e81"

URI_aarch64_rust-ptr_meta0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta0.1+std-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta0.1+std-devel}"
SRC_URI[aarch64_rust-ptr_meta0.1+std-devel.sha256sum] = "cc05309cbd6eab8026df0353000f196ecbfd2afce5693ba34b77b373cacbb9ee"

URI_aarch64_rust-ptr_meta0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta0.1-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta0.1-devel}"
SRC_URI[aarch64_rust-ptr_meta0.1-devel.sha256sum] = "68dca0ccfe5e6c0109ac0304507817d6a1d9d25957091639d96a12fe457510f8"

RDEPENDS:rust-ptr_meta0.1+default-devel = " \
 cargo \
 rust-ptr_meta0.1+std-devel \
 rust-ptr_meta0.1-devel \
 "
RDEPENDS:rust-ptr_meta0.1+std-devel = " \
 cargo \
 rust-ptr_meta0.1-devel \
 "
RDEPENDS:rust-ptr_meta0.1-devel = " \
 cargo \
 rust-ptr_meta_derive0.1+default-devel \
 "
