# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-termtree"
PV = "0.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-termtree+default-devel \
 rust-termtree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-termtree-0.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b49f46111caddc35ea646e02cab1f9a41422c802c33b59a6728ef592704b5a36"

URI_x86_64_v2_rust-termtree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termtree+default-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termtree+default-devel}"
SRC_URI[x86_64_v2_rust-termtree+default-devel.sha256sum] = "47bc8b5d43b7d111601a83a7e1b4158213407bd1f13e274f735c0d6be3245434"

URI_x86_64_v2_rust-termtree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termtree-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termtree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termtree-devel}"
SRC_URI[x86_64_v2_rust-termtree-devel.sha256sum] = "a39fbf00264b2a2910b800456ab7685ecf9df6b30e6766a4d70338b34b2cbd4b"

URI_aarch64_rust-termtree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termtree+default-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-termtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termtree+default-devel}"
SRC_URI[aarch64_rust-termtree+default-devel.sha256sum] = "a41a82dcaf4599a35af17cabd7ef1eae59d6652ed662765bf48b810f61eccd3a"

URI_aarch64_rust-termtree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termtree-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-termtree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termtree-devel}"
SRC_URI[aarch64_rust-termtree-devel.sha256sum] = "26d6655f015f990f7a9688e36c05eb226c61a26eb64d1322ebb5e4e50c9fdb34"

RDEPENDS:rust-termtree+default-devel = " \
 cargo \
 rust-termtree-devel \
 "
RDEPENDS:rust-termtree-devel = " \
 cargo \
 rust \
 "
