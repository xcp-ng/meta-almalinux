# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pjbgf-sha1cd"
PV = "0.3.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-pjbgf-sha1cd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pjbgf-sha1cd-0.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62b0e6a43ce2b264eebda178646e0b2324305c1ae7254e74c65bea81ddbdd97e"

URI_x86_64_v2_golang-github-pjbgf-sha1cd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pjbgf-sha1cd-devel-0.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pjbgf-sha1cd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pjbgf-sha1cd-devel}"
SRC_URI[x86_64_v2_golang-github-pjbgf-sha1cd-devel.sha256sum] = "311f1344c04d4f69a66496fb83a59ea8a81125291adc04a0284784e54dca49fa"

URI_aarch64_golang-github-pjbgf-sha1cd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pjbgf-sha1cd-devel-0.3.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-pjbgf-sha1cd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pjbgf-sha1cd-devel}"
SRC_URI[aarch64_golang-github-pjbgf-sha1cd-devel.sha256sum] = "02df2ba31ef0154c3a28f174e5e60926ce4b0e39a20a65e6346ea1db7b0f0ab6"

RDEPENDS:golang-github-pjbgf-sha1cd-devel = " \
 go-filesystem \
 "
