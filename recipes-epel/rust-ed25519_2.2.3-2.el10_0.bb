# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ed25519"
PV = "2.2.3"
PR = "2.el10_0"
PACKAGES = " \
 rust-ed25519+alloc-devel \
 rust-ed25519+default-devel \
 rust-ed25519+pem-devel \
 rust-ed25519+pkcs8-devel \
 rust-ed25519+serde-devel \
 rust-ed25519+serde_bytes-devel \
 rust-ed25519+std-devel \
 rust-ed25519+zeroize-devel \
 rust-ed25519-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ed25519-2.2.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "770f8a5f93e85547eb01626c6ce54bc1bde69d9309c975c7106ab0a9850fd246"

URI_x86_64_v2_rust-ed25519+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519+alloc-devel-2.2.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519+alloc-devel}"
SRC_URI[x86_64_v2_rust-ed25519+alloc-devel.sha256sum] = "b827ec6dbf7af029d2761c3a4799280d458d15d11d6cc0b4bcd7ae14e0c4eb18"

URI_x86_64_v2_rust-ed25519+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519+default-devel-2.2.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519+default-devel}"
SRC_URI[x86_64_v2_rust-ed25519+default-devel.sha256sum] = "04907be42727b4603602745c49e1d9a090771c5bac6d14259f790b5bcbff3c78"

URI_x86_64_v2_rust-ed25519+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519+pem-devel-2.2.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519+pem-devel}"
SRC_URI[x86_64_v2_rust-ed25519+pem-devel.sha256sum] = "4cf39ab7d7e0ad9d82a45971c6f6c25b9e5a68240bc1834fc734448406343e9b"

URI_x86_64_v2_rust-ed25519+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519+pkcs8-devel-2.2.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-ed25519+pkcs8-devel.sha256sum] = "752aef248205b3b62679408ad6b6832ceaf1a72a41af5dd59de3ac91e377681e"

URI_x86_64_v2_rust-ed25519+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519+serde-devel-2.2.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519+serde-devel}"
SRC_URI[x86_64_v2_rust-ed25519+serde-devel.sha256sum] = "99823b0480a6ab3f95b84a182aa3140554ebabf365220c511f8be4df46d0cd3f"

URI_x86_64_v2_rust-ed25519+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519+serde_bytes-devel-2.2.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-ed25519+serde_bytes-devel.sha256sum] = "df18d11ae848320b37649159f0e116ed3abb1d160416823b9761f8a33222fe96"

URI_x86_64_v2_rust-ed25519+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519+std-devel-2.2.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519+std-devel}"
SRC_URI[x86_64_v2_rust-ed25519+std-devel.sha256sum] = "0c1b28525caf6093bb23275eebff5f3a5b5a1ce867a8fc24c7a663bf49830b91"

URI_x86_64_v2_rust-ed25519+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519+zeroize-devel-2.2.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519+zeroize-devel}"
SRC_URI[x86_64_v2_rust-ed25519+zeroize-devel.sha256sum] = "5bebc286191f22d79870bfc047564ee1bce965d54044d1021574fb677ec9f968"

URI_x86_64_v2_rust-ed25519-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-devel-2.2.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-devel}"
SRC_URI[x86_64_v2_rust-ed25519-devel.sha256sum] = "fb0d441ebc6cccf59b8ebec6b67fe1b7c61c3fe7c3a13b3cd60f7ef21631c016"

URI_aarch64_rust-ed25519+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519+alloc-devel-2.2.3-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519+alloc-devel}"
SRC_URI[aarch64_rust-ed25519+alloc-devel.sha256sum] = "2eeddbbbd512a6ed0d2fea151d05c21b35a2af838c287aa49a0d3139cbc14abe"

URI_aarch64_rust-ed25519+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519+default-devel-2.2.3-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519+default-devel}"
SRC_URI[aarch64_rust-ed25519+default-devel.sha256sum] = "4b78d99eedf01047c23b02c4e56c358b3a7e7c3d78c99096d36b74a7bd73544e"

URI_aarch64_rust-ed25519+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519+pem-devel-2.2.3-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519+pem-devel}"
SRC_URI[aarch64_rust-ed25519+pem-devel.sha256sum] = "3fc2963d46d17371c251490c39bc8d74af8ae07bb5b0529ce633d5d63a063be6"

URI_aarch64_rust-ed25519+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519+pkcs8-devel-2.2.3-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519+pkcs8-devel}"
SRC_URI[aarch64_rust-ed25519+pkcs8-devel.sha256sum] = "a38d924b6f0f160c5241d4dc38386fc0d78103fd20335816023d179df387c151"

URI_aarch64_rust-ed25519+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519+serde-devel-2.2.3-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519+serde-devel}"
SRC_URI[aarch64_rust-ed25519+serde-devel.sha256sum] = "878ad82d4adbebd9d1c3d527e222fe7f594d077fc2d433ee931dd02aaf9e3c23"

URI_aarch64_rust-ed25519+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519+serde_bytes-devel-2.2.3-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519+serde_bytes-devel}"
SRC_URI[aarch64_rust-ed25519+serde_bytes-devel.sha256sum] = "acb45201255fe1ca2fb2eaec6f51bbf19a2921b3b2a7792e1487610efd03eab9"

URI_aarch64_rust-ed25519+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519+std-devel-2.2.3-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519+std-devel}"
SRC_URI[aarch64_rust-ed25519+std-devel.sha256sum] = "a83af0a5e58402fc658d5f212e6f6fe23b6c0fcbb8159ad5574582f09b8f9060"

URI_aarch64_rust-ed25519+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519+zeroize-devel-2.2.3-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519+zeroize-devel}"
SRC_URI[aarch64_rust-ed25519+zeroize-devel.sha256sum] = "6dae6573cad13025941770f853fc5d1514ebaa1444baaf6e851212ac3bdd7268"

URI_aarch64_rust-ed25519-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-devel-2.2.3-2.el10_0.noarch.rpm;name=aarch64_rust-ed25519-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-devel}"
SRC_URI[aarch64_rust-ed25519-devel.sha256sum] = "1f9749b5934037f67445938b68d2f1a912354f3cd76a4004372168b1928d1ccc"

RDEPENDS:rust-ed25519+alloc-devel = " \
 cargo \
 rust-ed25519-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8+default-devel \
 "
RDEPENDS:rust-ed25519+default-devel = " \
 cargo \
 rust-ed25519+std-devel \
 rust-ed25519-devel \
 "
RDEPENDS:rust-ed25519+pem-devel = " \
 cargo \
 rust-ed25519+alloc-devel \
 rust-ed25519-devel \
 rust-pkcs8+default-devel \
 rust-pkcs8+pem-devel \
 "
RDEPENDS:rust-ed25519+pkcs8-devel = " \
 cargo \
 rust-ed25519-devel \
 rust-pkcs8+default-devel \
 "
RDEPENDS:rust-ed25519+serde-devel = " \
 cargo \
 rust-ed25519-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ed25519+serde_bytes-devel = " \
 cargo \
 rust-ed25519+serde-devel \
 rust-ed25519-devel \
 rust-serde_bytes+default-devel \
 "
RDEPENDS:rust-ed25519+std-devel = " \
 cargo \
 rust-ed25519-devel \
 rust-pkcs8+default-devel \
 rust-pkcs8+std-devel \
 rust-signature+std-devel \
 "
RDEPENDS:rust-ed25519+zeroize-devel = " \
 cargo \
 rust-ed25519-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-ed25519-devel = " \
 cargo \
 rust \
 rust-signature-devel \
 "
