# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "busybox"
PE = "1"
PV = "1.37.0"
PR = "4.el10_2"
PACKAGES = " \
 busybox \
 busybox-petitboot \
 busybox-shared \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/busybox-1.37.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f80e2abc86a721f0e279b2aeca8a4cc1948db1a8b268e90656d36c8d4b3dcab6"

URI_x86_64_v2_busybox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/busybox-1.37.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_busybox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_busybox}"
SRC_URI[x86_64_v2_busybox.sha256sum] = "b68256183ed8797da39aacc1b16444e1aef6db459974afd15e7cb4a9ae4cd704"

URI_x86_64_v2_busybox-petitboot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/busybox-petitboot-1.37.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_busybox-petitboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_busybox-petitboot}"
SRC_URI[x86_64_v2_busybox-petitboot.sha256sum] = "f237b5f100b813905bb2bebb3755c6ad23f90b46d5bd826b7890a9969d6327ce"

URI_x86_64_v2_busybox-shared = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/busybox-shared-1.37.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_busybox-shared;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_busybox-shared}"
SRC_URI[x86_64_v2_busybox-shared.sha256sum] = "b4fc9dbce538fd61a304f35fa0322281d12b232fbdc43492bca8e2b2ff5da1b5"

URI_aarch64_busybox = "${EPEL_MIRROR}/aarch64/Packages/b/busybox-1.37.0-4.el10_2.aarch64.rpm;name=aarch64_busybox;unpack=0"
SRC_URI:append = " ${URI_aarch64_busybox}"
SRC_URI[aarch64_busybox.sha256sum] = "0b85d2c99e56920ca7563638c18e354713e9d64e731e43e6001a3cab73ee46a0"

URI_aarch64_busybox-petitboot = "${EPEL_MIRROR}/aarch64/Packages/b/busybox-petitboot-1.37.0-4.el10_2.aarch64.rpm;name=aarch64_busybox-petitboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_busybox-petitboot}"
SRC_URI[aarch64_busybox-petitboot.sha256sum] = "1f49b4cf92edbe4c049d671c006b90d3b76e76d6ccc183a917d16daeb794f9c9"

URI_aarch64_busybox-shared = "${EPEL_MIRROR}/aarch64/Packages/b/busybox-shared-1.37.0-4.el10_2.aarch64.rpm;name=aarch64_busybox-shared;unpack=0"
SRC_URI:append = " ${URI_aarch64_busybox-shared}"
SRC_URI[aarch64_busybox-shared.sha256sum] = "3b2758d06b7ea10d27aa6d97e84458719d4562b4a3ce51b6121dda6e766cfce0"

RDEPENDS:busybox = " \
 "
RDEPENDS:busybox-petitboot = " \
 glibc \
 "
RDEPENDS:busybox-shared = " \
 glibc \
 "
