# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-json5"
PV = "0.12.0"
PR = "2.el10_1"
PACKAGES = " \
 pyjson5 \
 python3-json5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-json5-0.12.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb7708e009b687f5e09bf617e1209600276273ed3b7c3660821ae137a0eb1c78"

URI_x86_64_v2_pyjson5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyjson5-0.12.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pyjson5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyjson5}"
SRC_URI[x86_64_v2_pyjson5.sha256sum] = "d488799bef352a8806f3f4c6fc3c8b5795554165f154619334b3d92d8d00723f"

URI_x86_64_v2_python3-json5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-json5-0.12.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-json5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-json5}"
SRC_URI[x86_64_v2_python3-json5.sha256sum] = "dc9950381107e2aedc46304d9dde80076616e5598912465a4d7fb7504249115d"

URI_aarch64_pyjson5 = "${EPEL_MIRROR}/aarch64/Packages/p/pyjson5-0.12.0-2.el10_1.noarch.rpm;name=aarch64_pyjson5;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyjson5}"
SRC_URI[aarch64_pyjson5.sha256sum] = "0798d3ae408f8f99606474bcfa3c88dbabab3115c875606ffbf8795a66d8d835"

URI_aarch64_python3-json5 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-json5-0.12.0-2.el10_1.noarch.rpm;name=aarch64_python3-json5;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-json5}"
SRC_URI[aarch64_python3-json5.sha256sum] = "855709f756c96bb90ddc4b2ea6f54b4928759cbe64821288d1850bccfc79c185"

RDEPENDS:pyjson5 = " \
 python3 \
 python3-json5 \
 "
RDEPENDS:python3-json5 = " \
 python3 \
 "
