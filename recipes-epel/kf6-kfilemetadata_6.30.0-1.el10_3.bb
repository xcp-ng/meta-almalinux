# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kfilemetadata"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kfilemetadata \
 kf6-kfilemetadata-devel \
 kf6-kfilemetadata-doc \
 kf6-kfilemetadata-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kfilemetadata-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa5cf4abcfa4b32888d54a14b06d6278336debde18a6afb92d7d92ac5d72d531"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata;unpack=0"
SRC_URI[x86_64_v2_kf6-kfilemetadata.sha256sum] = "41e8c379764d156daf75e06ce4da0b7dec18ea82637973e148054dc4ba3b03c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kfilemetadata-devel.sha256sum] = "9bbdfb60edad8b730c6837f06941a196496006ac7e1fdd4f8dfaf53449eb4927"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kfilemetadata-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kfilemetadata-doc.sha256sum] = "7f9dbaf721097c0f89a74ccda2a566324feb68311b02306c673c5d48425e8ef9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kfilemetadata-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kfilemetadata-html.sha256sum] = "3c52e8f9e2b76887ef4977e599f98113dfe98cf37b3922fb7661557c449bbece"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kfilemetadata;unpack=0"
SRC_URI[aarch64_kf6-kfilemetadata.sha256sum] = "e9f83f0b0a04b0297e0fd189ba569c85c232e95bc49c6f061e74e22356589e98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kfilemetadata-devel;unpack=0"
SRC_URI[aarch64_kf6-kfilemetadata-devel.sha256sum] = "680c86ff0542dbf471f805f56e25735b074617b42301ffb96a5d6bd5dbfab81f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kfilemetadata-doc;unpack=0"
SRC_URI[aarch64_kf6-kfilemetadata-doc.sha256sum] = "c843570ccb6d258790a5e4cdc7965b43e11bf79df97ce965521568fb650925df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kfilemetadata-html;unpack=0"
SRC_URI[aarch64_kf6-kfilemetadata-html.sha256sum] = "904f2908b50ed0bf1ce626c60a22f594d2a891934db24c4fede1aefad63e83db"

RDEPENDS:kf6-kfilemetadata = " \
 exiv2-libs \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libstdc++ \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 taglib \
 "
RDEPENDS:kf6-kfilemetadata-devel = " \
 cmake-filesystem \
 kf6-kfilemetadata \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kfilemetadata-doc = " \
 "
RDEPENDS:kf6-kfilemetadata-html = " \
 "
