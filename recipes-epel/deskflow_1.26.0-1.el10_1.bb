# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "deskflow"
PV = "1.26.0"
PR = "1.el10_1"
PACKAGES = " \
 deskflow \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/deskflow-1.26.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62661d97cfe8ccbf511330a60ceb80a737aada67664f983d39f01fdb6d8ab3e2"

URI_x86_64_v2_deskflow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/deskflow-1.26.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_deskflow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_deskflow}"
SRC_URI[x86_64_v2_deskflow.sha256sum] = "b1c635a17664f116670ae68def515dd209255e8c53ab14d44a1eae0c6cf5810b"

URI_aarch64_deskflow = "${EPEL_MIRROR}/aarch64/Packages/d/deskflow-1.26.0-1.el10_1.aarch64.rpm;name=aarch64_deskflow;unpack=0"
SRC_URI:append = " ${URI_aarch64_deskflow}"
SRC_URI[aarch64_deskflow.sha256sum] = "3f2f94a8da2d30819cd6a1014ce154b892045231d9bc81d6a3ea5e1af57e996b"

RDEPENDS:deskflow = " \
 bash \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libei \
 libgcc \
 libportal \
 libstdc++ \
 libxkbcommon \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
