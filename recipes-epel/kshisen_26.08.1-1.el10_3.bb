# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kshisen"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kshisen \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kshisen-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5b42fb10b1ae3c20f7a40197bb5472324151d04880ab81d92898a22681f04a0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kshisen-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kshisen;unpack=0"
SRC_URI[x86_64_v2_kshisen.sha256sum] = "05d9e456a7ac78882cea6688ba3599d43f6c59480844a4572be9cbd999185b35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kshisen-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kshisen;unpack=0"
SRC_URI[aarch64_kshisen.sha256sum] = "658ce560b8bfb8af41fa3e3c8f8c1d65cb17a66d37bfaace50e81f51ec0672a2"

RDEPENDS:kshisen = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libkmahjongg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
