# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat9"
PE = "1"
PV = "9.0.120"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 tomcat9 \
 tomcat9-admin-webapps \
 tomcat9-docs-webapp \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-lib \
 tomcat9-servlet-4.0-api \
 tomcat9-webapps \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat9-9.0.120-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cabe120adc3e9b3e19e4c3d52b1552820f742f81d06164b4ec541ecdcb6df936"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-9.0.120-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9;unpack=0"
SRC_URI[x86_64_v2_tomcat9.sha256sum] = "4345bedf4762f697d7820e4c40e33db6d512fbb7bb3aa1bb1736a9517eb26bb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-admin-webapps-9.0.120-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-admin-webapps;unpack=0"
SRC_URI[x86_64_v2_tomcat9-admin-webapps.sha256sum] = "5abf8cce64844d9b8d793f656ee9059ff88d5778b36b2132610327becea70b50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-docs-webapp-9.0.120-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-docs-webapp;unpack=0"
SRC_URI[x86_64_v2_tomcat9-docs-webapp.sha256sum] = "8f39945c344abb46ae48edaeeb08c9422248d21b0fa78a5168faae09fb3f81ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-el-3.0-api-9.0.120-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-el-3.0-api;unpack=0"
SRC_URI[x86_64_v2_tomcat9-el-3.0-api.sha256sum] = "127036aa147028de0c591c915f5913b3c80dbbbb60b91558081f3842befb9deb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-jsp-2.3-api-9.0.120-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI[x86_64_v2_tomcat9-jsp-2.3-api.sha256sum] = "079235eb90790724bd53fa760599c4fabc2ca146f0df04dc03b825473f6929f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-lib-9.0.120-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-lib;unpack=0"
SRC_URI[x86_64_v2_tomcat9-lib.sha256sum] = "c47704f2da56adf112c8a1acc1d7fe27bb3e7896bbfcbcdff7dcc0673fda1877"
RPROVIDES:tomcat9-lib:append:x86_64_v2 = " virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-servlet-4.0-api-9.0.120-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI[x86_64_v2_tomcat9-servlet-4.0-api.sha256sum] = "ddabae1dd27c35dd4cee5c1eae2a7f3dd9d8d1aa22810be1c19a7df07b7d56ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-webapps-9.0.120-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-webapps;unpack=0"
SRC_URI[x86_64_v2_tomcat9-webapps.sha256sum] = "5438a76184cee45e329a47afa3263e09dfcd6150cbd0ff81c9aa64f29718fbaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-9.0.120-1.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9;unpack=0"
SRC_URI[aarch64_tomcat9.sha256sum] = "4345bedf4762f697d7820e4c40e33db6d512fbb7bb3aa1bb1736a9517eb26bb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-admin-webapps-9.0.120-1.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-admin-webapps;unpack=0"
SRC_URI[aarch64_tomcat9-admin-webapps.sha256sum] = "5abf8cce64844d9b8d793f656ee9059ff88d5778b36b2132610327becea70b50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-docs-webapp-9.0.120-1.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-docs-webapp;unpack=0"
SRC_URI[aarch64_tomcat9-docs-webapp.sha256sum] = "8f39945c344abb46ae48edaeeb08c9422248d21b0fa78a5168faae09fb3f81ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-el-3.0-api-9.0.120-1.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-el-3.0-api;unpack=0"
SRC_URI[aarch64_tomcat9-el-3.0-api.sha256sum] = "127036aa147028de0c591c915f5913b3c80dbbbb60b91558081f3842befb9deb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-jsp-2.3-api-9.0.120-1.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI[aarch64_tomcat9-jsp-2.3-api.sha256sum] = "079235eb90790724bd53fa760599c4fabc2ca146f0df04dc03b825473f6929f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-lib-9.0.120-1.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-lib;unpack=0"
SRC_URI[aarch64_tomcat9-lib.sha256sum] = "c47704f2da56adf112c8a1acc1d7fe27bb3e7896bbfcbcdff7dcc0673fda1877"
RPROVIDES:tomcat9-lib:append:aarch64 = " virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-servlet-4.0-api-9.0.120-1.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI[aarch64_tomcat9-servlet-4.0-api.sha256sum] = "ddabae1dd27c35dd4cee5c1eae2a7f3dd9d8d1aa22810be1c19a7df07b7d56ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-webapps-9.0.120-1.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-webapps;unpack=0"
SRC_URI[aarch64_tomcat9-webapps.sha256sum] = "5438a76184cee45e329a47afa3263e09dfcd6150cbd0ff81c9aa64f29718fbaf"

RDEPENDS:tomcat9 = " \
 bash \
 javapackages-tools \
 shadow-utils \
 systemd \
 tomcat9-lib \
 virtual/java-headless_or_java-25-headless \
 "
RDEPENDS:tomcat9-admin-webapps = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-docs-webapp = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-el-3.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-jsp-2.3-api = " \
 bash \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-servlet-4.0-api \
 "
RDEPENDS:tomcat9-lib = " \
 ecj \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-servlet-4.0-api \
 virtual/coreutils \
 "
RDEPENDS:tomcat9-servlet-4.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-webapps = " \
 tomcat9 \
 "
