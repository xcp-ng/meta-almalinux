# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Log-Any-Adapter-Screen"
PV = "0.141"
PR = "3.el10_1"
PACKAGES = " \
 perl-Log-Any-Adapter-Screen \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Log-Any-Adapter-Screen-0.141-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4a17d41a52559ef1b46e6df9355a6c8be772c86e085d8e6c8b5d7200a75334bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Any-Adapter-Screen-0.141-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Any-Adapter-Screen;unpack=0"
SRC_URI[x86_64_v2_perl-Log-Any-Adapter-Screen.sha256sum] = "575e3ee1cbc7ece7c7d352aa78f85a97f60d00a601d20ea8f278481c9724456c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Any-Adapter-Screen-0.141-3.el10_1.noarch.rpm;name=aarch64_perl-Log-Any-Adapter-Screen;unpack=0"
SRC_URI[aarch64_perl-Log-Any-Adapter-Screen.sha256sum] = "79dc1bb437104ff739b4d100bd42bc5a19d320220b6fdf7a084428b839fce794"

RDEPENDS:perl-Log-Any-Adapter-Screen = " \
 perl-Log-Any \
 perl-libs \
 perl-parent \
 "
