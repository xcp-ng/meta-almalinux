# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcftools"
PV = "1.23.1"
PR = "1.el10_1"
PACKAGES = " \
 bcftools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bcftools-1.23.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd4d960ec1ce215d001704c7c04062714f4a68f1a9802cc5699a505a86a429cc"

URI_x86_64_v2_bcftools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bcftools-1.23.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bcftools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcftools}"
SRC_URI[x86_64_v2_bcftools.sha256sum] = "08996d06be355188a50e31aa696a1f86a49f3a0b77feebc58a0080cd6ac437dd"

URI_aarch64_bcftools = "${EPEL_MIRROR}/aarch64/Packages/b/bcftools-1.23.1-1.el10_1.aarch64.rpm;name=aarch64_bcftools;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcftools}"
SRC_URI[aarch64_bcftools.sha256sum] = "d3576c8751aa9b11f6c7054b6c2159537b8f8b832a026a8d430d6c3406442e5d"

RDEPENDS:bcftools = " \
 glibc \
 gsl \
 htslib \
 perl-interpreter \
 perl-libs \
 python3 \
 "
