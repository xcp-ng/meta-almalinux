# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm"
PV = "6.4.1"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 rocm \
 rocm-devel \
 rocm-test \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-6.4.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "368826b569d47b1a91cc2fa344f3919cf1b20b377f6dbeedfe598caf511884d7"

URI_x86_64_v2_rocm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-6.4.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rocm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm}"
SRC_URI[x86_64_v2_rocm.sha256sum] = "cd592d89bfa0566927861c268a07e7ceabe25b5d1823a3d8fb875d1204e3eddb"

URI_x86_64_v2_rocm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-devel-6.4.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-devel}"
SRC_URI[x86_64_v2_rocm-devel.sha256sum] = "3e9ba166cbebc450506c65e9a543c2e5b22466c0f5579859865e11f9784873dd"

URI_x86_64_v2_rocm-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-test-6.4.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-test}"
SRC_URI[x86_64_v2_rocm-test.sha256sum] = "8266e082640d76833f5b1d11175f4459f6a0f89d387ff6a53158fde6a15b0f8c"

RDEPENDS:rocm = " \
 amdsmi \
 hipblas \
 hipcc \
 hipfft \
 hiprand \
 hipsolver \
 hipsparse \
 rocblas \
 rocfft \
 rocm-clang \
 rocm-hip \
 rocm-runtime \
 rocm-smi \
 rocminfo \
 rocrand \
 rocsolver \
 rocsparse \
 "
RDEPENDS:rocm-devel = " \
 amdsmi-devel \
 half-devel \
 hipblas-common-devel \
 hipblas-devel \
 hipcub-devel \
 hipfft-devel \
 hiprand-devel \
 hipsolver-devel \
 hipsparse-devel \
 rocblas-devel \
 rocfft-devel \
 rocm-clang-devel \
 rocm-cmake \
 rocm-compilersupport-macros \
 rocm-hip-devel \
 rocm-rpm-macros \
 rocm-rpm-macros-modules \
 rocm-runtime-devel \
 rocm-smi-devel \
 rocprim-devel \
 rocrand-devel \
 rocsolver-devel \
 rocsparse-devel \
 "
RDEPENDS:rocm-test = " \
 kfdtest \
 "
