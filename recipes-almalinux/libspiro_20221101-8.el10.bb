# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libspiro"
PV = "20221101"
PR = "8.el10"
PACKAGES = " \
 libspiro \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libspiro-20221101-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b272a2e69cef6ca8baec083a05866f4a1ac25cacdc94e96665489a9591e7387b"

URI_x86_64_v2_libspiro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libspiro-20221101-8.el10.x86_64_v2.rpm;name=x86_64_v2_libspiro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspiro}"
SRC_URI[x86_64_v2_libspiro.sha256sum] = "659a66b5775543256800ff4c3a94fd209378afa5a77dc205db7364b7c30ce8a6"

URI_aarch64_libspiro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libspiro-20221101-8.el10.aarch64.rpm;name=aarch64_libspiro;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspiro}"
SRC_URI[aarch64_libspiro.sha256sum] = "029691bd0daccc35159774ed021c39c71e316955f6ae69dc04f12cf0bb21ad01"

RDEPENDS:libspiro = " \
 glibc \
 "
