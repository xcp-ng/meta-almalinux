# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-image"
PV = "0.25.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-image+avif-devel \
 rust-image+avif-native-devel \
 rust-image+bmp-devel \
 rust-image+color_quant-devel \
 rust-image+dds-devel \
 rust-image+default-devel \
 rust-image+default-formats-devel \
 rust-image+exr-devel \
 rust-image+ff-devel \
 rust-image+gif-devel \
 rust-image+hdr-devel \
 rust-image+ico-devel \
 rust-image+jpeg-devel \
 rust-image+nasm-devel \
 rust-image+png-devel \
 rust-image+pnm-devel \
 rust-image+qoi-devel \
 rust-image+rayon-devel \
 rust-image+serde-devel \
 rust-image+tga-devel \
 rust-image+tiff-devel \
 rust-image+webp-devel \
 rust-image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-image-0.25.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b38713f73fbbe3468b23b1bf3a9cb6ab070949c6b9e4f53a120ff92beac938d2"

URI_x86_64_v2_rust-image+avif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+avif-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+avif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+avif-devel}"
SRC_URI[x86_64_v2_rust-image+avif-devel.sha256sum] = "83eb2946ac4ad13626f76e396113f3d722b80ec62c01e13f03cd41d014d6f146"

URI_x86_64_v2_rust-image+avif-native-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+avif-native-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+avif-native-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+avif-native-devel}"
SRC_URI[x86_64_v2_rust-image+avif-native-devel.sha256sum] = "760b24be016ef772021d856660ba4a4b354aa70758443cbfbb019ca165e0fbd7"

URI_x86_64_v2_rust-image+bmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+bmp-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+bmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+bmp-devel}"
SRC_URI[x86_64_v2_rust-image+bmp-devel.sha256sum] = "1d7938cf336e253c87c4e211a42b3a3145e868984c609383036389475635abf8"

URI_x86_64_v2_rust-image+color_quant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+color_quant-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+color_quant-devel}"
SRC_URI[x86_64_v2_rust-image+color_quant-devel.sha256sum] = "65615566c904fa7eee0851ba9e083e8330f4c3fb72ce811f733105e646ce2ad3"

URI_x86_64_v2_rust-image+dds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+dds-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+dds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+dds-devel}"
SRC_URI[x86_64_v2_rust-image+dds-devel.sha256sum] = "a1b772fe92fc41974d03459c2387f9df084cc084d1b701e5475302c729b0dc05"

URI_x86_64_v2_rust-image+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+default-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+default-devel}"
SRC_URI[x86_64_v2_rust-image+default-devel.sha256sum] = "055838a5d32f461c9ad3961be4db2039b2cbf2fad34b0fa11b383fe264b2a76e"

URI_x86_64_v2_rust-image+default-formats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+default-formats-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+default-formats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+default-formats-devel}"
SRC_URI[x86_64_v2_rust-image+default-formats-devel.sha256sum] = "8c05c91a1299d4cfdc25b4896fdb81ec83aedc7c56f87d20bcd3533855033cff"

URI_x86_64_v2_rust-image+exr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+exr-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+exr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+exr-devel}"
SRC_URI[x86_64_v2_rust-image+exr-devel.sha256sum] = "eee250c73e3dc70456c23197b5524aee6e860babfc8722d79192a4ba3960d7f3"

URI_x86_64_v2_rust-image+ff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+ff-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+ff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+ff-devel}"
SRC_URI[x86_64_v2_rust-image+ff-devel.sha256sum] = "7f550159010043fdea030f9d19475af61ceadafae33d9729ccc92f581262c0d2"

URI_x86_64_v2_rust-image+gif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+gif-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+gif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+gif-devel}"
SRC_URI[x86_64_v2_rust-image+gif-devel.sha256sum] = "63a07bd02737cc476cc4be511519fb4f3b10c0d7cb09300971788cb439b24bc6"

URI_x86_64_v2_rust-image+hdr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+hdr-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+hdr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+hdr-devel}"
SRC_URI[x86_64_v2_rust-image+hdr-devel.sha256sum] = "aa1c219fd536bb800687da336c271c20580519744605a59a7a2219e00d8a9761"

URI_x86_64_v2_rust-image+ico-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+ico-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+ico-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+ico-devel}"
SRC_URI[x86_64_v2_rust-image+ico-devel.sha256sum] = "44ee78b7df4935c84e9a5a4d24270402d7ed3d3c67dd6fe813ca364056724b7a"

URI_x86_64_v2_rust-image+jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+jpeg-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+jpeg-devel}"
SRC_URI[x86_64_v2_rust-image+jpeg-devel.sha256sum] = "b2d0f4b33dfe587ad7ff0cc76675dc3ba6cd61c3c8a51e2196e852f6e6f75f01"

URI_x86_64_v2_rust-image+nasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+nasm-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+nasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+nasm-devel}"
SRC_URI[x86_64_v2_rust-image+nasm-devel.sha256sum] = "7a0c228091050edd5a6fc6976471f65f46098fa93d600d10256b34f7a3122440"

URI_x86_64_v2_rust-image+png-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+png-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+png-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+png-devel}"
SRC_URI[x86_64_v2_rust-image+png-devel.sha256sum] = "4ec945c68b0d028638661d4d4c748fcb9de534461e7c5a5003f5bd965808f9e9"

URI_x86_64_v2_rust-image+pnm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+pnm-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+pnm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+pnm-devel}"
SRC_URI[x86_64_v2_rust-image+pnm-devel.sha256sum] = "b196454df04a41f748c65a62226c4e0da16ca06380f1e6bdca5a3c2f25ad1c3a"

URI_x86_64_v2_rust-image+qoi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+qoi-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+qoi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+qoi-devel}"
SRC_URI[x86_64_v2_rust-image+qoi-devel.sha256sum] = "60a81e9ea2094aad5119256ebfb3746e63ffb41c335699bb9eeb4e7b77c52a31"

URI_x86_64_v2_rust-image+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+rayon-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+rayon-devel}"
SRC_URI[x86_64_v2_rust-image+rayon-devel.sha256sum] = "615eb77eb407f4bc97d5d9527ebaab6e94bcbebfacbff521d71db74a0f37bbf5"

URI_x86_64_v2_rust-image+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+serde-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+serde-devel}"
SRC_URI[x86_64_v2_rust-image+serde-devel.sha256sum] = "8ca1ec021639031188fcab7cff541ebb160e75bab3455048238c4d4c79ef38b4"

URI_x86_64_v2_rust-image+tga-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+tga-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+tga-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+tga-devel}"
SRC_URI[x86_64_v2_rust-image+tga-devel.sha256sum] = "aa0b4490608d8207bcc8fe246dd9e57fa367d0ac1b637745f103e07267a71929"

URI_x86_64_v2_rust-image+tiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+tiff-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+tiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+tiff-devel}"
SRC_URI[x86_64_v2_rust-image+tiff-devel.sha256sum] = "e1080622021a0a7b1857b2cd242c75f588e467699c614e08ad63cafa18143342"

URI_x86_64_v2_rust-image+webp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+webp-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+webp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+webp-devel}"
SRC_URI[x86_64_v2_rust-image+webp-devel.sha256sum] = "20e4d6a87670a59a93c01d980477247d215c5d746cf0aecf9abda5270e4a864d"

URI_x86_64_v2_rust-image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-devel-0.25.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-devel}"
SRC_URI[x86_64_v2_rust-image-devel.sha256sum] = "c77f30cee62e0872c8daa8566f56d4624d765e5a3cf0cb8e9959232dbfaf06f6"

URI_aarch64_rust-image+avif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+avif-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+avif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+avif-devel}"
SRC_URI[aarch64_rust-image+avif-devel.sha256sum] = "b9b5ca3d53e91af4aeffdb223024f8214422f384c243dbcf51ebd3cc43007975"

URI_aarch64_rust-image+avif-native-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+avif-native-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+avif-native-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+avif-native-devel}"
SRC_URI[aarch64_rust-image+avif-native-devel.sha256sum] = "eaedbd813c8c888c4da0c2688bb11fec543a3d3ad7c24913b64a731f500c45d3"

URI_aarch64_rust-image+bmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+bmp-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+bmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+bmp-devel}"
SRC_URI[aarch64_rust-image+bmp-devel.sha256sum] = "3c011d420b21914bc86728ed4ab009bad06fdc1813391dc5bab322922136aeee"

URI_aarch64_rust-image+color_quant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+color_quant-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+color_quant-devel}"
SRC_URI[aarch64_rust-image+color_quant-devel.sha256sum] = "239a7508addebed8e72be98f05dee4d94c5c4bac1c7bbd5036b65b5b01c77efe"

URI_aarch64_rust-image+dds-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+dds-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+dds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+dds-devel}"
SRC_URI[aarch64_rust-image+dds-devel.sha256sum] = "7aa5798b8945565bb347f3c11243cba76b7e03b19defad90f848552c33ba8808"

URI_aarch64_rust-image+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+default-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+default-devel}"
SRC_URI[aarch64_rust-image+default-devel.sha256sum] = "58b7c279ab0866a71566a08602d651813fec74866619e7c35035619c0a290a84"

URI_aarch64_rust-image+default-formats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+default-formats-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+default-formats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+default-formats-devel}"
SRC_URI[aarch64_rust-image+default-formats-devel.sha256sum] = "ca7909703b3a40e423e3253683c9bdc2ba2df6713fca1fd309771ec32690251a"

URI_aarch64_rust-image+exr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+exr-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+exr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+exr-devel}"
SRC_URI[aarch64_rust-image+exr-devel.sha256sum] = "c06f61689e61f6b17c2102d285e02f774c4377813ad1138cd29e653277fb4fb9"

URI_aarch64_rust-image+ff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+ff-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+ff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+ff-devel}"
SRC_URI[aarch64_rust-image+ff-devel.sha256sum] = "5596b0d049efe55564864646bb60ef99960788c88e0713372675359ece6f9b7a"

URI_aarch64_rust-image+gif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+gif-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+gif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+gif-devel}"
SRC_URI[aarch64_rust-image+gif-devel.sha256sum] = "7443adf14ec9e0543e85c1ebdf28febc29d5d55650851660834959d6af53eec6"

URI_aarch64_rust-image+hdr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+hdr-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+hdr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+hdr-devel}"
SRC_URI[aarch64_rust-image+hdr-devel.sha256sum] = "1a0894c948a400cd6ce3b03f0059671b7ea918b4e52d6627b0cbb60a8b832df9"

URI_aarch64_rust-image+ico-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+ico-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+ico-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+ico-devel}"
SRC_URI[aarch64_rust-image+ico-devel.sha256sum] = "9c8a355d305b965ecdc7602b99ab046d39e6490bdf8b52c35463589b451b2818"

URI_aarch64_rust-image+jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+jpeg-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+jpeg-devel}"
SRC_URI[aarch64_rust-image+jpeg-devel.sha256sum] = "c8eafa6736280c3e36a52e72e39db03e42f6e145f821fe05c3bd4b71a5910e09"

URI_aarch64_rust-image+nasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+nasm-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+nasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+nasm-devel}"
SRC_URI[aarch64_rust-image+nasm-devel.sha256sum] = "7da97780f0e0d982f33adff11a48ab2b0d9e71388c06025d82582dbf17730613"

URI_aarch64_rust-image+png-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+png-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+png-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+png-devel}"
SRC_URI[aarch64_rust-image+png-devel.sha256sum] = "fd234987dc1948b0174e402b47fb0d9bd9fe8df51401a16ff54caaac5f5ff92e"

URI_aarch64_rust-image+pnm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+pnm-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+pnm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+pnm-devel}"
SRC_URI[aarch64_rust-image+pnm-devel.sha256sum] = "5e1d8da18c7a59a0c697b5968fc0d74be4b04376ee86f82f739bf8e2804af374"

URI_aarch64_rust-image+qoi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+qoi-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+qoi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+qoi-devel}"
SRC_URI[aarch64_rust-image+qoi-devel.sha256sum] = "e3b34068d5d52942d1dab1dc86e9f1950f908b5cae005105fa8dd827ed2dc58e"

URI_aarch64_rust-image+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+rayon-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+rayon-devel}"
SRC_URI[aarch64_rust-image+rayon-devel.sha256sum] = "354d2d5c99e3aff44e19815d67f0be5a6e51814941cd26a178fded4efe9d6b6e"

URI_aarch64_rust-image+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+serde-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+serde-devel}"
SRC_URI[aarch64_rust-image+serde-devel.sha256sum] = "5e65245e6bb6270c25efd056465eea6107ca5a9ac1bcecc8d24d482e160e68ed"

URI_aarch64_rust-image+tga-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+tga-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+tga-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+tga-devel}"
SRC_URI[aarch64_rust-image+tga-devel.sha256sum] = "7e9cc3a3cf4fb9ef844258116689a5e13cf9bc3dc8fe66f61766d0292ec68ecf"

URI_aarch64_rust-image+tiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+tiff-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+tiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+tiff-devel}"
SRC_URI[aarch64_rust-image+tiff-devel.sha256sum] = "1ed03b414bcfeb0e7f2317018c367617e7a94379ea77a55bc143efc606d274aa"

URI_aarch64_rust-image+webp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+webp-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image+webp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+webp-devel}"
SRC_URI[aarch64_rust-image+webp-devel.sha256sum] = "573d8dcd8fa142089562a43a98fb6eb67b9bff955b885dffeb9d6b083c818d13"

URI_aarch64_rust-image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-devel-0.25.10-1.el10_3.noarch.rpm;name=aarch64_rust-image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-devel}"
SRC_URI[aarch64_rust-image-devel.sha256sum] = "a2a5344e29d4b38b72211f4837a38a65d48752e394c0de7e1027660484cd4d3b"

RDEPENDS:rust-image+avif-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-image+avif-native-devel = " \
 cargo \
 rust-dav1d+default-devel \
 rust-image-devel \
 rust-mp4parse+default-devel \
 "
RDEPENDS:rust-image+bmp-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+color_quant-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+dds-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+default-devel = " \
 cargo \
 rust-image+default-formats-devel \
 rust-image+rayon-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+default-formats-devel = " \
 cargo \
 rust-image+avif-devel \
 rust-image+bmp-devel \
 rust-image+dds-devel \
 rust-image+exr-devel \
 rust-image+ff-devel \
 rust-image+gif-devel \
 rust-image+hdr-devel \
 rust-image+ico-devel \
 rust-image+jpeg-devel \
 rust-image+png-devel \
 rust-image+pnm-devel \
 rust-image+qoi-devel \
 rust-image+tga-devel \
 rust-image+tiff-devel \
 rust-image+webp-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+exr-devel = " \
 cargo \
 rust-exr-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+ff-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+gif-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-gif+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+hdr-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+ico-devel = " \
 cargo \
 rust-image+bmp-devel \
 rust-image+png-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+jpeg-devel = " \
 cargo \
 rust-image-devel \
 rust-zune-core-devel \
 rust-zune-jpeg+default-devel \
 "
RDEPENDS:rust-image+nasm-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif+asm-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-image+png-devel = " \
 cargo \
 rust-image-devel \
 rust-png+default-devel \
 "
RDEPENDS:rust-image+pnm-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+qoi-devel = " \
 cargo \
 rust-image-devel \
 rust-qoi+default-devel \
 "
RDEPENDS:rust-image+rayon-devel = " \
 cargo \
 rust-exr+rayon-devel \
 rust-exr-devel \
 rust-image-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-image+serde-devel = " \
 cargo \
 rust-image-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-image+tga-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+tiff-devel = " \
 cargo \
 rust-image-devel \
 rust-tiff+default-devel \
 "
RDEPENDS:rust-image+webp-devel = " \
 cargo \
 rust-image-devel \
 rust-image-webp+default-devel \
 "
RDEPENDS:rust-image-devel = " \
 cargo \
 rust \
 rust-bytemuck+default-devel \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-byteorder-lite+default-devel \
 rust-moxcms+default-devel \
 rust-num-traits+default-devel \
 "
