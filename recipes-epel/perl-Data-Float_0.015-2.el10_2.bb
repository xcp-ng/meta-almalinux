# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Float"
PV = "0.015"
PR = "2.el10_2"
PACKAGES = " \
 perl-Data-Float \
 perl-Data-Float-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Float-0.015-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e70463c0aadb3e17a776ce6d4f8667b379155dbb1e392f8eb138dcaa37e1b5c"

URI_x86_64_v2_perl-Data-Float = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Float-0.015-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Float;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Float}"
SRC_URI[x86_64_v2_perl-Data-Float.sha256sum] = "66f429a34df5957b61e09ee518470de453de18009dd943f5e6d4465360bd7ac3"

URI_x86_64_v2_perl-Data-Float-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Float-tests-0.015-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Float-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Float-tests}"
SRC_URI[x86_64_v2_perl-Data-Float-tests.sha256sum] = "b1ed52e0bf4c7b17225d16e448fd56923f7d1306c01736a17ae2a0b99f923033"

URI_aarch64_perl-Data-Float = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Float-0.015-2.el10_2.noarch.rpm;name=aarch64_perl-Data-Float;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Float}"
SRC_URI[aarch64_perl-Data-Float.sha256sum] = "ad64ab65ea4d309a3c28e3a8d561a43f293a70cba497ec078d0e484f8c2f693c"

URI_aarch64_perl-Data-Float-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Float-tests-0.015-2.el10_2.noarch.rpm;name=aarch64_perl-Data-Float-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Float-tests}"
SRC_URI[aarch64_perl-Data-Float-tests.sha256sum] = "983ee88e2bba531f5a456731e570ccfe6b4af0ab7645f84eda0bd24426afb676"

RDEPENDS:perl-Data-Float = " \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-Data-Float-tests = " \
 bash \
 perl-Data-Float \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-libs \
 "
