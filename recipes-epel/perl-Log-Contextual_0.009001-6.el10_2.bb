# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Log-Contextual"
PV = "0.009001"
PR = "6.el10_2"
PACKAGES = " \
 perl-Log-Contextual \
 perl-Log-Contextual-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Log-Contextual-0.009001-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05298f83ec988ac5593dcd9c9639a1c697335f0e6950e5b969cd44bfff57bb8d"

URI_x86_64_v2_perl-Log-Contextual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Contextual-0.009001-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Contextual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Contextual}"
SRC_URI[x86_64_v2_perl-Log-Contextual.sha256sum] = "8b0f8ea0fde1c8c7ed315dbd2839a652111fa8c6c1621ad90ab9578596de7139"

URI_x86_64_v2_perl-Log-Contextual-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Contextual-tests-0.009001-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Contextual-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Contextual-tests}"
SRC_URI[x86_64_v2_perl-Log-Contextual-tests.sha256sum] = "38cc1601fe41545cb2f192412997cc4dea04e2e0800ce0e0047a39503f035aa3"

URI_aarch64_perl-Log-Contextual = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Contextual-0.009001-6.el10_2.noarch.rpm;name=aarch64_perl-Log-Contextual;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Contextual}"
SRC_URI[aarch64_perl-Log-Contextual.sha256sum] = "f5a97de546d6f7d545f1828497066ae07b816fc7589ba628f38b942dcf31aaaf"

URI_aarch64_perl-Log-Contextual-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Contextual-tests-0.009001-6.el10_2.noarch.rpm;name=aarch64_perl-Log-Contextual-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Contextual-tests}"
SRC_URI[aarch64_perl-Log-Contextual-tests.sha256sum] = "01e5307a56a5acf77169610741d4ffc4fb8548b3ee4b097b2158bbbf60fed7e8"

RDEPENDS:perl-Log-Contextual = " \
 perl-B \
 perl-Carp \
 perl-Data-Dumper-Concise \
 perl-Log-Contextual \
 perl-Moo \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-Log-Contextual-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-File-Temp \
 perl-IO \
 perl-IPC-Open3 \
 perl-Log-Contextual \
 perl-Log-Log4perl \
 perl-PathTools \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Needs \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
