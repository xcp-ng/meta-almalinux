# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "man2html"
PV = "1.6"
PR = "33.g.el10_0"
PACKAGES = " \
 man2html \
 man2html-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/man2html-1.6-33.g.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91ef4a24405311f32802c48b05e9a07ebaf606233e228b6bad850c0078995c10"

URI_x86_64_v2_man2html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/man2html-1.6-33.g.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_man2html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_man2html}"
SRC_URI[x86_64_v2_man2html.sha256sum] = "79e649a27ad2a3983c1a3805dc040411326a097d94a9537ce5d8ea88c0078eca"

URI_x86_64_v2_man2html-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/man2html-core-1.6-33.g.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_man2html-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_man2html-core}"
SRC_URI[x86_64_v2_man2html-core.sha256sum] = "4e91a34be877a1ed86114f45d778c29978a05e7be527e2b2d819e654f609fd47"

URI_aarch64_man2html = "${EPEL_MIRROR}/aarch64/Packages/m/man2html-1.6-33.g.el10_0.aarch64.rpm;name=aarch64_man2html;unpack=0"
SRC_URI:append = " ${URI_aarch64_man2html}"
SRC_URI[aarch64_man2html.sha256sum] = "d47e526591a9674055a937ad34f3fd7e857fa74d182eebb486d214e99c224923"

URI_aarch64_man2html-core = "${EPEL_MIRROR}/aarch64/Packages/m/man2html-core-1.6-33.g.el10_0.aarch64.rpm;name=aarch64_man2html-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_man2html-core}"
SRC_URI[aarch64_man2html-core.sha256sum] = "6e10f322caec6a5fc9d0ec8f1c66d569c1052a636cc2e3ff60733f9cbba4e21c"

RDEPENDS:man2html = " \
 bash \
 glibc \
 httpd \
 man2html-core \
 "
RDEPENDS:man2html-core = " \
 glibc \
 "
