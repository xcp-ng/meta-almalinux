# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-file-embed"
PV = "0.0.16.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-file-embed \
 ghc-file-embed-devel \
 ghc-file-embed-doc \
 ghc-file-embed-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-file-embed-0.0.16.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06ad0dd6131b1f503753e2a289d89350cb7a58b805eb0c3364db55073ed74ea0"

URI_x86_64_v2_ghc-file-embed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-file-embed-0.0.16.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-file-embed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-file-embed}"
SRC_URI[x86_64_v2_ghc-file-embed.sha256sum] = "0ddb6a327ffa2f51b9539226433907f25becb94e64b09d62f34f1fdcbf851fa1"

URI_x86_64_v2_ghc-file-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-file-embed-devel-0.0.16.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-file-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-file-embed-devel}"
SRC_URI[x86_64_v2_ghc-file-embed-devel.sha256sum] = "36c3a61b9c6dddc579c263821917970d9b19057763a38ce500b7a033a08a0004"

URI_x86_64_v2_ghc-file-embed-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-file-embed-doc-0.0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-file-embed-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-file-embed-doc}"
SRC_URI[x86_64_v2_ghc-file-embed-doc.sha256sum] = "6ffa61d27384fde4bb0457f26203f25f81796795735c902db10aa0bf72de6759"

URI_x86_64_v2_ghc-file-embed-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-file-embed-prof-0.0.16.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-file-embed-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-file-embed-prof}"
SRC_URI[x86_64_v2_ghc-file-embed-prof.sha256sum] = "6ae53eef1c6a4fac1a8b803e9bc5491efb0108ee1d3f1870377de030cadad45d"

URI_aarch64_ghc-file-embed = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-file-embed-0.0.16.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-file-embed;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-file-embed}"
SRC_URI[aarch64_ghc-file-embed.sha256sum] = "f89824b1b3e0b2100b0a31b1233bfb9ec57ac2a0c1c1622ba886bb4ef05b52dd"

URI_aarch64_ghc-file-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-file-embed-devel-0.0.16.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-file-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-file-embed-devel}"
SRC_URI[aarch64_ghc-file-embed-devel.sha256sum] = "2e64bd0a6d7101f44c2923ce448f8bd313dfd299741d5268682ec5ce2b0c8e60"

URI_aarch64_ghc-file-embed-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-file-embed-doc-0.0.16.0-1.el10_0.noarch.rpm;name=aarch64_ghc-file-embed-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-file-embed-doc}"
SRC_URI[aarch64_ghc-file-embed-doc.sha256sum] = "773cfd506ff53c773a5fecd474dc059ad28f22c3675feedc938f014d6af66f12"

URI_aarch64_ghc-file-embed-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-file-embed-prof-0.0.16.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-file-embed-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-file-embed-prof}"
SRC_URI[aarch64_ghc-file-embed-prof.sha256sum] = "f04c82edf216ecb9c2b3465acae228147672f6cffc9135bec4f27e9a616cf3d3"

RDEPENDS:ghc-file-embed = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-file-embed-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-file-embed \
 ghc-filepath-devel \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-file-embed-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-file-embed-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-directory-prof \
 ghc-file-embed-devel \
 ghc-filepath-prof \
 ghc-template-haskell-prof \
 "
