# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prodash"
PV = "31.0.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-prodash+async-io-devel \
 rust-prodash+bytesize-devel \
 rust-prodash+crosstermion-devel \
 rust-prodash+ctrlc-devel \
 rust-prodash+dashmap-devel \
 rust-prodash+default-devel \
 rust-prodash+futures-core-devel \
 rust-prodash+futures-lite-devel \
 rust-prodash+human_format-devel \
 rust-prodash+is-terminal-devel \
 rust-prodash+jiff-devel \
 rust-prodash+local-time-devel \
 rust-prodash+log-devel \
 rust-prodash+parking_lot-devel \
 rust-prodash+progress-log-devel \
 rust-prodash+progress-tree-devel \
 rust-prodash+progress-tree-hp-hashmap-devel \
 rust-prodash+progress-tree-log-devel \
 rust-prodash+render-line-autoconfigure-devel \
 rust-prodash+render-line-crossterm-devel \
 rust-prodash+render-line-devel \
 rust-prodash+render-tui-crossterm-devel \
 rust-prodash+render-tui-devel \
 rust-prodash+signal-hook-devel \
 rust-prodash+tui-devel \
 rust-prodash+tui-react-devel \
 rust-prodash+unicode-segmentation-devel \
 rust-prodash+unicode-width-devel \
 rust-prodash+unit-bytes-devel \
 rust-prodash+unit-duration-devel \
 rust-prodash+unit-human-devel \
 rust-prodash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prodash-31.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65a4d53625a9ee5ae891a211b1d3cbba029e9c1e5c6b144ed59019b167a0140a"

URI_x86_64_v2_rust-prodash+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+async-io-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+async-io-devel}"
SRC_URI[x86_64_v2_rust-prodash+async-io-devel.sha256sum] = "57f99e002c33d6d0ff159b232a1559468b4341bcb3820ba7c11047ef835156f3"

URI_x86_64_v2_rust-prodash+bytesize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+bytesize-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+bytesize-devel}"
SRC_URI[x86_64_v2_rust-prodash+bytesize-devel.sha256sum] = "f0a7a32899cc1c330e054d168b0979c45c62346c2226bb4a7a917d6502b713c4"

URI_x86_64_v2_rust-prodash+crosstermion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+crosstermion-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+crosstermion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+crosstermion-devel}"
SRC_URI[x86_64_v2_rust-prodash+crosstermion-devel.sha256sum] = "1acb01938b511d3c3ed244dcfeffb1a379fe011671d9206590fdf22362ab37a5"

URI_x86_64_v2_rust-prodash+ctrlc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+ctrlc-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+ctrlc-devel}"
SRC_URI[x86_64_v2_rust-prodash+ctrlc-devel.sha256sum] = "d7c02422edff7f6a285916be57112dc5f50a08bc946af0c13e6f679de23abd2a"

URI_x86_64_v2_rust-prodash+dashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+dashmap-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+dashmap-devel}"
SRC_URI[x86_64_v2_rust-prodash+dashmap-devel.sha256sum] = "0c15928126c0a35e4d3c212d1c3a641a9bc404be96a8604150131d01f9750dec"

URI_x86_64_v2_rust-prodash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+default-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+default-devel}"
SRC_URI[x86_64_v2_rust-prodash+default-devel.sha256sum] = "410c74c9caf87ab3cb26e08fbddf131f79602bd72cd9593ca5395c6ea9456f6f"

URI_x86_64_v2_rust-prodash+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+futures-core-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+futures-core-devel}"
SRC_URI[x86_64_v2_rust-prodash+futures-core-devel.sha256sum] = "283de6a51bb90fe83f4e25a1895f9ccb7e3a6603fe4d55834ad5926a84cc3f2b"

URI_x86_64_v2_rust-prodash+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+futures-lite-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-prodash+futures-lite-devel.sha256sum] = "cc87c282e80cf04d7176cd1af7e63ba42c75729f665cbd1bde221774087466e3"

URI_x86_64_v2_rust-prodash+human_format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+human_format-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+human_format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+human_format-devel}"
SRC_URI[x86_64_v2_rust-prodash+human_format-devel.sha256sum] = "3a42ab3acef91035d939d3cdcf5886dff38a1bf3321f7e1a3b4b22fefcd7907e"

URI_x86_64_v2_rust-prodash+is-terminal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+is-terminal-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+is-terminal-devel}"
SRC_URI[x86_64_v2_rust-prodash+is-terminal-devel.sha256sum] = "781592a27660032244ae5b0731df00b431fa608bc1d1f1e6a1ba416b10fe192f"

URI_x86_64_v2_rust-prodash+jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+jiff-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+jiff-devel}"
SRC_URI[x86_64_v2_rust-prodash+jiff-devel.sha256sum] = "88dd200c97bea27dd93d10fd3ee8725e7ae21d1ebdd56a12fac31b8f40c8acec"

URI_x86_64_v2_rust-prodash+local-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+local-time-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+local-time-devel}"
SRC_URI[x86_64_v2_rust-prodash+local-time-devel.sha256sum] = "d0a4898104a411e77eb6dd5a7b1e4a955ec0712892435deff3ab11aba89e8a8c"

URI_x86_64_v2_rust-prodash+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+log-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+log-devel}"
SRC_URI[x86_64_v2_rust-prodash+log-devel.sha256sum] = "bf842b9970767c781b850e9c48ba6192250b991d04f57041655e08db8aa2b493"

URI_x86_64_v2_rust-prodash+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+parking_lot-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-prodash+parking_lot-devel.sha256sum] = "b93bc1d76a6ad89eefb3a39ff874236a457045397b44ddb63f1093a30a67d6e6"

URI_x86_64_v2_rust-prodash+progress-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-log-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-log-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-log-devel.sha256sum] = "451e94248038ab3ea08fd11e4c90e0f374df427cba4c0a26284fd7af7fda7cd3"

URI_x86_64_v2_rust-prodash+progress-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-tree-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-tree-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-tree-devel.sha256sum] = "f798db9ea9e34806b2eca85ee3d32104efe88f68a87d8dc85fa964b26b00b8bb"

URI_x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-tree-hp-hashmap-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel.sha256sum] = "43796793378dd1ea8ebbcf4547c08f870d389517e9cd9de5dc071758b9b40e55"

URI_x86_64_v2_rust-prodash+progress-tree-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-tree-log-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-tree-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-tree-log-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-tree-log-devel.sha256sum] = "25ce5eeba8db572b19c7572bed375a4b8aca5d85b0fd274d9266d8839b2a35b6"

URI_x86_64_v2_rust-prodash+render-line-autoconfigure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-line-autoconfigure-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-line-autoconfigure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-line-autoconfigure-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-line-autoconfigure-devel.sha256sum] = "94e28b74de4d7d1884c51a7bc35d96ed65e50bcb3b9303bbb300425f11d4154e"

URI_x86_64_v2_rust-prodash+render-line-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-line-crossterm-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-line-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-line-crossterm-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-line-crossterm-devel.sha256sum] = "f0e901ac3ef0db011d5b5b417d238251d5f97017c578344f0be3cb64ec79d1f5"

URI_x86_64_v2_rust-prodash+render-line-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-line-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-line-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-line-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-line-devel.sha256sum] = "423a77a5f90c01596a3b796fa3254ccc7ec19f459fefc7ebc17a8b10529c79a7"

URI_x86_64_v2_rust-prodash+render-tui-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-tui-crossterm-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-tui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-tui-crossterm-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-tui-crossterm-devel.sha256sum] = "ec1092aca36aae6ff5e53b9fa14a010d3d769626f268a4923eb0516fd5f54ac3"

URI_x86_64_v2_rust-prodash+render-tui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-tui-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-tui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-tui-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-tui-devel.sha256sum] = "6ebb4282f0468f1a351023e57c957eafb7a6d221c68b0f7514151a9f580828d7"

URI_x86_64_v2_rust-prodash+signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+signal-hook-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+signal-hook-devel}"
SRC_URI[x86_64_v2_rust-prodash+signal-hook-devel.sha256sum] = "074174be65334823d2493d294aecb941a0caa4c75e5b7e3fca514e09e0d01f82"

URI_x86_64_v2_rust-prodash+tui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+tui-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+tui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+tui-devel}"
SRC_URI[x86_64_v2_rust-prodash+tui-devel.sha256sum] = "32304c1ca0751250e8ae623c9b6c70b5218a5f914da5d9db03d6e39b5c8a25c0"

URI_x86_64_v2_rust-prodash+tui-react-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+tui-react-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+tui-react-devel}"
SRC_URI[x86_64_v2_rust-prodash+tui-react-devel.sha256sum] = "77dc94c3142987fbcd2964fb1457c30e78d176ac60d9d78f184b8dbf7ad68a9f"

URI_x86_64_v2_rust-prodash+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unicode-segmentation-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-prodash+unicode-segmentation-devel.sha256sum] = "e5d48779a1e4ced244125c4d72fcce0f52c3f4b1a4213eb97d3b8ab3844233f3"

URI_x86_64_v2_rust-prodash+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unicode-width-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-prodash+unicode-width-devel.sha256sum] = "c17b98d531cfc8cc3dffe6825cc9975f07672a1812a6950ecdadac47ec5f6aa2"

URI_x86_64_v2_rust-prodash+unit-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unit-bytes-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unit-bytes-devel}"
SRC_URI[x86_64_v2_rust-prodash+unit-bytes-devel.sha256sum] = "af42c6cc47b42ce6229538c2b0f5f91a836f9ce7ab67335f5c0ef1353a2126ca"

URI_x86_64_v2_rust-prodash+unit-duration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unit-duration-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unit-duration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unit-duration-devel}"
SRC_URI[x86_64_v2_rust-prodash+unit-duration-devel.sha256sum] = "85146992a80d27c32e969b6efcbab7cff81b681171c11b9bed63bbd4f7c76e06"

URI_x86_64_v2_rust-prodash+unit-human-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unit-human-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unit-human-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unit-human-devel}"
SRC_URI[x86_64_v2_rust-prodash+unit-human-devel.sha256sum] = "f65daa7511f292ee92c7ae9edf6b4fbf8b1e7499e114c6ef89cdf2c5a67088b8"

URI_x86_64_v2_rust-prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash-devel-31.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash-devel}"
SRC_URI[x86_64_v2_rust-prodash-devel.sha256sum] = "0a3ddd6d5b561a942ec9a9d8f1aff915ab40fde07eaa074f240198dad98b9118"

URI_aarch64_rust-prodash+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+async-io-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+async-io-devel}"
SRC_URI[aarch64_rust-prodash+async-io-devel.sha256sum] = "f07c602e0155b2b73f0d7f584b89e36f2e7f66538aede8a55efc127948f02c78"

URI_aarch64_rust-prodash+bytesize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+bytesize-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+bytesize-devel}"
SRC_URI[aarch64_rust-prodash+bytesize-devel.sha256sum] = "77d51710d8f16ac919eb58adcc95914f5327cf88798915205e631bf11d6f562c"

URI_aarch64_rust-prodash+crosstermion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+crosstermion-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+crosstermion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+crosstermion-devel}"
SRC_URI[aarch64_rust-prodash+crosstermion-devel.sha256sum] = "f4954a719cec2848474670639cd41914e9a95b920c9aba5e3a31e99409ae98f7"

URI_aarch64_rust-prodash+ctrlc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+ctrlc-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+ctrlc-devel}"
SRC_URI[aarch64_rust-prodash+ctrlc-devel.sha256sum] = "d2a9f44bed01ad7d335e62c5d77d60cb18f5e390509a7aa46e945a89a6f79094"

URI_aarch64_rust-prodash+dashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+dashmap-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+dashmap-devel}"
SRC_URI[aarch64_rust-prodash+dashmap-devel.sha256sum] = "6b66c101c5d879cb650a973e1ca0d0a095e77de60cb9e76e3561f71e2e5d7d2e"

URI_aarch64_rust-prodash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+default-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+default-devel}"
SRC_URI[aarch64_rust-prodash+default-devel.sha256sum] = "ec301b6fde09a012d6a2b798159c46459bb459b97726f9f67b64c4b38fbf2755"

URI_aarch64_rust-prodash+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+futures-core-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+futures-core-devel}"
SRC_URI[aarch64_rust-prodash+futures-core-devel.sha256sum] = "06437b180380967c2dda3e5b3d8d4377ff484615646f047767a1866d03a1b569"

URI_aarch64_rust-prodash+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+futures-lite-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+futures-lite-devel}"
SRC_URI[aarch64_rust-prodash+futures-lite-devel.sha256sum] = "cded815acf8269855329707f8467d238ba4ac46fff2c407568c688f9a977224a"

URI_aarch64_rust-prodash+human_format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+human_format-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+human_format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+human_format-devel}"
SRC_URI[aarch64_rust-prodash+human_format-devel.sha256sum] = "b29e2215fec4574f11597311f6f1adcda7e2b81a6846c178562df560c832c8cc"

URI_aarch64_rust-prodash+is-terminal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+is-terminal-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+is-terminal-devel}"
SRC_URI[aarch64_rust-prodash+is-terminal-devel.sha256sum] = "fa046e523588d261e74912a8f7d0e94be5c5202ecc2d9db1f9e287804aea5558"

URI_aarch64_rust-prodash+jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+jiff-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+jiff-devel}"
SRC_URI[aarch64_rust-prodash+jiff-devel.sha256sum] = "b967a5ce084f9898d135b511bf12327cb34747ed12c7742774db74153e700100"

URI_aarch64_rust-prodash+local-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+local-time-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+local-time-devel}"
SRC_URI[aarch64_rust-prodash+local-time-devel.sha256sum] = "a3293f097dc9b8136e289903e145554804dc13441e33dd2ecdecfaff6818feea"

URI_aarch64_rust-prodash+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+log-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+log-devel}"
SRC_URI[aarch64_rust-prodash+log-devel.sha256sum] = "77a938da79567f2ff09ff90477d233f064658fa0f02bfcfe411a454ea79369f3"

URI_aarch64_rust-prodash+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+parking_lot-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+parking_lot-devel}"
SRC_URI[aarch64_rust-prodash+parking_lot-devel.sha256sum] = "f404db868274bbb837896858abcd932a19c37b6e9f4bd085d272608eef0f38e3"

URI_aarch64_rust-prodash+progress-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-log-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+progress-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-log-devel}"
SRC_URI[aarch64_rust-prodash+progress-log-devel.sha256sum] = "9c51767992bff054bb3663cf2c19ddb969ae3674c89a4d98d024d4c9255e630c"

URI_aarch64_rust-prodash+progress-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-tree-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-tree-devel}"
SRC_URI[aarch64_rust-prodash+progress-tree-devel.sha256sum] = "84667a706bfda4cafe94de9706dfb5c5ea53527f19aff654948fda5173479fbc"

URI_aarch64_rust-prodash+progress-tree-hp-hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-tree-hp-hashmap-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+progress-tree-hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-tree-hp-hashmap-devel}"
SRC_URI[aarch64_rust-prodash+progress-tree-hp-hashmap-devel.sha256sum] = "e55a746e152da58bc5f13e9bdb2a617dbdf0645cd099164b6821304366899bd4"

URI_aarch64_rust-prodash+progress-tree-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-tree-log-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+progress-tree-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-tree-log-devel}"
SRC_URI[aarch64_rust-prodash+progress-tree-log-devel.sha256sum] = "c413507977cf4c9eaf5687ea9c4e5a322b00fdc66c5de137d927996581ef05cf"

URI_aarch64_rust-prodash+render-line-autoconfigure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-line-autoconfigure-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+render-line-autoconfigure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-line-autoconfigure-devel}"
SRC_URI[aarch64_rust-prodash+render-line-autoconfigure-devel.sha256sum] = "c7f16c044eb89bfc5a7b1aff536c4d5ee86b55ea179c59a131f8c23487474900"

URI_aarch64_rust-prodash+render-line-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-line-crossterm-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+render-line-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-line-crossterm-devel}"
SRC_URI[aarch64_rust-prodash+render-line-crossterm-devel.sha256sum] = "4dfb17ce5353637e29195c729187bfba51305c6acee20eeba183a2823ccd8814"

URI_aarch64_rust-prodash+render-line-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-line-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+render-line-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-line-devel}"
SRC_URI[aarch64_rust-prodash+render-line-devel.sha256sum] = "a7ea0648b128234d3a12ab02d305bbed267203236cba1df34e6b98fa55f89074"

URI_aarch64_rust-prodash+render-tui-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-tui-crossterm-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+render-tui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-tui-crossterm-devel}"
SRC_URI[aarch64_rust-prodash+render-tui-crossterm-devel.sha256sum] = "06fd79f2ed7ef9a22c6b5e2c7fd9c163337134e9cda667f914827cf32cd1b4d0"

URI_aarch64_rust-prodash+render-tui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-tui-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+render-tui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-tui-devel}"
SRC_URI[aarch64_rust-prodash+render-tui-devel.sha256sum] = "5db63a5a5fd18906e957c1cbc39ebca1c37a5288710d708595f2e465ae223087"

URI_aarch64_rust-prodash+signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+signal-hook-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+signal-hook-devel}"
SRC_URI[aarch64_rust-prodash+signal-hook-devel.sha256sum] = "e76837a424466fff4861e4802c56333b75ed870ca1aa3e0d3b4c92ded2631042"

URI_aarch64_rust-prodash+tui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+tui-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+tui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+tui-devel}"
SRC_URI[aarch64_rust-prodash+tui-devel.sha256sum] = "b5698963788765fd76b3d1533263a683287042e6df45f05d4f47d692b64dd5ce"

URI_aarch64_rust-prodash+tui-react-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+tui-react-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+tui-react-devel}"
SRC_URI[aarch64_rust-prodash+tui-react-devel.sha256sum] = "9a5f25b36d36fa2a278a488615bb59922f4389d5a7d8650bea4b6dfdc29bfb5b"

URI_aarch64_rust-prodash+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unicode-segmentation-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-prodash+unicode-segmentation-devel.sha256sum] = "06242b9d2be687659f94539617328010d36c8f977ac500741c00e5dfaf9bbe61"

URI_aarch64_rust-prodash+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unicode-width-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unicode-width-devel}"
SRC_URI[aarch64_rust-prodash+unicode-width-devel.sha256sum] = "7f27c1e3784db4b001bb99c8a6ebf4f9ec2d41570e268eaa467f5aef2d15c8fc"

URI_aarch64_rust-prodash+unit-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unit-bytes-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unit-bytes-devel}"
SRC_URI[aarch64_rust-prodash+unit-bytes-devel.sha256sum] = "fc8350d9806efba8aef3a8265b5202d1ea5b579e8f8c293d9f54c0f0eadcbc00"

URI_aarch64_rust-prodash+unit-duration-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unit-duration-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+unit-duration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unit-duration-devel}"
SRC_URI[aarch64_rust-prodash+unit-duration-devel.sha256sum] = "854f97d9c3ab1966d3e60bb341ef2cfd2a4c559e1e2edce47b319eceda9f6256"

URI_aarch64_rust-prodash+unit-human-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unit-human-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash+unit-human-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unit-human-devel}"
SRC_URI[aarch64_rust-prodash+unit-human-devel.sha256sum] = "566d7ed7cb1f3fb2d00d63a24f90d2f87ecc8b65a07cea5b8559f5a52e0e044e"

URI_aarch64_rust-prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash-devel-31.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash-devel}"
SRC_URI[aarch64_rust-prodash-devel.sha256sum] = "5eae3dbe695e224c0c1b038e5d1aa060426d3132fb10dc79aae70f4236721a69"

RDEPENDS:rust-prodash+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+bytesize-devel = " \
 cargo \
 rust-bytesize+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+crosstermion-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+ctrlc-devel = " \
 cargo \
 rust-ctrlc+termination-devel \
 rust-ctrlc-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+dashmap-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+default-devel = " \
 cargo \
 rust-prodash+progress-tree-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+futures-core-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+human_format-devel = " \
 cargo \
 rust-human_format+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+is-terminal-devel = " \
 cargo \
 rust-is-terminal+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+jiff-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+local-time-devel = " \
 cargo \
 rust-prodash+jiff-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+parking_lot-devel = " \
 cargo \
 rust-parking_lot-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-log-devel = " \
 cargo \
 rust-prodash+log-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-tree-devel = " \
 cargo \
 rust-prodash+parking_lot-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-tree-hp-hashmap-devel = " \
 cargo \
 rust-prodash+dashmap-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-tree-log-devel = " \
 cargo \
 rust-prodash+log-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-line-autoconfigure-devel = " \
 cargo \
 rust-prodash+is-terminal-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-line-crossterm-devel = " \
 cargo \
 rust-crosstermion+crossterm-devel \
 rust-crosstermion-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-line-devel = " \
 cargo \
 rust-crosstermion+color-devel \
 rust-crosstermion-devel \
 rust-prodash+jiff-devel \
 rust-prodash+unicode-width-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-tui-crossterm-devel = " \
 cargo \
 rust-crosstermion+input-async-crossterm-devel \
 rust-crosstermion+tui-react-crossterm-devel \
 rust-crosstermion-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-tui-devel = " \
 cargo \
 rust-crosstermion+input-async-devel \
 rust-crosstermion-devel \
 rust-prodash+async-io-devel \
 rust-prodash+futures-core-devel \
 rust-prodash+futures-lite-devel \
 rust-prodash+jiff-devel \
 rust-prodash+tui-devel \
 rust-prodash+tui-react-devel \
 rust-prodash+unicode-segmentation-devel \
 rust-prodash+unicode-width-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+signal-hook-devel = " \
 cargo \
 rust-prodash-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-prodash+tui-devel = " \
 cargo \
 rust-prodash-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-prodash+tui-react-devel = " \
 cargo \
 rust-prodash-devel \
 rust-tui-react+default-devel \
 "
RDEPENDS:rust-prodash+unicode-segmentation-devel = " \
 cargo \
 rust-prodash-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-prodash+unicode-width-devel = " \
 cargo \
 rust-prodash-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-prodash+unit-bytes-devel = " \
 cargo \
 rust-prodash+bytesize-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+unit-duration-devel = " \
 cargo \
 rust-prodash+jiff-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+unit-human-devel = " \
 cargo \
 rust-prodash+human_format-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash-devel = " \
 cargo \
 rust \
 "
