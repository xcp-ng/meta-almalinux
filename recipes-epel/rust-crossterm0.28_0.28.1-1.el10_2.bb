# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossterm0.28"
PV = "0.28.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossterm0.28+bracketed-paste-devel \
 rust-crossterm0.28+default-devel \
 rust-crossterm0.28+event-stream-devel \
 rust-crossterm0.28+events-devel \
 rust-crossterm0.28+filedescriptor-devel \
 rust-crossterm0.28+libc-devel \
 rust-crossterm0.28+serde-devel \
 rust-crossterm0.28+use-dev-tty-devel \
 rust-crossterm0.28-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossterm0.28-0.28.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2b790094fd50175d09b09be515ef83baffb9ac9caf216ab4348d256877f3f5a"

URI_x86_64_v2_rust-crossterm0.28+bracketed-paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.28+bracketed-paste-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.28+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.28+bracketed-paste-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.28+bracketed-paste-devel.sha256sum] = "0631b9fca1024f97877b97a8e7d5939ff1fcf0ffdeb80e18c879f12d3f0690f7"

URI_x86_64_v2_rust-crossterm0.28+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.28+default-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.28+default-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.28+default-devel.sha256sum] = "0d15e67c1744e91397b4ff8779859374cafc74c24039e9b1bfd387819d66a066"

URI_x86_64_v2_rust-crossterm0.28+event-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.28+event-stream-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.28+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.28+event-stream-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.28+event-stream-devel.sha256sum] = "38b7ac807b11e212d92cb9942ca54bd3d6ec60c804b429340cc130c102208507"

URI_x86_64_v2_rust-crossterm0.28+events-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.28+events-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.28+events-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.28+events-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.28+events-devel.sha256sum] = "240152de9155e99a3a6347bb913ac3f5307a7f93dc12a5e66b661b9994559a97"

URI_x86_64_v2_rust-crossterm0.28+filedescriptor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.28+filedescriptor-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.28+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.28+filedescriptor-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.28+filedescriptor-devel.sha256sum] = "2e3b7e563e1e8a5b4904fe21bd9da69ef4860748dd7b58ee41b4cfcae4bc8a25"

URI_x86_64_v2_rust-crossterm0.28+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.28+libc-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.28+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.28+libc-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.28+libc-devel.sha256sum] = "f3bf47a4c3af59d163db12b1bfda248950b3382c73d25ce69d701c1a2e335a96"

URI_x86_64_v2_rust-crossterm0.28+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.28+serde-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.28+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.28+serde-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.28+serde-devel.sha256sum] = "174521d9b2a8492d746b801605e1ed4cda1b5ce5d5d886a0c8ba52a98cc05c8e"

URI_x86_64_v2_rust-crossterm0.28+use-dev-tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.28+use-dev-tty-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.28+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.28+use-dev-tty-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.28+use-dev-tty-devel.sha256sum] = "3f04b5bc634ba2d111ce1abafb978e24b56338011d8729b9466b1a6e6a24f0aa"

URI_x86_64_v2_rust-crossterm0.28-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.28-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.28-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.28-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.28-devel.sha256sum] = "257b3371866a86ac0121e7d7d2cb3f1aeecb058216b06a8ec9f36d52b3b08329"

URI_aarch64_rust-crossterm0.28+bracketed-paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.28+bracketed-paste-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm0.28+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.28+bracketed-paste-devel}"
SRC_URI[aarch64_rust-crossterm0.28+bracketed-paste-devel.sha256sum] = "42abc2ae9f527f9f161242fb96c9746dfd9f5b965e69cc2db293c1dfb07ceb53"

URI_aarch64_rust-crossterm0.28+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.28+default-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm0.28+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.28+default-devel}"
SRC_URI[aarch64_rust-crossterm0.28+default-devel.sha256sum] = "4c477699fac8f52c506f4344062be0c03a7abaf828922e878142c71e0c5541da"

URI_aarch64_rust-crossterm0.28+event-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.28+event-stream-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm0.28+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.28+event-stream-devel}"
SRC_URI[aarch64_rust-crossterm0.28+event-stream-devel.sha256sum] = "b6f512fd12d8a58311f1f78e26ce6f8a09623824596ad7777818c582598c4fc6"

URI_aarch64_rust-crossterm0.28+events-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.28+events-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm0.28+events-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.28+events-devel}"
SRC_URI[aarch64_rust-crossterm0.28+events-devel.sha256sum] = "3e340dd2fbcb11e2c05b75cf4716ed74c52520e4a35003018af084941db61992"

URI_aarch64_rust-crossterm0.28+filedescriptor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.28+filedescriptor-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm0.28+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.28+filedescriptor-devel}"
SRC_URI[aarch64_rust-crossterm0.28+filedescriptor-devel.sha256sum] = "80f1746b1f7954970d7bc4c3f48a436151ecb200184186d9828e49ad6c1b0371"

URI_aarch64_rust-crossterm0.28+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.28+libc-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm0.28+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.28+libc-devel}"
SRC_URI[aarch64_rust-crossterm0.28+libc-devel.sha256sum] = "2f813fcfe56f26431518c4402308a04c5ce2a92be025870486fafb5657b09a9a"

URI_aarch64_rust-crossterm0.28+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.28+serde-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm0.28+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.28+serde-devel}"
SRC_URI[aarch64_rust-crossterm0.28+serde-devel.sha256sum] = "71d7082c1cb29c3738d6c96e4e086fc064f22ddd330abf50ab8d596417b8f1cc"

URI_aarch64_rust-crossterm0.28+use-dev-tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.28+use-dev-tty-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm0.28+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.28+use-dev-tty-devel}"
SRC_URI[aarch64_rust-crossterm0.28+use-dev-tty-devel.sha256sum] = "440b06900524b309b32a47eeab04fae3080f8a1d225e1d4534bdcf8d56b69708"

URI_aarch64_rust-crossterm0.28-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.28-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-crossterm0.28-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.28-devel}"
SRC_URI[aarch64_rust-crossterm0.28-devel.sha256sum] = "257a894572abb2384f2ad1183e6f4c4718e4763dda9d76744f144ccdebb7fe6d"

RDEPENDS:rust-crossterm0.28+bracketed-paste-devel = " \
 cargo \
 rust-crossterm0.28-devel \
 "
RDEPENDS:rust-crossterm0.28+default-devel = " \
 cargo \
 rust-crossterm0.28+bracketed-paste-devel \
 rust-crossterm0.28+events-devel \
 rust-crossterm0.28-devel \
 "
RDEPENDS:rust-crossterm0.28+event-stream-devel = " \
 cargo \
 rust-crossterm0.28+events-devel \
 rust-crossterm0.28-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-crossterm0.28+events-devel = " \
 cargo \
 rust-crossterm0.28-devel \
 rust-mio+default-devel \
 rust-mio+os-poll-devel \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+support-v1_0-devel \
 rust-signal-hook0.3+default-devel \
 "
RDEPENDS:rust-crossterm0.28+filedescriptor-devel = " \
 cargo \
 rust-crossterm0.28-devel \
 rust-filedescriptor+default-devel \
 "
RDEPENDS:rust-crossterm0.28+libc-devel = " \
 cargo \
 rust-crossterm0.28-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-crossterm0.28+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-crossterm0.28-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-crossterm0.28+use-dev-tty-devel = " \
 cargo \
 rust-crossterm0.28+filedescriptor-devel \
 rust-crossterm0.28-devel \
 rust-rustix0.38+process-devel \
 "
RDEPENDS:rust-crossterm0.28-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-parking_lot+default-devel \
 rust-rustix0.38+std-devel \
 rust-rustix0.38+stdio-devel \
 rust-rustix0.38+termios-devel \
 rust-rustix0.38-devel \
 "
