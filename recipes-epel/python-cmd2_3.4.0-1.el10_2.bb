# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cmd2"
PV = "3.4.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-cmd2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cmd2-3.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1d438ee0e8342db98e33880d2ffc4c49834ab4afa1464aa83995075ba54f77a"

URI_x86_64_v2_python3-cmd2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cmd2-3.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cmd2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cmd2}"
SRC_URI[x86_64_v2_python3-cmd2.sha256sum] = "687231f8fd9421d6d78c08c67d30e0a78e7ad31707a80bab62b8efed84cde0e9"

URI_aarch64_python3-cmd2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cmd2-3.4.0-1.el10_2.noarch.rpm;name=aarch64_python3-cmd2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cmd2}"
SRC_URI[aarch64_python3-cmd2.sha256sum] = "7c46606060c33b8f7ae8e3beee36a4b834060dbd9c3307a137aef2d347d841ec"

RDEPENDS:python3-cmd2 = " \
 python3 \
 python3-pyperclip \
 python3-rich \
 python3-rich-argparse \
 which \
 "
