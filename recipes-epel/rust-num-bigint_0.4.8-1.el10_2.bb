# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-bigint"
PV = "0.4.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-num-bigint+arbitrary-devel \
 rust-num-bigint+default-devel \
 rust-num-bigint+quickcheck-devel \
 rust-num-bigint+rand-devel \
 rust-num-bigint+serde-devel \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-bigint-0.4.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1192eaa00f2aad2656f7c07fd1104fe4db098986c569a24b488a3c7aed96038"

URI_x86_64_v2_rust-num-bigint+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+arbitrary-devel-0.4.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+arbitrary-devel.sha256sum] = "2d4163c95b10145e402d0cf234564bcd57a2a63110dd250d692df48f1532b26b"

URI_x86_64_v2_rust-num-bigint+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+default-devel-0.4.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+default-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+default-devel.sha256sum] = "b2aa106a90add8cd37134d891de3d755956c462ac1f3b2a1d1bd373e02ede4e1"

URI_x86_64_v2_rust-num-bigint+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+quickcheck-devel-0.4.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+quickcheck-devel.sha256sum] = "703fe039c8991998946f9a017b6767e529c88319d28cb6b88a784b8ee7c82cdc"

URI_x86_64_v2_rust-num-bigint+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+rand-devel-0.4.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+rand-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+rand-devel.sha256sum] = "60f0e7ecb20502d87eaff90c9592662e55084f29cc6bdc38666978db386249c6"

URI_x86_64_v2_rust-num-bigint+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+serde-devel-0.4.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+serde-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+serde-devel.sha256sum] = "e23c4051ffc938956d15e49d95c3aa75442e6100b0564758bda92e71be91f365"

URI_x86_64_v2_rust-num-bigint+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint+std-devel-0.4.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint+std-devel}"
SRC_URI[x86_64_v2_rust-num-bigint+std-devel.sha256sum] = "52bc580f623d66f26b22049b0f1da8dc54bc503d543e7477f94d3262c1a33659"

URI_x86_64_v2_rust-num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-devel-0.4.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-devel.sha256sum] = "a3111529f45b5106c04b8f26084e8a147dd765c2c7842c5c77856666cbb43c81"

URI_aarch64_rust-num-bigint+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+arbitrary-devel-0.4.8-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+arbitrary-devel}"
SRC_URI[aarch64_rust-num-bigint+arbitrary-devel.sha256sum] = "be5d703b1356f40cd2d4c2b142351760d5d2fb1bdbbc549607f68d66709c6e7a"

URI_aarch64_rust-num-bigint+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+default-devel-0.4.8-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+default-devel}"
SRC_URI[aarch64_rust-num-bigint+default-devel.sha256sum] = "c7df6a28d30eab817ad16f839fdf924fa5cdcf1b9b5afcab90a4cc2faa6231c2"

URI_aarch64_rust-num-bigint+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+quickcheck-devel-0.4.8-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+quickcheck-devel}"
SRC_URI[aarch64_rust-num-bigint+quickcheck-devel.sha256sum] = "cf78576eb2a1b7cec314b01de007774b6d1876aae3f3f2340de0025412e1b0cc"

URI_aarch64_rust-num-bigint+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+rand-devel-0.4.8-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+rand-devel}"
SRC_URI[aarch64_rust-num-bigint+rand-devel.sha256sum] = "8769d1af91729839a75dacc84ed61a4445bf87cc567dd228a0ce5c0bdf273f5b"

URI_aarch64_rust-num-bigint+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+serde-devel-0.4.8-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+serde-devel}"
SRC_URI[aarch64_rust-num-bigint+serde-devel.sha256sum] = "1405e274148b92607ae3b1d5082c0a943499fbf4fea22f13cb6395e66c5fc70d"

URI_aarch64_rust-num-bigint+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint+std-devel-0.4.8-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint+std-devel}"
SRC_URI[aarch64_rust-num-bigint+std-devel.sha256sum] = "344bb434f491a3b11c183fbaea465c0fdbe9a78bf2546c80b2ac04e1eeb0585a"

URI_aarch64_rust-num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-devel-0.4.8-1.el10_2.noarch.rpm;name=aarch64_rust-num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-devel}"
SRC_URI[aarch64_rust-num-bigint-devel.sha256sum] = "9f71e39de220d5a9133edd19e9e88dcfcfa2b79338b45097fa6bf4c8dc360db8"

RDEPENDS:rust-num-bigint+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-num-bigint-devel \
 "
RDEPENDS:rust-num-bigint+default-devel = " \
 cargo \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 "
RDEPENDS:rust-num-bigint+quickcheck-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-num-bigint+rand-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint+serde-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-bigint+std-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-bigint-devel = " \
 cargo \
 rust \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
