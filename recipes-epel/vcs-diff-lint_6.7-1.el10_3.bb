# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vcs-diff-lint"
PV = "6.7"
PR = "1.el10_3"
PACKAGES = " \
 vcs-diff-lint \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vcs-diff-lint-6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcc7fda722c4ac8af052ed95ca479f8447d0f63e32869db61bccb27fa9b18be8"

URI_x86_64_v2_vcs-diff-lint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vcs-diff-lint-6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_vcs-diff-lint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vcs-diff-lint}"
SRC_URI[x86_64_v2_vcs-diff-lint.sha256sum] = "0460e61ee8598ff597bb31525749bc94c649f80175f3602c7ed9da673444823a"

URI_aarch64_vcs-diff-lint = "${EPEL_MIRROR}/aarch64/Packages/v/vcs-diff-lint-6.7-1.el10_3.noarch.rpm;name=aarch64_vcs-diff-lint;unpack=0"
SRC_URI:append = " ${URI_aarch64_vcs-diff-lint}"
SRC_URI[aarch64_vcs-diff-lint.sha256sum] = "225f36143881c55dfec600c6ff3822a732564a7a5bf62daaf185f604ee575f00"

RDEPENDS:vcs-diff-lint = " \
 csdiff \
 git-core \
 python3 \
 "
