# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-vcr"
PV = "1.0.2"
PR = "22.el10_0"
PACKAGES = " \
 python3-pytest-vcr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-vcr-1.0.2-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2fa962826ba5d2402bda382f1319a588c2557dd34e5ce4483b5640f7379c92f"

URI_x86_64_v2_python3-pytest-vcr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-vcr-1.0.2-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-vcr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-vcr}"
SRC_URI[x86_64_v2_python3-pytest-vcr.sha256sum] = "4b671f175aff566e9edebbe14da048c8edf0a868c6fd3212cc6144765eb8fd9f"

URI_aarch64_python3-pytest-vcr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-vcr-1.0.2-22.el10_0.noarch.rpm;name=aarch64_python3-pytest-vcr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-vcr}"
SRC_URI[aarch64_python3-pytest-vcr.sha256sum] = "4a9e2821696bbccd4be709712fefb9a2c69d19cab7316379f14092490e5fd08e"

RDEPENDS:python3-pytest-vcr = " \
 python3 \
 python3-pytest \
 python3-vcrpy \
 "
