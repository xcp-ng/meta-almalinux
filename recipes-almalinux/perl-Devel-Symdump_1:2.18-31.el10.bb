# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-Symdump"
PE = "1"
PV = "2.18"
PR = "31.el10"
PACKAGES = " \
 perl-Devel-Symdump \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Devel-Symdump-2.18-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5da4b3748b0a179880baa44ce17f976fff4033097f589d7de4830123ddb6b30"

URI_x86_64_v2_perl-Devel-Symdump = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Devel-Symdump-2.18-31.el10.noarch.rpm;name=x86_64_v2_perl-Devel-Symdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-Symdump}"
SRC_URI[x86_64_v2_perl-Devel-Symdump.sha256sum] = "097d58f504b8d47500b899f327635d57583071394979bd8266e13acb24e1c4bc"

URI_aarch64_perl-Devel-Symdump = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Devel-Symdump-2.18-31.el10.noarch.rpm;name=aarch64_perl-Devel-Symdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-Symdump}"
SRC_URI[aarch64_perl-Devel-Symdump.sha256sum] = "097d58f504b8d47500b899f327635d57583071394979bd8266e13acb24e1c4bc"

RDEPENDS:perl-Devel-Symdump = " \
 perl-B \
 perl-Carp \
 perl-Devel-Symdump \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-vars \
 "
