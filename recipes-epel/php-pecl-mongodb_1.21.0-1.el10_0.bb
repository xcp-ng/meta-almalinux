# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb"
PV = "1.21.0"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-mongodb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb-1.21.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae12585fc28d3fa59e41d9cbc65f21409bd8fa7c302e7f066016523f50b74e9e"

URI_x86_64_v2_php-pecl-mongodb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb-1.21.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mongodb}"
SRC_URI[x86_64_v2_php-pecl-mongodb.sha256sum] = "fd62b2fbfa5b1288895cb1c4ba1d17082c72523fed6c07998ab1f85829847f8a"

URI_aarch64_php-pecl-mongodb = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb-1.21.0-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mongodb}"
SRC_URI[aarch64_php-pecl-mongodb.sha256sum] = "f458685c2ef860c95a3c6c019fc7e57b0269311687a6f873edc6e163a8f7302e"

RDEPENDS:php-pecl-mongodb = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 "
