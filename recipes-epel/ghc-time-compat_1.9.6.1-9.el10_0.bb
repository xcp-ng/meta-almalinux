# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-time-compat"
PV = "1.9.6.1"
PR = "9.el10_0"
PACKAGES = " \
 ghc-time-compat \
 ghc-time-compat-devel \
 ghc-time-compat-doc \
 ghc-time-compat-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-time-compat-1.9.6.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5aa733006515afc42e90764395412026ae4bea64f52367044dbad200665ae4ff"

URI_x86_64_v2_ghc-time-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-compat-1.9.6.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-compat}"
SRC_URI[x86_64_v2_ghc-time-compat.sha256sum] = "cf84dfa8686a19d2a63f05ebcff4915d1173164227f484edeaa4aee76eec85f8"

URI_x86_64_v2_ghc-time-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-compat-devel-1.9.6.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-compat-devel}"
SRC_URI[x86_64_v2_ghc-time-compat-devel.sha256sum] = "a61a498298a0755e3db9e3fb135ddd387ac59f313c42d725f44972dcc7df4cc5"

URI_x86_64_v2_ghc-time-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-compat-doc-1.9.6.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-time-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-compat-doc}"
SRC_URI[x86_64_v2_ghc-time-compat-doc.sha256sum] = "32b2dc57448c4daf18f499518bae5c28e4d3de3a07faf7295c5eda69490fdc9b"

URI_x86_64_v2_ghc-time-compat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-time-compat-prof-1.9.6.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-time-compat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-time-compat-prof}"
SRC_URI[x86_64_v2_ghc-time-compat-prof.sha256sum] = "93b55ee53e141130d012d2d4ddb5d5edbd19908aac5fcb1d4d352b4e8623f306"

URI_aarch64_ghc-time-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-compat-1.9.6.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-time-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-compat}"
SRC_URI[aarch64_ghc-time-compat.sha256sum] = "de77749433772536bb4c06940284adc34ef85f8e3ba0b3520ae6a152a34d0bc8"

URI_aarch64_ghc-time-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-compat-devel-1.9.6.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-time-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-compat-devel}"
SRC_URI[aarch64_ghc-time-compat-devel.sha256sum] = "7200d37c5eca0c54fc628142c535e4bec5f2b480d8413846ecf713453d63dd1c"

URI_aarch64_ghc-time-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-compat-doc-1.9.6.1-9.el10_0.noarch.rpm;name=aarch64_ghc-time-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-compat-doc}"
SRC_URI[aarch64_ghc-time-compat-doc.sha256sum] = "c8f79e00ca8c2eb290b16860894f946c2242142b5453716037587ed21c0950e0"

URI_aarch64_ghc-time-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-time-compat-prof-1.9.6.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-time-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-time-compat-prof}"
SRC_URI[aarch64_ghc-time-compat-prof.sha256sum] = "5667ec4fb78b9566ed274489c4efe437545f19b1c614c84ede33cbef3dfd96c0"

RDEPENDS:ghc-time-compat = " \
 ghc-array \
 ghc-base \
 ghc-base-orphans \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-time-compat-devel = " \
 ghc-base-devel \
 ghc-base-orphans-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-time-compat \
 ghc-time-devel \
 "
RDEPENDS:ghc-time-compat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-time-compat-prof = " \
 ghc-base-orphans-prof \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-time-compat-devel \
 ghc-time-prof \
 "
