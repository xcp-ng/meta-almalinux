# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vulkan-validation-layers"
PV = "1.4.328.1"
PR = "1.el10"
PACKAGES = " \
 vulkan-validation-layers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vulkan-validation-layers-1.4.328.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93ba0a60ffc634adfc59315030088482052548b3bedbcb5f61950c02b801a763"

URI_x86_64_v2_vulkan-validation-layers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vulkan-validation-layers-1.4.328.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_vulkan-validation-layers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vulkan-validation-layers}"
SRC_URI[x86_64_v2_vulkan-validation-layers.sha256sum] = "299cd9c3066c8c3e4c0d9b7637758a2c839b0245c93a1400898f139667331526"

URI_aarch64_vulkan-validation-layers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vulkan-validation-layers-1.4.328.1-1.el10.aarch64.rpm;name=aarch64_vulkan-validation-layers;unpack=0"
SRC_URI:append = " ${URI_aarch64_vulkan-validation-layers}"
SRC_URI[aarch64_vulkan-validation-layers.sha256sum] = "13998ae70c6c58509363e6bb3d62c80595b1844ded22879709b62f32329f806c"

RDEPENDS:vulkan-validation-layers = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
