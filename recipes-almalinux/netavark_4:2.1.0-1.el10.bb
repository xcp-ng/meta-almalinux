# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netavark"
PE = "4"
PV = "2.1.0"
PR = "1.el10"
PACKAGES = " \
 netavark \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/netavark-2.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e1cbf4fa4ba2dd4ece9682eb9a40306791d4b31523b36cb2a0af39aac3e7b54"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netavark-2.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_netavark;unpack=0"
SRC_URI[x86_64_v2_netavark.sha256sum] = "caa60adf1c35b74900eea9d75882d80bdd8a721af378f57ab058c16835d259da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netavark-2.1.0-1.el10.aarch64.rpm;name=aarch64_netavark;unpack=0"
SRC_URI[aarch64_netavark.sha256sum] = "428319310e6f63325323cda87d913b88af6290f4e2f448c800199d3c11c5a8da"

RDEPENDS:netavark = " \
 aardvark-dns \
 bash \
 glibc \
 libgcc \
 nftables \
 "
