# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bpftrace"
PV = "0.22.1"
PR = "1.el10"
PACKAGES = " \
 bpftrace \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bpftrace-0.22.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a36eff99718979bf1c24628860d73a0c3ee2722d28eedbed26d1fb51863e761c"

URI_x86_64_v2_bpftrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bpftrace-0.22.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_bpftrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bpftrace}"
SRC_URI[x86_64_v2_bpftrace.sha256sum] = "aff45f40e7e554447703b0ebc2b16b9ed334bd4f6dbeaa65b768cad9998d9b5a"

URI_aarch64_bpftrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bpftrace-0.22.1-1.el10.aarch64.rpm;name=aarch64_bpftrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_bpftrace}"
SRC_URI[aarch64_bpftrace.sha256sum] = "7186af203aadd10e1327f10df296f2b11f0681d5eaeb98830a712efebcbe6903"

RDEPENDS:bpftrace = " \
 bcc \
 clang-libs \
 elfutils-libelf \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 lldb \
 llvm-libs \
 zlib-ng-compat \
 "
