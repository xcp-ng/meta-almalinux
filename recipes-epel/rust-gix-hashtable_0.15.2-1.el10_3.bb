# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-hashtable"
PV = "0.15.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-hashtable+default-devel \
 rust-gix-hashtable+sha1-devel \
 rust-gix-hashtable+sha256-devel \
 rust-gix-hashtable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-hashtable-0.15.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9025d821708aecb04411fcb02a22a9e8f9ad71546de1cc6e15c069f07a620893"

URI_x86_64_v2_rust-gix-hashtable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable+default-devel-0.15.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable+default-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable+default-devel.sha256sum] = "7e8e92c4ea2dfe55e813a45ae769e4f3ddc5773392a7df5cfeabda2db5fcb8b2"

URI_x86_64_v2_rust-gix-hashtable+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable+sha1-devel-0.15.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable+sha1-devel.sha256sum] = "d35fd6cae9ce6e0cfc675211a1779805f27f3c19110f7218f707d4fd480d8d59"

URI_x86_64_v2_rust-gix-hashtable+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable+sha256-devel-0.15.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable+sha256-devel.sha256sum] = "7d94374e610b92bfad7f0c39d8a764ceb61e7896763d3eef0263175c9ea5c73e"

URI_x86_64_v2_rust-gix-hashtable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable-devel-0.15.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable-devel.sha256sum] = "d5a8c31b6ecdba2f03ec261baa810be821ec86dfb25afde9187b49f1471d7a71"

URI_aarch64_rust-gix-hashtable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable+default-devel-0.15.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hashtable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable+default-devel}"
SRC_URI[aarch64_rust-gix-hashtable+default-devel.sha256sum] = "e5408144b557fcf03699a6d1dd785df8cdbbfcb2768fecad191f70ad50c800d9"

URI_aarch64_rust-gix-hashtable+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable+sha1-devel-0.15.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hashtable+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable+sha1-devel}"
SRC_URI[aarch64_rust-gix-hashtable+sha1-devel.sha256sum] = "d91cafd55cede8c0ab8177cf987424de26fc44670fb0bdfa88a811e99231725d"

URI_aarch64_rust-gix-hashtable+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable+sha256-devel-0.15.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hashtable+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable+sha256-devel}"
SRC_URI[aarch64_rust-gix-hashtable+sha256-devel.sha256sum] = "512c501e48520be7e6a3206ac2b80dca513d1be83eebf944cf12451541467663"

URI_aarch64_rust-gix-hashtable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable-devel-0.15.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hashtable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable-devel}"
SRC_URI[aarch64_rust-gix-hashtable-devel.sha256sum] = "22bd68906044a1b84263530337fea18c4032bd5c63db22e395c35854f3dd498a"

RDEPENDS:rust-gix-hashtable+default-devel = " \
 cargo \
 rust-gix-hashtable-devel \
 "
RDEPENDS:rust-gix-hashtable+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-hashtable-devel \
 "
RDEPENDS:rust-gix-hashtable+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-hashtable-devel \
 "
RDEPENDS:rust-gix-hashtable-devel = " \
 cargo \
 rust \
 rust-gix-hash+default-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 rust-parking_lot+default-devel \
 "
