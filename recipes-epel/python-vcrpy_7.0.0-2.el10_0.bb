# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-vcrpy"
PV = "7.0.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-vcrpy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-vcrpy-7.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7280b23f95a1f0499f756d99302b28de979f36ca689e088954e35ad53320a614"

URI_x86_64_v2_python3-vcrpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vcrpy-7.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-vcrpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vcrpy}"
SRC_URI[x86_64_v2_python3-vcrpy.sha256sum] = "efc73fe316e5251fa5c95883aee67ae24a20a050509040da6169eb64615111d1"

URI_aarch64_python3-vcrpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vcrpy-7.0.0-2.el10_0.noarch.rpm;name=aarch64_python3-vcrpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vcrpy}"
SRC_URI[aarch64_python3-vcrpy.sha256sum] = "56304c4ace50ad3d4f69eb363c6824365adaf1837e9f2b4902ae63dc7db00850"

RDEPENDS:python3-vcrpy = " \
 python3 \
 python3-pyyaml \
 python3-urllib3 \
 python3-wrapt \
 python3-yarl \
 "
