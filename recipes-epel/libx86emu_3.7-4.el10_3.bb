# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libx86emu"
PV = "3.7"
PR = "4.el10_3"
PACKAGES = " \
 libx86emu \
 libx86emu-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libx86emu-3.7-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95a895254bdb4a29b598d4a480812ddc8a3851c67624350ae189cb97e153d6ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libx86emu-3.7-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libx86emu;unpack=0"
SRC_URI[x86_64_v2_libx86emu.sha256sum] = "e4ffe778e094e8e978fc343d9be5f31ae74fda8330d5a751e0f87fc3927648b1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libx86emu-devel-3.7-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libx86emu-devel;unpack=0"
SRC_URI[x86_64_v2_libx86emu-devel.sha256sum] = "9b5d625750f7eec14bc7c0b491d331d236997377ecf083b8f464f7e8f8944d4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libx86emu-3.7-4.el10_3.aarch64.rpm;name=aarch64_libx86emu;unpack=0"
SRC_URI[aarch64_libx86emu.sha256sum] = "f95ce5b3390f84b96ac2158ecffd14bdfdc9fca82a32cdd0ff4e0c3c2ebb96a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libx86emu-devel-3.7-4.el10_3.aarch64.rpm;name=aarch64_libx86emu-devel;unpack=0"
SRC_URI[aarch64_libx86emu-devel.sha256sum] = "004032e48e044e9a98320167a1f8e640b2a6bba78cfc886ab7f11c38e283caff"

RDEPENDS:libx86emu = " \
 glibc \
 "
RDEPENDS:libx86emu-devel = " \
 libx86emu \
 "
