# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radeontop"
PV = "1.4"
PR = "1.el10_0"
PACKAGES = " \
 radeontop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radeontop-1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff256c91a73b2d70e9c03556f80f7384e3137b15afce723e000a6506d28a8906"

URI_x86_64_v2_radeontop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radeontop-1.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radeontop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radeontop}"
SRC_URI[x86_64_v2_radeontop.sha256sum] = "c65fa8b1c8f5ab7c6c47c03b679ad688e4ec0d18999bab51469cba5ee252dc59"

URI_aarch64_radeontop = "${EPEL_MIRROR}/aarch64/Packages/r/radeontop-1.4-1.el10_0.aarch64.rpm;name=aarch64_radeontop;unpack=0"
SRC_URI:append = " ${URI_aarch64_radeontop}"
SRC_URI[aarch64_radeontop.sha256sum] = "08f55a111b3bb8bcd3ce1c2e141dc733f96acdb2b05355915d8bd0c99f0b52f7"

RDEPENDS:radeontop = " \
 glibc \
 libdrm \
 libpciaccess \
 libxcb \
 ncurses-libs \
 "
