# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert2-macros"
PV = "0.3.16"
PR = "2.el10_2"
PACKAGES = " \
 rust-assert2-macros+default-devel \
 rust-assert2-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert2-macros-0.3.16-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35ec6672ce53d0615ca887feaed99b04ece67880dcd07db56ba1b3e463672d5c"

URI_x86_64_v2_rust-assert2-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert2-macros+default-devel-0.3.16-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert2-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert2-macros+default-devel}"
SRC_URI[x86_64_v2_rust-assert2-macros+default-devel.sha256sum] = "89120faf51748ecc1eb2d19e10636da057d763bbfbd7b61098044a20ba459b44"

URI_x86_64_v2_rust-assert2-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert2-macros-devel-0.3.16-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert2-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert2-macros-devel}"
SRC_URI[x86_64_v2_rust-assert2-macros-devel.sha256sum] = "508f3d8edd34e215ed3443a282dd0fae5423bfb494b4af98dc71ba489be21369"

URI_aarch64_rust-assert2-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert2-macros+default-devel-0.3.16-2.el10_2.noarch.rpm;name=aarch64_rust-assert2-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert2-macros+default-devel}"
SRC_URI[aarch64_rust-assert2-macros+default-devel.sha256sum] = "0bda7b60c6da0d6e4655b6a202009acccb075f1bd210d696ad8325728f18f371"

URI_aarch64_rust-assert2-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert2-macros-devel-0.3.16-2.el10_2.noarch.rpm;name=aarch64_rust-assert2-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert2-macros-devel}"
SRC_URI[aarch64_rust-assert2-macros-devel.sha256sum] = "2601d3be2ccc94c3efe23e397ff226ac5161bd5e0b483044389f216febdad2c5"

RDEPENDS:rust-assert2-macros+default-devel = " \
 cargo \
 rust-assert2-macros-devel \
 "
RDEPENDS:rust-assert2-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rustc_version+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 "
