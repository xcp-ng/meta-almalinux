# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av1-grain"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-av1-grain+create-devel \
 rust-av1-grain+default-devel \
 rust-av1-grain+diff-devel \
 rust-av1-grain+estimate-devel \
 rust-av1-grain+nom-devel \
 rust-av1-grain+num-rational-devel \
 rust-av1-grain+parse-devel \
 rust-av1-grain+serde-devel \
 rust-av1-grain+serialize-devel \
 rust-av1-grain+unstable-devel \
 rust-av1-grain+v_frame-devel \
 rust-av1-grain-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av1-grain-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c78ecc377a982656eed33110ba43c838020df9967b7c028edadce0b6637c29c9"

URI_x86_64_v2_rust-av1-grain+create-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+create-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+create-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+create-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+create-devel.sha256sum] = "a023de01afdae549cbab31d498759545651eeed874d565ecb8ba3912a31a0f95"

URI_x86_64_v2_rust-av1-grain+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+default-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+default-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+default-devel.sha256sum] = "9cd1ce4d0170f15e528d459942fc1202b48157642f29910d8c21e101d9ebbbb8"

URI_x86_64_v2_rust-av1-grain+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+diff-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+diff-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+diff-devel.sha256sum] = "f2a99b1fc1e902af2c4dd442132c3b0695e0789253d2d5060877af9daf0eba15"

URI_x86_64_v2_rust-av1-grain+estimate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+estimate-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+estimate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+estimate-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+estimate-devel.sha256sum] = "a1e68e32dfe709095eb0d749c74e06eb41051b0f0c249134294b7e843f4ce215"

URI_x86_64_v2_rust-av1-grain+nom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+nom-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+nom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+nom-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+nom-devel.sha256sum] = "54eb63e6d03bfc566a87b653004f58c5822e3b7f3842e53cf2bde00b31bc00c8"

URI_x86_64_v2_rust-av1-grain+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+num-rational-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+num-rational-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+num-rational-devel.sha256sum] = "bf53eca7b27e1bcf4fc4f6dd7382083e409c2fc31a7071a3fc5d829b996cd631"

URI_x86_64_v2_rust-av1-grain+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+parse-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+parse-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+parse-devel.sha256sum] = "acafa53a076915059d890d942d7c6242d0e84a2f83271a1aaa83c42bc600f469"

URI_x86_64_v2_rust-av1-grain+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+serde-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+serde-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+serde-devel.sha256sum] = "fb4a83a4dd816f372830258f317f4d779ac6c0973d44dcb55e1ab38217d1e99c"

URI_x86_64_v2_rust-av1-grain+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+serialize-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+serialize-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+serialize-devel.sha256sum] = "b4c1f9ee05894e0076758953e84929dfc4367b26c652e2821ceac18ac780b506"

URI_x86_64_v2_rust-av1-grain+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+unstable-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+unstable-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+unstable-devel.sha256sum] = "f54283a69bb2145418f7deb821316e00c1912c47109de2cfe144ac8ba5db4f41"

URI_x86_64_v2_rust-av1-grain+v_frame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain+v_frame-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain+v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain+v_frame-devel}"
SRC_URI[x86_64_v2_rust-av1-grain+v_frame-devel.sha256sum] = "56c7ef4b266a4dc340856f397731727b6b6da02b304e9545816f1b0e43f6a46b"

URI_x86_64_v2_rust-av1-grain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av1-grain-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av1-grain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av1-grain-devel}"
SRC_URI[x86_64_v2_rust-av1-grain-devel.sha256sum] = "7687c0b7e29b77fa2dbc625e3873fa98777410e6c2c46cfee723e4211fa6bfb2"

URI_aarch64_rust-av1-grain+create-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+create-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+create-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+create-devel}"
SRC_URI[aarch64_rust-av1-grain+create-devel.sha256sum] = "b5989fa09bc67caf0336e1233aa381ec0b3712831a5012644735c0c516149488"

URI_aarch64_rust-av1-grain+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+default-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+default-devel}"
SRC_URI[aarch64_rust-av1-grain+default-devel.sha256sum] = "40c8f3edb9c8d38f6da8d8d5d185ac0cfddc01044e364867ba02faa8ec3f5916"

URI_aarch64_rust-av1-grain+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+diff-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+diff-devel}"
SRC_URI[aarch64_rust-av1-grain+diff-devel.sha256sum] = "bd251c2ae6f51f11cdf43de755b59c08d61244badcf7b1c726e78b7598cbc447"

URI_aarch64_rust-av1-grain+estimate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+estimate-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+estimate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+estimate-devel}"
SRC_URI[aarch64_rust-av1-grain+estimate-devel.sha256sum] = "27ae55fdf18d7482a8dd733dfd1ee05c5ea68301b87abbcf8c63ef664ff97695"

URI_aarch64_rust-av1-grain+nom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+nom-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+nom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+nom-devel}"
SRC_URI[aarch64_rust-av1-grain+nom-devel.sha256sum] = "84e08234a1d72542e9ba76c0d3ee224cfa53d1de76d953928d8c856d860b6adb"

URI_aarch64_rust-av1-grain+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+num-rational-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+num-rational-devel}"
SRC_URI[aarch64_rust-av1-grain+num-rational-devel.sha256sum] = "fa586e7a807dece46b7561aa24ec6e8f2b3ca885f038d45f5c835fcdc427dbaa"

URI_aarch64_rust-av1-grain+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+parse-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+parse-devel}"
SRC_URI[aarch64_rust-av1-grain+parse-devel.sha256sum] = "f2373331c05c0e027aacb01fa2ff791279565e633d00eefe77153f012707cdff"

URI_aarch64_rust-av1-grain+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+serde-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+serde-devel}"
SRC_URI[aarch64_rust-av1-grain+serde-devel.sha256sum] = "901eee0294c07bcde9f3bdde3642b38cbd95f1c1a87d063e1d6cbea22025b9e8"

URI_aarch64_rust-av1-grain+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+serialize-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+serialize-devel}"
SRC_URI[aarch64_rust-av1-grain+serialize-devel.sha256sum] = "87a80200bb21b798bec67ffb35c34b15ec6f0f91e75bcb85329528c0f635afff"

URI_aarch64_rust-av1-grain+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+unstable-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+unstable-devel}"
SRC_URI[aarch64_rust-av1-grain+unstable-devel.sha256sum] = "5dda7c830b01a9c56820f9c030f9c5effcc30e170233e4a2bfabfbefdd0a39f6"

URI_aarch64_rust-av1-grain+v_frame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain+v_frame-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain+v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain+v_frame-devel}"
SRC_URI[aarch64_rust-av1-grain+v_frame-devel.sha256sum] = "d9e53971be7095b3440ed7f5e533a5bdab05c2703efa1f646c6f916a72c2faa4"

URI_aarch64_rust-av1-grain-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av1-grain-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-av1-grain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av1-grain-devel}"
SRC_URI[aarch64_rust-av1-grain-devel.sha256sum] = "bcf8247cc2f8878c91719bfd7eac6044572b5b37014abab4a874dba02a06f2f2"

RDEPENDS:rust-av1-grain+create-devel = " \
 cargo \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+default-devel = " \
 cargo \
 rust-av1-grain+create-devel \
 rust-av1-grain+diff-devel \
 rust-av1-grain+estimate-devel \
 rust-av1-grain+parse-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+diff-devel = " \
 cargo \
 rust-av1-grain+num-rational-devel \
 rust-av1-grain+v_frame-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+estimate-devel = " \
 cargo \
 rust-av1-grain+v_frame-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+nom-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-nom+default-devel \
 "
RDEPENDS:rust-av1-grain+num-rational-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-num-rational+default-devel \
 "
RDEPENDS:rust-av1-grain+parse-devel = " \
 cargo \
 rust-av1-grain+nom-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+serde-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-av1-grain+serialize-devel = " \
 cargo \
 rust-arrayvec+serde-devel \
 rust-av1-grain+serde-devel \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+unstable-devel = " \
 cargo \
 rust-av1-grain-devel \
 "
RDEPENDS:rust-av1-grain+v_frame-devel = " \
 cargo \
 rust-av1-grain-devel \
 rust-v_frame+default-devel \
 "
RDEPENDS:rust-av1-grain-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-arrayvec+default-devel \
 rust-log+default-devel \
 "
