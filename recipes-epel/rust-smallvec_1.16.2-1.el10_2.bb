# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smallvec"
PV = "1.16.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-smallvec+arbitrary-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-smallvec+drain_filter-devel \
 rust-smallvec+drain_keep_rest-devel \
 rust-smallvec+may_dangle-devel \
 rust-smallvec+serde-devel \
 rust-smallvec+specialization-devel \
 rust-smallvec+union-devel \
 rust-smallvec+write-devel \
 rust-smallvec-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-smallvec-1.16.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9fa2f6d7a97499c67c2f48db6c513cb33e4a27b0c2a18bdae617aa148686acdd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+arbitrary-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+arbitrary-devel.sha256sum] = "f0eb696ccdab09d9000c603c55b0828d418912028ddc8ae28322a9dfc2cc2b01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_generics-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+const_generics-devel.sha256sum] = "b5425367132412b4289ba9329a8c427e83670c4d9a5d967184e2517e84670015"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_new-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_new-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+const_new-devel.sha256sum] = "a01f8e99e097a960b61b98840fb7c800a4c62c24599431d9db53f3eff24f7f9a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+default-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+default-devel.sha256sum] = "edbb4f45e9a6c0c3f2f5a8d841b94f00215dc90f0b95aff38414a352667c406c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_filter-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+drain_filter-devel.sha256sum] = "9396e2f5ce1f2a9580187ca62581eae08321b6e951f45a553755423aaceb75e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_keep_rest-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+drain_keep_rest-devel.sha256sum] = "0f38fa9a92a74ccec26501bc220c1cbd4d5482355721df82657aca0b209dbec3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+may_dangle-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+may_dangle-devel.sha256sum] = "2d6d2e7908b25ec91e2cb2138eb25c529e70e79eb2764c6e42c83c812d734095"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+serde-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+serde-devel.sha256sum] = "b5a402d2bdcc177188b2a30a4b3403fb08328e066a4fdcb00b1b8e9164e9ce9e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+specialization-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+specialization-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+specialization-devel.sha256sum] = "75e0091e6d89f17bcd10d2cc2916cc68e93e32efe3234b7a583cecba2efc692b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+union-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+union-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+union-devel.sha256sum] = "34e3b13a71837824a76b9bb1f1afd7155519d92760a44b31b9d71dbb23799a5f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+write-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+write-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+write-devel.sha256sum] = "b50c6ee6fbd24e4031e53f0e66cd61a3ff2e160362de13a973d6a28b89565d8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec-devel-1.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec-devel.sha256sum] = "6541737d34dff5751c2b7bd8d167cc33261e2f8454bdc3d11ae41fdeb50a102f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+arbitrary-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+arbitrary-devel.sha256sum] = "3bbec7df9473f4143677cf20067ea9bc716efecd3d36084babd8d1de9e0676ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_generics-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+const_generics-devel.sha256sum] = "7fed63263072c7006bf3f0189d48aa1150d65009ec8f13fa078725293c04c369"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_new-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+const_new-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+const_new-devel.sha256sum] = "41bc1de071e8cb0a3b0041852dd7628aa3dbdc6b51e6e66d8241f9aa2042e228"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+default-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+default-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+default-devel.sha256sum] = "148d9dcb13a35b5e03b74234185781e1d338a22d21ecdf0f0ef4eb6a10e1b64a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_filter-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+drain_filter-devel.sha256sum] = "13ffc11258ec59b774d883c5baae1acc6ef292fef18eda39d8e03122ced2e756"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_keep_rest-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+drain_keep_rest-devel.sha256sum] = "5fb924adfc0a9cbbdbbfa7a6f43e0d5a3edf5c15509dc9fcb7bdc4946614964b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+may_dangle-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+may_dangle-devel.sha256sum] = "d4f3e34ec65218ff5cce8ce2719c244f0645969a8fdfaa178962091bdd795c71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+serde-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+serde-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+serde-devel.sha256sum] = "799a532ee29269d4307371706f57eee4ae66cae6d9ae03d01d75483d1c6bded1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+specialization-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+specialization-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+specialization-devel.sha256sum] = "86af6b791bef71ac2f2ba0f1e8124ee0267f1f96ba822d675401c3426caa9211"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+union-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+union-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+union-devel.sha256sum] = "3d57aee28df232ae5929ccb2a06e3e3e228a8ac5fc92791c09cb22a537f29901"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+write-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec+write-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+write-devel.sha256sum] = "a64c826f3e6cf7b0d336eda756c470a218ddb7f8a3f6999becb6576845827f54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec-devel-1.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-smallvec-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec-devel.sha256sum] = "47b130acc340dca27f94e0b4cc3c05fac63303843800880f27e51077796e2c38"

RDEPENDS:rust-smallvec+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_generics-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_new-devel = " \
 cargo \
 rust-smallvec+const_generics-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+default-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_filter-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_keep_rest-devel = " \
 cargo \
 rust-smallvec+drain_filter-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+may_dangle-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+specialization-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+union-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+write-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec-devel = " \
 cargo \
 "
