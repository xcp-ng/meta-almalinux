# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdns"
PV = "5.0.1"
PR = "1.el10_0"
PACKAGES = " \
 pdns \
 pdns-backend-ldap \
 pdns-backend-lmdb \
 pdns-backend-lua2 \
 pdns-backend-mysql \
 pdns-backend-pipe \
 pdns-backend-postgresql \
 pdns-backend-remote \
 pdns-backend-sqlite \
 pdns-backend-tinydns \
 pdns-ixfrdist \
 pdns-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pdns-5.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0deadaa2d4bd2360f2bf02f68a23a8dd2aa4b3b6dde66f117adc9ef355b663a3"

URI_x86_64_v2_pdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns}"
SRC_URI[x86_64_v2_pdns.sha256sum] = "33f3f1d1205a56ec024735fd010756f6a5e5390ee2b2990ec0a92511caa989ad"

URI_x86_64_v2_pdns-backend-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-ldap-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-ldap}"
SRC_URI[x86_64_v2_pdns-backend-ldap.sha256sum] = "1226c0ac1321c703f1269f5d08c23ebb583d08382b1c52b02ce8a7a12b8ec98f"

URI_x86_64_v2_pdns-backend-lmdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-lmdb-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-lmdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-lmdb}"
SRC_URI[x86_64_v2_pdns-backend-lmdb.sha256sum] = "d03a5e9512838b5631f91fc85c4ee85674b2d8dc21c295453cac7476cdaae773"

URI_x86_64_v2_pdns-backend-lua2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-lua2-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-lua2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-lua2}"
SRC_URI[x86_64_v2_pdns-backend-lua2.sha256sum] = "042172cc82b35da217d25fec0c3eeaeb743dabd58ba0e3cb04b960b90c6b6735"

URI_x86_64_v2_pdns-backend-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-mysql-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-mysql}"
SRC_URI[x86_64_v2_pdns-backend-mysql.sha256sum] = "baa4f72e728a520f0be436a46607a9f7fb8c9fec6c0a360ff0e4edf8185694a0"

URI_x86_64_v2_pdns-backend-pipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-pipe-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-pipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-pipe}"
SRC_URI[x86_64_v2_pdns-backend-pipe.sha256sum] = "765887be4dea0c968f501082c048b7b4af755872d43fd3ae050d3863a1aff7a4"

URI_x86_64_v2_pdns-backend-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-postgresql-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-postgresql}"
SRC_URI[x86_64_v2_pdns-backend-postgresql.sha256sum] = "05c9a1cd3e24a57873133117c45d7bd0bec66e9b537c960221cc816bdda95949"

URI_x86_64_v2_pdns-backend-remote = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-remote-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-remote}"
SRC_URI[x86_64_v2_pdns-backend-remote.sha256sum] = "edc67159f7919e0f564c7e976d37b9010725b673f150f79ab12a5214c458d99f"

URI_x86_64_v2_pdns-backend-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-sqlite-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-sqlite}"
SRC_URI[x86_64_v2_pdns-backend-sqlite.sha256sum] = "83e0904f7a6d7b69b8632b6a37a573f582037721ec61cbeb3eb71fa05de82c21"

URI_x86_64_v2_pdns-backend-tinydns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-backend-tinydns-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-backend-tinydns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-backend-tinydns}"
SRC_URI[x86_64_v2_pdns-backend-tinydns.sha256sum] = "511e4c835278753b98af30a1c109f9dee952f4afffe262f23b2920920393559d"

URI_x86_64_v2_pdns-ixfrdist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-ixfrdist-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-ixfrdist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-ixfrdist}"
SRC_URI[x86_64_v2_pdns-ixfrdist.sha256sum] = "d77fd7033abf3041986e7b2f1652af5e0d6d0b58be5febf3dbfc441f61209f00"

URI_x86_64_v2_pdns-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-tools-5.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-tools}"
SRC_URI[x86_64_v2_pdns-tools.sha256sum] = "d6670eff6e9f6c26940e1c3ec8721c0b221bed05474225f5c5296f729cac5be9"

URI_aarch64_pdns = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns}"
SRC_URI[aarch64_pdns.sha256sum] = "69f55878f492bed811fb3f5cf71a4851da908378b3837c865672401989af8e43"

URI_aarch64_pdns-backend-ldap = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-ldap-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-backend-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-ldap}"
SRC_URI[aarch64_pdns-backend-ldap.sha256sum] = "e3fe5053a37f43a9a88df7c1fcd6d4f98eec0c2c157afbe9d8eb1025a16eebc9"

URI_aarch64_pdns-backend-lmdb = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-lmdb-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-backend-lmdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-lmdb}"
SRC_URI[aarch64_pdns-backend-lmdb.sha256sum] = "af0f14f20ab1b3ed1ac9875c016245a0390eafec9f08c198aa31c72de87c9ee9"

URI_aarch64_pdns-backend-lua2 = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-lua2-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-backend-lua2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-lua2}"
SRC_URI[aarch64_pdns-backend-lua2.sha256sum] = "4896d0828993abd25dc578df4b161869e60fd90f3f696af152464dc823c4ff9a"

URI_aarch64_pdns-backend-mysql = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-mysql-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-backend-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-mysql}"
SRC_URI[aarch64_pdns-backend-mysql.sha256sum] = "456270fbb9e9547c4f90ca3429dc093309cb47f51d9e112e61887040f27d1d16"

URI_aarch64_pdns-backend-pipe = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-pipe-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-backend-pipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-pipe}"
SRC_URI[aarch64_pdns-backend-pipe.sha256sum] = "ca14648c107135f9de6fbff9d7568ca48f4e89554697ef13b86f1ae3f309ae40"

URI_aarch64_pdns-backend-postgresql = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-postgresql-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-backend-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-postgresql}"
SRC_URI[aarch64_pdns-backend-postgresql.sha256sum] = "ae5bd89667c8418bc1ab15699f2b429fd3503295bf60ee3cc1aaab9050f6f0e4"

URI_aarch64_pdns-backend-remote = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-remote-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-backend-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-remote}"
SRC_URI[aarch64_pdns-backend-remote.sha256sum] = "9ffab43db305a982fdc95d3cd7a3f76251346ba80ba9b1e31eb8685b7689c5fb"

URI_aarch64_pdns-backend-sqlite = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-sqlite-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-backend-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-sqlite}"
SRC_URI[aarch64_pdns-backend-sqlite.sha256sum] = "2ce03c6649c661f5da621ab324588e04f4ef733192e09f2c395b41a275e04cb0"

URI_aarch64_pdns-backend-tinydns = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-backend-tinydns-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-backend-tinydns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-backend-tinydns}"
SRC_URI[aarch64_pdns-backend-tinydns.sha256sum] = "1075f0cd1b3ad768c057084edc5e2597bf37bf33a794017bc0791c720da837e3"

URI_aarch64_pdns-ixfrdist = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-ixfrdist-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-ixfrdist;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-ixfrdist}"
SRC_URI[aarch64_pdns-ixfrdist.sha256sum] = "2b6248212194d100adfbf5cb6981d7a5077d36c46bff58835f6ec96687bf9872"

URI_aarch64_pdns-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-tools-5.0.1-1.el10_0.aarch64.rpm;name=aarch64_pdns-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-tools}"
SRC_URI[aarch64_pdns-tools.sha256sum] = "8602e30b9c9f053757604dacb0accdbcd778334b2eb070069983ab3b1f0a2e77"

RDEPENDS:pdns = " \
 bash \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 p11-kit \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:pdns-backend-ldap = " \
 glibc \
 krb5-libs \
 libgcc \
 libstdc++ \
 openldap \
 pdns \
 "
RDEPENDS:pdns-backend-lmdb = " \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 lmdb-libs \
 pdns \
 systemd-libs \
 "
RDEPENDS:pdns-backend-lua2 = " \
 glibc \
 libgcc \
 libstdc++ \
 luajit \
 pdns \
 "
RDEPENDS:pdns-backend-mysql = " \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 pdns \
 "
RDEPENDS:pdns-backend-pipe = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-postgresql = " \
 glibc \
 libgcc \
 libpq \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-remote = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-sqlite = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 "
RDEPENDS:pdns-backend-tinydns = " \
 glibc \
 libgcc \
 libstdc++ \
 pdns \
 tinycdb \
 "
RDEPENDS:pdns-ixfrdist = " \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 p11-kit \
 yaml-cpp \
 "
RDEPENDS:pdns-tools = " \
 boost-program-options \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 openssl-libs \
 p11-kit \
 virtual/libcurl.so.4___64bit_ \
 "
