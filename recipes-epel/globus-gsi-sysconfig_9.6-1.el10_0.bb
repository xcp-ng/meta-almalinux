# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-sysconfig"
PV = "9.6"
PR = "1.el10_0"
PACKAGES = " \
 globus-gsi-sysconfig \
 globus-gsi-sysconfig-devel \
 globus-gsi-sysconfig-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-sysconfig-9.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52da94a6c24bdc198cdc666b4951fd3b15251146b15b132407141e7c91b02141"

URI_x86_64_v2_globus-gsi-sysconfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-sysconfig-9.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-sysconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-sysconfig}"
SRC_URI[x86_64_v2_globus-gsi-sysconfig.sha256sum] = "d271e33daf18795fd8a95c77350f9e73d5006a13ddcfcbe69c2c0206a343c4c0"

URI_x86_64_v2_globus-gsi-sysconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-sysconfig-devel-9.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-sysconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-sysconfig-devel}"
SRC_URI[x86_64_v2_globus-gsi-sysconfig-devel.sha256sum] = "33d75c751c097fc8073e4ceae56c5fc7f2eb196b0468b079eba63b97885dbeda"

URI_x86_64_v2_globus-gsi-sysconfig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-sysconfig-doc-9.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-sysconfig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-sysconfig-doc}"
SRC_URI[x86_64_v2_globus-gsi-sysconfig-doc.sha256sum] = "5f5a94203bedfb0e46245493115298f6add1626d1b43ceb672d991b69a665f1a"

URI_aarch64_globus-gsi-sysconfig = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-sysconfig-9.6-1.el10_0.aarch64.rpm;name=aarch64_globus-gsi-sysconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-sysconfig}"
SRC_URI[aarch64_globus-gsi-sysconfig.sha256sum] = "2695089a6caadb918884fc625151bc41820e5642921c9f593f3048ceffed6571"

URI_aarch64_globus-gsi-sysconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-sysconfig-devel-9.6-1.el10_0.aarch64.rpm;name=aarch64_globus-gsi-sysconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-sysconfig-devel}"
SRC_URI[aarch64_globus-gsi-sysconfig-devel.sha256sum] = "67c144b4a1d270b411d82b257ad7ecfd9c058ddd6c42bbeeef3caddc23fb7509"

URI_aarch64_globus-gsi-sysconfig-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-sysconfig-doc-9.6-1.el10_0.noarch.rpm;name=aarch64_globus-gsi-sysconfig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-sysconfig-doc}"
SRC_URI[aarch64_globus-gsi-sysconfig-doc.sha256sum] = "96399839fa3656762c858a4d580572bf2d150b0982131cad7df72f4c68cd950e"

RDEPENDS:globus-gsi-sysconfig = " \
 glibc \
 globus-common \
 globus-gsi-openssl-error \
 openssl-libs \
 "
RDEPENDS:globus-gsi-sysconfig-devel = " \
 globus-common-devel \
 globus-gsi-openssl-error-devel \
 globus-gsi-sysconfig \
 globus-openssl-module-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-sysconfig-doc = " \
 "
