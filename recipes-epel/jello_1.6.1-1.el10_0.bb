# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jello"
PV = "1.6.1"
PR = "1.el10_0"
PACKAGES = " \
 jello \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jello-1.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d49d1733fddf2a14c75558a89be6730da89dfa59aae5e8b79f57e5ca22ed9960"

URI_x86_64_v2_jello = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jello-1.6.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jello;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jello}"
SRC_URI[x86_64_v2_jello.sha256sum] = "281a905a2c812e699d404ee35a5502ae17312a5980d3adf7ab20425a0065a587"

URI_aarch64_jello = "${EPEL_MIRROR}/aarch64/Packages/j/jello-1.6.1-1.el10_0.noarch.rpm;name=aarch64_jello;unpack=0"
SRC_URI:append = " ${URI_aarch64_jello}"
SRC_URI[aarch64_jello.sha256sum] = "724f69a380d073b3b63cc7b0354fc25187c0be70e299f4ccb2cae29ca966bfbb"

RDEPENDS:jello = " \
 python3 \
 python3-pygments \
 "
