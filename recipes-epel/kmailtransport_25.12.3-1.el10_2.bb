# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmailtransport"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmailtransport \
 kmailtransport-devel \
 kmailtransport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmailtransport-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88a20af85439c31d01baf09925fdb8f2689bbc880a54e92f1274d6ea7ab067ce"

URI_x86_64_v2_kmailtransport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmailtransport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmailtransport}"
SRC_URI[x86_64_v2_kmailtransport.sha256sum] = "e78d504337716625d4c4895c3e668716fa6ba036700f7e15f88ed73c3c6d6308"

URI_x86_64_v2_kmailtransport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmailtransport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmailtransport-devel}"
SRC_URI[x86_64_v2_kmailtransport-devel.sha256sum] = "b0f93f5c6920e1aab42dc0f3df6ec34858af2b740595c3c63c6237d79a5f0470"

URI_x86_64_v2_kmailtransport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kmailtransport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmailtransport-doc}"
SRC_URI[x86_64_v2_kmailtransport-doc.sha256sum] = "adaf0b28a1e48a29a5a32bbecf8ba920b85f492626c26ffa890e433ec7246ca8"

URI_aarch64_kmailtransport = "${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmailtransport;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmailtransport}"
SRC_URI[aarch64_kmailtransport.sha256sum] = "6944ce07d749bac7480e62e4ef7a9a216ee2d1bc982ae3d400bfa6e59b3aec5a"

URI_aarch64_kmailtransport-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmailtransport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmailtransport-devel}"
SRC_URI[aarch64_kmailtransport-devel.sha256sum] = "bf961caf04f01f8653337be0dbca272f40dd9550b7eacabe64e55e29e8341c8f"

URI_aarch64_kmailtransport-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kmailtransport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmailtransport-doc}"
SRC_URI[aarch64_kmailtransport-doc.sha256sum] = "fdd0544ed837ec4b33ed8c6855beb12d7aaaa9f7d832a1a1ba64301ea3e01dc4"

RDEPENDS:kmailtransport = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 ksmtp \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kmailtransport-devel = " \
 akonadi-mime-devel \
 cmake-filesystem \
 kmailtransport \
 kmime-devel \
 "
RDEPENDS:kmailtransport-doc = " \
 "
