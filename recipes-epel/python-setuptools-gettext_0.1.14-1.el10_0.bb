# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-setuptools-gettext"
PV = "0.1.14"
PR = "1.el10_0"
PACKAGES = " \
 python3-setuptools-gettext \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-setuptools-gettext-0.1.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a5e45a46b596e8f623b54265fe86f539a07413bb284cfef57950f189b8e4afc"

URI_x86_64_v2_python3-setuptools-gettext = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-setuptools-gettext-0.1.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-setuptools-gettext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setuptools-gettext}"
SRC_URI[x86_64_v2_python3-setuptools-gettext.sha256sum] = "9a736277be089ae7001efcad669d0815b83dba893902c0306da969f7dcf9fe19"

URI_aarch64_python3-setuptools-gettext = "${EPEL_MIRROR}/aarch64/Packages/p/python3-setuptools-gettext-0.1.14-1.el10_0.noarch.rpm;name=aarch64_python3-setuptools-gettext;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setuptools-gettext}"
SRC_URI[aarch64_python3-setuptools-gettext.sha256sum] = "f56e391cb8da03c93e840ac886db8724b7e3785f5879cac96af9389a6866115a"

RDEPENDS:python3-setuptools-gettext = " \
 python3 \
 python3-setuptools \
 "
