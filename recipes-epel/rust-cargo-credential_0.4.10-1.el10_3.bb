# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-credential"
PV = "0.4.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-credential+default-devel \
 rust-cargo-credential-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-credential-0.4.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0abad38a3da3b7222b636f656790f97c1f9dde18eb369df64e38b2b5be3f291"

URI_x86_64_v2_rust-cargo-credential+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential+default-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential+default-devel.sha256sum] = "643aebda9ac7629622a0f825fd4046ee1a50d27ff9d36bbea2d5582f24a11753"

URI_x86_64_v2_rust-cargo-credential-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-devel-0.4.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-devel.sha256sum] = "335255670984521abd5f41ef2d9207cf25fd386a2e081b9eff56817202a01f48"

URI_aarch64_rust-cargo-credential+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential+default-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-credential+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential+default-devel}"
SRC_URI[aarch64_rust-cargo-credential+default-devel.sha256sum] = "4fcec10b224cc9ae532d36cc5616f655b4d1e426e3b3f4c4b61035136e24ffc9"

URI_aarch64_rust-cargo-credential-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-devel-0.4.10-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-credential-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-devel}"
SRC_URI[aarch64_rust-cargo-credential-devel.sha256sum] = "13093cf7a66251fda3ce38dde2bfcbb558c6af15a6d123377767e1e90910bce9"

RDEPENDS:rust-cargo-credential+default-devel = " \
 cargo \
 rust-cargo-credential-devel \
 "
RDEPENDS:rust-cargo-credential-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-libc+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 "
