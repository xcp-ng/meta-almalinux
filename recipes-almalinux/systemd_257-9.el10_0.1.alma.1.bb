# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemd"
PV = "257"
PR = "9.el10_0.1.alma.1"
PACKAGES = " \
 systemd \
 systemd-boot-unsigned \
 systemd-container \
 systemd-devel \
 systemd-journal-remote \
 systemd-libs \
 systemd-oomd \
 systemd-pam \
 systemd-resolved \
 systemd-rpm-macros \
 systemd-udev \
 systemd-ukify \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/systemd-257-9.el10_0.1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8576788b4bbf6c13fd97cebd15b0d11f61e1b598931f50a01c1d3d81878b9bc6"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - systemd-udev: (sdubby > 1.0-3 if sdubby)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - systemd-udev: (sdubby > 1.0-3 if sdubby)

URI_x86_64_v2_systemd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd}"
SRC_URI[x86_64_v2_systemd.sha256sum] = "390c2d11e3f9b1f46a13c8c8d249561d3cd8a5d12b23f57bf35291018913d94f"
RPROVIDES:systemd:x86_64_v2 = "virtual/syslog"

URI_x86_64_v2_systemd-boot-unsigned = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-boot-unsigned-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-boot-unsigned;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-boot-unsigned}"
SRC_URI[x86_64_v2_systemd-boot-unsigned.sha256sum] = "ae5f55021037567e423ea1ea2648dc1003eea1d288472377bf9bda158763ffe2"

URI_x86_64_v2_systemd-container = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-container-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-container;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-container}"
SRC_URI[x86_64_v2_systemd-container.sha256sum] = "fd94cc7b800b343e398f031f85e491f887089eafc17c924832aaa91b230923b4"

URI_x86_64_v2_systemd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-devel-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-devel}"
SRC_URI[x86_64_v2_systemd-devel.sha256sum] = "8b6ef28756f0f3df1858c8d4a0d21fa4debea37b5c2cfc7c7acad1744b057aaf"

URI_x86_64_v2_systemd-journal-remote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-journal-remote-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-journal-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-journal-remote}"
SRC_URI[x86_64_v2_systemd-journal-remote.sha256sum] = "f325b78854748499d4dcd97815143226125c32d5324a4c707b1c2a3739a2e188"

URI_x86_64_v2_systemd-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-libs-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-libs}"
SRC_URI[x86_64_v2_systemd-libs.sha256sum] = "760070d2df56d62efcbb77449286e4de7edb6c596252808a9acddeb254bfc10c"

URI_x86_64_v2_systemd-oomd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-oomd-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-oomd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-oomd}"
SRC_URI[x86_64_v2_systemd-oomd.sha256sum] = "f3540d4cb8c5eb81a3f6a02f28f19202424a0508344a6f9723b6e55fdeeae8ec"

URI_x86_64_v2_systemd-pam = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-pam-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-pam}"
SRC_URI[x86_64_v2_systemd-pam.sha256sum] = "28f63f2e99b13347773edfa10f6f03e0e45937b2095ae88135a15bef3b631dde"

URI_x86_64_v2_systemd-resolved = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-resolved-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-resolved;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-resolved}"
SRC_URI[x86_64_v2_systemd-resolved.sha256sum] = "cf42bc8304f7c2fd690a06aead9cb2988e6b570eb64a15e5b9ed35f421f8ead0"

URI_x86_64_v2_systemd-rpm-macros = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-rpm-macros-257-9.el10_0.1.alma.1.noarch.rpm;name=x86_64_v2_systemd-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-rpm-macros}"
SRC_URI[x86_64_v2_systemd-rpm-macros.sha256sum] = "ee4cc3d347dbab2f4fe1cb9c55c64f951c793999206234c427cd8cfeb3b56b46"

URI_x86_64_v2_systemd-udev = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-udev-257-9.el10_0.1.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-udev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-udev}"
SRC_URI[x86_64_v2_systemd-udev.sha256sum] = "28e1b1aeed26d79ddccbda37a2517cf3ff430100d37caa1d8cd58885ef38b93c"

URI_x86_64_v2_systemd-ukify = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-ukify-257-9.el10_0.1.alma.1.noarch.rpm;name=x86_64_v2_systemd-ukify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-ukify}"
SRC_URI[x86_64_v2_systemd-ukify.sha256sum] = "b0e7fdfc580a9962ea94f400bdca3c0e5571e31e3edd5930dca08713b09eebb6"

URI_aarch64_systemd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd}"
SRC_URI[aarch64_systemd.sha256sum] = "6f512fdb97b067ca9abb2fd89a8cf9362288ef4928a5e83cb91c19d98f57bacc"
RPROVIDES:systemd:aarch64 = "virtual/syslog"

URI_aarch64_systemd-boot-unsigned = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-boot-unsigned-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd-boot-unsigned;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-boot-unsigned}"
SRC_URI[aarch64_systemd-boot-unsigned.sha256sum] = "95efedafa6abeed1f17c2e1a67179eb7a0afe3d96d6e00a7e2da44d4b35a7335"

URI_aarch64_systemd-container = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-container-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd-container;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-container}"
SRC_URI[aarch64_systemd-container.sha256sum] = "077d6dd89e9b987bd28a41f65589f92fe371ac7e774475359590707836a90cb9"

URI_aarch64_systemd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-devel-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-devel}"
SRC_URI[aarch64_systemd-devel.sha256sum] = "a2abbd7bd8d401b337ef9675118e039e6b22d6daa7381d6bf957866eb2e79772"

URI_aarch64_systemd-journal-remote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-journal-remote-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd-journal-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-journal-remote}"
SRC_URI[aarch64_systemd-journal-remote.sha256sum] = "e6f72e2e6442e4b06b1e077e33497be6368b3cd6c92fbe515b85a6c65f4a5b10"

URI_aarch64_systemd-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-libs-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-libs}"
SRC_URI[aarch64_systemd-libs.sha256sum] = "e375684a6fc5cde8bf05dbb78b46aaf4c911fb71c5bb5998fa1441cc591e5615"

URI_aarch64_systemd-oomd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-oomd-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd-oomd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-oomd}"
SRC_URI[aarch64_systemd-oomd.sha256sum] = "17a79addacee8a53215bbe2ce47f60640e1ac0a898278905947ffc6a923bf28c"

URI_aarch64_systemd-pam = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-pam-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-pam}"
SRC_URI[aarch64_systemd-pam.sha256sum] = "8cdd0e9311d91c46a95ac7d3addfa742ed4ef6ae16a6be0c4ee2360467ab79f0"

URI_aarch64_systemd-resolved = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-resolved-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd-resolved;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-resolved}"
SRC_URI[aarch64_systemd-resolved.sha256sum] = "55bddbc5a18e98be0c6ba7a9449998fa9d0eb9291238e8338c1a58f166108f81"

URI_aarch64_systemd-rpm-macros = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-rpm-macros-257-9.el10_0.1.alma.1.noarch.rpm;name=aarch64_systemd-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-rpm-macros}"
SRC_URI[aarch64_systemd-rpm-macros.sha256sum] = "ee4cc3d347dbab2f4fe1cb9c55c64f951c793999206234c427cd8cfeb3b56b46"

URI_aarch64_systemd-udev = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-udev-257-9.el10_0.1.alma.1.aarch64.rpm;name=aarch64_systemd-udev;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-udev}"
SRC_URI[aarch64_systemd-udev.sha256sum] = "fecea49a283676715bca7c89e1093b78e097d281d3b81e61488ef9791a0cb3e9"

URI_aarch64_systemd-ukify = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-ukify-257-9.el10_0.1.alma.1.noarch.rpm;name=aarch64_systemd-ukify;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-ukify}"
SRC_URI[aarch64_systemd-ukify.sha256sum] = "b0e7fdfc580a9962ea94f400bdca3c0e5571e31e3edd5930dca08713b09eebb6"

RDEPENDS:systemd = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libcap \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:systemd-boot-unsigned = " \
 "
RDEPENDS:systemd-container = " \
 bzip2-libs \
 glibc \
 libacl \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:systemd-devel = " \
 systemd-libs \
 systemd-rpm-macros \
 "
RDEPENDS:systemd-journal-remote = " \
 bash \
 firewalld-filesystem \
 glibc \
 libgcc \
 libmicrohttpd \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:systemd-libs = " \
 glibc \
 libcap \
 libgcc \
 "
RDEPENDS:systemd-oomd = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-udev \
 "
RDEPENDS:systemd-pam = " \
 glibc \
 libcap \
 libgcc \
 pam-libs \
 systemd \
 "
RDEPENDS:systemd-resolved = " \
 bash \
 glibc \
 grep \
 libgcc \
 libidn2 \
 openssl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:systemd-rpm-macros = " \
 bash \
 "
RDEPENDS:systemd-udev = " \
 bash \
 cryptsetup-libs \
 glibc \
 grep \
 grubby \
 kbd \
 kmod \
 kmod-libs \
 libblkid \
 libfdisk \
 libgcc \
 openssl-libs \
 systemd \
 "
RDEPENDS:systemd-ukify = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-zstd \
 systemd \
 systemd-boot-unsigned \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/syslog"
