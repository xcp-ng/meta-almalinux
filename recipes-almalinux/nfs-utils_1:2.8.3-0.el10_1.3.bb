# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfs-utils"
PE = "1"
PV = "2.8.3"
PR = "0.el10_1.3"
PACKAGES = " \
 libnfsidmap \
 libnfsidmap-devel \
 nfs-utils \
 nfs-utils-coreos \
 nfsv4-client-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nfs-utils-2.8.3-0.el10_1.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d425768ec65be26f3f0d7ddf17c3f2f09ed40c19f0e5edc8557c9b6e384afc6a"

URI_x86_64_v2_libnfsidmap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnfsidmap-2.8.3-0.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfsidmap}"
SRC_URI[x86_64_v2_libnfsidmap.sha256sum] = "1a829d29516d0ac3c2f2479c224585f8ada3c333bf794de0ba7d41c43adbf48f"

URI_x86_64_v2_libnfsidmap-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnfsidmap-devel-2.8.3-0.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfsidmap-devel}"
SRC_URI[x86_64_v2_libnfsidmap-devel.sha256sum] = "b52252d5c6bc605a721e59a19b476801996f23601ec9543c31a475acf43ffd3a"

URI_x86_64_v2_nfs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nfs-utils-2.8.3-0.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_nfs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfs-utils}"
SRC_URI[x86_64_v2_nfs-utils.sha256sum] = "d3656db3d8b4cf29727dee2ca56c89368453ef76dc4fc55eac8d8146bb92b04e"
RPROVIDES:nfs-utils:x86_64_v2 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_x86_64_v2_nfs-utils-coreos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfs-utils-coreos-2.8.3-0.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_nfs-utils-coreos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfs-utils-coreos}"
SRC_URI[x86_64_v2_nfs-utils-coreos.sha256sum] = "c18d60c23acf09f1962604e85f111da21ac2a2ad4de6789a1bdbe6f1ea4695c5"

URI_x86_64_v2_nfsv4-client-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfsv4-client-utils-2.8.3-0.el10_1.3.x86_64_v2.rpm;name=x86_64_v2_nfsv4-client-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nfsv4-client-utils}"
SRC_URI[x86_64_v2_nfsv4-client-utils.sha256sum] = "f40688f3e03774cc1d896afedb914e28b7015e6b82451f6f9e54e9b72876e8fc"
RPROVIDES:nfsv4-client-utils:x86_64_v2 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_aarch64_libnfsidmap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnfsidmap-2.8.3-0.el10_1.3.aarch64.rpm;name=aarch64_libnfsidmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfsidmap}"
SRC_URI[aarch64_libnfsidmap.sha256sum] = "baa6622a161990e563adf03aa4dabc2e8b970bde8c7d0a4e502c170e292d87e8"

URI_aarch64_libnfsidmap-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnfsidmap-devel-2.8.3-0.el10_1.3.aarch64.rpm;name=aarch64_libnfsidmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfsidmap-devel}"
SRC_URI[aarch64_libnfsidmap-devel.sha256sum] = "c95a7f6307069f2aefe168cd6e83470f7ec42e6bcf27abf13811e8774633f5f4"

URI_aarch64_nfs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nfs-utils-2.8.3-0.el10_1.3.aarch64.rpm;name=aarch64_nfs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfs-utils}"
SRC_URI[aarch64_nfs-utils.sha256sum] = "6542bf270aaa0a4c92bfeff77f72da50a824c89e386caef8b7e73ce1bbd6ffba"
RPROVIDES:nfs-utils:aarch64 = "virtual/nfs-utils_or_nfsv4-client-utils"

URI_aarch64_nfs-utils-coreos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfs-utils-coreos-2.8.3-0.el10_1.3.aarch64.rpm;name=aarch64_nfs-utils-coreos;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfs-utils-coreos}"
SRC_URI[aarch64_nfs-utils-coreos.sha256sum] = "86d60034dbaa26281809325af1f2dfcfef53307bfb91521758e3def454d2bf03"

URI_aarch64_nfsv4-client-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfsv4-client-utils-2.8.3-0.el10_1.3.aarch64.rpm;name=aarch64_nfsv4-client-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nfsv4-client-utils}"
SRC_URI[aarch64_nfsv4-client-utils.sha256sum] = "87ee3f35959946b7cd63cb8d38322226bf169e08898bb9fd2f32114fb509785a"
RPROVIDES:nfsv4-client-utils:aarch64 = "virtual/nfs-utils_or_nfsv4-client-utils"

RDEPENDS:libnfsidmap = " \
 glibc \
 krb5-libs \
 openldap \
 "
RDEPENDS:libnfsidmap-devel = " \
 libnfsidmap \
 pkgconf-pkg-config \
 "
RDEPENDS:nfs-utils = " \
 bash \
 device-mapper-libs \
 gawk \
 glibc \
 grep \
 gssproxy \
 keyutils \
 keyutils-libs \
 kmod \
 krb5-libs \
 libblkid \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libnl3 \
 libtirpc \
 libuuid \
 libxml2 \
 python3 \
 quota \
 readline \
 rpcbind \
 sed \
 selinux-policy \
 shadow-utils \
 sqlite-libs \
 systemd \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:nfs-utils-coreos = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 rpcbind \
 systemd \
 "
RDEPENDS:nfsv4-client-utils = " \
 glibc \
 gssproxy \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nfs-utils_or_nfsv4-client-utils"

PROVIDES:append:aarch64 = " rpm/virtual/nfs-utils_or_nfsv4-client-utils"
