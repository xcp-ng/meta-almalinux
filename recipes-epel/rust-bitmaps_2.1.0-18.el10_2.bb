# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitmaps"
PV = "2.1.0"
PR = "18.el10_2"
PACKAGES = " \
 rust-bitmaps+default-devel \
 rust-bitmaps+std-devel \
 rust-bitmaps-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitmaps-2.1.0-18.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc1624bb64a364da13260948ab4f9d14ccd60fbda0c9124a46705060e362003d"

URI_x86_64_v2_rust-bitmaps+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitmaps+default-devel-2.1.0-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitmaps+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitmaps+default-devel}"
SRC_URI[x86_64_v2_rust-bitmaps+default-devel.sha256sum] = "580a1d9dacb719f821473e9324bf6e90d63c40148526f09020eea0b39ca9ca78"

URI_x86_64_v2_rust-bitmaps+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitmaps+std-devel-2.1.0-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitmaps+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitmaps+std-devel}"
SRC_URI[x86_64_v2_rust-bitmaps+std-devel.sha256sum] = "1a46f53fb31c497b832be15a44760fc95cc80e933e5655588c800ca79fa4584c"

URI_x86_64_v2_rust-bitmaps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitmaps-devel-2.1.0-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitmaps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitmaps-devel}"
SRC_URI[x86_64_v2_rust-bitmaps-devel.sha256sum] = "548ea59df3dd27c838af6644f489e7d6189962b5c76aae0b575699ce66c619e0"

URI_aarch64_rust-bitmaps+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitmaps+default-devel-2.1.0-18.el10_2.noarch.rpm;name=aarch64_rust-bitmaps+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitmaps+default-devel}"
SRC_URI[aarch64_rust-bitmaps+default-devel.sha256sum] = "2d95ab8102fa24daa3e5d521e56d47ca0806100c268e51fac489250e2268e0ad"

URI_aarch64_rust-bitmaps+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitmaps+std-devel-2.1.0-18.el10_2.noarch.rpm;name=aarch64_rust-bitmaps+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitmaps+std-devel}"
SRC_URI[aarch64_rust-bitmaps+std-devel.sha256sum] = "f323f8f2864a4a9a5e846925d9fa993d9d3840a36853e1fb77515f388faf3a1e"

URI_aarch64_rust-bitmaps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitmaps-devel-2.1.0-18.el10_2.noarch.rpm;name=aarch64_rust-bitmaps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitmaps-devel}"
SRC_URI[aarch64_rust-bitmaps-devel.sha256sum] = "642fef30027ca50c8f058616d306c914769f98c78bfb97a5c8a2990a8c9d48b4"

RDEPENDS:rust-bitmaps+default-devel = " \
 cargo \
 rust-bitmaps+std-devel \
 rust-bitmaps-devel \
 "
RDEPENDS:rust-bitmaps+std-devel = " \
 cargo \
 rust-bitmaps-devel \
 "
RDEPENDS:rust-bitmaps-devel = " \
 cargo \
 rust-typenum+default-devel \
 "
