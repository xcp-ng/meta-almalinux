# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb10.11"
PE = "3"
PV = "10.11.18"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 mariadb \
 mariadb-backup \
 mariadb-client-utils \
 mariadb-common \
 mariadb-devel \
 mariadb-embedded \
 mariadb-embedded-devel \
 mariadb-errmsg \
 mariadb-gssapi-server \
 mariadb-oqgraph-engine \
 mariadb-pam \
 mariadb-server \
 mariadb-server-galera \
 mariadb-server-utils \
 mariadb-test \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mariadb10.11-10.11.18-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe5d840d9f318fa634fe56a1c113ef20660f94f48e782bb493b7ad0c9f1ce391"

URI_x86_64_v2_mariadb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb}"
SRC_URI[x86_64_v2_mariadb.sha256sum] = "4bb48e1c6270648f32591f3d9aba6a1ad48c2327d947bcd3a231ee3816f8893a"
RPROVIDES:mariadb:x86_64_v2 = "virtual//usr/bin/mariadb-dump virtual//usr/bin/mysqldump"

URI_x86_64_v2_mariadb-backup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-backup-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-backup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-backup}"
SRC_URI[x86_64_v2_mariadb-backup.sha256sum] = "989d48ff744efe0e267e9956b806ecfa63964197900e0c49114cfcfc34eee7b5"
RPROVIDES:mariadb-backup:x86_64_v2 = "virtual//usr/bin/mariabackup"

URI_x86_64_v2_mariadb-client-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-client-utils-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-client-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-client-utils}"
SRC_URI[x86_64_v2_mariadb-client-utils.sha256sum] = "2cdbcd312899147909ed6d6988350b3389283e5ee148d2fb5ff8bf2588d1c777"

URI_x86_64_v2_mariadb-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-common-10.11.18-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_mariadb-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-common}"
SRC_URI[x86_64_v2_mariadb-common.sha256sum] = "681f8ea6830f9775d238ef434fe0cb1d7ae292f04e23bb51b564dd3396b48a53"

URI_x86_64_v2_mariadb-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-devel-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-devel}"
SRC_URI[x86_64_v2_mariadb-devel.sha256sum] = "dea2546406679212d3caaa85ba9b158863340a093b1a6b7a14668c84e916efde"

URI_x86_64_v2_mariadb-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-embedded-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-embedded}"
SRC_URI[x86_64_v2_mariadb-embedded.sha256sum] = "8c429704c3213a03eb6f1ccf248eb69373e1c7e96cb2bdab0ad2d44d2afe5e41"
RPROVIDES:mariadb-embedded:x86_64_v2 = "virtual/libmariadbd.so.19___64bit_"

URI_x86_64_v2_mariadb-embedded-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-embedded-devel-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-embedded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-embedded-devel}"
SRC_URI[x86_64_v2_mariadb-embedded-devel.sha256sum] = "4cc5c6fb7aa4378254f0db05c0dfe006b8a39fa4855ef3a7b4097d3fc97b5cd2"

URI_x86_64_v2_mariadb-errmsg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-errmsg-10.11.18-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_mariadb-errmsg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-errmsg}"
SRC_URI[x86_64_v2_mariadb-errmsg.sha256sum] = "714e7719347d3e47e8ad2c0770a97c3dca85f00f5f67c30868bbc81cbeae8dea"

URI_x86_64_v2_mariadb-gssapi-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-gssapi-server-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-gssapi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-gssapi-server}"
SRC_URI[x86_64_v2_mariadb-gssapi-server.sha256sum] = "8457a4413ad6441c4533fb5f3e6eb025af8f28c10824dbf556e70aeb3f0840dc"

URI_x86_64_v2_mariadb-oqgraph-engine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-oqgraph-engine-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-oqgraph-engine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-oqgraph-engine}"
SRC_URI[x86_64_v2_mariadb-oqgraph-engine.sha256sum] = "3bde01f09e48272100fe36765e394a87f581c1a796af305416728df73d768e18"

URI_x86_64_v2_mariadb-pam = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-pam-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-pam}"
SRC_URI[x86_64_v2_mariadb-pam.sha256sum] = "9493e05b18d2c743377c03cb691666531cfd858d0be5abc82ab485d1d8c6cb0e"

URI_x86_64_v2_mariadb-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-server}"
SRC_URI[x86_64_v2_mariadb-server.sha256sum] = "fa3829147dc8f1142109f8dbbc718cb9fcf6c3977fe23dc6e6bc6145ad0ca5c3"

URI_x86_64_v2_mariadb-server-galera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-galera-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-server-galera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-server-galera}"
SRC_URI[x86_64_v2_mariadb-server-galera.sha256sum] = "257517092416bb97bbfc4b236006cdb0309282b682bafecdaee09bde42a65de8"

URI_x86_64_v2_mariadb-server-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-utils-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-server-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-server-utils}"
SRC_URI[x86_64_v2_mariadb-server-utils.sha256sum] = "ca460ed61fb5badad77d5f11229575b080a91ff2e1825856d294bf9cf7d6afd5"

URI_x86_64_v2_mariadb-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-test-10.11.18-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_mariadb-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-test}"
SRC_URI[x86_64_v2_mariadb-test.sha256sum] = "49bc1c8cf85548f0a35b68c0ae07323d0b54496d59ddba01ef4bb261e3353d42"

URI_aarch64_mariadb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb}"
SRC_URI[aarch64_mariadb.sha256sum] = "ee840fb2d91f2a2c5639149a8990be2abc76ac4ed74d4d0ac1c72c80824bebb7"
RPROVIDES:mariadb:aarch64 = "virtual//usr/bin/mariadb-dump virtual//usr/bin/mysqldump"

URI_aarch64_mariadb-backup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-backup-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-backup;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-backup}"
SRC_URI[aarch64_mariadb-backup.sha256sum] = "96b19f03939d5808ee6abcf789d117cbdc6b33e0ea4cd0d257630e38d3129f1e"
RPROVIDES:mariadb-backup:aarch64 = "virtual//usr/bin/mariabackup"

URI_aarch64_mariadb-client-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-client-utils-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-client-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-client-utils}"
SRC_URI[aarch64_mariadb-client-utils.sha256sum] = "95f54b5291154104ba12c2b2cf9e171c544543a7ef1df96d283cad538b0646bf"

URI_aarch64_mariadb-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-common-10.11.18-1.el10_2.alma.1.noarch.rpm;name=aarch64_mariadb-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-common}"
SRC_URI[aarch64_mariadb-common.sha256sum] = "681f8ea6830f9775d238ef434fe0cb1d7ae292f04e23bb51b564dd3396b48a53"

URI_aarch64_mariadb-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-devel-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-devel}"
SRC_URI[aarch64_mariadb-devel.sha256sum] = "a67ca83d13003497be85815bcc24ff49c81a5d5646d90fd87c33f8deebf9ad18"

URI_aarch64_mariadb-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-embedded-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-embedded}"
SRC_URI[aarch64_mariadb-embedded.sha256sum] = "1ea9b1eb7cfdc21caae3e57a59bbf30fc09915acfe778de8d16f9ac63a031036"
RPROVIDES:mariadb-embedded:aarch64 = "virtual/libmariadbd.so.19___64bit_"

URI_aarch64_mariadb-embedded-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-embedded-devel-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-embedded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-embedded-devel}"
SRC_URI[aarch64_mariadb-embedded-devel.sha256sum] = "09a5839bbf61fe2904b666529ab3ae61ae98eb58168de37e43c9f43b37f0f661"

URI_aarch64_mariadb-errmsg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-errmsg-10.11.18-1.el10_2.alma.1.noarch.rpm;name=aarch64_mariadb-errmsg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-errmsg}"
SRC_URI[aarch64_mariadb-errmsg.sha256sum] = "714e7719347d3e47e8ad2c0770a97c3dca85f00f5f67c30868bbc81cbeae8dea"

URI_aarch64_mariadb-gssapi-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-gssapi-server-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-gssapi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-gssapi-server}"
SRC_URI[aarch64_mariadb-gssapi-server.sha256sum] = "43a24405225252a4df5deb02d5fab5248db4f9259e6eb5ea6356c881c3f607d4"

URI_aarch64_mariadb-oqgraph-engine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-oqgraph-engine-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-oqgraph-engine;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-oqgraph-engine}"
SRC_URI[aarch64_mariadb-oqgraph-engine.sha256sum] = "44843fa92af96bac73be3e7c1b270f627d7b1bc8688789124e928264888c8b41"

URI_aarch64_mariadb-pam = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-pam-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-pam}"
SRC_URI[aarch64_mariadb-pam.sha256sum] = "5895936535c18a02c3fb0f309a87a002427e76305aac4cacf21467ff87496f2d"

URI_aarch64_mariadb-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-server}"
SRC_URI[aarch64_mariadb-server.sha256sum] = "30b70d1b001bbf68c4638325a720e0aba7d051af10eb2394c5b7c7135be86322"

URI_aarch64_mariadb-server-galera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-galera-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-server-galera;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-server-galera}"
SRC_URI[aarch64_mariadb-server-galera.sha256sum] = "077af148f355258681facadaca0dcc557f6dcc519a3480e5bbccfc6a4f9e18fe"

URI_aarch64_mariadb-server-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-utils-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-server-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-server-utils}"
SRC_URI[aarch64_mariadb-server-utils.sha256sum] = "fcc46fd5d727b3d878f74747fea1c4a0488c5ac88ced685c83799b869a433ffc"

URI_aarch64_mariadb-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-test-10.11.18-1.el10_2.alma.1.aarch64.rpm;name=aarch64_mariadb-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-test}"
SRC_URI[aarch64_mariadb-test.sha256sum] = "fea47a35d27512fb98f68b0b41e756f11b1731564b7839b132a5bc6eb7fdf468"

RDEPENDS:mariadb = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 mariadb-common \
 mariadb-connector-c \
 ncurses-libs \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-backup = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb-server \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-client-utils = " \
 mariadb \
 perl-DBI \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Sys-Hostname \
 perl-interpreter \
 "
RDEPENDS:mariadb-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mariadb-devel = " \
 mariadb-connector-c-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mariadb-embedded = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb-common \
 mariadb-errmsg \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-embedded-devel = " \
 libaio-devel \
 mariadb-devel \
 mariadb-embedded \
 virtual/libmariadbd.so.19___64bit_ \
 "
RDEPENDS:mariadb-errmsg = " \
 mariadb-common \
 "
RDEPENDS:mariadb-gssapi-server = " \
 glibc \
 krb5-libs \
 mariadb-server \
 "
RDEPENDS:mariadb-oqgraph-engine = " \
 Judy \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-server \
 "
RDEPENDS:mariadb-pam = " \
 glibc \
 mariadb-server \
 pam-libs \
 "
RDEPENDS:mariadb-server = " \
 bash \
 bzip2-libs \
 glibc \
 iproute \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 lz4-libs \
 lzo \
 mariadb \
 mariadb-common \
 mariadb-connector-c-config \
 mariadb-errmsg \
 mysql-selinux \
 openssl-libs \
 pam-libs \
 pcre2 \
 shadow-utils \
 snappy \
 systemd \
 systemd-libs \
 virtual/coreutils \
 which \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-server-galera = " \
 bash \
 galera \
 libselinux-utils \
 lsof \
 mariadb-common \
 mariadb-server \
 policycoreutils \
 policycoreutils-python-utils \
 rsync \
 "
RDEPENDS:mariadb-server-utils = " \
 glibc \
 mariadb-server \
 perl-DBD-MariaDB \
 perl-DBI \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:mariadb-test = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb \
 mariadb-common \
 mariadb-server \
 openssl-libs \
 patch \
 pcre2 \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Memoize \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Test-Simple \
 perl-Text-Tabs+Wrap \
 perl-Time \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/mariabackup rpm/virtual//usr/bin/mariadb-dump rpm/virtual//usr/bin/mysqldump rpm/virtual/libmariadbd.so.19___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/mariabackup rpm/virtual//usr/bin/mariadb-dump rpm/virtual//usr/bin/mysqldump rpm/virtual/libmariadbd.so.19___64bit_"
