# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-HsYAML"
PV = "0.2.1.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-HsYAML \
 ghc-HsYAML-devel \
 ghc-HsYAML-doc \
 ghc-HsYAML-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-HsYAML-0.2.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fe39360e52ebcaefef2a2a722a94e92c8f677b3dfe3d78330a9aeccfb176f69"

URI_x86_64_v2_ghc-HsYAML = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HsYAML-0.2.1.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HsYAML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HsYAML}"
SRC_URI[x86_64_v2_ghc-HsYAML.sha256sum] = "e9e6c6fdc6ff3892a0ab202efb69041c00a14f18c67959bb0758fd8a31f0a7ee"

URI_x86_64_v2_ghc-HsYAML-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HsYAML-devel-0.2.1.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HsYAML-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HsYAML-devel}"
SRC_URI[x86_64_v2_ghc-HsYAML-devel.sha256sum] = "b77343214aac2324cb3b6fa5e889fd7a7cdb2019a7d64998c1ebf0de922c72cd"

URI_x86_64_v2_ghc-HsYAML-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HsYAML-doc-0.2.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-HsYAML-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HsYAML-doc}"
SRC_URI[x86_64_v2_ghc-HsYAML-doc.sha256sum] = "579d6ba5e3fb4b1d95c2aa93eb0b1403fca021f5237861c72262ff55b1b3954f"

URI_x86_64_v2_ghc-HsYAML-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HsYAML-prof-0.2.1.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HsYAML-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HsYAML-prof}"
SRC_URI[x86_64_v2_ghc-HsYAML-prof.sha256sum] = "735babd06726d169927021b38c26ff05c7907a9c3ac2c62fc0c97827de44752b"

URI_aarch64_ghc-HsYAML = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HsYAML-0.2.1.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-HsYAML;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HsYAML}"
SRC_URI[aarch64_ghc-HsYAML.sha256sum] = "7a6a95f1ed0b03dce0495ab4748bcbfa1eb6bca614420725180fd2a880028773"

URI_aarch64_ghc-HsYAML-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HsYAML-devel-0.2.1.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-HsYAML-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HsYAML-devel}"
SRC_URI[aarch64_ghc-HsYAML-devel.sha256sum] = "99b9227131fd5c80ec06f54ec53b52d9f71270a731515d056cbe0c0407fcfce6"

URI_aarch64_ghc-HsYAML-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HsYAML-doc-0.2.1.4-1.el10_0.noarch.rpm;name=aarch64_ghc-HsYAML-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HsYAML-doc}"
SRC_URI[aarch64_ghc-HsYAML-doc.sha256sum] = "b98b98f4437860af8ccb8754b88db25b05c78cdcac016dbcac3e61ad4da68bbe"

URI_aarch64_ghc-HsYAML-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HsYAML-prof-0.2.1.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-HsYAML-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HsYAML-prof}"
SRC_URI[aarch64_ghc-HsYAML-prof.sha256sum] = "afad43bdf8012f214f825d95092ec3e9701ad2d129625f51bf8bbda6b03f64c0"

RDEPENDS:ghc-HsYAML = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-HsYAML-devel = " \
 ghc-HsYAML \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-mtl-devel \
 ghc-parsec-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-HsYAML-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-HsYAML-prof = " \
 ghc-HsYAML-devel \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-mtl-prof \
 ghc-parsec-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
