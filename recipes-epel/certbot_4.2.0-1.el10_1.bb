# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "certbot"
PV = "4.2.0"
PR = "1.el10_1"
PACKAGES = " \
 certbot \
 python3-acme \
 python3-certbot \
 python3-certbot-apache \
 python3-certbot-dns-cloudflare \
 python3-certbot-dns-digitalocean \
 python3-certbot-dns-dnsimple \
 python3-certbot-dns-dnsmadeeasy \
 python3-certbot-dns-gehirn \
 python3-certbot-dns-linode \
 python3-certbot-dns-luadns \
 python3-certbot-dns-nsone \
 python3-certbot-dns-ovh \
 python3-certbot-dns-rfc2136 \
 python3-certbot-dns-route53 \
 python3-certbot-dns-sakuracloud \
 python3-certbot-nginx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/certbot-4.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "089cdf8a78dbd1cc16d93440037213dfa5fca942f206544e3c6113642cef015e"

URI_x86_64_v2_certbot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/certbot-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_certbot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_certbot}"
SRC_URI[x86_64_v2_certbot.sha256sum] = "99ceb00f50061a68f8c8218c2b69e8dd5b6ac17d6ef814c0670c9b9bd2d6cca3"

URI_x86_64_v2_python3-acme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-acme-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-acme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-acme}"
SRC_URI[x86_64_v2_python3-acme.sha256sum] = "aaa6237e1acfb9338597f44ea9ba48997d4a3e5780356345acc5349291014756"

URI_x86_64_v2_python3-certbot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot}"
SRC_URI[x86_64_v2_python3-certbot.sha256sum] = "3be6295ced82d3fdf0779e79ebc3058f9fcb3f4c17f6409456613908fadfc6a6"

URI_x86_64_v2_python3-certbot-apache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-apache-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-apache}"
SRC_URI[x86_64_v2_python3-certbot-apache.sha256sum] = "c65574583979b46a2a3d43de377f0972798e7dfa6f898cd0621e0df818979fba"

URI_x86_64_v2_python3-certbot-dns-cloudflare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-cloudflare-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-cloudflare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-cloudflare}"
SRC_URI[x86_64_v2_python3-certbot-dns-cloudflare.sha256sum] = "d3b8b8d4b7cceb630c19e8894819b3e899d87dabd492bec396f6b3ec954d5d15"

URI_x86_64_v2_python3-certbot-dns-digitalocean = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-digitalocean-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-digitalocean;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-digitalocean}"
SRC_URI[x86_64_v2_python3-certbot-dns-digitalocean.sha256sum] = "a75b2f64988d64464eec409f25a023460ea90fd29ce9857962afcf52cc5a7d5c"

URI_x86_64_v2_python3-certbot-dns-dnsimple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-dnsimple-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-dnsimple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-dnsimple}"
SRC_URI[x86_64_v2_python3-certbot-dns-dnsimple.sha256sum] = "95943e35707268576a08de676ae0994a13ea2ada7a53b23002a9962f0e951a37"

URI_x86_64_v2_python3-certbot-dns-dnsmadeeasy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-dnsmadeeasy-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-dnsmadeeasy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-dnsmadeeasy}"
SRC_URI[x86_64_v2_python3-certbot-dns-dnsmadeeasy.sha256sum] = "86afe6dcbc9323a74b32c1e9dd7ce9bd90362bb4bd00f8d44a1852161b0bab50"

URI_x86_64_v2_python3-certbot-dns-gehirn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-gehirn-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-gehirn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-gehirn}"
SRC_URI[x86_64_v2_python3-certbot-dns-gehirn.sha256sum] = "1c396b33e7c5c8860a8f193d7e657e2e9bd53dda62c1d968a85ee4b2903a3ac0"

URI_x86_64_v2_python3-certbot-dns-linode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-linode-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-linode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-linode}"
SRC_URI[x86_64_v2_python3-certbot-dns-linode.sha256sum] = "206db6af4ddd7f87bd17b92c61e1ee9698a0ac596f521dfdaad9432e459d35a6"

URI_x86_64_v2_python3-certbot-dns-luadns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-luadns-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-luadns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-luadns}"
SRC_URI[x86_64_v2_python3-certbot-dns-luadns.sha256sum] = "6ff0fda88b336585b6aecb1a2c4974c7319046aeb2a1ffca6da879c8093e74b4"

URI_x86_64_v2_python3-certbot-dns-nsone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-nsone-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-nsone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-nsone}"
SRC_URI[x86_64_v2_python3-certbot-dns-nsone.sha256sum] = "dbdf11e0b4f32bd3ff08befd0fa7819c9d9cc4e229b362bf214674074dda2bb8"

URI_x86_64_v2_python3-certbot-dns-ovh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-ovh-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-ovh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-ovh}"
SRC_URI[x86_64_v2_python3-certbot-dns-ovh.sha256sum] = "e973ef436267b158f49fcbcb298caf94dac1226359516f6b67d535605d287fff"

URI_x86_64_v2_python3-certbot-dns-rfc2136 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-rfc2136-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-rfc2136;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-rfc2136}"
SRC_URI[x86_64_v2_python3-certbot-dns-rfc2136.sha256sum] = "2178afab488915ad4f64888932a37ab31561e99175bd5392c9a0665c3dabff74"

URI_x86_64_v2_python3-certbot-dns-route53 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-route53-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-route53;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-route53}"
SRC_URI[x86_64_v2_python3-certbot-dns-route53.sha256sum] = "b693fd19242e54473d70e0c62d4b1468fd086b53178d22869968662b3d49798d"

URI_x86_64_v2_python3-certbot-dns-sakuracloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-dns-sakuracloud-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-dns-sakuracloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-dns-sakuracloud}"
SRC_URI[x86_64_v2_python3-certbot-dns-sakuracloud.sha256sum] = "b225adca2277539229aff24622d58afeed8aa38f0344a21360bf383da277e2b5"

URI_x86_64_v2_python3-certbot-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-certbot-nginx-4.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-certbot-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-certbot-nginx}"
SRC_URI[x86_64_v2_python3-certbot-nginx.sha256sum] = "67dc961e20db03cdca33066adfda0b2a70ac3751921d58541c82569ab02f7f77"

URI_aarch64_certbot = "${EPEL_MIRROR}/aarch64/Packages/c/certbot-4.2.0-1.el10_1.noarch.rpm;name=aarch64_certbot;unpack=0"
SRC_URI:append = " ${URI_aarch64_certbot}"
SRC_URI[aarch64_certbot.sha256sum] = "1fd9c501d75179ce525f4d6321eed9e5b98e9331254595bbcb8c30d719dde785"

URI_aarch64_python3-acme = "${EPEL_MIRROR}/aarch64/Packages/p/python3-acme-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-acme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-acme}"
SRC_URI[aarch64_python3-acme.sha256sum] = "8affa2c93b2351b33fbff0f1194b97ce70a819180ea4e82573afa26be85fa219"

URI_aarch64_python3-certbot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot}"
SRC_URI[aarch64_python3-certbot.sha256sum] = "4dbaa99cbad2686496b3c3a08e56f3dfdf0acf1b5d4cf4508df68fa10a1a4ae1"

URI_aarch64_python3-certbot-apache = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-apache-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-apache}"
SRC_URI[aarch64_python3-certbot-apache.sha256sum] = "19f382dfd01b93f6daa3e4b17f9b5a4e4adc0666898bd85e291802a59dacff3a"

URI_aarch64_python3-certbot-dns-cloudflare = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-cloudflare-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-cloudflare;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-cloudflare}"
SRC_URI[aarch64_python3-certbot-dns-cloudflare.sha256sum] = "e9d1a7f666af0ba96f104d770d4855f1ec663777ca9bc9105dfeed7ed24932c3"

URI_aarch64_python3-certbot-dns-digitalocean = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-digitalocean-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-digitalocean;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-digitalocean}"
SRC_URI[aarch64_python3-certbot-dns-digitalocean.sha256sum] = "2bc45cc6f16c865e1467be7e67f252553fe1470df9091b97eae527885fcb5adc"

URI_aarch64_python3-certbot-dns-dnsimple = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-dnsimple-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-dnsimple;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-dnsimple}"
SRC_URI[aarch64_python3-certbot-dns-dnsimple.sha256sum] = "b0bab28ac44a79ae4fdbd8d0b3b940975ccee086de0bab417381a4c661c0964f"

URI_aarch64_python3-certbot-dns-dnsmadeeasy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-dnsmadeeasy-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-dnsmadeeasy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-dnsmadeeasy}"
SRC_URI[aarch64_python3-certbot-dns-dnsmadeeasy.sha256sum] = "e590b3a91bd73f7f703a69abb2da3255409482872d19bb46af08b515e74bea98"

URI_aarch64_python3-certbot-dns-gehirn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-gehirn-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-gehirn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-gehirn}"
SRC_URI[aarch64_python3-certbot-dns-gehirn.sha256sum] = "d91543180f50e404853bdea8cd99ec22a19e3d81181aa29dcaf9acc505076fe6"

URI_aarch64_python3-certbot-dns-linode = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-linode-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-linode;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-linode}"
SRC_URI[aarch64_python3-certbot-dns-linode.sha256sum] = "84d82efc8a391f5ff91b0b08da62777fecbafd69df6dac314b37612d4337fd73"

URI_aarch64_python3-certbot-dns-luadns = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-luadns-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-luadns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-luadns}"
SRC_URI[aarch64_python3-certbot-dns-luadns.sha256sum] = "a4e3cbf9e290d3befcdf30f60ac0b20521282dffc6d0d5f60d9b1a3814c63c73"

URI_aarch64_python3-certbot-dns-nsone = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-nsone-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-nsone;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-nsone}"
SRC_URI[aarch64_python3-certbot-dns-nsone.sha256sum] = "7c57fd7b1a57bf8216d5d7f0f4ae3f995ec959ccee4949ddfda36a8d6294f705"

URI_aarch64_python3-certbot-dns-ovh = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-ovh-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-ovh;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-ovh}"
SRC_URI[aarch64_python3-certbot-dns-ovh.sha256sum] = "a6f1511c266afefaeb5697fe62b64ae957395b652fcb42e6a8874de43970cdab"

URI_aarch64_python3-certbot-dns-rfc2136 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-rfc2136-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-rfc2136;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-rfc2136}"
SRC_URI[aarch64_python3-certbot-dns-rfc2136.sha256sum] = "fb3a13677ee977ee6e7d8a3d1ff6b7776b1626d676ae7a681d3665125ddb56d2"

URI_aarch64_python3-certbot-dns-route53 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-route53-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-route53;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-route53}"
SRC_URI[aarch64_python3-certbot-dns-route53.sha256sum] = "1ae7d66af81fe373e566972b7eb2e5369213954eef798c5eb003255654d59eb6"

URI_aarch64_python3-certbot-dns-sakuracloud = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-dns-sakuracloud-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-dns-sakuracloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-dns-sakuracloud}"
SRC_URI[aarch64_python3-certbot-dns-sakuracloud.sha256sum] = "508f09133830667bcc4f895b6b55cc816ee780f56c0847f095450172c768fddd"

URI_aarch64_python3-certbot-nginx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-certbot-nginx-4.2.0-1.el10_1.noarch.rpm;name=aarch64_python3-certbot-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-certbot-nginx}"
SRC_URI[aarch64_python3-certbot-nginx.sha256sum] = "18c38a46bbc659b55859426794d1fb75f426a4197f6287597e5876de09703a15"

RDEPENDS:certbot = " \
 bash \
 fontawesome4-fonts \
 policycoreutils \
 python3-certbot \
 systemd \
 "
RDEPENDS:python3-acme = " \
 python3 \
 python3-cryptography \
 python3-josepy \
 python3-pyOpenSSL \
 python3-pyrfc3339 \
 python3-requests \
 "
RDEPENDS:python3-certbot = " \
 python3 \
 python3-acme \
 python3-configargparse \
 python3-configobj \
 python3-cryptography \
 python3-distro \
 python3-josepy \
 python3-parsedatetime \
 python3-pyrfc3339 \
 "
RDEPENDS:python3-certbot-apache = " \
 mod_ssl \
 python3 \
 python3-acme \
 python3-augeas \
 python3-certbot \
 "
RDEPENDS:python3-certbot-dns-cloudflare = " \
 python3 \
 python3-cloudflare \
 "
RDEPENDS:python3-certbot-dns-digitalocean = " \
 python3 \
 python3-digitalocean \
 "
RDEPENDS:python3-certbot-dns-dnsimple = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-dnsmadeeasy = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-gehirn = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-linode = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-luadns = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-nsone = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-ovh = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-dns-rfc2136 = " \
 python3 \
 python3-dns \
 "
RDEPENDS:python3-certbot-dns-route53 = " \
 python3 \
 python3-boto3 \
 "
RDEPENDS:python3-certbot-dns-sakuracloud = " \
 python3 \
 python3-dns-lexicon \
 "
RDEPENDS:python3-certbot-nginx = " \
 python3 \
 python3-acme \
 python3-certbot \
 python3-pyOpenSSL \
 python3-pyparsing \
 "
