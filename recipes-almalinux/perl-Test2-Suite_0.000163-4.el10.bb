# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test2-Suite"
PV = "0.000163"
PR = "4.el10"
PACKAGES = " \
 perl-Test2-Suite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Test2-Suite-0.000163-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2667bcea667f3a409c192c1effc54a63ee9cb2ab908b0c25664ffcc659e41760"

URI_x86_64_v2_perl-Test2-Suite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Test2-Suite-0.000163-4.el10.noarch.rpm;name=x86_64_v2_perl-Test2-Suite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test2-Suite}"
SRC_URI[x86_64_v2_perl-Test2-Suite.sha256sum] = "d407092af2e0551d68c5322def158e0c2186de661b7d4ba55c200fff3d027efc"

URI_aarch64_perl-Test2-Suite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Test2-Suite-0.000163-4.el10.noarch.rpm;name=aarch64_perl-Test2-Suite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test2-Suite}"
SRC_URI[aarch64_perl-Test2-Suite.sha256sum] = "d407092af2e0551d68c5322def158e0c2186de661b7d4ba55c200fff3d027efc"

RDEPENDS:perl-Test2-Suite = " \
 perl-B \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Temp \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Term-Table \
 perl-Test-Simple \
 perl-Test2-Suite \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-vars \
 "
