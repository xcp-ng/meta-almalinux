# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-shallow"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-shallow+default-devel \
 rust-gix-shallow+serde-devel \
 rust-gix-shallow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-shallow-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2af33565bdc5b5792d50db2f20494a9899a0e5c5c51c4ddac578c888ad5532e7"

URI_x86_64_v2_rust-gix-shallow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+default-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+default-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+default-devel.sha256sum] = "9a96f35fd4a8090e89523acee503923170ab30a71daffe36b85047074e2e93a1"

URI_x86_64_v2_rust-gix-shallow+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+serde-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+serde-devel.sha256sum] = "bc7053e2755afb8249074b7d6b0ff06ab30b8bc00c2f2f605756c781d5d6e7ee"

URI_x86_64_v2_rust-gix-shallow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow-devel.sha256sum] = "bab4dc5c98e87e35f51ef041ac9e3a35607a793e74c849b065ae79545d0fbbd0"

URI_aarch64_rust-gix-shallow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+default-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-shallow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+default-devel}"
SRC_URI[aarch64_rust-gix-shallow+default-devel.sha256sum] = "46143b94ebede7ba62c517e93b43298eb61f0cb45f12c6898d6663076f141330"

URI_aarch64_rust-gix-shallow+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+serde-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-shallow+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+serde-devel}"
SRC_URI[aarch64_rust-gix-shallow+serde-devel.sha256sum] = "da83429670fb43298f46b70961c0d0633349e639a7cdd53ddc99f3b81ac4a849"

URI_aarch64_rust-gix-shallow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-shallow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow-devel}"
SRC_URI[aarch64_rust-gix-shallow-devel.sha256sum] = "c8bc16699e6acbc1a9b6c37b39888c23139aa0e64e49f8ee5dd97263f720cb31"

RDEPENDS:rust-gix-shallow+default-devel = " \
 cargo \
 rust-gix-shallow-devel \
 "
RDEPENDS:rust-gix-shallow+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-shallow-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-shallow-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-thiserror+default-devel \
 "
