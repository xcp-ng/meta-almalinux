# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-ident"
PV = "1.0.24"
PR = "1.el10_1"
PACKAGES = " \
 rust-unicode-ident+default-devel \
 rust-unicode-ident-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-ident-1.0.24-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "400967ef5a8fb07a0bde6caf95976527d657ad1e0e525514024755b613d4d320"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident+default-devel-1.0.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-ident+default-devel.sha256sum] = "dd7fe1737abc3359cc142b5b37ef5623b916512ed6b52859e4a36411e491ef12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident-devel-1.0.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-ident-devel.sha256sum] = "7f14fa394969b7f47ae61cdd6d29f858145964febe98782da592862e8a147df4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident+default-devel-1.0.24-1.el10_1.noarch.rpm;name=aarch64_rust-unicode-ident+default-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-ident+default-devel.sha256sum] = "cb830d06a1cb1843f64f57b03a97627f75446266735c5cc2acd93f8f833eb425"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident-devel-1.0.24-1.el10_1.noarch.rpm;name=aarch64_rust-unicode-ident-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-ident-devel.sha256sum] = "0ddad2539e80ddd95f5792053f195351e6c80fcfd638f4a102fc34172668b08a"

RDEPENDS:rust-unicode-ident+default-devel = " \
 cargo \
 rust-unicode-ident-devel \
 "
RDEPENDS:rust-unicode-ident-devel = " \
 cargo \
 rust \
 "
