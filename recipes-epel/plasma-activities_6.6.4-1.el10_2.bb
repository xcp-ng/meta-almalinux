# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-activities \
 plasma-activities-devel \
 plasma-activities-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1c37e387cce1433e081cec4988bf66467dcd54bf634b40262626996573049a5"

URI_x86_64_v2_plasma-activities = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities}"
SRC_URI[x86_64_v2_plasma-activities.sha256sum] = "b067fbb205a15afa2252d6135ec52dfd12aba3ffe3231345fec8c655266c26aa"

URI_x86_64_v2_plasma-activities-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-devel}"
SRC_URI[x86_64_v2_plasma-activities-devel.sha256sum] = "d8929fe4b6bcd6989cebdaa4ea110ecd76049d926832545f5234642e04016d56"

URI_x86_64_v2_plasma-activities-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-doc-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-doc}"
SRC_URI[x86_64_v2_plasma-activities-doc.sha256sum] = "15115a4bd52a207728bff0e5d8953504394d08c9c1a7d7d397403e4ecd2f78bd"

URI_aarch64_plasma-activities = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-activities;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities}"
SRC_URI[aarch64_plasma-activities.sha256sum] = "7b28234dc56d6cf65ed8b2fd62053eb379c5eac7f5df155511e83b3d5b84b1ed"

URI_aarch64_plasma-activities-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-activities-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-devel}"
SRC_URI[aarch64_plasma-activities-devel.sha256sum] = "360c76e85c0d03f0bce345bcf05a1d86f38d19b5e7d3f62dd1990069f953ac12"

URI_aarch64_plasma-activities-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-doc-6.6.4-1.el10_2.noarch.rpm;name=aarch64_plasma-activities-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-doc}"
SRC_URI[aarch64_plasma-activities-doc.sha256sum] = "129e0012678aaad8cb0a268e1c3a32856ab6f1ecc0439364004b2d896de01f9f"

RDEPENDS:plasma-activities = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-activities-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-doc = " \
 "
