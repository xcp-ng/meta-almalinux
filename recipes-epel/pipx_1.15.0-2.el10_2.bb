# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipx"
PV = "1.15.0"
PR = "2.el10_2"
PACKAGES = " \
 pipx \
 pipx+uv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pipx-1.15.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4342bec7f49c2c6451adb276004ff692ef57ff482de26c277c1bd0352906dcbe"

URI_x86_64_v2_pipx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipx-1.15.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pipx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipx}"
SRC_URI[x86_64_v2_pipx.sha256sum] = "71319f50f47a3b3402cd4ad3622b1bf7a060e02e9a87b594f29bb6cf9b4d5181"

URI_x86_64_v2_pipx+uv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipx+uv-1.15.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pipx+uv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipx+uv}"
SRC_URI[x86_64_v2_pipx+uv.sha256sum] = "0d10d4ba5d4c0fe7378b0feae62d612e4054b3cb7ac4830db8470527cdb6a34e"

URI_aarch64_pipx = "${EPEL_MIRROR}/aarch64/Packages/p/pipx-1.15.0-2.el10_2.noarch.rpm;name=aarch64_pipx;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipx}"
SRC_URI[aarch64_pipx.sha256sum] = "98ab487c135c4103a0e9afbbe1cff0fdd62cdedd8cfadd9bf48dae5a0aae51aa"

URI_aarch64_pipx+uv = "${EPEL_MIRROR}/aarch64/Packages/p/pipx+uv-1.15.0-2.el10_2.noarch.rpm;name=aarch64_pipx+uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipx+uv}"
SRC_URI[aarch64_pipx+uv.sha256sum] = "e649131329b55c58746715d2bd57afdf483117512a1c3a6ef1b9dc2656e015b7"

RDEPENDS:pipx = " \
 python3 \
 python3-argcomplete \
 python3-packaging \
 python3-platformdirs \
 python3-userpath \
 "
RDEPENDS:pipx+uv = " \
 pipx \
 python3 \
 python3-uv \
 "
