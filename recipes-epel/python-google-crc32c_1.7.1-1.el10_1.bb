# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-crc32c"
PV = "1.7.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-google-crc32c \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-crc32c-1.7.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d726cb6cd2be7c2989e9f2ebe1d6a65f3769e61965ef5fd8e5427e196bba42d"

URI_x86_64_v2_python3-google-crc32c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-crc32c-1.7.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-google-crc32c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-crc32c}"
SRC_URI[x86_64_v2_python3-google-crc32c.sha256sum] = "32d59eb6822abab29edaefa1995a001a1dbde5553cbb60e59496cb69eec10e7c"

URI_aarch64_python3-google-crc32c = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-crc32c-1.7.1-1.el10_1.aarch64.rpm;name=aarch64_python3-google-crc32c;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-crc32c}"
SRC_URI[aarch64_python3-google-crc32c.sha256sum] = "7c2a44a08a3f5462ea0a2ff2a0b6de272ad9675de8e9ddefc5d7d361e95f0ec4"

RDEPENDS:python3-google-crc32c = " \
 glibc \
 google-crc32c \
 python3 \
 "
