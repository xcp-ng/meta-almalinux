# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdpyinfo"
PV = "1.3.4"
PR = "2.el10_0"
PACKAGES = " \
 xdpyinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xdpyinfo-1.3.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90db5283392ca4dfff6fc7160b4a014b2cbf05344a21d3f12e844fab88b20b44"

URI_x86_64_v2_xdpyinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdpyinfo-1.3.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xdpyinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdpyinfo}"
SRC_URI[x86_64_v2_xdpyinfo.sha256sum] = "47d8c4250c1aa26750682fffa71cb7819ea2c93e74b8a7256b13618a4333363e"

URI_aarch64_xdpyinfo = "${EPEL_MIRROR}/aarch64/Packages/x/xdpyinfo-1.3.4-2.el10_0.aarch64.rpm;name=aarch64_xdpyinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdpyinfo}"
SRC_URI[aarch64_xdpyinfo.sha256sum] = "120ab40489b07bc8634ddffc6d428258ad8ac3950c394470132de99d81369b11"

RDEPENDS:xdpyinfo = " \
 glibc \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXext \
 libXi \
 libXinerama \
 libXrender \
 libXtst \
 libXxf86dga \
 libXxf86vm \
 libxcb \
 "
