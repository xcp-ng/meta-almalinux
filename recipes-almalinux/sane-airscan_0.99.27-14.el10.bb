# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sane-airscan"
PV = "0.99.27"
PR = "14.el10"
PACKAGES = " \
 libsane-airscan \
 sane-airscan \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sane-airscan-0.99.27-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "302a5892faa117f64e81ff230e68548e90227e790f281e3089587b630e31429d"

URI_x86_64_v2_libsane-airscan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsane-airscan-0.99.27-14.el10.x86_64_v2.rpm;name=x86_64_v2_libsane-airscan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsane-airscan}"
SRC_URI[x86_64_v2_libsane-airscan.sha256sum] = "32af6e7bfe4e58924415a7abcbe3e5b387da0afda003f3ce6be3a1f1df08154e"

URI_x86_64_v2_sane-airscan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sane-airscan-0.99.27-14.el10.x86_64_v2.rpm;name=x86_64_v2_sane-airscan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sane-airscan}"
SRC_URI[x86_64_v2_sane-airscan.sha256sum] = "ec21f50f209eedc1d01d73ed96729d6b09cbbe7a1f19be4687d91dbf1802e7b5"

URI_aarch64_libsane-airscan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsane-airscan-0.99.27-14.el10.aarch64.rpm;name=aarch64_libsane-airscan;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsane-airscan}"
SRC_URI[aarch64_libsane-airscan.sha256sum] = "42a002498b488a6732981c379b1b3efd2897eba0084dad0eb456ae7ba272cc0c"

URI_aarch64_sane-airscan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sane-airscan-0.99.27-14.el10.aarch64.rpm;name=aarch64_sane-airscan;unpack=0"
SRC_URI:append = " ${URI_aarch64_sane-airscan}"
SRC_URI[aarch64_sane-airscan.sha256sum] = "2ad0d3e0fc1faffb13ac2e9a844b2ebc86a975f7b51052c9efec2e9d21e8bbf9"

RDEPENDS:libsane-airscan = " \
 avahi-libs \
 glibc \
 gnutls \
 libjpeg-turbo \
 libpng \
 libxml2 \
 "
RDEPENDS:sane-airscan = " \
 avahi-libs \
 glibc \
 gnutls \
 libsane-airscan \
 libxml2 \
 "
