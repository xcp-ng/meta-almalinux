# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet10.0"
PV = "10.0.111"
PR = "1.el10_2"
PACKAGES = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-runtime-dbg-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-host \
 dotnet-hostfxr-10.0 \
 dotnet-runtime-10.0 \
 dotnet-runtime-dbg-10.0 \
 dotnet-sdk-10.0 \
 dotnet-sdk-10.0-source-built-artifacts \
 dotnet-sdk-aot-10.0 \
 dotnet-sdk-dbg-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet10.0-10.0.111-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3db4f658de30a782f81f3d299f4f6ec2f2b5b8643a72c120755c99c326a8b5e"

URI_x86_64_v2_aspnetcore-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-10.0-10.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-10.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-10.0.sha256sum] = "38bf5c10e77cc5d0dee468dbfecef893b045d6231046b48ba999529d19e40bc7"

URI_x86_64_v2_aspnetcore-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-10.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-10.0.sha256sum] = "f3b5cac56a8f89be284c694b08020bb71e9191be08683c43106ffdbc8e8b8f30"

URI_x86_64_v2_aspnetcore-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-10.0-10.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-10.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-10.0.sha256sum] = "0381b821e443f730f4e781eef06580f07209d4be9a515ae34f16910beead6e17"

URI_x86_64_v2_dotnet-apphost-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-10.0-10.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-10.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-10.0.sha256sum] = "8579f777460edf01146b1decbb63d9bf63581185220f88e34953b3da36dc9760"

URI_x86_64_v2_dotnet-host = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-host-10.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-host;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-host}"
SRC_URI[x86_64_v2_dotnet-host.sha256sum] = "f81d05c85ea019a494f9cd13511ebe3466aa64cb3874bb1c354872037e8012bd"

URI_x86_64_v2_dotnet-hostfxr-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-10.0-10.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-10.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-10.0.sha256sum] = "2166d0dfb44c90d8db4ed828054bd8cf565112ca75788bfd682b312889517ff6"

URI_x86_64_v2_dotnet-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-10.0-10.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-10.0}"
SRC_URI[x86_64_v2_dotnet-runtime-10.0.sha256sum] = "b3643a031d1f4406483f6bbbdc142020746741fbbfa6b29d314693101a933579"

URI_x86_64_v2_dotnet-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-10.0-10.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-10.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-10.0.sha256sum] = "68593d1a490bc455d7acf96d13dcb583049640c507f55d924a1607b86f73ce78"

URI_x86_64_v2_dotnet-sdk-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-10.0-10.0.111-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-10.0}"
SRC_URI[x86_64_v2_dotnet-sdk-10.0.sha256sum] = "eccff7f77f5d488f40e358e2cfe766b4a86f93ad414696c68161ec1dfb27a49c"

URI_x86_64_v2_dotnet-sdk-10.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.111-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-10.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "738c880c68be9fb4c9baed62939231e82b2ab1e78ffc9cc7268ad3bb142a1338"

URI_x86_64_v2_dotnet-sdk-aot-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-10.0-10.0.111-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-aot-10.0}"
SRC_URI[x86_64_v2_dotnet-sdk-aot-10.0.sha256sum] = "2ce58e69ffe5f3aa350feab846a11e854fc657737000f84d85495286da7282f8"

URI_x86_64_v2_dotnet-sdk-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-10.0-10.0.111-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-10.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-10.0.sha256sum] = "e32c4171c2a131141f8496a3995331c6793cf1eef954b0e988876e9bf5f7bbdb"

URI_x86_64_v2_dotnet-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-10.0-10.0.11-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-10.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-10.0.sha256sum] = "06a83c9140b3036a15f78e061b63d735e6866e99ff594503b8a5a6d246f9a77d"

URI_x86_64_v2_dotnet-templates-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-10.0-10.0.111-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-10.0}"
SRC_URI[x86_64_v2_dotnet-templates-10.0.sha256sum] = "37df30ec1c7702246bf241886175b1864831f1f6e622aa7f9fefc3c9a656d181"

URI_aarch64_aspnetcore-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-10.0-10.0.11-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-10.0}"
SRC_URI[aarch64_aspnetcore-runtime-10.0.sha256sum] = "ed4f6fe60330bff81e642d521f0865e6e7ad6ff56ed7da338f5fdb079d48bb92"

URI_aarch64_aspnetcore-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.11-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-10.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-10.0.sha256sum] = "d4562111b60f98924068d14b0e4ab6a2ca87f67f4ad2f359343ea1bc31aaa274"

URI_aarch64_aspnetcore-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-10.0-10.0.11-1.el10_2.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-10.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-10.0.sha256sum] = "27355e30cb9c901087e582232169bcc0dd3254cf1b5ca5eff44babe1a0089c38"

URI_aarch64_dotnet-apphost-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-10.0-10.0.11-1.el10_2.aarch64.rpm;name=aarch64_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-10.0}"
SRC_URI[aarch64_dotnet-apphost-pack-10.0.sha256sum] = "585b76e8ab2230bce706efd60ab7a595ab27356aa9c989326b1d9af89143276d"

URI_aarch64_dotnet-host = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-host-10.0.11-1.el10_2.aarch64.rpm;name=aarch64_dotnet-host;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-host}"
SRC_URI[aarch64_dotnet-host.sha256sum] = "1a50d3ca1a13375d792a193659078fdf517c95e1ec3fd3a1b2a4369137daf545"

URI_aarch64_dotnet-hostfxr-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-10.0-10.0.11-1.el10_2.aarch64.rpm;name=aarch64_dotnet-hostfxr-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-10.0}"
SRC_URI[aarch64_dotnet-hostfxr-10.0.sha256sum] = "c611df009036667d4197b0ba12c8ba2ec07de23560c60b877ee66e38f6bcd127"

URI_aarch64_dotnet-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-10.0-10.0.11-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-10.0}"
SRC_URI[aarch64_dotnet-runtime-10.0.sha256sum] = "6fcdbbf5036abf9beed12fc9634fcf07c2fb8b268071ad7be1db97a8478572a6"

URI_aarch64_dotnet-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-10.0-10.0.11-1.el10_2.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-10.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-10.0.sha256sum] = "f41cda88d459152005440b7474bf203f00e947c91145a0e914a752534c921575"

URI_aarch64_dotnet-sdk-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-10.0-10.0.111-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-10.0}"
SRC_URI[aarch64_dotnet-sdk-10.0.sha256sum] = "72732d5d2d0551356fa348c7318ec8f69d8ac1812cb18cd14611bf6bfd316722"

URI_aarch64_dotnet-sdk-10.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.111-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-10.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "61451bdce0c3f7be025ee30a2c61984aface52d548a1cc96b6bcda237e444efd"

URI_aarch64_dotnet-sdk-aot-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-10.0-10.0.111-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-aot-10.0}"
SRC_URI[aarch64_dotnet-sdk-aot-10.0.sha256sum] = "6eee7ed65086a1b67291a6167a7fda01a3b81bf58851baa3701253cce9455b33"

URI_aarch64_dotnet-sdk-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-10.0-10.0.111-1.el10_2.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-10.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-10.0.sha256sum] = "aceca5b11718904dfa30b9e4ac26a169a2e59206b6e05b8e66c269389907f771"

URI_aarch64_dotnet-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-10.0-10.0.11-1.el10_2.aarch64.rpm;name=aarch64_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-10.0}"
SRC_URI[aarch64_dotnet-targeting-pack-10.0.sha256sum] = "70b2a6f4b533d582a207f81103e25d10fe380259f2768268822f69cae2e3bd4e"

URI_aarch64_dotnet-templates-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-10.0-10.0.111-1.el10_2.aarch64.rpm;name=aarch64_dotnet-templates-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-10.0}"
SRC_URI[aarch64_dotnet-templates-10.0.sha256sum] = "11e1252b3fe45cf55ff7025c09ab1ccc19396338bd8af511524a5981dc8c3bb9"

RDEPENDS:aspnetcore-runtime-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-10.0 = " \
 aspnetcore-runtime-10.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-10.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-host = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-hostfxr-10.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-10.0 = " \
 dotnet-hostfxr-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:dotnet-sdk-10.0 = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-runtime-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-sdk-10.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-10.0 = " \
 brotli-devel \
 clang \
 dotnet-sdk-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-10.0 = " \
 dotnet-sdk-10.0 \
 "
RDEPENDS:dotnet-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-10.0 = " \
 dotnet-host \
 "
