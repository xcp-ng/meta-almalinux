# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipblas-common"
PV = "7.2.0"
PR = "3.el10_3"
PACKAGES:x86_64_v2 = " \
 hipblas-common-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipblas-common-7.2.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4512f6c3ea37b3b8b9bd377251586124017d49cf7239421a520159a55c03dabb"

URI_x86_64_v2_hipblas-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblas-common-devel-7.2.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_hipblas-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblas-common-devel}"
SRC_URI[x86_64_v2_hipblas-common-devel.sha256sum] = "7d4b28c557744fb45e550e9b2c042ee28bbdd5dbe4ce391e5fb12bcfa1626815"

RDEPENDS:hipblas-common-devel = " \
 cmake-filesystem \
 rocm-filesystem \
 "
