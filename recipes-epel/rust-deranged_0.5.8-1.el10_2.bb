# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deranged"
PV = "0.5.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-deranged+alloc-devel \
 rust-deranged+default-devel \
 rust-deranged+num-devel \
 rust-deranged+powerfmt-devel \
 rust-deranged+quickcheck-devel \
 rust-deranged+rand-devel \
 rust-deranged+rand010-devel \
 rust-deranged+rand08-devel \
 rust-deranged+rand09-devel \
 rust-deranged+serde-devel \
 rust-deranged-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deranged-0.5.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92aafabff1b2108992e9ac4be4343da2a00fef694b6abd0073597c1d441053ac"

URI_x86_64_v2_rust-deranged+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+alloc-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+alloc-devel}"
SRC_URI[x86_64_v2_rust-deranged+alloc-devel.sha256sum] = "5e68ca285e6e4d0647299dd50274e704046188d2a80d91e3d03bb89b19316fe6"

URI_x86_64_v2_rust-deranged+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+default-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+default-devel}"
SRC_URI[x86_64_v2_rust-deranged+default-devel.sha256sum] = "e7ae06de99ef27a646a6cebb631bc9636460af7a91a3715bb13914edd03b4ba8"

URI_x86_64_v2_rust-deranged+num-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+num-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+num-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+num-devel}"
SRC_URI[x86_64_v2_rust-deranged+num-devel.sha256sum] = "c9b949716fe32b9876ffaf08282079289407c136e74421f50d65a6473150d829"

URI_x86_64_v2_rust-deranged+powerfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+powerfmt-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+powerfmt-devel}"
SRC_URI[x86_64_v2_rust-deranged+powerfmt-devel.sha256sum] = "bf714cc56659dcabfbdae2302e40e12b99cb507eaeec86024ee2648b559ac77d"

URI_x86_64_v2_rust-deranged+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+quickcheck-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-deranged+quickcheck-devel.sha256sum] = "ffbc728113d4b7f51bb1a51e3ad0cb2efac9f89c3f03f889a2ed313e3bb72c6b"

URI_x86_64_v2_rust-deranged+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand-devel.sha256sum] = "b6721d9a156e37f1ac7bd6eb204941e1096c124e83d6dc672a34394d35e3ede5"

URI_x86_64_v2_rust-deranged+rand010-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand010-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand010-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand010-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand010-devel.sha256sum] = "c0de8484195aaf10bd2a44055ae3e286850411cd3d094413821b26e21f88a8b3"

URI_x86_64_v2_rust-deranged+rand08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand08-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand08-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand08-devel.sha256sum] = "22baf1ea4337b6fbb35ad3be954c534144ecb713ef91ddd77fa50c9fd4f98b94"

URI_x86_64_v2_rust-deranged+rand09-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand09-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand09-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand09-devel.sha256sum] = "1a4123c9d5b69db2dd90f8f45e63e8dd90b0550f8ab30cefe8d0000a7be687cf"

URI_x86_64_v2_rust-deranged+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+serde-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+serde-devel}"
SRC_URI[x86_64_v2_rust-deranged+serde-devel.sha256sum] = "066cf61f343e8158bbc497786f33247a6f34ee257bde6a2b3810bddebe10f911"

URI_x86_64_v2_rust-deranged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged-devel-0.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged-devel}"
SRC_URI[x86_64_v2_rust-deranged-devel.sha256sum] = "291f18833d833cecbcde813dfc42e632a69820abf7d6c40e651b76ab21324a93"

URI_aarch64_rust-deranged+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+alloc-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+alloc-devel}"
SRC_URI[aarch64_rust-deranged+alloc-devel.sha256sum] = "678db93a87c0566839e2e0cb9b2c33773e4d76785ff7def20e6cd4fd4f6ca9a2"

URI_aarch64_rust-deranged+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+default-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+default-devel}"
SRC_URI[aarch64_rust-deranged+default-devel.sha256sum] = "df992307b4771fd292ed752f9722c789a61f06782f85d9b2d7289c5f10ea1568"

URI_aarch64_rust-deranged+num-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+num-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+num-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+num-devel}"
SRC_URI[aarch64_rust-deranged+num-devel.sha256sum] = "d64c5b0ba80c72f9c5b0f17307b1eb15997486ac8b4234d56ea970a41817797e"

URI_aarch64_rust-deranged+powerfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+powerfmt-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+powerfmt-devel}"
SRC_URI[aarch64_rust-deranged+powerfmt-devel.sha256sum] = "e3e415bc54c5e4426c60eb4dbf5b1ec2502a88410e32a782033e404389127fb8"

URI_aarch64_rust-deranged+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+quickcheck-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+quickcheck-devel}"
SRC_URI[aarch64_rust-deranged+quickcheck-devel.sha256sum] = "f76c09ed695ae956593f1bd9ef3436893d14438b070ddcd0ae9fd3ca751badf1"

URI_aarch64_rust-deranged+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand-devel}"
SRC_URI[aarch64_rust-deranged+rand-devel.sha256sum] = "fd5d9f630b4b95e4f8b4d5c66d5c91604663c8952679f6405bd820f796a1e494"

URI_aarch64_rust-deranged+rand010-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand010-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+rand010-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand010-devel}"
SRC_URI[aarch64_rust-deranged+rand010-devel.sha256sum] = "2972ebd09f6152eb0147c38745800cc8264829bcecce171d9c2a8593bb181f53"

URI_aarch64_rust-deranged+rand08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand08-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand08-devel}"
SRC_URI[aarch64_rust-deranged+rand08-devel.sha256sum] = "970ede58e534e3e56d7b9476d36e125c6eff669911e52dbde6c7ecea72422f7f"

URI_aarch64_rust-deranged+rand09-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand09-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand09-devel}"
SRC_URI[aarch64_rust-deranged+rand09-devel.sha256sum] = "1fe844276d9ec25a758b4eda06128b4ea6f132b4363a055f1f5810e065a31c83"

URI_aarch64_rust-deranged+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+serde-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+serde-devel}"
SRC_URI[aarch64_rust-deranged+serde-devel.sha256sum] = "57f41353894dd9944f3ac21c25e52d9df6add448f7d316c2618400929a69c6d2"

URI_aarch64_rust-deranged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged-devel-0.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-deranged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged-devel}"
SRC_URI[aarch64_rust-deranged-devel.sha256sum] = "2b1a9cf756a13e82c6484ad5f92acb0dc4286373d84ff832c6154fac8cd58ea9"

RDEPENDS:rust-deranged+alloc-devel = " \
 cargo \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+default-devel = " \
 cargo \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+num-devel = " \
 cargo \
 rust-deranged-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-deranged+powerfmt-devel = " \
 cargo \
 rust-deranged-devel \
 rust-powerfmt-devel \
 "
RDEPENDS:rust-deranged+quickcheck-devel = " \
 cargo \
 rust-deranged+alloc-devel \
 rust-deranged-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-deranged+rand-devel = " \
 cargo \
 rust-deranged+rand010-devel \
 rust-deranged+rand08-devel \
 rust-deranged+rand09-devel \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+rand010-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-deranged+rand08-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-deranged+rand09-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-deranged+serde-devel = " \
 cargo \
 rust-deranged-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-deranged-devel = " \
 cargo \
 rust \
 "
