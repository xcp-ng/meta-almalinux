# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-ada"
PV = "0.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-ada+default-devel \
 rust-tree-sitter-ada-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-ada-0.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3736292cdf81ee4c34fc3f83232853d3264c89e465baf1686565ba99804a47ad"

URI_x86_64_v2_rust-tree-sitter-ada+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ada+default-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ada+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ada+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ada+default-devel.sha256sum] = "bee942b8826c1ee71c6b05e1b62818201ade71db39c9afda899aab01b3ec71f2"

URI_x86_64_v2_rust-tree-sitter-ada-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ada-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ada-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ada-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ada-devel.sha256sum] = "d4969eee4c423899553f2a6476168624939c8b5cb7e6cf2b74d446542d547530"

URI_aarch64_rust-tree-sitter-ada+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ada+default-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-ada+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ada+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-ada+default-devel.sha256sum] = "ada0249f48136861c93b0beebfb12c179dac8d64229c6ffc42161621010634f0"

URI_aarch64_rust-tree-sitter-ada-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ada-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-ada-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ada-devel}"
SRC_URI[aarch64_rust-tree-sitter-ada-devel.sha256sum] = "798b8da0afa418b0e40fcaebe4f1471352cdf86d46100aec0875930bb568ac6b"

RDEPENDS:rust-tree-sitter-ada+default-devel = " \
 cargo \
 rust-tree-sitter-ada-devel \
 "
RDEPENDS:rust-tree-sitter-ada-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
