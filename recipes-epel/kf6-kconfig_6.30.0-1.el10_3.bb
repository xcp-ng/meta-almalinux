# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfig"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kconfig \
 kf6-kconfig-devel \
 kf6-kconfig-doc \
 kf6-kconfig-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfig-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "03497b74dc2ee2a3ade7b9d459243c4e46d2a97d12c753f17dca5f06f16b2564"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig;unpack=0"
SRC_URI[x86_64_v2_kf6-kconfig.sha256sum] = "7c7adaa3113699fe1fa54581ec1c0cb6dc33af3e03894719df38dbac2c26afd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfig-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kconfig-devel.sha256sum] = "6cb56c4d32e831ebd9e923658909121bc151d82fe05aa7e4d0b7139c72c7b818"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfig-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kconfig-doc.sha256sum] = "6944107f382b769a42feb8f67ad429980c7a852d33f1215fcb3ac7404b6a88c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfig-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfig-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kconfig-html.sha256sum] = "21133ce98eb833ddc9bdad1148bf8556ce68c5050d73201cb2c2eed0d6bbeb1d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kconfig;unpack=0"
SRC_URI[aarch64_kf6-kconfig.sha256sum] = "b55e5d6b2a44d3c7920de070ef8fa2d10c006694bc97715bb1fa7fd280d322bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kconfig-devel;unpack=0"
SRC_URI[aarch64_kf6-kconfig-devel.sha256sum] = "a4f6fb2333c9bc8a8aaf2fe1f26a77371a39fbc926f1b678c1d8d70349e9fa4e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kconfig-doc;unpack=0"
SRC_URI[aarch64_kf6-kconfig-doc.sha256sum] = "559fb91ca86abb4e6f940450372d89d74553a625be410a980fed53686d4cce58"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfig-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kconfig-html;unpack=0"
SRC_URI[aarch64_kf6-kconfig-html.sha256sum] = "746f33fb3a6852d7945e5432f09ae617dbc0fdaf6d28cc560264bc0cc3cbc48a"

RDEPENDS:kf6-kconfig = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kconfig-devel = " \
 cmake-filesystem \
 kf6-kconfig \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kconfig-doc = " \
 "
RDEPENDS:kf6-kconfig-html = " \
 "
