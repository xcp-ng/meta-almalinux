# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-bigint-dig"
PV = "0.8.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-num-bigint-dig+arbitrary-devel \
 rust-num-bigint-dig+default-devel \
 rust-num-bigint-dig+fuzz-devel \
 rust-num-bigint-dig+i128-devel \
 rust-num-bigint-dig+prime-devel \
 rust-num-bigint-dig+rand-devel \
 rust-num-bigint-dig+serde-devel \
 rust-num-bigint-dig+std-devel \
 rust-num-bigint-dig+u64_digit-devel \
 rust-num-bigint-dig+zeroize-devel \
 rust-num-bigint-dig-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-bigint-dig-0.8.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaee1e479eb20bfef7db72c58bbf4ac88ea49f4107abe527ba20000e39204ed7"

URI_x86_64_v2_rust-num-bigint-dig+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+arbitrary-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+arbitrary-devel.sha256sum] = "99c14e02a209b2cca826dfd366e399c84a28c5efa587ab099b35ddfee4194066"

URI_x86_64_v2_rust-num-bigint-dig+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+default-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+default-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+default-devel.sha256sum] = "d0bf3f15696ec7589388d2d19be5c49bd03b19905b8687f7ec5d0a137dab7d58"

URI_x86_64_v2_rust-num-bigint-dig+fuzz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+fuzz-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+fuzz-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+fuzz-devel.sha256sum] = "25837c235c17af2feffbf0c1b13ddc0fd59d3761dab39372247ce208f001983b"

URI_x86_64_v2_rust-num-bigint-dig+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+i128-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+i128-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+i128-devel.sha256sum] = "9712d3a1a59cabe18150848d93072d86e213b1727750658fb1558dcd0ed6ab2f"

URI_x86_64_v2_rust-num-bigint-dig+prime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+prime-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+prime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+prime-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+prime-devel.sha256sum] = "40d4caee4ef1584d251f5587e9f3f48b74f910536b9c76e8c3922874d293ece7"

URI_x86_64_v2_rust-num-bigint-dig+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+rand-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+rand-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+rand-devel.sha256sum] = "b7c069d7f05f9aa6e3e3dbcebbadcb151877e355cfe63183f9fbe5e9faa6ccb6"

URI_x86_64_v2_rust-num-bigint-dig+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+serde-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+serde-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+serde-devel.sha256sum] = "80f3f47b62f084dec12f934023e610aa31bcc61262a8a71ba2bb634784602a3b"

URI_x86_64_v2_rust-num-bigint-dig+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+std-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+std-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+std-devel.sha256sum] = "d094721c2eeff85579481810c5158951ba3b4ed6c78cc2b42a52496ed4e3eab2"

URI_x86_64_v2_rust-num-bigint-dig+u64_digit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+u64_digit-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+u64_digit-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+u64_digit-devel.sha256sum] = "2b3550f7e03572abfe9efa67255c9b389bc68e8c1dbff44a35990cd24a2a7925"

URI_x86_64_v2_rust-num-bigint-dig+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig+zeroize-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig+zeroize-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig+zeroize-devel.sha256sum] = "9f9fa7a8c9c71f0c9a5534302d807efc4bbd442ddb22d760377bf61060ad01b2"

URI_x86_64_v2_rust-num-bigint-dig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig-devel.sha256sum] = "ae39d9fbfd37a822fa7501dc8ec69cfb08a7517f90b541947784f48da80c7415"

URI_aarch64_rust-num-bigint-dig+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+arbitrary-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+arbitrary-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+arbitrary-devel.sha256sum] = "9e997ceb5693f2d32aec85a43a37d28741e16f1fda2dfa9714f17464c9d7aa72"

URI_aarch64_rust-num-bigint-dig+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+default-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+default-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+default-devel.sha256sum] = "65e15134d3e06faaca57aa9315d06ed46565f59469dbb0eae740e120988908a5"

URI_aarch64_rust-num-bigint-dig+fuzz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+fuzz-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+fuzz-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+fuzz-devel.sha256sum] = "602185cea5c5cf8b73c21b6889df7fedf0e358cc656246a7b2d291e50cd8c9fc"

URI_aarch64_rust-num-bigint-dig+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+i128-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+i128-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+i128-devel.sha256sum] = "4f042dc9322cd7db14e8e990a90977d809f2b7d7b392ea40d065084e19271c40"

URI_aarch64_rust-num-bigint-dig+prime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+prime-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+prime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+prime-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+prime-devel.sha256sum] = "59abbf4068ce829323888a28ad37d841e784dd54ecc768370980b2fe58665936"

URI_aarch64_rust-num-bigint-dig+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+rand-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+rand-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+rand-devel.sha256sum] = "007b7b0e74370efb8031a7ee55e12c1249e485859c111271176fc5b157b0cf3f"

URI_aarch64_rust-num-bigint-dig+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+serde-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+serde-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+serde-devel.sha256sum] = "62ac7d24a8e7c65c7be65e91fdaa39d849ad4be4a36da438cd05d6d392625baa"

URI_aarch64_rust-num-bigint-dig+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+std-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+std-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+std-devel.sha256sum] = "093bd76186f01691ce02eda6f8dc7df88ce8238d718b8f894464c69e39215c50"

URI_aarch64_rust-num-bigint-dig+u64_digit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+u64_digit-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+u64_digit-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+u64_digit-devel.sha256sum] = "5f5c6d12399453ba872121f100fd50bfc2795f341a0039eca7cb499f267b26da"

URI_aarch64_rust-num-bigint-dig+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig+zeroize-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig+zeroize-devel}"
SRC_URI[aarch64_rust-num-bigint-dig+zeroize-devel.sha256sum] = "9712465983ec3364f8364a9b13c0fa8f45cae1f0619d8e5219847388c7bfd2d6"

URI_aarch64_rust-num-bigint-dig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-num-bigint-dig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig-devel}"
SRC_URI[aarch64_rust-num-bigint-dig-devel.sha256sum] = "ef1a35087edcf4a479e24085ca8ae75e69d739a522c2b226dab16a4fb2010378"

RDEPENDS:rust-num-bigint-dig+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+default-devel = " \
 cargo \
 rust-num-bigint-dig+std-devel \
 rust-num-bigint-dig+u64_digit-devel \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+fuzz-devel = " \
 cargo \
 rust-num-bigint-dig+arbitrary-devel \
 rust-num-bigint-dig-devel \
 rust-smallvec+arbitrary-devel \
 "
RDEPENDS:rust-num-bigint-dig+i128-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+prime-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig+rand-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig+serde-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-bigint-dig+std-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-smallvec+write-devel \
 "
RDEPENDS:rust-num-bigint-dig+u64_digit-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 "
RDEPENDS:rust-num-bigint-dig+zeroize-devel = " \
 cargo \
 rust-num-bigint-dig-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-num-bigint-dig-devel = " \
 bash \
 cargo \
 rust \
 rust-lazy_static+spin_no_std-devel \
 rust-lazy_static-devel \
 rust-libm+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-iter-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 rust-smallvec-devel \
 "
