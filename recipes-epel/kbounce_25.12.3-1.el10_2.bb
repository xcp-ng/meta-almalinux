# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbounce"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kbounce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbounce-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c6434da216f61b056dba24500be64b33790024b0fee82a245c9004cc3270d06"

URI_x86_64_v2_kbounce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbounce-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbounce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbounce}"
SRC_URI[x86_64_v2_kbounce.sha256sum] = "9c6074f9a97e2a0e99632f7e104b77c98e9fec87f9c8ea8596f16b1ef9d1b74f"

URI_aarch64_kbounce = "${EPEL_MIRROR}/aarch64/Packages/k/kbounce-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kbounce;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbounce}"
SRC_URI[aarch64_kbounce.sha256sum] = "b948947198ca83c652bc0a5a605f3e8604e5abfff82a3e16c70a645e81ee2ab3"

RDEPENDS:kbounce = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
