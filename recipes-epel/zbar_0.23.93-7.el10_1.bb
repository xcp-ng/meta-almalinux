# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zbar"
PV = "0.23.93"
PR = "7.el10_1"
PACKAGES = " \
 python3-zbar \
 zbar \
 zbar-devel \
 zbar-gtk \
 zbar-gtk-devel \
 zbar-java \
 zbar-libs \
 zbar-qt \
 zbar-qt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zbar-0.23.93-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a76514319cac8ee3c48861ea8fa800cae8570d030832b9bf5bb05149c803ba2"

URI_x86_64_v2_python3-zbar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zbar-0.23.93-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-zbar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zbar}"
SRC_URI[x86_64_v2_python3-zbar.sha256sum] = "99f7efb53ad5557295ec539d9711fcbfcd1fad712bdd9b6c54fe969df42f11b9"

URI_x86_64_v2_zbar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zbar-0.23.93-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zbar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zbar}"
SRC_URI[x86_64_v2_zbar.sha256sum] = "21dc6a75e543f1164e61876bb24c9144aebbdab23b9ac209f2539e37f0ab6764"

URI_x86_64_v2_zbar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zbar-devel-0.23.93-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zbar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zbar-devel}"
SRC_URI[x86_64_v2_zbar-devel.sha256sum] = "b4c001c1c45eb7a259573e7eddadec04a70121ff795db835d47ee6585eebc14f"

URI_x86_64_v2_zbar-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zbar-gtk-0.23.93-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zbar-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zbar-gtk}"
SRC_URI[x86_64_v2_zbar-gtk.sha256sum] = "c4bcf383d999c247edd9f4eac0627e590428187fac0a28ababa9f3df1936fdec"

URI_x86_64_v2_zbar-gtk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zbar-gtk-devel-0.23.93-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zbar-gtk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zbar-gtk-devel}"
SRC_URI[x86_64_v2_zbar-gtk-devel.sha256sum] = "b70134a8ffd134f57cf3de0b3408dedafb2d27397e14550d3108436f8a8b1950"

URI_x86_64_v2_zbar-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zbar-java-0.23.93-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zbar-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zbar-java}"
SRC_URI[x86_64_v2_zbar-java.sha256sum] = "d2b930e2bc6c1e8e30ac032e2d11f7f991a52c017e4ecb6261a17120bfe61003"

URI_x86_64_v2_zbar-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zbar-libs-0.23.93-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zbar-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zbar-libs}"
SRC_URI[x86_64_v2_zbar-libs.sha256sum] = "b8d7fba25b84d107b4aa2e788e6e56790d0ca3f49e5dbb10e2c83044367ca79a"

URI_x86_64_v2_zbar-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zbar-qt-0.23.93-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zbar-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zbar-qt}"
SRC_URI[x86_64_v2_zbar-qt.sha256sum] = "6fd973040b98d2b57890f3b8ee985ebe134c945474b8da9a0c0284f0c73c62ab"

URI_x86_64_v2_zbar-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zbar-qt-devel-0.23.93-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zbar-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zbar-qt-devel}"
SRC_URI[x86_64_v2_zbar-qt-devel.sha256sum] = "6f5ab2cf42b1ec942e0687053010614e1a1f3afd04328093ce0425931600aad5"

URI_aarch64_python3-zbar = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zbar-0.23.93-7.el10_1.aarch64.rpm;name=aarch64_python3-zbar;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zbar}"
SRC_URI[aarch64_python3-zbar.sha256sum] = "c347334c1cafb94220f8a8cc7a3090f1e33785c2d9e8dae7717033c718b0a963"

URI_aarch64_zbar = "${EPEL_MIRROR}/aarch64/Packages/z/zbar-0.23.93-7.el10_1.aarch64.rpm;name=aarch64_zbar;unpack=0"
SRC_URI:append = " ${URI_aarch64_zbar}"
SRC_URI[aarch64_zbar.sha256sum] = "68db6c77c73918048d6f7b5c8f19f4b86b15b1685a63b58ad9c520afd32694b6"

URI_aarch64_zbar-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zbar-devel-0.23.93-7.el10_1.aarch64.rpm;name=aarch64_zbar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zbar-devel}"
SRC_URI[aarch64_zbar-devel.sha256sum] = "f38a8aa6e1ddf09377a3acfed387833ad08c97879b370c865cd8f21305c4cb9a"

URI_aarch64_zbar-gtk = "${EPEL_MIRROR}/aarch64/Packages/z/zbar-gtk-0.23.93-7.el10_1.aarch64.rpm;name=aarch64_zbar-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_zbar-gtk}"
SRC_URI[aarch64_zbar-gtk.sha256sum] = "6572db7631727afef7828acd68573a0ffea7129d47ceab05a3adf4ab77c33bad"

URI_aarch64_zbar-gtk-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zbar-gtk-devel-0.23.93-7.el10_1.aarch64.rpm;name=aarch64_zbar-gtk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zbar-gtk-devel}"
SRC_URI[aarch64_zbar-gtk-devel.sha256sum] = "2956d375c269088f5d2ad7168d68279ae6077bfefa0ec4e1550ccd83e023076d"

URI_aarch64_zbar-java = "${EPEL_MIRROR}/aarch64/Packages/z/zbar-java-0.23.93-7.el10_1.aarch64.rpm;name=aarch64_zbar-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_zbar-java}"
SRC_URI[aarch64_zbar-java.sha256sum] = "740302e14106a47776170145341333a84daf096715697de0614822a01e8663d7"

URI_aarch64_zbar-libs = "${EPEL_MIRROR}/aarch64/Packages/z/zbar-libs-0.23.93-7.el10_1.aarch64.rpm;name=aarch64_zbar-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_zbar-libs}"
SRC_URI[aarch64_zbar-libs.sha256sum] = "580c9a3f841c8f1736e0ff4a34ba128ff10c0f83095a95e7fc1f1d88c8a26029"

URI_aarch64_zbar-qt = "${EPEL_MIRROR}/aarch64/Packages/z/zbar-qt-0.23.93-7.el10_1.aarch64.rpm;name=aarch64_zbar-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_zbar-qt}"
SRC_URI[aarch64_zbar-qt.sha256sum] = "8fd33fab3b04f8ccc4bb18eb19cf0df6d9de5e04e56d1cee646980b3a3a3a60d"

URI_aarch64_zbar-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zbar-qt-devel-0.23.93-7.el10_1.aarch64.rpm;name=aarch64_zbar-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zbar-qt-devel}"
SRC_URI[aarch64_zbar-qt-devel.sha256sum] = "829745f4b81b279335af0c7e19c2a8be5ab09624738722156687108ee1e3ef78"

RDEPENDS:python3-zbar = " \
 dbus-libs \
 glibc \
 libICE \
 libSM \
 libX11 \
 libjpeg-turbo \
 libv4l \
 python3 \
 python3-pillow \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 zbar-libs \
 "
RDEPENDS:zbar = " \
 GraphicsMagick \
 glibc \
 zbar-libs \
 "
RDEPENDS:zbar-devel = " \
 pkgconf-pkg-config \
 zbar-libs \
 "
RDEPENDS:zbar-gtk = " \
 atk \
 cairo \
 cairo-gobject \
 dbus-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libjpeg-turbo \
 libv4l \
 pango \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 zbar-libs \
 "
RDEPENDS:zbar-gtk-devel = " \
 glib2-devel \
 gtk3-devel \
 pkgconf-pkg-config \
 zbar-devel \
 zbar-gtk \
 "
RDEPENDS:zbar-java = " \
 dbus-libs \
 glibc \
 libICE \
 libSM \
 libX11 \
 libjpeg-turbo \
 libv4l \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 zbar-devel \
 zbar-gtk \
 zbar-libs \
 "
RDEPENDS:zbar-libs = " \
 dbus-libs \
 glibc \
 libICE \
 libSM \
 libX11 \
 libjpeg-turbo \
 libv4l \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 "
RDEPENDS:zbar-qt = " \
 dbus-libs \
 glibc \
 libICE \
 libSM \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libv4l \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtx11extras \
 zbar-libs \
 "
RDEPENDS:zbar-qt-devel = " \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 zbar-devel \
 zbar-qt \
 "
