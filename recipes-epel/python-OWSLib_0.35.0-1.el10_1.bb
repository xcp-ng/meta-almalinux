# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-OWSLib"
PV = "0.35.0"
PR = "1.el10_1"
PACKAGES = " \
 python-OWSLib-doc \
 python3-OWSLib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-OWSLib-0.35.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18772224cfb98cc022901e70c993f2ed360e11856082ac8bfec8ce53284df98c"

URI_x86_64_v2_python-OWSLib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-OWSLib-doc-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-OWSLib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-OWSLib-doc}"
SRC_URI[x86_64_v2_python-OWSLib-doc.sha256sum] = "ca8795a5af073976087ca9a2acefba2e4a4371452bef207a06c2b4a2d4c8c2d3"

URI_x86_64_v2_python3-OWSLib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-OWSLib-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-OWSLib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-OWSLib}"
SRC_URI[x86_64_v2_python3-OWSLib.sha256sum] = "c8c53e536991f2570f02ac3f6c6b9d39463712f13b042a074e65ef7636169955"

URI_aarch64_python-OWSLib-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-OWSLib-doc-0.35.0-1.el10_1.noarch.rpm;name=aarch64_python-OWSLib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-OWSLib-doc}"
SRC_URI[aarch64_python-OWSLib-doc.sha256sum] = "cde5fd1f9fc2f5f8059059c7ca62e2641a68fe7533572a4fbaab87bfd6860b09"

URI_aarch64_python3-OWSLib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-OWSLib-0.35.0-1.el10_1.noarch.rpm;name=aarch64_python3-OWSLib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-OWSLib}"
SRC_URI[aarch64_python3-OWSLib.sha256sum] = "75ca017e0fc26e203a81275f9f32975e683642fa96415fc72ecc60e00f23042b"

RDEPENDS:python-OWSLib-doc = " \
 "
RDEPENDS:python3-OWSLib = " \
 python3 \
 python3-dateutil \
 python3-lxml \
 python3-pyyaml \
 python3-requests \
 "
