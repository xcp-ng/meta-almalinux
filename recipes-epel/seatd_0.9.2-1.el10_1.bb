# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "seatd"
PV = "0.9.2"
PR = "1.el10_1"
PACKAGES = " \
 libseat \
 libseat-devel \
 seatd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/seatd-0.9.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67c2a270feffa5b11dd61afbb05e9e8d947d5a8bc2de8c57b9c12ddc162ed900"

URI_x86_64_v2_libseat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libseat-0.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libseat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseat}"
SRC_URI[x86_64_v2_libseat.sha256sum] = "4d19ca964d7372d11478459dd3dbe781c9e9f9511fd1305fb694f74af69c2e46"

URI_x86_64_v2_libseat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libseat-devel-0.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libseat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseat-devel}"
SRC_URI[x86_64_v2_libseat-devel.sha256sum] = "d1b0cd9e478635d97a55025434b12b5b4d058c11a0adf0c4b907ea341eba3c91"

URI_x86_64_v2_seatd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/seatd-0.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_seatd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seatd}"
SRC_URI[x86_64_v2_seatd.sha256sum] = "032523c572ee809e8b76f5ed7012e3b6c4855d872250491dd6ade3e664de0375"

URI_aarch64_libseat = "${EPEL_MIRROR}/aarch64/Packages/l/libseat-0.9.2-1.el10_1.aarch64.rpm;name=aarch64_libseat;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseat}"
SRC_URI[aarch64_libseat.sha256sum] = "fdc259b61f763016a5b7cf39d74c5737364c0566681326228c38788a7cc9f4ff"

URI_aarch64_libseat-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libseat-devel-0.9.2-1.el10_1.aarch64.rpm;name=aarch64_libseat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseat-devel}"
SRC_URI[aarch64_libseat-devel.sha256sum] = "d39b89b735273835f1e1aa9ad1ea4e631462a1632aeaf0fd1dab55d2e3798e89"

URI_aarch64_seatd = "${EPEL_MIRROR}/aarch64/Packages/s/seatd-0.9.2-1.el10_1.aarch64.rpm;name=aarch64_seatd;unpack=0"
SRC_URI:append = " ${URI_aarch64_seatd}"
SRC_URI[aarch64_seatd.sha256sum] = "ac465f9a422c045024d6fbc519b9d5430d8ef5ebdaed0421d28ad7d02f50e7a8"

RDEPENDS:libseat = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:libseat-devel = " \
 libseat \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:seatd = " \
 bash \
 glibc \
 "
