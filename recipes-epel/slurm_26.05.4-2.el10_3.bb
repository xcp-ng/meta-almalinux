# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "slurm"
PV = "26.05.4"
PR = "2.el10_3"
PACKAGES = " \
 slurm \
 slurm-contribs \
 slurm-devel \
 slurm-doc \
 slurm-gui \
 slurm-libs \
 slurm-nss_slurm \
 slurm-openlava \
 slurm-pam_slurm \
 slurm-perlapi \
 slurm-sackd \
 slurm-slurmctld \
 slurm-slurmd \
 slurm-slurmdbd \
 slurm-slurmrestd \
 slurm-torque \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/slurm-26.05.4-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d02cca045852675d381eefac7317c143e973a224bf9124135ad2fb8c387666d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm;unpack=0"
SRC_URI[x86_64_v2_slurm.sha256sum] = "a5bc144f4ae5db29f7e5d38974e78bc8195ac3993a8dcebe27b9de377a0adbf9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-contribs-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-contribs;unpack=0"
SRC_URI[x86_64_v2_slurm-contribs.sha256sum] = "01fbc7c664061abb04191a3d40c3475efdf8bc4d574c77cc7d5ef5145b7fc45d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-devel-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-devel;unpack=0"
SRC_URI[x86_64_v2_slurm-devel.sha256sum] = "b6152bb7f69f63d61f3b3c2277901bc84d79e820c66c4ebaff62478b7679b616"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-doc-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-doc;unpack=0"
SRC_URI[x86_64_v2_slurm-doc.sha256sum] = "0e955332e5e1c16939ca6a0fbd6b949a559ab63be4fc43f31e4c926ab786cd85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-gui-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-gui;unpack=0"
SRC_URI[x86_64_v2_slurm-gui.sha256sum] = "383b0f2c6322936f2e1de973808a20c6d52ba7ed219e538ca3bb1e19dcde2c58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-libs-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-libs;unpack=0"
SRC_URI[x86_64_v2_slurm-libs.sha256sum] = "3849fa7286195228c67e128255a66e7931ae95d9781647b5462171b15b53da15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-nss_slurm-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-nss_slurm;unpack=0"
SRC_URI[x86_64_v2_slurm-nss_slurm.sha256sum] = "c48e6e87d0f52ec8f6ab4c4ce74676569d6263d7822114ea0de58ab8b45b12ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-openlava-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-openlava;unpack=0"
SRC_URI[x86_64_v2_slurm-openlava.sha256sum] = "28aa763d914e4eeeb0f4c81df2495ef08b725c4e8b3c0baa4ff6317606329e21"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-pam_slurm-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-pam_slurm;unpack=0"
SRC_URI[x86_64_v2_slurm-pam_slurm.sha256sum] = "9fb116e3f5ea5434696bb8a6b26fcca3fe627855910e8cf4009bdf0cf1a55812"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-perlapi-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-perlapi;unpack=0"
SRC_URI[x86_64_v2_slurm-perlapi.sha256sum] = "441bacb1d52dab47d6c1c46a0cdb342a3ebd7f3e7a13ed37d842ceff35a6c5c7"
RPROVIDES:slurm-perlapi:append:x86_64_v2 = " virtual/perl_Slurm_"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-sackd-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-sackd;unpack=0"
SRC_URI[x86_64_v2_slurm-sackd.sha256sum] = "a763feedb0c630037f42968426ae471412cba83917a1403b018bc0d22156aa78"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-slurmctld-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-slurmctld;unpack=0"
SRC_URI[x86_64_v2_slurm-slurmctld.sha256sum] = "859f7f4bbd8e9eb01c59dffd9c73c948607ebaeac188f4830277dd62f6bbd74e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-slurmd-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-slurmd;unpack=0"
SRC_URI[x86_64_v2_slurm-slurmd.sha256sum] = "077b214e957d8a2a252aa07e2288682c61e780d269ee47aec420b6a0b47d2a80"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-slurmdbd-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-slurmdbd;unpack=0"
SRC_URI[x86_64_v2_slurm-slurmdbd.sha256sum] = "31a73839aed3ddc15701b38c938ae3b2af89e94bf4221a340ffaa6126bb42336"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-slurmrestd-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-slurmrestd;unpack=0"
SRC_URI[x86_64_v2_slurm-slurmrestd.sha256sum] = "09b1bc7c20747b8e17242a805fb1c4a756492a1e918ea1a99cb9ccef74426d3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/slurm-torque-26.05.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_slurm-torque;unpack=0"
SRC_URI[x86_64_v2_slurm-torque.sha256sum] = "3b931241cce4d297a5cefbb8b35b57dee98ece19988da73f90b0ceca6db184c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm;unpack=0"
SRC_URI[aarch64_slurm.sha256sum] = "e9ab0ff7614bec8751cb0a5ced72ce017de6e830496e8e3177ec60b94d48ba94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-contribs-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-contribs;unpack=0"
SRC_URI[aarch64_slurm-contribs.sha256sum] = "99de4de55593d82e1b10895f81753f64cdab9edaff847e204f1b086b05f2022a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-devel-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-devel;unpack=0"
SRC_URI[aarch64_slurm-devel.sha256sum] = "5dd3f30a2d320ab8b3a468005232896184029694109576b74ddc069f951c5d0b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-doc-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-doc;unpack=0"
SRC_URI[aarch64_slurm-doc.sha256sum] = "923b95754cc2c8fec9f5c502f6ca80fd3d5a0469ec5a2d70099210c72aecb106"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-gui-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-gui;unpack=0"
SRC_URI[aarch64_slurm-gui.sha256sum] = "7b5de9d135915aa9b8c371d8a5d8e8c28008456e4578de216d27101e964eeed9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-libs-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-libs;unpack=0"
SRC_URI[aarch64_slurm-libs.sha256sum] = "d2dfcafc7d39db09ebfffc41f473d0a74b685c84ec5dd5f96065617df684296d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-nss_slurm-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-nss_slurm;unpack=0"
SRC_URI[aarch64_slurm-nss_slurm.sha256sum] = "00f506eeab138ac3c2185156728156e367f11dd217dffca29478088c923b9f69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-openlava-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-openlava;unpack=0"
SRC_URI[aarch64_slurm-openlava.sha256sum] = "a589c09b50cc040682ad002b6498d00a580da5bf2dbd2a29c0aa3e4d3238085f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-pam_slurm-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-pam_slurm;unpack=0"
SRC_URI[aarch64_slurm-pam_slurm.sha256sum] = "6e2c23c4076aa0886b8bfd823f1b2df2a383ff94b31b1bdaad3f8745a93d00d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-perlapi-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-perlapi;unpack=0"
SRC_URI[aarch64_slurm-perlapi.sha256sum] = "747b37e0a6fad7467277c5f44cdeca0de8d9b9d356fe5442cd910312ae716a7e"
RPROVIDES:slurm-perlapi:append:aarch64 = " virtual/perl_Slurm_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-sackd-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-sackd;unpack=0"
SRC_URI[aarch64_slurm-sackd.sha256sum] = "07a6c55251f327191ae79b30dd33b04acb97b740c3cbea08da9ea6821a84cf94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-slurmctld-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-slurmctld;unpack=0"
SRC_URI[aarch64_slurm-slurmctld.sha256sum] = "d3f20ae4cc34f076f852172d680420de0d5768a953e9e7e4b7f30a8b668b4d43"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-slurmd-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-slurmd;unpack=0"
SRC_URI[aarch64_slurm-slurmd.sha256sum] = "ac545443507b44d1e9fb3982cfbeee9f2721e6f359f297a88d0ebc175507a6c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-slurmdbd-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-slurmdbd;unpack=0"
SRC_URI[aarch64_slurm-slurmdbd.sha256sum] = "a08521844f9f60ccd90957da7ed1b931757c9587103ebe7d7713d1ab3a5dc408"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-slurmrestd-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-slurmrestd;unpack=0"
SRC_URI[aarch64_slurm-slurmrestd.sha256sum] = "dc7cf64a24a0d31c19ac204d322c0f1f530fc02d62d3ea43386f67869c8f6c32"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/slurm-torque-26.05.4-2.el10_3.aarch64.rpm;name=aarch64_slurm-torque;unpack=0"
SRC_URI[aarch64_slurm-torque.sha256sum] = "a7af6825087f5ea39a9e617ac086714ddcdfcde6124440bf4115a3d2db882ccc"

RDEPENDS:slurm = " \
 bash \
 dbus-libs \
 freeipmi \
 glibc \
 hdf5 \
 hwloc-libs \
 infiniband-diags \
 json-c \
 libaec \
 libibumad \
 libjwt \
 librdkafka \
 libyaml \
 llhttp \
 lua-libs \
 lz4-libs \
 mariadb-connector-c \
 munge \
 munge-libs \
 numactl-libs \
 pmix \
 readline \
 s-nail \
 slurm-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:slurm-contribs = " \
 bash \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-autouse \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-podlators \
 slurm-perlapi \
 virtual/perl_Slurm_ \
 "
RDEPENDS:slurm-devel = " \
 slurm-libs \
 "
RDEPENDS:slurm-doc = " \
 "
RDEPENDS:slurm-gui = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-libs = " \
 glibc \
 "
RDEPENDS:slurm-nss_slurm = " \
 glibc \
 slurm-libs \
 "
RDEPENDS:slurm-openlava = " \
 perl-FindBin \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Switch \
 perl-autouse \
 perl-interpreter \
 perl-lib \
 perl-libs \
 slurm-perlapi \
 virtual/perl_Slurm_ \
 "
RDEPENDS:slurm-pam_slurm = " \
 glibc \
 slurm-libs \
 "
RDEPENDS:slurm-perlapi = " \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 slurm-libs \
 "
RDEPENDS:slurm-sackd = " \
 glibc \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-slurmctld = " \
 bash \
 glibc \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-slurmd = " \
 bash \
 glibc \
 hwloc-libs \
 pam-libs \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-slurmdbd = " \
 bash \
 glibc \
 mariadb-connector-c \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-slurmrestd = " \
 glibc \
 slurm \
 slurm-libs \
 "
RDEPENDS:slurm-torque = " \
 glibc \
 perl-English \
 perl-File-Basename \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-POSIX \
 perl-autouse \
 perl-interpreter \
 perl-lib \
 perl-libs \
 slurm \
 slurm-perlapi \
 virtual/perl_Slurm_ \
 "
