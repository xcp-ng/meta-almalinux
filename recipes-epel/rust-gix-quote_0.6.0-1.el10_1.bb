# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-quote"
PV = "0.6.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-quote+default-devel \
 rust-gix-quote-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-quote-0.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "698ec4b6697d2ca51bc7d590655be4960b8d4979fb68b7db7c62b7e6a535524e"

URI_x86_64_v2_rust-gix-quote+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-quote+default-devel-0.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-quote+default-devel}"
SRC_URI[x86_64_v2_rust-gix-quote+default-devel.sha256sum] = "c803d8a19c301d8d8e7cf7da2002da1c5374f548766b6fc607ef7a998d9a15f5"

URI_x86_64_v2_rust-gix-quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-quote-devel-0.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-quote-devel}"
SRC_URI[x86_64_v2_rust-gix-quote-devel.sha256sum] = "29af2507754013893c919d0757c193d911c8ce5a417478dc09134a330a424b1b"

URI_aarch64_rust-gix-quote+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-quote+default-devel-0.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-quote+default-devel}"
SRC_URI[aarch64_rust-gix-quote+default-devel.sha256sum] = "942815438ebb5d41d3c10b8a4ae25d2858e4314e566a8dc5557168cb2c83773f"

URI_aarch64_rust-gix-quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-quote-devel-0.6.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-quote-devel}"
SRC_URI[aarch64_rust-gix-quote-devel.sha256sum] = "f393dd0283f0e0a75a5db06e9df8bad72f2a471ee4cee83d9e596e694c6608c6"

RDEPENDS:rust-gix-quote+default-devel = " \
 cargo \
 rust-gix-quote-devel \
 "
RDEPENDS:rust-gix-quote-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-utils+default-devel \
 rust-thiserror+default-devel \
 "
