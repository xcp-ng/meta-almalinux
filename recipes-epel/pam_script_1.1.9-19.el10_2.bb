# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_script"
PV = "1.1.9"
PR = "19.el10_2"
PACKAGES = " \
 pam_script \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_script-1.1.9-19.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e1571233aa0277cc062da0632e5e9a4b493b3db04e5b5802406faacb575f11f"

URI_x86_64_v2_pam_script = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_script-1.1.9-19.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_script;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_script}"
SRC_URI[x86_64_v2_pam_script.sha256sum] = "0064001250932b25ee318a082e70b95b40cea6304e028da0fb36e45b202725a3"

URI_aarch64_pam_script = "${EPEL_MIRROR}/aarch64/Packages/p/pam_script-1.1.9-19.el10_2.aarch64.rpm;name=aarch64_pam_script;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_script}"
SRC_URI[aarch64_pam_script.sha256sum] = "4d3b63c49b3d7f44b6581534b316b6174099742a33bf36c073c3468fbafa1d06"

RDEPENDS:pam_script = " \
 bash \
 glibc \
 pam-libs \
 "
