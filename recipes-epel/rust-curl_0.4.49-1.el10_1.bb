# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curl"
PV = "0.4.49"
PR = "1.el10_1"
PACKAGES = " \
 rust-curl+default-devel \
 rust-curl+http2-devel \
 rust-curl+ntlm-devel \
 rust-curl+openssl-probe-devel \
 rust-curl+openssl-sys-devel \
 rust-curl+poll_7_68_0-devel \
 rust-curl+protocol-ftp-devel \
 rust-curl+spnego-devel \
 rust-curl+ssl-devel \
 rust-curl+upkeep_7_62_0-devel \
 rust-curl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-curl-0.4.49-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc264f87076f577a427344038db7e40e96eff27ee38609a90b16309b9f9f40e3"

URI_x86_64_v2_rust-curl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+default-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+default-devel}"
SRC_URI[x86_64_v2_rust-curl+default-devel.sha256sum] = "e5517c2e3d49435fbaf3d3b62ea635d28de27ee8c7ba2f225caee7bf566cd00a"

URI_x86_64_v2_rust-curl+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+http2-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+http2-devel}"
SRC_URI[x86_64_v2_rust-curl+http2-devel.sha256sum] = "66707617e021ee430060fa2287d0d25f2cc7266985f63709ffee00360da847f2"

URI_x86_64_v2_rust-curl+ntlm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+ntlm-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+ntlm-devel}"
SRC_URI[x86_64_v2_rust-curl+ntlm-devel.sha256sum] = "ddfe20e8804f3f639ebf22b7adb3fa8a5f6eea706b436f60775b31b8836ff729"

URI_x86_64_v2_rust-curl+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+openssl-probe-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-curl+openssl-probe-devel.sha256sum] = "0fa987282b8b7f2af980bd649e25478e1e6c6e7ffe628fec35822eb6ccffa896"

URI_x86_64_v2_rust-curl+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+openssl-sys-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl+openssl-sys-devel.sha256sum] = "d950f6868869ca411a46792f2800235cd906bc453560929a11e47714ffc5b79e"

URI_x86_64_v2_rust-curl+poll_7_68_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+poll_7_68_0-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+poll_7_68_0-devel}"
SRC_URI[x86_64_v2_rust-curl+poll_7_68_0-devel.sha256sum] = "f66f242abe2476dd5021925ff0dfeb50c5253343b3c17b3d3d38c68790021c93"

URI_x86_64_v2_rust-curl+protocol-ftp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+protocol-ftp-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+protocol-ftp-devel}"
SRC_URI[x86_64_v2_rust-curl+protocol-ftp-devel.sha256sum] = "93ffee209b981553fd4eef9b1a944651c7c7bfd93fce4a8f6823b8393cdd75af"

URI_x86_64_v2_rust-curl+spnego-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+spnego-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+spnego-devel}"
SRC_URI[x86_64_v2_rust-curl+spnego-devel.sha256sum] = "5867cda49f85d1d5b91c195b2a2b99fb09d7e32fca742f17a6c434435ade9c43"

URI_x86_64_v2_rust-curl+ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+ssl-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+ssl-devel}"
SRC_URI[x86_64_v2_rust-curl+ssl-devel.sha256sum] = "0d7067949f0fbc8b67ed9bb6b50e94f6f727b5691f411c416f9ff20bb7ec8308"

URI_x86_64_v2_rust-curl+upkeep_7_62_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl+upkeep_7_62_0-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl+upkeep_7_62_0-devel}"
SRC_URI[x86_64_v2_rust-curl+upkeep_7_62_0-devel.sha256sum] = "1d30272a9769036af5bb2946538001a2e82387f3bcb84fb2dd359a9ed0ec715d"

URI_x86_64_v2_rust-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-devel-0.4.49-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-devel}"
SRC_URI[x86_64_v2_rust-curl-devel.sha256sum] = "47b932c6d06bfd8bbd2ceac7cf502e6d7314606002a4d89f22af2b8c6a4a55e4"

URI_aarch64_rust-curl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+default-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+default-devel}"
SRC_URI[aarch64_rust-curl+default-devel.sha256sum] = "e01e428e0dee1f74f69ab34cd0f8315072af5936b6b9a1cb22cb8cf09e8097dd"

URI_aarch64_rust-curl+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+http2-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+http2-devel}"
SRC_URI[aarch64_rust-curl+http2-devel.sha256sum] = "76db2a430b70b3bf4bb8dc6c28aeb3d1c4265bdf77171491078650593edf1c04"

URI_aarch64_rust-curl+ntlm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+ntlm-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+ntlm-devel}"
SRC_URI[aarch64_rust-curl+ntlm-devel.sha256sum] = "f4a8ef98e6e35cde7fa9492748b21f508277df0a19ab701650bb73fa1063bd68"

URI_aarch64_rust-curl+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+openssl-probe-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+openssl-probe-devel}"
SRC_URI[aarch64_rust-curl+openssl-probe-devel.sha256sum] = "78c79f7b4b1a4f21a59c27cb201dc316087486c9b62e0b390a23bb76df9aa455"

URI_aarch64_rust-curl+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+openssl-sys-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+openssl-sys-devel}"
SRC_URI[aarch64_rust-curl+openssl-sys-devel.sha256sum] = "b711e8a431490b3788e5d89f1972875e03006d64c94b6bc7e010f334c0b282ba"

URI_aarch64_rust-curl+poll_7_68_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+poll_7_68_0-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+poll_7_68_0-devel}"
SRC_URI[aarch64_rust-curl+poll_7_68_0-devel.sha256sum] = "08698702c39b920cb4e75b63b390a48c712228dd7b464feef25d4ca75c555b8c"

URI_aarch64_rust-curl+protocol-ftp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+protocol-ftp-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+protocol-ftp-devel}"
SRC_URI[aarch64_rust-curl+protocol-ftp-devel.sha256sum] = "1900e64a33eba397af8d2798cf7bf277b833dff2278b7cb4ce32f423f70f6abc"

URI_aarch64_rust-curl+spnego-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+spnego-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+spnego-devel}"
SRC_URI[aarch64_rust-curl+spnego-devel.sha256sum] = "43bc3693ae1f833d0732667f10dc8c3399781820fd1d78fa2486d8c59c352848"

URI_aarch64_rust-curl+ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+ssl-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+ssl-devel}"
SRC_URI[aarch64_rust-curl+ssl-devel.sha256sum] = "c72576632ac7961233e3c3ad74a66195f3055b78f1dafefb1beebb0cb30dd006"

URI_aarch64_rust-curl+upkeep_7_62_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl+upkeep_7_62_0-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl+upkeep_7_62_0-devel}"
SRC_URI[aarch64_rust-curl+upkeep_7_62_0-devel.sha256sum] = "2c9be487bd52da0f29034d28512c2c8055d9662f5888e4a33bacbff6a9be765a"

URI_aarch64_rust-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-devel-0.4.49-1.el10_1.noarch.rpm;name=aarch64_rust-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-devel}"
SRC_URI[aarch64_rust-curl-devel.sha256sum] = "4e078a24ee433cafd6e804e57e385131dbdc94469f45b27e1a31df7862fd42a2"

RDEPENDS:rust-curl+default-devel = " \
 cargo \
 rust-curl+ssl-devel \
 rust-curl-devel \
 "
RDEPENDS:rust-curl+http2-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+http2-devel \
 "
RDEPENDS:rust-curl+ntlm-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+ntlm-devel \
 "
RDEPENDS:rust-curl+openssl-probe-devel = " \
 cargo \
 rust-curl-devel \
 rust-openssl-probe+default-devel \
 "
RDEPENDS:rust-curl+openssl-sys-devel = " \
 cargo \
 rust-curl-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-curl+poll_7_68_0-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+poll_7_68_0-devel \
 "
RDEPENDS:rust-curl+protocol-ftp-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+protocol-ftp-devel \
 "
RDEPENDS:rust-curl+spnego-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+spnego-devel \
 "
RDEPENDS:rust-curl+ssl-devel = " \
 cargo \
 rust-curl+openssl-probe-devel \
 rust-curl+openssl-sys-devel \
 rust-curl-devel \
 rust-curl-sys+ssl-devel \
 "
RDEPENDS:rust-curl+upkeep_7_62_0-devel = " \
 cargo \
 rust-curl-devel \
 rust-curl-sys+upkeep_7_62_0-devel \
 "
RDEPENDS:rust-curl-devel = " \
 cargo \
 rust-curl-sys-devel \
 rust-libc+default-devel \
 rust-socket2+default-devel \
 "
