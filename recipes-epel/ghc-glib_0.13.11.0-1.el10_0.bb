# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-glib"
PV = "0.13.11.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-glib \
 ghc-glib-devel \
 ghc-glib-doc \
 ghc-glib-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-glib-0.13.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd6ac2fa395e1e4df1cef5795cba717be85eb44b5e82bbdff213770253aef56f"

URI_x86_64_v2_ghc-glib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-glib-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-glib}"
SRC_URI[x86_64_v2_ghc-glib.sha256sum] = "7e0c5f96da8be08e33f1e7283124c3210942a1fa15a0583f917978a9ee5743dd"

URI_x86_64_v2_ghc-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-glib-devel-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-glib-devel}"
SRC_URI[x86_64_v2_ghc-glib-devel.sha256sum] = "0a76e771cff2148d981387f794ab215bbcb1c4e1e534319da3f3706db0145a71"

URI_x86_64_v2_ghc-glib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-glib-doc-0.13.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-glib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-glib-doc}"
SRC_URI[x86_64_v2_ghc-glib-doc.sha256sum] = "f21684c8168edbc89231763d50dbc97aa31095d09ba73a92ce31e6c741e8f017"

URI_x86_64_v2_ghc-glib-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-glib-prof-0.13.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-glib-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-glib-prof}"
SRC_URI[x86_64_v2_ghc-glib-prof.sha256sum] = "748bc6d7baae18d046a1fd8c316f7f34e15641aa57113d79d98b3579aa004c5c"

URI_aarch64_ghc-glib = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-glib-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-glib}"
SRC_URI[aarch64_ghc-glib.sha256sum] = "5c50f297b73255d3ec5e2f7ef9e5af5eca91e5b11d25f6f77eba8b4418b8039e"

URI_aarch64_ghc-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-glib-devel-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-glib-devel}"
SRC_URI[aarch64_ghc-glib-devel.sha256sum] = "3681776d1184b565eef3db086770a50b6fabbe1069f0fa9548c14b10df32e58e"

URI_aarch64_ghc-glib-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-glib-doc-0.13.11.0-1.el10_0.noarch.rpm;name=aarch64_ghc-glib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-glib-doc}"
SRC_URI[aarch64_ghc-glib-doc.sha256sum] = "cdd26ed603c3d0b633f106f9d680e6e03a225247abd3de1509b5a0d630d62d97"

URI_aarch64_ghc-glib-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-glib-prof-0.13.11.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-glib-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-glib-prof}"
SRC_URI[aarch64_ghc-glib-prof.sha256sum] = "a2c3aef969a709172f7b106d1f94defe5eabdd6f1ef4650c7f0a7e16f2ad3dc2"

RDEPENDS:ghc-glib = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-utf8-string \
 glib2 \
 glibc \
 gmp \
 "
RDEPENDS:ghc-glib-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-glib \
 ghc-text-devel \
 ghc-utf8-string-devel \
 glib2-devel \
 "
RDEPENDS:ghc-glib-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-glib-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-glib-devel \
 ghc-text-prof \
 ghc-utf8-string-prof \
 "
