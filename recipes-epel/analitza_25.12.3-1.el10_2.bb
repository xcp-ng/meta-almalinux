# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "analitza"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 analitza \
 analitza-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/analitza-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62aa482c5958bc2c7c97cc25f51516a031f2ef5b21bf89846ff0507b16af7409"

URI_x86_64_v2_analitza = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_analitza}"
SRC_URI[x86_64_v2_analitza.sha256sum] = "7cff9473d4e1a4cd4795e4b1ff041134ca87e610c51fce2a7ee02062826c9013"

URI_x86_64_v2_analitza-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/analitza-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_analitza-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_analitza-devel}"
SRC_URI[x86_64_v2_analitza-devel.sha256sum] = "7285d6af9f2daa33fa05d9534764d5ddc66c32c2cb325fb01bf034e831bc70a2"

URI_aarch64_analitza = "${EPEL_MIRROR}/aarch64/Packages/a/analitza-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_analitza;unpack=0"
SRC_URI:append = " ${URI_aarch64_analitza}"
SRC_URI[aarch64_analitza.sha256sum] = "8d306501bab81b180cc655ba45748b1b692d6a45b9ede198a1c6d969391a7ed2"

URI_aarch64_analitza-devel = "${EPEL_MIRROR}/aarch64/Packages/a/analitza-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_analitza-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_analitza-devel}"
SRC_URI[aarch64_analitza-devel.sha256sum] = "3d6cafc095106d655ee023b5f7823b83f96e2e1df0bf463db596463a3a357bb9"

RDEPENDS:analitza = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:analitza-devel = " \
 analitza \
 cmake-filesystem \
 "
