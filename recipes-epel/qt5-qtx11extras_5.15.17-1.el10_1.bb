# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtx11extras"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtx11extras \
 qt5-qtx11extras-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtx11extras-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00f763aaff930fc430941dff84671b29220bb6be5ae376a53844af247046ef69"

URI_x86_64_v2_qt5-qtx11extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtx11extras-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtx11extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtx11extras}"
SRC_URI[x86_64_v2_qt5-qtx11extras.sha256sum] = "386c1de64cf1a265f8ce675da6ddbffba613050c5c4b195303e70ead53c0e1dc"

URI_x86_64_v2_qt5-qtx11extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtx11extras-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtx11extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtx11extras-devel}"
SRC_URI[x86_64_v2_qt5-qtx11extras-devel.sha256sum] = "f6b41d5ab3e74507c902e7ccccd32884d04f1ecdabac3cb0c34eaffd1436bb03"

URI_aarch64_qt5-qtx11extras = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtx11extras-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtx11extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtx11extras}"
SRC_URI[aarch64_qt5-qtx11extras.sha256sum] = "b122561372434d32eb0a0172ca299686f662b021f3960b06ed12ea6b24fe9a0b"

URI_aarch64_qt5-qtx11extras-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtx11extras-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtx11extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtx11extras-devel}"
SRC_URI[aarch64_qt5-qtx11extras-devel.sha256sum] = "bf105e275601e1460a0520bd717bcc5fa2eb163a9727093efbb9182e3c80fca1"

RDEPENDS:qt5-qtx11extras = " \
 glibc \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:qt5-qtx11extras-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtx11extras \
 "
