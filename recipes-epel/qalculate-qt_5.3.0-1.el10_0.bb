# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qalculate-qt"
PV = "5.3.0"
PR = "1.el10_0"
PACKAGES = " \
 qalculate-qt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qalculate-qt-5.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e1f0066b4328e4c2da29f70f83c66ec64d0d89afd8540c4b0452073f8bec2c5"

URI_x86_64_v2_qalculate-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qalculate-qt-5.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qalculate-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qalculate-qt}"
SRC_URI[x86_64_v2_qalculate-qt.sha256sum] = "59e1f50ddb8060194291f8d6598fa289d78f924c0ce796c173cdb6e8a1f46f11"

URI_aarch64_qalculate-qt = "${EPEL_MIRROR}/aarch64/Packages/q/qalculate-qt-5.3.0-1.el10_0.aarch64.rpm;name=aarch64_qalculate-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_qalculate-qt}"
SRC_URI[aarch64_qalculate-qt.sha256sum] = "e55631e8a367b9901e1fcc506603a021bbd0b4d6219681f3d54b4e7e91549649"

RDEPENDS:qalculate-qt = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libqalculate \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
