# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-path"
PV = "0.10.20"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-path+default-devel \
 rust-gix-path-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-path-0.10.20-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50fc36443a2738aacba334a342e5ceb4c0e0530535b8f940b02cd83ca6a306e1"

URI_x86_64_v2_rust-gix-path+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-path+default-devel-0.10.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-path+default-devel}"
SRC_URI[x86_64_v2_rust-gix-path+default-devel.sha256sum] = "117502ccb2c74381ccee90c8fc30b83b0b1b49c620a9cc02f3c94224fd89d9e1"

URI_x86_64_v2_rust-gix-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-path-devel-0.10.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-path-devel}"
SRC_URI[x86_64_v2_rust-gix-path-devel.sha256sum] = "412c51af9556bf63138c9910e4158b14e0941641d632f2bb174a07e03793b10b"

URI_aarch64_rust-gix-path+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-path+default-devel-0.10.20-1.el10_1.noarch.rpm;name=aarch64_rust-gix-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-path+default-devel}"
SRC_URI[aarch64_rust-gix-path+default-devel.sha256sum] = "a54899aa2c154e2e1736521cc5b88b2009cafcd9f18862295c840b262b311d7c"

URI_aarch64_rust-gix-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-path-devel-0.10.20-1.el10_1.noarch.rpm;name=aarch64_rust-gix-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-path-devel}"
SRC_URI[aarch64_rust-gix-path-devel.sha256sum] = "a0815b1ffa9da9dfc0a5e81a9449e6b8d07579bed2fd283136ad4f040de60f80"

RDEPENDS:rust-gix-path+default-devel = " \
 cargo \
 rust-gix-path-devel \
 "
RDEPENDS:rust-gix-path-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-trace+default-devel \
 rust-gix-validate+default-devel \
 rust-home+default-devel \
 rust-once_cell+default-devel \
 rust-thiserror+default-devel \
 "
