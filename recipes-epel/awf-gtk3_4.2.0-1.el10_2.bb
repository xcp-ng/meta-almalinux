# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awf-gtk3"
PV = "4.2.0"
PR = "1.el10_2"
PACKAGES = " \
 awf-gtk3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awf-gtk3-4.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2cd637c5ef7e114f65c4747bc0c94a42d3400536a3decd885ec5ddfe7c98ef1"

URI_x86_64_v2_awf-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awf-gtk3-4.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_awf-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awf-gtk3}"
SRC_URI[x86_64_v2_awf-gtk3.sha256sum] = "72786dd51d704f731ae51c015e45e0955ae808d96648e03d9a8e97eb1e38dc50"

URI_aarch64_awf-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/a/awf-gtk3-4.2.0-1.el10_2.aarch64.rpm;name=aarch64_awf-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_awf-gtk3}"
SRC_URI[aarch64_awf-gtk3.sha256sum] = "500d3cfe2068fe04b9df5ee7569b5af69fb08120037bc5af1cd2927a39e3865f"

RDEPENDS:awf-gtk3 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libnotify \
 pango \
 "
