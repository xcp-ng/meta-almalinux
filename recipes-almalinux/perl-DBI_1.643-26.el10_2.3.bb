# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBI"
PV = "1.643"
PR = "26.el10_2.3"
PACKAGES = " \
 perl-DBI \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-DBI-1.643-26.el10_2.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66788f416d323bc85464bf135ee50f44af05ca0286f7b39c4b167f88a0e57183"

URI_x86_64_v2_perl-DBI = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBI-1.643-26.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_perl-DBI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DBI}"
SRC_URI[x86_64_v2_perl-DBI.sha256sum] = "fa2bd9d95aa4d2ec9e7a4144d0b6945c34862f96f0c99ff53cbfc891c3f8c47a"

URI_aarch64_perl-DBI = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBI-1.643-26.el10_2.3.aarch64.rpm;name=aarch64_perl-DBI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DBI}"
SRC_URI[aarch64_perl-DBI.sha256sum] = "2d1ce3dcffe28252054022af52461c97c96a3aca23a30d17904a29abce015934"

RDEPENDS:perl-DBI = " \
 glibc \
 perl-Carp \
 perl-DBI \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Math-BigInt \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Symbol \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
