# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unsafe-libyaml"
PV = "0.2.11"
PR = "2.el10_0"
PACKAGES = " \
 rust-unsafe-libyaml+default-devel \
 rust-unsafe-libyaml-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-unsafe-libyaml-0.2.11-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9bd1e343613375c13dd3894c4568773d828aecd77f807d4157adc0141d21754d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unsafe-libyaml+default-devel-0.2.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unsafe-libyaml+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unsafe-libyaml+default-devel.sha256sum] = "96ff3f88b612a35fa254f0daa395406597a279ea496cb569f25d8e61dba2dde5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unsafe-libyaml-devel-0.2.11-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unsafe-libyaml-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unsafe-libyaml-devel.sha256sum] = "507da7207d554ec00713b6e8ea862d9d38171fcf2f5a54d15f339e463d2b6ccf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unsafe-libyaml+default-devel-0.2.11-2.el10_0.noarch.rpm;name=aarch64_rust-unsafe-libyaml+default-devel;unpack=0"
SRC_URI[aarch64_rust-unsafe-libyaml+default-devel.sha256sum] = "ddd2bb37f87211ceac3687b3c2383400790aa8ce02159d032f66c45fe1162e22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unsafe-libyaml-devel-0.2.11-2.el10_0.noarch.rpm;name=aarch64_rust-unsafe-libyaml-devel;unpack=0"
SRC_URI[aarch64_rust-unsafe-libyaml-devel.sha256sum] = "2132876d3404d4cb9538a8e1b52d240c5cdca0d7596fa694edde02c9837a7eee"

RDEPENDS:rust-unsafe-libyaml+default-devel = " \
 cargo \
 rust-unsafe-libyaml-devel \
 "
RDEPENDS:rust-unsafe-libyaml-devel = " \
 cargo \
 rust \
 "
