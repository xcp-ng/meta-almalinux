# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-persistent-template"
PV = "2.12.0.0"
PR = "13.el10_0"
PACKAGES = " \
 ghc-persistent-template-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-persistent-template-2.12.0.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "432260c6e2c7b8165c2e9eb29dcc02d973ccd171ebb65f1761bea88fe271239e"

URI_x86_64_v2_ghc-persistent-template-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-persistent-template-devel-2.12.0.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-persistent-template-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-persistent-template-devel}"
SRC_URI[x86_64_v2_ghc-persistent-template-devel.sha256sum] = "c262292ff8ee8ec51cfe113756d6f890c0c7786ddd258d4e1579a22c4babc339"

URI_aarch64_ghc-persistent-template-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-persistent-template-devel-2.12.0.0-13.el10_0.aarch64.rpm;name=aarch64_ghc-persistent-template-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-persistent-template-devel}"
SRC_URI[aarch64_ghc-persistent-template-devel.sha256sum] = "53a6b0cc7831c52622cd5189f288836e72c8dbb750e66222d341909da3264893"

RDEPENDS:ghc-persistent-template-devel = " \
 ghc-base-devel \
 ghc-compiler \
 "
