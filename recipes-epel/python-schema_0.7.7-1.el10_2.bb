# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-schema"
PV = "0.7.7"
PR = "1.el10_2"
PACKAGES = " \
 python3-schema \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-schema-0.7.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d4c6da25caeb3445d98b8eb71f8a917eaa8d4f1dfe44ff137b599c79a53c349"

URI_x86_64_v2_python3-schema = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-schema-0.7.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-schema;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-schema}"
SRC_URI[x86_64_v2_python3-schema.sha256sum] = "0b547436a199b0b686a2dc6d61124c8b7cbd9d70ddfca45f22b31d096f0fb0c2"

URI_aarch64_python3-schema = "${EPEL_MIRROR}/aarch64/Packages/p/python3-schema-0.7.7-1.el10_2.noarch.rpm;name=aarch64_python3-schema;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-schema}"
SRC_URI[aarch64_python3-schema.sha256sum] = "f4ced352ec78a486bcb61c34d0d1d89a8d7cb014a98afea57333299158d58137"

RDEPENDS:python3-schema = " \
 python3 \
 "
