# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-match_token"
PV = "0.35.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-match_token+default-devel \
 rust-match_token-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-match_token-0.35.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da1e167bfc4d82ab32610b189f6f524e9abfda538eb6f61a89d83a31b3915acc"

URI_x86_64_v2_rust-match_token+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-match_token+default-devel-0.35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-match_token+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-match_token+default-devel}"
SRC_URI[x86_64_v2_rust-match_token+default-devel.sha256sum] = "8ae94ee2577f16c2b3d5199a0806b4e2017c559644f83a22eac11f8ed6341257"

URI_x86_64_v2_rust-match_token-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-match_token-devel-0.35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-match_token-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-match_token-devel}"
SRC_URI[x86_64_v2_rust-match_token-devel.sha256sum] = "fa6157670bb3d81a2d57529e81d58befb4e4d909a90e2f02461e7dc75fc2497d"

URI_aarch64_rust-match_token+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-match_token+default-devel-0.35.0-1.el10_2.noarch.rpm;name=aarch64_rust-match_token+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-match_token+default-devel}"
SRC_URI[aarch64_rust-match_token+default-devel.sha256sum] = "1658a5346023259175b6ed9cc60a0b13e1ee49e0ffc2d4717a6d198ea8c45b48"

URI_aarch64_rust-match_token-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-match_token-devel-0.35.0-1.el10_2.noarch.rpm;name=aarch64_rust-match_token-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-match_token-devel}"
SRC_URI[aarch64_rust-match_token-devel.sha256sum] = "f8859c11b4fd3e18cd4c6c39955b4faa826860cf1cb51e50a511b358c60b3230"

RDEPENDS:rust-match_token+default-devel = " \
 cargo \
 rust-match_token-devel \
 "
RDEPENDS:rust-match_token-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
