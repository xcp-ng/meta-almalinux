# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jessevdk-flags"
PV = "1.4.0"
PR = "20.20200728gitc17162f.el10_0"
PACKAGES = " \
 golang-github-jessevdk-flags-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-jessevdk-flags-1.4.0-20.20200728gitc17162f.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a3684b5d3b61b900b5607c3e53b97f9240e5499078b9d95048c27d293c289ae4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jessevdk-flags-devel-1.4.0-20.20200728gitc17162f.el10_0.noarch.rpm;name=aarch64_golang-github-jessevdk-flags-devel;unpack=0"
SRC_URI[aarch64_golang-github-jessevdk-flags-devel.sha256sum] = "0f292d433d6ece14b93e5ccd7d74e24b0df366ac4401d5902ee623391d2884d1"

RDEPENDS:golang-github-jessevdk-flags-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
