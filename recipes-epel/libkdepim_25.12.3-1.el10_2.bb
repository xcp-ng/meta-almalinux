# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdepim"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkdepim \
 libkdepim-devel \
 libkdepim-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdepim-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb949145eec69a60e3a0bba76fd1804c83f20a89233060c2e134278ebefdc8c5"

URI_x86_64_v2_libkdepim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim}"
SRC_URI[x86_64_v2_libkdepim.sha256sum] = "54ae53ecb3dfd58f3d5e16232dda2fafb6e96a8e0bab4cea7772ab1b8f3f76f3"

URI_x86_64_v2_libkdepim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim-devel}"
SRC_URI[x86_64_v2_libkdepim-devel.sha256sum] = "3f8cb1f0e978c6a3ab71fd42096abfd9ca64c1de7e461087b98c65710ae02ca2"

URI_x86_64_v2_libkdepim-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libkdepim-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim-doc}"
SRC_URI[x86_64_v2_libkdepim-doc.sha256sum] = "e979fa8ca5293f554edfe3ce4e84c8eedb4bc4c103699c88268b0e734defcb77"

URI_aarch64_libkdepim = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkdepim;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim}"
SRC_URI[aarch64_libkdepim.sha256sum] = "d02399b5a11173025a2e3c754e51c079698971a64088ab0e7583cde420a0dd83"

URI_aarch64_libkdepim-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkdepim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim-devel}"
SRC_URI[aarch64_libkdepim-devel.sha256sum] = "b418b3525642ff92698e6117ea3a278db1b83234fbbe427783ff062ef45a7b28"

URI_aarch64_libkdepim-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_libkdepim-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim-doc}"
SRC_URI[aarch64_libkdepim-doc.sha256sum] = "6ba5386276ec5b54d76c780ac1453cc2fe3947a22574e9713fea33a6585d494e"

RDEPENDS:libkdepim = " \
 glibc \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-devel = " \
 cmake-filesystem \
 glibc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-doc = " \
 "
