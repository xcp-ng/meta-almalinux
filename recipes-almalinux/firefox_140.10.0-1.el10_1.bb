# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firefox"
PV = "140.10.0"
PR = "1.el10_1"
PACKAGES = " \
 firefox \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/firefox-140.10.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e4e90dacab833afb785628044ee6114f77a32efed5fa77f442e53e3e4a024c97"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firefox-140.10.0-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_firefox;unpack=0"
SRC_URI[x86_64_v2_firefox.sha256sum] = "302fc303876fd64395c5991d26e5bdbae159d36283e980038e18183674f541c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firefox-140.10.0-1.el10_1.aarch64.rpm;name=aarch64_firefox;unpack=0"
SRC_URI[aarch64_firefox.sha256sum] = "60e887ca9945db4610c66d2ceed328670969e7efe5a809579bfaa030c86a7185"

RDEPENDS:firefox = " \
 almalinux-indexhtml \
 alsa-lib \
 atk \
 bash \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 mozilla-filesystem \
 nspr \
 nss \
 nss-util \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
