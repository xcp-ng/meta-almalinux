# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnsl2"
PV = "2.0.1"
PR = "1.el10_0"
PACKAGES = " \
 libnsl2 \
 libnsl2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnsl2-2.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41168616d611ba0456cb0f16bd95fe90492fc9476b58d123f76ead6d202b1af2"

URI_x86_64_v2_libnsl2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnsl2-2.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnsl2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnsl2}"
SRC_URI[x86_64_v2_libnsl2.sha256sum] = "be12a3a6cf6bd105280b9f64368ff809fdbf8b4bf41780f426af4c44f033b99f"

URI_x86_64_v2_libnsl2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnsl2-devel-2.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnsl2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnsl2-devel}"
SRC_URI[x86_64_v2_libnsl2-devel.sha256sum] = "10c41f2aef972986bfda3cb31317d31ff01231682a61df9865c1c1e90e2c5769"

URI_aarch64_libnsl2 = "${EPEL_MIRROR}/aarch64/Packages/l/libnsl2-2.0.1-1.el10_0.aarch64.rpm;name=aarch64_libnsl2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnsl2}"
SRC_URI[aarch64_libnsl2.sha256sum] = "0e571bc8bb08686fb051add827936baccdc5cf1313ee0baa6bdec12f104b0097"

URI_aarch64_libnsl2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libnsl2-devel-2.0.1-1.el10_0.aarch64.rpm;name=aarch64_libnsl2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnsl2-devel}"
SRC_URI[aarch64_libnsl2-devel.sha256sum] = "fcebe39e50b9cef45eb67045db50d68e24a101d00e107e47553648769d9d54a6"

RDEPENDS:libnsl2 = " \
 glibc \
 libtirpc \
 "
RDEPENDS:libnsl2-devel = " \
 libnsl2 \
 libtirpc-devel \
 pkgconf-pkg-config \
 "
