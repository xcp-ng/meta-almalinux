# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-jpeg"
PV = "0.5.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-zune-jpeg+default-devel \
 rust-zune-jpeg+log-devel \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+portable_simd-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-zune-jpeg-0.5.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a9cde99458e513f11495ea0cf413f71e2bfd1f43484cbcf33a63e3bc6176875f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+default-devel-0.5.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zune-jpeg+default-devel.sha256sum] = "9fb599138105236676d8d483ac4a50cb70b3779e2e4858f9c78310136914186e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+log-devel-0.5.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zune-jpeg+log-devel.sha256sum] = "cfe1a5615126c9b752926496ad972c756784a4a43c484484c6c3d073fecd4bfe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+neon-devel-0.5.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zune-jpeg+neon-devel.sha256sum] = "e21cc493f38aecd0179ff0f3aa40b696439904fd9ac70435613f1c9d84ec935a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+portable_simd-devel-0.5.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+portable_simd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zune-jpeg+portable_simd-devel.sha256sum] = "5ea7d19624e6ba42285c4f1afaed98320f6cf2ebb7c3a81c8510e8fbd34c96fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+std-devel-0.5.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zune-jpeg+std-devel.sha256sum] = "32f13d3d20335ee4ca41a9805a4ab0ec76c3257faafc413c7eebb91daab61fdb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+x86-devel-0.5.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zune-jpeg+x86-devel.sha256sum] = "7e2f90fb8bdf9350d893b25236e0272539c74048d8cb14ef0599d61689caab1d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg-devel-0.5.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg-devel;unpack=0"
SRC_URI[x86_64_v2_rust-zune-jpeg-devel.sha256sum] = "61ca3c0b12def12db61f1eca08382b5a9ceb3b593e951a6c404a388ab50984e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+default-devel-0.5.15-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI[aarch64_rust-zune-jpeg+default-devel.sha256sum] = "3175e3dc428cacd5ba4ea8d5dacdd264ca65472ca2a86289b26fd3985866ce98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+log-devel-0.5.15-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI[aarch64_rust-zune-jpeg+log-devel.sha256sum] = "c4cb1646a36c45ae695ef3710b81436c8619bc96cb08db007218863ea374f5b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+neon-devel-0.5.15-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI[aarch64_rust-zune-jpeg+neon-devel.sha256sum] = "2af226d609196645512f0d53f5149160a6180db1964f8c6c8b5f45be504a61a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+portable_simd-devel-0.5.15-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+portable_simd-devel;unpack=0"
SRC_URI[aarch64_rust-zune-jpeg+portable_simd-devel.sha256sum] = "bbf579e581e399b64e7ee82fb2210cc5620fc5ef832bc928cf30963e0c8db461"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+std-devel-0.5.15-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI[aarch64_rust-zune-jpeg+std-devel.sha256sum] = "256eb1084868ffe7b67f75695d7e4b13cac1980a72c0afdb59b18816c536cdcd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+x86-devel-0.5.15-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI[aarch64_rust-zune-jpeg+x86-devel.sha256sum] = "c1ea6ddf4ce7a18f53dcbb4528da19a9741dc0859d4e946a46f29352a7a796e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg-devel-0.5.15-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg-devel;unpack=0"
SRC_URI[aarch64_rust-zune-jpeg-devel.sha256sum] = "575f58ffc03668370f6bd421426178130230fd8964bcfc5ee265c9c272a6e744"

RDEPENDS:rust-zune-jpeg+default-devel = " \
 cargo \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+log-devel = " \
 cargo \
 rust-zune-core+log-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+neon-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+portable_simd-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+std-devel = " \
 cargo \
 rust-zune-core+std-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+x86-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg-devel = " \
 cargo \
 rust \
 rust-zune-core+default-devel \
 "
