# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ahash"
PV = "0.8.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-ahash+atomic-polyfill-devel \
 rust-ahash+compile-time-rng-devel \
 rust-ahash+const-random-devel \
 rust-ahash+default-devel \
 rust-ahash+getrandom-devel \
 rust-ahash+nightly-arm-aes-devel \
 rust-ahash+no-rng-devel \
 rust-ahash+runtime-rng-devel \
 rust-ahash+serde-devel \
 rust-ahash+std-devel \
 rust-ahash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ahash-0.8.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "247d6b667dd484f6926b06d8762c811f32ee837d7508d5314b8fedbc72427cb3"

URI_x86_64_v2_rust-ahash+atomic-polyfill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+atomic-polyfill-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+atomic-polyfill-devel}"
SRC_URI[x86_64_v2_rust-ahash+atomic-polyfill-devel.sha256sum] = "e01329c04c94a53512639c5300045dfd38a27ad34a187d4c754871eb875f0fd2"

URI_x86_64_v2_rust-ahash+compile-time-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+compile-time-rng-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+compile-time-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+compile-time-rng-devel}"
SRC_URI[x86_64_v2_rust-ahash+compile-time-rng-devel.sha256sum] = "50c00c828ba2756fc7c5bc982b88d453e54c903f00f0653135046907730a2c08"

URI_x86_64_v2_rust-ahash+const-random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+const-random-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+const-random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+const-random-devel}"
SRC_URI[x86_64_v2_rust-ahash+const-random-devel.sha256sum] = "2de96055019322b09a2084483dac6557963719dc5aa90ef8f0282d0461a29107"

URI_x86_64_v2_rust-ahash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+default-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+default-devel}"
SRC_URI[x86_64_v2_rust-ahash+default-devel.sha256sum] = "56a667a4ae7e16cd6940bd2cc9de2ed8961705092c226775c7878ea15ed26e6e"

URI_x86_64_v2_rust-ahash+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+getrandom-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+getrandom-devel}"
SRC_URI[x86_64_v2_rust-ahash+getrandom-devel.sha256sum] = "c2eae5424f3d81e39d1a1a9c0b0d7e2c424751001a7e9bfcaa649706642c8767"

URI_x86_64_v2_rust-ahash+nightly-arm-aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+nightly-arm-aes-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+nightly-arm-aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+nightly-arm-aes-devel}"
SRC_URI[x86_64_v2_rust-ahash+nightly-arm-aes-devel.sha256sum] = "e5e095879ae7b2b5a8e7c7b4e93d3f28bfd03d61ccc19eef82aab5003d3cd1d2"

URI_x86_64_v2_rust-ahash+no-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+no-rng-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+no-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+no-rng-devel}"
SRC_URI[x86_64_v2_rust-ahash+no-rng-devel.sha256sum] = "8384b3bca5d5a4d257402c915b92684a75af459af58863e51198e60841bfc8ec"

URI_x86_64_v2_rust-ahash+runtime-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+runtime-rng-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+runtime-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+runtime-rng-devel}"
SRC_URI[x86_64_v2_rust-ahash+runtime-rng-devel.sha256sum] = "5bb095e9b45ce8afaa974010e83c38d468cb90f6612d1b95daa7cae0f75f083b"

URI_x86_64_v2_rust-ahash+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+serde-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+serde-devel}"
SRC_URI[x86_64_v2_rust-ahash+serde-devel.sha256sum] = "33f3e6e945a439d58d5797961119dde723964918e50041e7e9f1409de462fd6c"

URI_x86_64_v2_rust-ahash+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash+std-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash+std-devel}"
SRC_URI[x86_64_v2_rust-ahash+std-devel.sha256sum] = "939d11f7e8e93e0492ecfcc3c2885a10aef3378ddbd188ace7ac6066dd057a2e"

URI_x86_64_v2_rust-ahash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ahash-devel-0.8.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ahash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ahash-devel}"
SRC_URI[x86_64_v2_rust-ahash-devel.sha256sum] = "bc1c868f34cd8a211090c82393514a308a7c9a237be2b648613118bef2bfcbfb"

URI_aarch64_rust-ahash+atomic-polyfill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+atomic-polyfill-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+atomic-polyfill-devel}"
SRC_URI[aarch64_rust-ahash+atomic-polyfill-devel.sha256sum] = "e72a74875052b50c25fa9b354a4953fac7c14b6d877d5efe31e55e9e3d00e87d"

URI_aarch64_rust-ahash+compile-time-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+compile-time-rng-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+compile-time-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+compile-time-rng-devel}"
SRC_URI[aarch64_rust-ahash+compile-time-rng-devel.sha256sum] = "5f6d23c224476b1cb7a577de125fdf50bd5212302fa33fd113557aef29b4b0f9"

URI_aarch64_rust-ahash+const-random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+const-random-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+const-random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+const-random-devel}"
SRC_URI[aarch64_rust-ahash+const-random-devel.sha256sum] = "df8ba381e1e650c1bb52eab353c1e1f46c66d3ef2e86c0d8a1daa2844a66daf9"

URI_aarch64_rust-ahash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+default-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+default-devel}"
SRC_URI[aarch64_rust-ahash+default-devel.sha256sum] = "71682726dcf7c9e7276c69eff8cfe052d5d8eb93c97b2178031143b154ee33cb"

URI_aarch64_rust-ahash+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+getrandom-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+getrandom-devel}"
SRC_URI[aarch64_rust-ahash+getrandom-devel.sha256sum] = "9ca967b6f65d963f8a7ef0d5267d54144637936aaa1a5bfc9372b017f602d5f0"

URI_aarch64_rust-ahash+nightly-arm-aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+nightly-arm-aes-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+nightly-arm-aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+nightly-arm-aes-devel}"
SRC_URI[aarch64_rust-ahash+nightly-arm-aes-devel.sha256sum] = "35e8a4ad8625a8f05ab3a773d283b3d61799dc21fb2198dd15cb71a7b2cd345d"

URI_aarch64_rust-ahash+no-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+no-rng-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+no-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+no-rng-devel}"
SRC_URI[aarch64_rust-ahash+no-rng-devel.sha256sum] = "3c42e3cd201e17f487ab3a63e122c4b1d5c122c6dd064bc3a4103ef22320ab63"

URI_aarch64_rust-ahash+runtime-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+runtime-rng-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+runtime-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+runtime-rng-devel}"
SRC_URI[aarch64_rust-ahash+runtime-rng-devel.sha256sum] = "f3c47ce7cca53e00b7ce3e9e7b5d7d94868ed8697eebc8cd20622e28744e853b"

URI_aarch64_rust-ahash+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+serde-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+serde-devel}"
SRC_URI[aarch64_rust-ahash+serde-devel.sha256sum] = "9d889051e1bdf6ac73d31efa0b7b7cfa37e98c25e447e2dfe3e829f88e44e9ea"

URI_aarch64_rust-ahash+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash+std-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash+std-devel}"
SRC_URI[aarch64_rust-ahash+std-devel.sha256sum] = "7a0513f1de4d0bc47187fa3d51cedab0614c37b1925ca18346791466d2860173"

URI_aarch64_rust-ahash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ahash-devel-0.8.12-1.el10_1.noarch.rpm;name=aarch64_rust-ahash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ahash-devel}"
SRC_URI[aarch64_rust-ahash-devel.sha256sum] = "cd236377b709d484001579cd87937cb0f5d23485d477d54c211f9303932ea529"

RDEPENDS:rust-ahash+atomic-polyfill-devel = " \
 cargo \
 rust-ahash-devel \
 rust-once_cell+critical-section-devel \
 rust-portable-atomic+default-devel \
 "
RDEPENDS:rust-ahash+compile-time-rng-devel = " \
 cargo \
 rust-ahash+const-random-devel \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+const-random-devel = " \
 cargo \
 rust-ahash-devel \
 rust-const-random+default-devel \
 "
RDEPENDS:rust-ahash+default-devel = " \
 cargo \
 rust-ahash+runtime-rng-devel \
 rust-ahash+std-devel \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+getrandom-devel = " \
 cargo \
 rust-ahash-devel \
 rust-getrandom0.3+default-devel \
 "
RDEPENDS:rust-ahash+nightly-arm-aes-devel = " \
 cargo \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+no-rng-devel = " \
 cargo \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+runtime-rng-devel = " \
 cargo \
 rust-ahash+getrandom-devel \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash+serde-devel = " \
 cargo \
 rust-ahash-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-ahash+std-devel = " \
 cargo \
 rust-ahash-devel \
 "
RDEPENDS:rust-ahash-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 rust-version_check+default-devel \
 rust-zerocopy+simd-devel \
 rust-zerocopy-devel \
 "
