# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "phoronix-test-suite"
PV = "10.8.4"
PR = "9.el10_0"
PACKAGES = " \
 phoronix-test-suite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/phoronix-test-suite-10.8.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f426d09f551c00b74b0b5046985b800743ba4f58d9a2bac9c76848884f3c04f"

URI_x86_64_v2_phoronix-test-suite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phoronix-test-suite-10.8.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_phoronix-test-suite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_phoronix-test-suite}"
SRC_URI[x86_64_v2_phoronix-test-suite.sha256sum] = "36b525b2bf6c69a6e15b7122702a732667a421489dcde4a74d019f4c4a35e724"

URI_aarch64_phoronix-test-suite = "${EPEL_MIRROR}/aarch64/Packages/p/phoronix-test-suite-10.8.4-9.el10_0.noarch.rpm;name=aarch64_phoronix-test-suite;unpack=0"
SRC_URI:append = " ${URI_aarch64_phoronix-test-suite}"
SRC_URI[aarch64_phoronix-test-suite.sha256sum] = "2cbaa0511ea0cd26c9ba3f69068a0d73b29dcbad1b09681177f39db7c7ab1771"

RDEPENDS:phoronix-test-suite = " \
 bash \
 hicolor-icon-theme \
 php-cli \
 php-common \
 php-gd \
 php-pdo \
 php-process \
 php-xml \
 systemd \
 "
