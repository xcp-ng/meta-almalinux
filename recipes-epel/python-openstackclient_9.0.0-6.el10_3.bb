# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstackclient"
PV = "9.0.0"
PR = "6.el10_3"
PACKAGES = " \
 python-openstackclient-doc \
 python-openstackclient-lang \
 python3-openstackclient \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-openstackclient-9.0.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "15ca1d5c34bf4129b58a93fd4c21f166c3411a2bce7e6ebe997aa3f22fd5edd0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-openstackclient-doc-9.0.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-openstackclient-doc;unpack=0"
SRC_URI[x86_64_v2_python-openstackclient-doc.sha256sum] = "9d1877ad1d82e123d1c0bfa56deb3f41482aa8fc3b0ad45c18f5837634f9fa87"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-openstackclient-lang-9.0.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-openstackclient-lang;unpack=0"
SRC_URI[x86_64_v2_python-openstackclient-lang.sha256sum] = "fd17c34e2c5bda92b59543fa2f4d47024bfbcd07b5e8a974cba11ec89bf135d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstackclient-9.0.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openstackclient;unpack=0"
SRC_URI[x86_64_v2_python3-openstackclient.sha256sum] = "bdcb45e376b662c4c6cb272b3909c2f2de93cbf3d59436b59cb4dd59f083fa91"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-openstackclient-doc-9.0.0-6.el10_3.noarch.rpm;name=aarch64_python-openstackclient-doc;unpack=0"
SRC_URI[aarch64_python-openstackclient-doc.sha256sum] = "c6a0dd1d3c6ddfe0bee24ef492ebcf00151a35dbcab345e39167b17cf1756aa4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-openstackclient-lang-9.0.0-6.el10_3.noarch.rpm;name=aarch64_python-openstackclient-lang;unpack=0"
SRC_URI[aarch64_python-openstackclient-lang.sha256sum] = "4fb650a5c89127ba5c52dda67a965e089fd005763e13e119fdcb71219bf83326"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-openstackclient-9.0.0-6.el10_3.noarch.rpm;name=aarch64_python3-openstackclient;unpack=0"
SRC_URI[aarch64_python3-openstackclient.sha256sum] = "9d0ae1d56e6c04bfbf0bae968a5a74f2dd5c2cc43efd5757ac74a9f9ee28b3d0"

RDEPENDS:python-openstackclient-doc = " \
 python3-openstackclient \
 "
RDEPENDS:python-openstackclient-lang = " \
 "
RDEPENDS:python3-openstackclient = " \
 bash \
 python-openstackclient-lang \
 python3 \
 python3-cinderclient \
 python3-cliff \
 python3-cryptography \
 python3-iso8601 \
 python3-keystoneclient \
 python3-openstacksdk \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 "
