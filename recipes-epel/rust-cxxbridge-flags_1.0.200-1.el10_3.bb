# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-flags"
PV = "1.0.200"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxxbridge-flags+c++14-devel \
 rust-cxxbridge-flags+c++17-devel \
 rust-cxxbridge-flags+c++20-devel \
 rust-cxxbridge-flags+default-devel \
 rust-cxxbridge-flags-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-flags-1.0.200-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f9e810dd268bcf8c95432d79c7f56b45add3c7c6326cec6aebaa67f11cc8003f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++14-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++14-devel.sha256sum] = "4a47a195f509e9f6a8cb021ed2fe31a4e3e6d6fe5f57e1d42df02cc33cfdc9bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++17-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++17-devel.sha256sum] = "3da56e10662c4f2b633adceb5208ada3214366696894e281fbeb27d414c743fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+c++20-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+c++20-devel.sha256sum] = "f329cfdeea60f0563a29d88e26f44f0418042a13b7bf5e4d46d3fd1971f6ed55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags+default-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxxbridge-flags+default-devel.sha256sum] = "d44bac8e1f48334c1de1dcaa17d3f9e1914efe897690acddc3fcd11ab147fcf6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-flags-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxxbridge-flags-devel.sha256sum] = "37e543f5cc6f83e2d91f2d40d81533e739af5e7447d671b2c43365352520554f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++14-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++14-devel;unpack=0"
SRC_URI[aarch64_rust-cxxbridge-flags+c++14-devel.sha256sum] = "8234b7f658e1526c20a77bc6909b05c44829a2142a936228bf10ab80c637cd7f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++17-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++17-devel;unpack=0"
SRC_URI[aarch64_rust-cxxbridge-flags+c++17-devel.sha256sum] = "f34f6e85c0b11737e3f65fbe9417f5bf8c4cd1efda5d476089d5133ccc66677c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+c++20-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags+c++20-devel;unpack=0"
SRC_URI[aarch64_rust-cxxbridge-flags+c++20-devel.sha256sum] = "e768ca0ab94f8c4bfe18f6452cfdd07fada5799dfea282abf825590b395ae990"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags+default-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags+default-devel;unpack=0"
SRC_URI[aarch64_rust-cxxbridge-flags+default-devel.sha256sum] = "9e02cf4060f626cfcf9576ec1851158931aec4a77ebd649469e3a5c6b2de573a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-flags-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-flags-devel;unpack=0"
SRC_URI[aarch64_rust-cxxbridge-flags-devel.sha256sum] = "182ac09b585edaeee9d7c8957e8eb1d4435eb9bb69403a5f0e9f6c24233fb473"

RDEPENDS:rust-cxxbridge-flags+c++14-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++17-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+c++20-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags+default-devel = " \
 cargo \
 rust-cxxbridge-flags-devel \
 "
RDEPENDS:rust-cxxbridge-flags-devel = " \
 cargo \
 rust \
 "
