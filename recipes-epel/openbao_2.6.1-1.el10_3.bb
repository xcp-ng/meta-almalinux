# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openbao"
PV = "2.6.1"
PR = "1.el10_3"
PACKAGES = " \
 openbao \
 openbao-vault-compat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openbao-2.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b149cc69ae6bfd4f88673ddcb0b1b867ec7859c7a73fb16843cf5c40b047532d"

URI_x86_64_v2_openbao = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-2.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbao}"
SRC_URI[x86_64_v2_openbao.sha256sum] = "fbe7c131c88ccc714c6031fb4a2e9129ac2a05119a097ce81c9d8a610816f684"

URI_x86_64_v2_openbao-vault-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openbao-vault-compat-2.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openbao-vault-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openbao-vault-compat}"
SRC_URI[x86_64_v2_openbao-vault-compat.sha256sum] = "6ae660aee167d07f6bbe89537f3d615cf3edac5b0acaefa4c6ca512a42dbd08d"

URI_aarch64_openbao = "${EPEL_MIRROR}/aarch64/Packages/o/openbao-2.6.1-1.el10_3.aarch64.rpm;name=aarch64_openbao;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbao}"
SRC_URI[aarch64_openbao.sha256sum] = "8d0ccbc531b78887a76ef1ecd925f4a24ee00d3fe0a29e8387c9a0f835225df9"

URI_aarch64_openbao-vault-compat = "${EPEL_MIRROR}/aarch64/Packages/o/openbao-vault-compat-2.6.1-1.el10_3.aarch64.rpm;name=aarch64_openbao-vault-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openbao-vault-compat}"
SRC_URI[aarch64_openbao-vault-compat.sha256sum] = "ab58f84f6f93b6c6a5e6431393b7849528754aa583ba07e16b0ed3f8b7a46457"

RDEPENDS:openbao = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:openbao-vault-compat = " \
 openbao \
 "
