# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "createrepo-agent"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 createrepo-agent \
 python3-createrepo-agent \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/createrepo-agent-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7a141a09b9b7d574784490a92c9ddd44a3c88b1b9565fd575310a10ce02b6a71"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/createrepo-agent-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_createrepo-agent;unpack=0"
SRC_URI[x86_64_v2_createrepo-agent.sha256sum] = "b9efebe3dd57314dfbef79ff8ac9c85c0ebfaf137c98cdb510d0d52ecde29d0b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-createrepo-agent-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-createrepo-agent;unpack=0"
SRC_URI[x86_64_v2_python3-createrepo-agent.sha256sum] = "7f3b93d4f976fc439e55048eb61ac5a3d7ad7eb9fd7295ce692b771be83808f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/createrepo-agent-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_createrepo-agent;unpack=0"
SRC_URI[aarch64_createrepo-agent.sha256sum] = "9836690192361ad9f0e8a8c1eac6a29a91f088605b3ea4e14af7755b80e0d297"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-createrepo-agent-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_python3-createrepo-agent;unpack=0"
SRC_URI[aarch64_python3-createrepo-agent.sha256sum] = "ba405e112fa9f4366d31195581a95e60d4c18985383a61d89bb5d03db6600c04"

RDEPENDS:createrepo-agent = " \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme \
 libassuan \
 libgpg-error \
 "
RDEPENDS:python3-createrepo-agent = " \
 createrepo-agent \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme \
 libassuan \
 libgpg-error \
 python3 \
 "
