# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distrobox"
PV = "1.8.2.3"
PR = "1.el10_2"
PACKAGES = " \
 distrobox \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/distrobox-1.8.2.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "16c0ecb76afa3def0cddb66fd9f15d94760f463f24f098906a602211c2c9456d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distrobox-1.8.2.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_distrobox;unpack=0"
SRC_URI[x86_64_v2_distrobox.sha256sum] = "bae0b5ff117a9ecc03f2a094388a6f8dba9b4148da744e9d383f79c8b8b6540f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/distrobox-1.8.2.3-1.el10_2.noarch.rpm;name=aarch64_distrobox;unpack=0"
SRC_URI[aarch64_distrobox.sha256sum] = "38f32ada866231804934a0957aab50f04880f5e6bf5e4170a5641e65d43f529a"

RDEPENDS:distrobox = " \
 bash \
 findutils \
 grep \
 hicolor-icon-theme \
 sed \
 virtual//usr/bin/basename \
 virtual/podman_or_/usr/bin/docker \
 "
