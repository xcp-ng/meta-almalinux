# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-critical-section"
PV = "1.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-critical-section+default-devel \
 rust-critical-section+restore-state-bool-devel \
 rust-critical-section+restore-state-none-devel \
 rust-critical-section+restore-state-u16-devel \
 rust-critical-section+restore-state-u32-devel \
 rust-critical-section+restore-state-u64-devel \
 rust-critical-section+restore-state-u8-devel \
 rust-critical-section+restore-state-usize-devel \
 rust-critical-section+std-devel \
 rust-critical-section-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-critical-section-1.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1153b8b04d0c1bb30cf428c333420f6fc9e6db7ca58615d3127e1db0b62e2d5c"

URI_x86_64_v2_rust-critical-section+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section+default-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section+default-devel}"
SRC_URI[x86_64_v2_rust-critical-section+default-devel.sha256sum] = "248d170b4f0bb8058a0492b026588450b5e7dcd7c2a858433cf85db5addf3d13"

URI_x86_64_v2_rust-critical-section+restore-state-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section+restore-state-bool-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section+restore-state-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section+restore-state-bool-devel}"
SRC_URI[x86_64_v2_rust-critical-section+restore-state-bool-devel.sha256sum] = "1a012dd8265d4d7ffe06f80185f89c263fcbc48c1d1a5f63bde4c06501e0960f"

URI_x86_64_v2_rust-critical-section+restore-state-none-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section+restore-state-none-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section+restore-state-none-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section+restore-state-none-devel}"
SRC_URI[x86_64_v2_rust-critical-section+restore-state-none-devel.sha256sum] = "9a46e237ef6be99e1c688e5be44ea18d7e5cde3d3226739370d605a3e9fb105d"

URI_x86_64_v2_rust-critical-section+restore-state-u16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section+restore-state-u16-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section+restore-state-u16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section+restore-state-u16-devel}"
SRC_URI[x86_64_v2_rust-critical-section+restore-state-u16-devel.sha256sum] = "b22063b6b7240771d19168c9e4f1a801ad9133cc95d9f8ad50694a37067169c2"

URI_x86_64_v2_rust-critical-section+restore-state-u32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section+restore-state-u32-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section+restore-state-u32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section+restore-state-u32-devel}"
SRC_URI[x86_64_v2_rust-critical-section+restore-state-u32-devel.sha256sum] = "97013d187a8f055a30c5bc355a2d8c397bb868fb1fa13e36f99c8ff908be4cb1"

URI_x86_64_v2_rust-critical-section+restore-state-u64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section+restore-state-u64-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section+restore-state-u64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section+restore-state-u64-devel}"
SRC_URI[x86_64_v2_rust-critical-section+restore-state-u64-devel.sha256sum] = "983d7c05a76d9dd3df2d820c2baf888741998fa47d436956d3a4065b20772b69"

URI_x86_64_v2_rust-critical-section+restore-state-u8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section+restore-state-u8-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section+restore-state-u8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section+restore-state-u8-devel}"
SRC_URI[x86_64_v2_rust-critical-section+restore-state-u8-devel.sha256sum] = "11a683072dfab8e56b23fbfbadea279f3edc6a9c8fedcf30808ff22aa69a49e1"

URI_x86_64_v2_rust-critical-section+restore-state-usize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section+restore-state-usize-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section+restore-state-usize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section+restore-state-usize-devel}"
SRC_URI[x86_64_v2_rust-critical-section+restore-state-usize-devel.sha256sum] = "94492a2757b6c7e26f2959b95366a2b55a7effbaf5e23c5f05fe0bf0817c71e8"

URI_x86_64_v2_rust-critical-section+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section+std-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section+std-devel}"
SRC_URI[x86_64_v2_rust-critical-section+std-devel.sha256sum] = "35bd319b85ac4ab81b618798118c3186a43a1da64fa465dfdc50ea7a3fd7139e"

URI_x86_64_v2_rust-critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-critical-section-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-critical-section-devel}"
SRC_URI[x86_64_v2_rust-critical-section-devel.sha256sum] = "4cd6e85c18302cec3a69f3161024256f8d2e8688be16303a51cdbf7c9c5716bb"

URI_aarch64_rust-critical-section+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section+default-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section+default-devel}"
SRC_URI[aarch64_rust-critical-section+default-devel.sha256sum] = "8d9c1589e6b3602f1b4287162a97c54efe8d59e0291ea026515b213b1db0c37e"

URI_aarch64_rust-critical-section+restore-state-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section+restore-state-bool-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section+restore-state-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section+restore-state-bool-devel}"
SRC_URI[aarch64_rust-critical-section+restore-state-bool-devel.sha256sum] = "300625ef104459b2d9371367a97270cf705546630a6ca478d6d8e7e20db794df"

URI_aarch64_rust-critical-section+restore-state-none-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section+restore-state-none-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section+restore-state-none-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section+restore-state-none-devel}"
SRC_URI[aarch64_rust-critical-section+restore-state-none-devel.sha256sum] = "68b19fdc7712508bb6007d7452838f16f59df723797609d890e4e342907a96b7"

URI_aarch64_rust-critical-section+restore-state-u16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section+restore-state-u16-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section+restore-state-u16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section+restore-state-u16-devel}"
SRC_URI[aarch64_rust-critical-section+restore-state-u16-devel.sha256sum] = "7fdcaed9461f50677d24af42712f92cedce716ee0619cf57a70fc9e106e087cd"

URI_aarch64_rust-critical-section+restore-state-u32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section+restore-state-u32-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section+restore-state-u32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section+restore-state-u32-devel}"
SRC_URI[aarch64_rust-critical-section+restore-state-u32-devel.sha256sum] = "91c076bd0102766204a628fb1c6c108628e6f7afccc0c511fee0692dd6f86cd5"

URI_aarch64_rust-critical-section+restore-state-u64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section+restore-state-u64-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section+restore-state-u64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section+restore-state-u64-devel}"
SRC_URI[aarch64_rust-critical-section+restore-state-u64-devel.sha256sum] = "d9de55e70876b2e8dbfc7119299b78630229cf73ebc3c207e4f00c3402263283"

URI_aarch64_rust-critical-section+restore-state-u8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section+restore-state-u8-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section+restore-state-u8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section+restore-state-u8-devel}"
SRC_URI[aarch64_rust-critical-section+restore-state-u8-devel.sha256sum] = "968212ed07df4d11a1222dadc82a6e3d0190643c0890577f869b804c8a4f5f32"

URI_aarch64_rust-critical-section+restore-state-usize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section+restore-state-usize-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section+restore-state-usize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section+restore-state-usize-devel}"
SRC_URI[aarch64_rust-critical-section+restore-state-usize-devel.sha256sum] = "28b886c43292c5b3740e115a6eaa120828a5189cc5fac955806edcaa6df21c40"

URI_aarch64_rust-critical-section+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section+std-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section+std-devel}"
SRC_URI[aarch64_rust-critical-section+std-devel.sha256sum] = "2d9a3a6b23b5b6aef0b8ac6184a6b637aab6466fda036deeb9407c3464429b6c"

URI_aarch64_rust-critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-critical-section-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-critical-section-devel}"
SRC_URI[aarch64_rust-critical-section-devel.sha256sum] = "dd09bdec20a9ad41116b5fde944f542399f04972eb410a97f094c3880765efe5"

RDEPENDS:rust-critical-section+default-devel = " \
 cargo \
 rust-critical-section-devel \
 "
RDEPENDS:rust-critical-section+restore-state-bool-devel = " \
 cargo \
 rust-critical-section-devel \
 "
RDEPENDS:rust-critical-section+restore-state-none-devel = " \
 cargo \
 rust-critical-section-devel \
 "
RDEPENDS:rust-critical-section+restore-state-u16-devel = " \
 cargo \
 rust-critical-section-devel \
 "
RDEPENDS:rust-critical-section+restore-state-u32-devel = " \
 cargo \
 rust-critical-section-devel \
 "
RDEPENDS:rust-critical-section+restore-state-u64-devel = " \
 cargo \
 rust-critical-section-devel \
 "
RDEPENDS:rust-critical-section+restore-state-u8-devel = " \
 cargo \
 rust-critical-section-devel \
 "
RDEPENDS:rust-critical-section+restore-state-usize-devel = " \
 cargo \
 rust-critical-section-devel \
 "
RDEPENDS:rust-critical-section+std-devel = " \
 cargo \
 rust-critical-section+restore-state-bool-devel \
 rust-critical-section-devel \
 "
RDEPENDS:rust-critical-section-devel = " \
 cargo \
 "
