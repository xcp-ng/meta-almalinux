# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-channel"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-channel+alloc-devel \
 rust-futures-channel+cfg-target-has-atomic-devel \
 rust-futures-channel+default-devel \
 rust-futures-channel+futures-sink-devel \
 rust-futures-channel+sink-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel+unstable-devel \
 rust-futures-channel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-channel-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce561f713ff7e81525dac8795a4ff1d6c00d0d4091e7f6bf57fb25088a761585"

URI_x86_64_v2_rust-futures-channel+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+alloc-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+alloc-devel.sha256sum] = "0715822bd2a8d871bfab87843678b28264effae3a8d8b21cc3ed366b98b4dfbc"

URI_x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+cfg-target-has-atomic-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+cfg-target-has-atomic-devel.sha256sum] = "c6589eef6ace45ed1c22aa89988ab96988cea53ea5098cb887936196cbcc0b60"

URI_x86_64_v2_rust-futures-channel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+default-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+default-devel.sha256sum] = "fcad65329e3bae931b12f97ab873e06729416e6a1dc78b17f6df673de8f12c61"

URI_x86_64_v2_rust-futures-channel+futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+futures-sink-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+futures-sink-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+futures-sink-devel.sha256sum] = "054c459bdfa2a38d78b12ed4c2a8882d6c1504e90d67a3d50c0c13ecb2fe8971"

URI_x86_64_v2_rust-futures-channel+sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+sink-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+sink-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+sink-devel.sha256sum] = "59e1b699c1e798f95775be0d1678d63ea900c95a386515505ff474776c4a0b09"

URI_x86_64_v2_rust-futures-channel+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+std-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+std-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+std-devel.sha256sum] = "d3ccf09c451cb04db25d2cf065300f72002c34a2bbbfa8c32d93825d524a5a63"

URI_x86_64_v2_rust-futures-channel+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel+unstable-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-channel+unstable-devel.sha256sum] = "c5c41ace1643cd0f9c4a51de13147019975dbe8787134cfc4331e2dc9a282127"

URI_x86_64_v2_rust-futures-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-channel-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-channel-devel}"
SRC_URI[x86_64_v2_rust-futures-channel-devel.sha256sum] = "863a113184ab0fc505882d0dd687657ff5de81fda2864208a359ca317dff5543"

URI_aarch64_rust-futures-channel+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+alloc-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+alloc-devel}"
SRC_URI[aarch64_rust-futures-channel+alloc-devel.sha256sum] = "9f6c6ebd4f6f9078eee82163df7d07b862058910be9c582bac23f95cbfed4f30"

URI_aarch64_rust-futures-channel+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+cfg-target-has-atomic-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-channel+cfg-target-has-atomic-devel.sha256sum] = "8897360c53622af5bc3f90528d0dffb0ec766c95c0c7882727f6e95d6c0fabd4"

URI_aarch64_rust-futures-channel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+default-devel}"
SRC_URI[aarch64_rust-futures-channel+default-devel.sha256sum] = "82ed3b7157f6d25c23a46d6889efcc5cd9cfda3d0e768051506e51e9dfc4f066"

URI_aarch64_rust-futures-channel+futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+futures-sink-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+futures-sink-devel}"
SRC_URI[aarch64_rust-futures-channel+futures-sink-devel.sha256sum] = "4b4896476149331ecffecc17881345855986fb3ec0a68d41e4406061d1b6c398"

URI_aarch64_rust-futures-channel+sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+sink-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+sink-devel}"
SRC_URI[aarch64_rust-futures-channel+sink-devel.sha256sum] = "24e3a80b1124354333d0e336dc27c281a78ac54c273f64ec9b8d65725b0f0e88"

URI_aarch64_rust-futures-channel+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+std-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+std-devel}"
SRC_URI[aarch64_rust-futures-channel+std-devel.sha256sum] = "a26113e7503a001d8b517e84785aa758cb30ffe86b21f99abde930f0d49344dc"

URI_aarch64_rust-futures-channel+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel+unstable-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel+unstable-devel}"
SRC_URI[aarch64_rust-futures-channel+unstable-devel.sha256sum] = "f982fb059eab8c94aac7decd3355b332fd4a591cbbc6eeb3ccc88e923c88e7f1"

URI_aarch64_rust-futures-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-channel-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-channel-devel}"
SRC_URI[aarch64_rust-futures-channel-devel.sha256sum] = "d5acec59aa6668673569ad331831cf3ece4e4ba6755284a620d8a5cb66399780"

RDEPENDS:rust-futures-channel+alloc-devel = " \
 cargo \
 rust-futures-channel-devel \
 rust-futures-core+alloc-devel \
 "
RDEPENDS:rust-futures-channel+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+default-devel = " \
 cargo \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+futures-sink-devel = " \
 cargo \
 rust-futures-channel-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-channel+sink-devel = " \
 cargo \
 rust-futures-channel+futures-sink-devel \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel+std-devel = " \
 cargo \
 rust-futures-channel+alloc-devel \
 rust-futures-channel-devel \
 rust-futures-core+std-devel \
 "
RDEPENDS:rust-futures-channel+unstable-devel = " \
 cargo \
 rust-futures-channel-devel \
 "
RDEPENDS:rust-futures-channel-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 "
