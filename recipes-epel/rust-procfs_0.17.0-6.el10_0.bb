# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-procfs"
PV = "0.17.0"
PR = "6.el10_0"
PACKAGES = " \
 rust-procfs+backtrace-devel \
 rust-procfs+chrono-devel \
 rust-procfs+default-devel \
 rust-procfs+flate2-devel \
 rust-procfs+serde-devel \
 rust-procfs+serde1-devel \
 rust-procfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-procfs-0.17.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ca172251397e955dca5a81a3e052e40c5d28816a182bbe2b0d3c77eef10ce9b"

URI_x86_64_v2_rust-procfs+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+backtrace-devel-0.17.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+backtrace-devel}"
SRC_URI[x86_64_v2_rust-procfs+backtrace-devel.sha256sum] = "691cb99c17e4ffc828b84678e5f0821f4889929b40d16f5982846b592c36ee06"

URI_x86_64_v2_rust-procfs+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+chrono-devel-0.17.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+chrono-devel}"
SRC_URI[x86_64_v2_rust-procfs+chrono-devel.sha256sum] = "6c5ae282d366dbe9c3b9eff772dcae39704e6f665426d655f4c498c8cd49dd81"

URI_x86_64_v2_rust-procfs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+default-devel-0.17.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+default-devel}"
SRC_URI[x86_64_v2_rust-procfs+default-devel.sha256sum] = "08469699b12a262379993cfa1b708b683b58128bc78a4cf50e5d2f2cee61c4c3"

URI_x86_64_v2_rust-procfs+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+flate2-devel-0.17.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+flate2-devel}"
SRC_URI[x86_64_v2_rust-procfs+flate2-devel.sha256sum] = "d76f0ac9198dc9f78337b092370ef9dab0543fba9343ed998b8253dc03a692b5"

URI_x86_64_v2_rust-procfs+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+serde-devel-0.17.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+serde-devel}"
SRC_URI[x86_64_v2_rust-procfs+serde-devel.sha256sum] = "311b42262ed3658b2b3c0c19bf790692313a2727913ff4246c24d50420289f99"

URI_x86_64_v2_rust-procfs+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs+serde1-devel-0.17.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs+serde1-devel}"
SRC_URI[x86_64_v2_rust-procfs+serde1-devel.sha256sum] = "7ebfa1864c0f251955251b2df7de3998f307e967f208a0d31385eb7935c5b533"

URI_x86_64_v2_rust-procfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-devel-0.17.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-devel}"
SRC_URI[x86_64_v2_rust-procfs-devel.sha256sum] = "19334d41a7b9558847b882db585b9ab6644bd4c4b98d76a33333a8c65528df5b"

URI_aarch64_rust-procfs+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+backtrace-devel-0.17.0-6.el10_0.noarch.rpm;name=aarch64_rust-procfs+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+backtrace-devel}"
SRC_URI[aarch64_rust-procfs+backtrace-devel.sha256sum] = "4e33362f49e01f347c8d718412f4f878beca74a54428e2bc7df8ff505c0d0101"

URI_aarch64_rust-procfs+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+chrono-devel-0.17.0-6.el10_0.noarch.rpm;name=aarch64_rust-procfs+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+chrono-devel}"
SRC_URI[aarch64_rust-procfs+chrono-devel.sha256sum] = "cc5e2708d606e7495d7d004b0193f58465b5b457ecfdbbd675ff94a7658c7049"

URI_aarch64_rust-procfs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+default-devel-0.17.0-6.el10_0.noarch.rpm;name=aarch64_rust-procfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+default-devel}"
SRC_URI[aarch64_rust-procfs+default-devel.sha256sum] = "5ab051d58d86771a856afc12cb5dfabdc4e1ad83014cc90158604917002a295c"

URI_aarch64_rust-procfs+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+flate2-devel-0.17.0-6.el10_0.noarch.rpm;name=aarch64_rust-procfs+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+flate2-devel}"
SRC_URI[aarch64_rust-procfs+flate2-devel.sha256sum] = "2948e96bc5aa33e3d63f48365430d5972b48356c5ef370f1177cb42edd7b12f8"

URI_aarch64_rust-procfs+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+serde-devel-0.17.0-6.el10_0.noarch.rpm;name=aarch64_rust-procfs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+serde-devel}"
SRC_URI[aarch64_rust-procfs+serde-devel.sha256sum] = "c960d9dbb4ebdcf51db0f863f00eb7394931bd34d16edfee4d7071ef5bd8f18c"

URI_aarch64_rust-procfs+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs+serde1-devel-0.17.0-6.el10_0.noarch.rpm;name=aarch64_rust-procfs+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs+serde1-devel}"
SRC_URI[aarch64_rust-procfs+serde1-devel.sha256sum] = "504f9be19a75d6d34b29c7d8e4153abeb4e2bdfc5118c8b4a1503f7d57e50301"

URI_aarch64_rust-procfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-devel-0.17.0-6.el10_0.noarch.rpm;name=aarch64_rust-procfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-devel}"
SRC_URI[aarch64_rust-procfs-devel.sha256sum] = "b9a644e85f10b62a88332a09a03ae7c08c5343ac3178807270dfd46ebe22fada"

RDEPENDS:rust-procfs+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-procfs-core+backtrace-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs+default-devel = " \
 cargo \
 rust-procfs+chrono-devel \
 rust-procfs+flate2-devel \
 rust-procfs-core+default-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs+flate2-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs+serde-devel = " \
 cargo \
 rust-procfs-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-procfs+serde1-devel = " \
 cargo \
 rust-procfs+serde-devel \
 rust-procfs-core+serde1-devel \
 rust-procfs-devel \
 "
RDEPENDS:rust-procfs-devel = " \
 cargo \
 rust \
 rust-bitflags-devel \
 rust-hex+default-devel \
 rust-procfs-core-devel \
 rust-rustix0.38+default-devel \
 rust-rustix0.38+fs-devel \
 rust-rustix0.38+param-devel \
 rust-rustix0.38+process-devel \
 rust-rustix0.38+system-devel \
 rust-rustix0.38+thread-devel \
 "
