# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s2n-tls"
PV = "1.5.10"
PR = "2.el10_0"
PACKAGES = " \
 s2n-tls \
 s2n-tls-devel \
 s2n-tls-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/s2n-tls-1.5.10-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89a5df28ecf973808a6e2ad8909a893a20af83f591f27efc72b1d53231fdb096"

URI_x86_64_v2_s2n-tls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s2n-tls-1.5.10-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_s2n-tls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s2n-tls}"
SRC_URI[x86_64_v2_s2n-tls.sha256sum] = "536f83f0a95db062a50445c66d4b02facd8cb64be8de1f0cd880fe9146484bf9"

URI_x86_64_v2_s2n-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s2n-tls-devel-1.5.10-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_s2n-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s2n-tls-devel}"
SRC_URI[x86_64_v2_s2n-tls-devel.sha256sum] = "be6ff15ac2f6cb710dfeb3bf5149308e189a664c5f6db751aba2615c943609f9"

URI_x86_64_v2_s2n-tls-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s2n-tls-doc-1.5.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_s2n-tls-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s2n-tls-doc}"
SRC_URI[x86_64_v2_s2n-tls-doc.sha256sum] = "08f85641dc592a1467ae548bd6c5233bfe0657508d74705beb076c54a099f7a2"

URI_aarch64_s2n-tls = "${EPEL_MIRROR}/aarch64/Packages/s/s2n-tls-1.5.10-2.el10_0.aarch64.rpm;name=aarch64_s2n-tls;unpack=0"
SRC_URI:append = " ${URI_aarch64_s2n-tls}"
SRC_URI[aarch64_s2n-tls.sha256sum] = "f701bb482834daccfc41b28cc9ef449d086caef349eacdafea1854805358193f"

URI_aarch64_s2n-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/s/s2n-tls-devel-1.5.10-2.el10_0.aarch64.rpm;name=aarch64_s2n-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_s2n-tls-devel}"
SRC_URI[aarch64_s2n-tls-devel.sha256sum] = "36292bd531f035cbc2d167bfdf3e220a3c95665a4d46718f061912d4ef613d22"

URI_aarch64_s2n-tls-doc = "${EPEL_MIRROR}/aarch64/Packages/s/s2n-tls-doc-1.5.10-2.el10_0.noarch.rpm;name=aarch64_s2n-tls-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_s2n-tls-doc}"
SRC_URI[aarch64_s2n-tls-doc.sha256sum] = "921ff7a31e1cd0d562affd926d23bf7758713735441625dcb47251746f335152"

RDEPENDS:s2n-tls = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:s2n-tls-devel = " \
 cmake-filesystem \
 openssl-devel \
 s2n-tls \
 "
RDEPENDS:s2n-tls-doc = " \
 "
