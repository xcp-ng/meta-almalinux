# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Tempdir"
PV = "0.02"
PR = "27.el10_0"
PACKAGES = " \
 perl-File-Tempdir \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Tempdir-0.02-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bd108feab86868be7ac48bb5b135049c487885675f406c736ab90f4404c16e6"

URI_x86_64_v2_perl-File-Tempdir = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Tempdir-0.02-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Tempdir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Tempdir}"
SRC_URI[x86_64_v2_perl-File-Tempdir.sha256sum] = "4cf6f77edf1ea005f0d8302d47f31e89efebe478dc45add7b3a87900efd6dea2"

URI_aarch64_perl-File-Tempdir = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Tempdir-0.02-27.el10_0.noarch.rpm;name=aarch64_perl-File-Tempdir;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Tempdir}"
SRC_URI[aarch64_perl-File-Tempdir.sha256sum] = "b3b0652afa8527e22ebb2ddb3efbc6a17d48a0d2b642fa07f5863f6cc818b004"

RDEPENDS:perl-File-Tempdir = " \
 perl-File-Path \
 perl-File-Temp \
 perl-libs \
 "
