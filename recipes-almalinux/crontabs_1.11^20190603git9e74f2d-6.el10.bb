# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crontabs"
PV = "1.11^20190603git9e74f2d"
PR = "6.el10"
PACKAGES = " \
 crontabs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/crontabs-1.11^20190603git9e74f2d-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4367b6060030d80c1171141a48ebb6fb3f44b91b1eb0875a32b7a580395c875b"

URI_x86_64_v2_crontabs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crontabs-1.11^20190603git9e74f2d-6.el10.noarch.rpm;name=x86_64_v2_crontabs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crontabs}"
SRC_URI[x86_64_v2_crontabs.sha256sum] = "879f1342347b6802f274b970f093d44aae46a05c3b3694c96cfec3fc83181b41"

URI_aarch64_crontabs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crontabs-1.11^20190603git9e74f2d-6.el10.noarch.rpm;name=aarch64_crontabs;unpack=0"
SRC_URI:append = " ${URI_aarch64_crontabs}"
SRC_URI[aarch64_crontabs.sha256sum] = "879f1342347b6802f274b970f093d44aae46a05c3b3694c96cfec3fc83181b41"

RDEPENDS:crontabs = " \
 bash \
 cronie \
 sed \
 "
