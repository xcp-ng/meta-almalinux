# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qt5compat"
PV = "6.10.1"
PR = "1.el10_2.1"
PACKAGES = " \
 qt6-qt5compat \
 qt6-qt5compat-devel \
 qt6-qt5compat-examples \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qt5compat-6.10.1-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "58a01d532a4e39cba0e4b2d80f1112fa486f51f2fd8e6014af01a71b9e71d77a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt5compat-6.10.1-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qt5compat;unpack=0"
SRC_URI[x86_64_v2_qt6-qt5compat.sha256sum] = "2173c6b49b07980d05ac76c8ee8c9a93de740ad9e1025fd69612ec2991f7922a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt5compat-devel-6.10.1-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qt5compat-devel;unpack=0"
SRC_URI[x86_64_v2_qt6-qt5compat-devel.sha256sum] = "19ab725f1d8a275602b5194c4719ad4b5d85f065031ed72b149885289f6c98ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qt5compat-examples-6.10.1-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_qt6-qt5compat-examples;unpack=0"
SRC_URI[x86_64_v2_qt6-qt5compat-examples.sha256sum] = "4d4c70d54b2a309bfd17c719bd5b16bdfa3d80d4c62c156080792fdc91fb83e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt5compat-6.10.1-1.el10_2.1.aarch64.rpm;name=aarch64_qt6-qt5compat;unpack=0"
SRC_URI[aarch64_qt6-qt5compat.sha256sum] = "ef5bdf52b2ac194bfe4ae2ca014f3bf7022c4388450c95ddde942d6e3d96873d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt5compat-devel-6.10.1-1.el10_2.1.aarch64.rpm;name=aarch64_qt6-qt5compat-devel;unpack=0"
SRC_URI[aarch64_qt6-qt5compat-devel.sha256sum] = "162cb8fc9008c44b590e21deb60d8f1beca466a654f62c2b0687d6cd3c1fd0f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qt5compat-examples-6.10.1-1.el10_2.1.aarch64.rpm;name=aarch64_qt6-qt5compat-examples;unpack=0"
SRC_URI[aarch64_qt6-qt5compat-examples.sha256sum] = "48393c36f582b9006a8d174fd8aec2f8c3c5580483453d2f749f8b38a7ae740f"

RDEPENDS:qt6-qt5compat = " \
 glibc \
 libicu \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtshadertools \
 "
RDEPENDS:qt6-qt5compat-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qt5compat \
 qt6-qtbase-devel \
 "
RDEPENDS:qt6-qt5compat-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
