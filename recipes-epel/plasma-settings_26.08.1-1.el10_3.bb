# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-settings"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 plasma-settings \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-settings-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f51635d82ee2524ce00cc979b7b3fb43d2d18c84a02a306afa1cc89c147687a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-settings-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-settings;unpack=0"
SRC_URI[x86_64_v2_plasma-settings.sha256sum] = "b604a576c69ce50564aaf46a5e45be3c466b88bab6a59740330c1e68ed5c53d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-settings-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_plasma-settings;unpack=0"
SRC_URI[aarch64_plasma-settings.sha256sum] = "07e7d4083437a1f9d919bdb676308e28c24000874e59895311d210b46ff2f0be"

RDEPENDS:plasma-settings = " \
 accountsservice \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kservice \
 libstdc++ \
 polkit-kde \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 sound-theme-freedesktop \
 "
