# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-String-CRC32"
PV = "2.100"
PR = "7.el10_0"
PACKAGES = " \
 perl-String-CRC32 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-String-CRC32-2.100-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7875baa5744e24d035a1af4b3069e40cdef15860d269458e2e6bcde90668bb20"

URI_x86_64_v2_perl-String-CRC32 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-String-CRC32-2.100-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-String-CRC32;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-String-CRC32}"
SRC_URI[x86_64_v2_perl-String-CRC32.sha256sum] = "fd79a3c26cfd23ed5abbde7bf9368c2a83a003d4e8b0caeee72f806e04bd9613"

URI_aarch64_perl-String-CRC32 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-String-CRC32-2.100-7.el10_0.aarch64.rpm;name=aarch64_perl-String-CRC32;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-String-CRC32}"
SRC_URI[aarch64_perl-String-CRC32.sha256sum] = "359288c3fdec105010bd20e5800f09aceda1427eb911f1dc1a6500a44f32bd33"

RDEPENDS:perl-String-CRC32 = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
