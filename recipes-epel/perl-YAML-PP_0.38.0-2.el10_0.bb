# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-YAML-PP"
PV = "0.38.0"
PR = "2.el10_0"
PACKAGES = " \
 perl-YAML-PP \
 perl-YAML-PP-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-YAML-PP-0.38.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1caf458b9cfb214b081355dfbe3a4ab873c14af5869b8b15a37ff760060c8261"

URI_x86_64_v2_perl-YAML-PP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-YAML-PP-0.38.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-YAML-PP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-YAML-PP}"
SRC_URI[x86_64_v2_perl-YAML-PP.sha256sum] = "2dfed8c95db7bb4ab880997067de5a5932272241b750b9f613b5b6bdca6761e0"

URI_x86_64_v2_perl-YAML-PP-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-YAML-PP-tests-0.38.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-YAML-PP-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-YAML-PP-tests}"
SRC_URI[x86_64_v2_perl-YAML-PP-tests.sha256sum] = "bdbbdd6aa09d5616a426a685b069c4deaabe73bf1c10b62f97a9137ad1745221"

URI_aarch64_perl-YAML-PP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-YAML-PP-0.38.0-2.el10_0.noarch.rpm;name=aarch64_perl-YAML-PP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-YAML-PP}"
SRC_URI[aarch64_perl-YAML-PP.sha256sum] = "6db986e35d2ddd240b8157bb93561268c06c647e24148c3ec41a5a3f8c5e6604"

URI_aarch64_perl-YAML-PP-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-YAML-PP-tests-0.38.0-2.el10_0.noarch.rpm;name=aarch64_perl-YAML-PP-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-YAML-PP-tests}"
SRC_URI[aarch64_perl-YAML-PP-tests.sha256sum] = "3f423dac539d7be252ddb89da2de5b1fcb61287b063d07ff1b78e4883d02273e"

RDEPENDS:perl-YAML-PP = " \
 perl-B \
 perl-Carp \
 perl-Cpanel-JSON-XS \
 perl-Data-Dumper \
 perl-Encode \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-HTML-Parser \
 perl-JSON-PP \
 perl-JSON-XS \
 perl-MIME-Base64 \
 perl-Module-Load \
 perl-Scalar-List-Utils \
 perl-Term-ANSIColor \
 perl-Tie \
 perl-Tie-IxHash \
 perl-YAML-PP \
 perl-base \
 perl-boolean \
 perl-constant \
 perl-experimental \
 perl-interpreter \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-YAML-PP-tests = " \
 bash \
 perl-B \
 perl-Data-Dumper \
 perl-Encode \
 perl-File-Basename \
 perl-FindBin \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test-Warn \
 perl-URI \
 perl-YAML-PP \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
