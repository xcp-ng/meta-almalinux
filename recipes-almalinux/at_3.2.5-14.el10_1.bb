# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "at"
PV = "3.2.5"
PR = "14.el10_1"
PACKAGES = " \
 at \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/at-3.2.5-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47bd008718dc13abbbf70c5f6cddb2563ef2dd17d66d54547904cd66c369a42b"

URI_x86_64_v2_at = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/at-3.2.5-14.el10_1.x86_64_v2.rpm;name=x86_64_v2_at;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_at}"
SRC_URI[x86_64_v2_at.sha256sum] = "f7985af05bf947fe0655629c558c1aeab1b19806099abf7c9c8818a8b951a420"

URI_aarch64_at = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/at-3.2.5-14.el10_1.aarch64.rpm;name=aarch64_at;unpack=0"
SRC_URI:append = " ${URI_aarch64_at}"
SRC_URI[aarch64_at.sha256sum] = "9558296b22ea78fd432f514698274ce4498f4fd5795cc41a3938be52217a13c8"

RDEPENDS:at = " \
 bash \
 glibc \
 libselinux \
 systemd \
 "
