# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syn2"
PV = "2.0.119"
PR = "1.el10_3"
PACKAGES = " \
 rust-syn2+clone-impls-devel \
 rust-syn2+default-devel \
 rust-syn2+derive-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+fold-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2+test-devel \
 rust-syn2+visit-devel \
 rust-syn2+visit-mut-devel \
 rust-syn2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syn2-2.0.119-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0499c8ed5ec5f166744cb61bea66958f5bf2b1bf181037ee5e6479136bf0707"

URI_x86_64_v2_rust-syn2+clone-impls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+clone-impls-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+clone-impls-devel}"
SRC_URI[x86_64_v2_rust-syn2+clone-impls-devel.sha256sum] = "687141d5fc6086c5f0bbd0a78d107142cc13c516fb5b0eaa817b4cf038daa2f3"

URI_x86_64_v2_rust-syn2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+default-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+default-devel}"
SRC_URI[x86_64_v2_rust-syn2+default-devel.sha256sum] = "3fc73f0ef437144f71b864db4241472ad62e6780b1ffc5d33581dcb0daef10e7"

URI_x86_64_v2_rust-syn2+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+derive-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+derive-devel}"
SRC_URI[x86_64_v2_rust-syn2+derive-devel.sha256sum] = "ef88ae81f2f61ee0f9a5c71a75800c203d3fa25237e16b668ea6c3260d6cc3d2"

URI_x86_64_v2_rust-syn2+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+extra-traits-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-syn2+extra-traits-devel.sha256sum] = "251a2bc785366c196797a9077e1e9586b4c703b4494a4ce2147972aa783809d3"

URI_x86_64_v2_rust-syn2+fold-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+fold-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+fold-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+fold-devel}"
SRC_URI[x86_64_v2_rust-syn2+fold-devel.sha256sum] = "f9e05c2a307d28a7600559c9e89c8acb08d9f26caed12a28cf72838d208fc162"

URI_x86_64_v2_rust-syn2+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+full-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+full-devel}"
SRC_URI[x86_64_v2_rust-syn2+full-devel.sha256sum] = "600c0445676b0be58e3a3dfbb06ee3ef34bb73df3b72adefd1b75a55f92f2d8a"

URI_x86_64_v2_rust-syn2+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+parsing-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+parsing-devel}"
SRC_URI[x86_64_v2_rust-syn2+parsing-devel.sha256sum] = "83549c6d09589b5e6321978faf444f4949cce67eb8952f568d921f42db28c474"
RPROVIDES:rust-syn2+parsing-devel:x86_64_v2 = "virtual/crate_syn/parsing__ge_1.0.0_with_crate_syn/parsing__lt_3.0.0~"

URI_x86_64_v2_rust-syn2+printing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+printing-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+printing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+printing-devel}"
SRC_URI[x86_64_v2_rust-syn2+printing-devel.sha256sum] = "d029090c1d4e8e7df8d3f23caf531440e55a6d7d4e02a5736083179d40dc0b0e"

URI_x86_64_v2_rust-syn2+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+proc-macro-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-syn2+proc-macro-devel.sha256sum] = "94d2bf29e4a7e5c6fb600598c9b4fcbcb4d15bd707a3762eebce25dfabd613e4"
RPROVIDES:rust-syn2+proc-macro-devel:x86_64_v2 = "virtual/crate_syn/proc-macro__ge_1.0.0_with_crate_syn/proc-macro__lt_3.0.0~"

URI_x86_64_v2_rust-syn2+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+test-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+test-devel}"
SRC_URI[x86_64_v2_rust-syn2+test-devel.sha256sum] = "9d00bb8ab87434da5ff6b4653790b1bf6ccf67009fe83cf4d0974ef7b30ef36a"

URI_x86_64_v2_rust-syn2+visit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+visit-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+visit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+visit-devel}"
SRC_URI[x86_64_v2_rust-syn2+visit-devel.sha256sum] = "4551eaf471077cf94b7e20d10e9740108bbc46bf2a3954891be7444a4df3dc81"

URI_x86_64_v2_rust-syn2+visit-mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2+visit-mut-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2+visit-mut-devel}"
SRC_URI[x86_64_v2_rust-syn2+visit-mut-devel.sha256sum] = "3027dd6d3120fdd9df3dfaf02e6d7a88ced2f414277189f5e92e521ad733dcda"

URI_x86_64_v2_rust-syn2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn2-devel-2.0.119-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn2-devel}"
SRC_URI[x86_64_v2_rust-syn2-devel.sha256sum] = "1f12993b765992363eac089f03e6afdc4b6f82fdccf8c6cbf7cebd2c622cc151"
RPROVIDES:rust-syn2-devel:x86_64_v2 = "virtual/crate_syn__ge_1.0.0_with_crate_syn__lt_3.0.0~"

URI_aarch64_rust-syn2+clone-impls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+clone-impls-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+clone-impls-devel}"
SRC_URI[aarch64_rust-syn2+clone-impls-devel.sha256sum] = "c3e4325ef687aae9e5501b233dd666e9504da485ebab4a096613dd023f165b71"

URI_aarch64_rust-syn2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+default-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+default-devel}"
SRC_URI[aarch64_rust-syn2+default-devel.sha256sum] = "07e8c36861e6fe9133c85a22b688e78e6a58c94b1355108d8731e0ef780f6d63"

URI_aarch64_rust-syn2+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+derive-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+derive-devel}"
SRC_URI[aarch64_rust-syn2+derive-devel.sha256sum] = "457e494a7e12eb4230f1c1c3980adfe7919af482962d85c4415a97c2295345cc"

URI_aarch64_rust-syn2+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+extra-traits-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+extra-traits-devel}"
SRC_URI[aarch64_rust-syn2+extra-traits-devel.sha256sum] = "d9efcdfcbdf7c99f1235ce10fc1776dac15df268ad87d283ba1a00399bf501ac"

URI_aarch64_rust-syn2+fold-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+fold-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+fold-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+fold-devel}"
SRC_URI[aarch64_rust-syn2+fold-devel.sha256sum] = "3bbb455e85b4e32380e0b158eb54ae756b08e65101f46c125089a354822ef5e7"

URI_aarch64_rust-syn2+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+full-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+full-devel}"
SRC_URI[aarch64_rust-syn2+full-devel.sha256sum] = "a90b8562d939833604ecd2985b74e4f8ed0d9bb3113f4fa7fdf3d742a3c1819b"

URI_aarch64_rust-syn2+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+parsing-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+parsing-devel}"
SRC_URI[aarch64_rust-syn2+parsing-devel.sha256sum] = "fa19e0b4bfaa2805bc6661666b3c8d1d7a474d99119b737b1eaef1a5d97e862e"
RPROVIDES:rust-syn2+parsing-devel:aarch64 = "virtual/crate_syn/parsing__ge_1.0.0_with_crate_syn/parsing__lt_3.0.0~"

URI_aarch64_rust-syn2+printing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+printing-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+printing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+printing-devel}"
SRC_URI[aarch64_rust-syn2+printing-devel.sha256sum] = "bdce7924df7c15e2e026416037e246790948294fafdf920c6190988a942fe05b"

URI_aarch64_rust-syn2+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+proc-macro-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+proc-macro-devel}"
SRC_URI[aarch64_rust-syn2+proc-macro-devel.sha256sum] = "bbef284d3503f73efd2791225bb1446757a225593786a91f7c9b145ec5d966a6"
RPROVIDES:rust-syn2+proc-macro-devel:aarch64 = "virtual/crate_syn/proc-macro__ge_1.0.0_with_crate_syn/proc-macro__lt_3.0.0~"

URI_aarch64_rust-syn2+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+test-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+test-devel}"
SRC_URI[aarch64_rust-syn2+test-devel.sha256sum] = "8f040e9e7e1fe4c6858177e745714ec25d34f0d45d53e9a17464eed6ae40ee88"

URI_aarch64_rust-syn2+visit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+visit-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+visit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+visit-devel}"
SRC_URI[aarch64_rust-syn2+visit-devel.sha256sum] = "ed3c050fd93b8056506a34b606f6a1aa790b34626862c9d58ebad76ec565ebcd"

URI_aarch64_rust-syn2+visit-mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2+visit-mut-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2+visit-mut-devel}"
SRC_URI[aarch64_rust-syn2+visit-mut-devel.sha256sum] = "73d93ffbc729fa3181b87dde4e06c1dc81f0121531bd7ed6d31aec1b2591290d"

URI_aarch64_rust-syn2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn2-devel-2.0.119-1.el10_3.noarch.rpm;name=aarch64_rust-syn2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn2-devel}"
SRC_URI[aarch64_rust-syn2-devel.sha256sum] = "7dd8b47c363b165ce7816a30297a79e1a53e0b315097e6bbd5fb9c978e97abe4"
RPROVIDES:rust-syn2-devel:aarch64 = "virtual/crate_syn__ge_1.0.0_with_crate_syn__lt_3.0.0~"

RDEPENDS:rust-syn2+clone-impls-devel = " \
 cargo \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+default-devel = " \
 cargo \
 rust-syn2+clone-impls-devel \
 rust-syn2+derive-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+derive-devel = " \
 cargo \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+extra-traits-devel = " \
 cargo \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+fold-devel = " \
 cargo \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+full-devel = " \
 cargo \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+parsing-devel = " \
 cargo \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+printing-devel = " \
 cargo \
 rust-quote-devel \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+test-devel = " \
 cargo \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+visit-devel = " \
 cargo \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2+visit-mut-devel = " \
 cargo \
 rust-syn2-devel \
 "
RDEPENDS:rust-syn2-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-unicode-ident+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_syn/parsing__ge_1.0.0_with_crate_syn/parsing__lt_3.0.0~ rpm/virtual/crate_syn/proc-macro__ge_1.0.0_with_crate_syn/proc-macro__lt_3.0.0~ rpm/virtual/crate_syn__ge_1.0.0_with_crate_syn__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_syn/parsing__ge_1.0.0_with_crate_syn/parsing__lt_3.0.0~ rpm/virtual/crate_syn/proc-macro__ge_1.0.0_with_crate_syn/proc-macro__lt_3.0.0~ rpm/virtual/crate_syn__ge_1.0.0_with_crate_syn__lt_3.0.0~"
