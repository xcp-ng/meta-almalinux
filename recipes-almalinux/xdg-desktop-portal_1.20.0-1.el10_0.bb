# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal"
PV = "1.20.0"
PR = "1.el10_0"
PACKAGES = " \
 xdg-desktop-portal \
 xdg-desktop-portal-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdg-desktop-portal-1.20.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c31e50da601497a175145e28b1e12561105d07cc966e9874aa211c08fc018011"

URI_x86_64_v2_xdg-desktop-portal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdg-desktop-portal-1.20.0-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal}"
SRC_URI[x86_64_v2_xdg-desktop-portal.sha256sum] = "0e70ccced87e218e25309b302ce2c95a399045096bdb4f0394a57e120dca5452"

URI_x86_64_v2_xdg-desktop-portal-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xdg-desktop-portal-devel-1.20.0-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal-devel}"
SRC_URI[x86_64_v2_xdg-desktop-portal-devel.sha256sum] = "e894c4254af16d356412eee61ad416471bba1ce38dd3804c0dbb1e49e92f9946"

URI_aarch64_xdg-desktop-portal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdg-desktop-portal-1.20.0-1.el10_0.aarch64.rpm;name=aarch64_xdg-desktop-portal;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal}"
SRC_URI[aarch64_xdg-desktop-portal.sha256sum] = "7ef24794a4cc29d0cedfe98fa2773bad54f21119dfc5acb25823cfb9b8e4aa13"

URI_aarch64_xdg-desktop-portal-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xdg-desktop-portal-devel-1.20.0-1.el10_0.aarch64.rpm;name=aarch64_xdg-desktop-portal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal-devel}"
SRC_URI[aarch64_xdg-desktop-portal-devel.sha256sum] = "69b522a9f0188b10f8b6d4f63272ab46c0b7fe6cc02c5083775eeb205b9dc6d9"

RDEPENDS:xdg-desktop-portal = " \
 bash \
 dbus \
 fuse3 \
 fuse3-libs \
 gdk-pixbuf2 \
 geoclue2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 json-glib \
 libdex \
 libgcc \
 libgudev \
 libportal \
 pipewire-libs \
 systemd-libs \
 "
RDEPENDS:xdg-desktop-portal-devel = " \
 pkgconf-pkg-config \
 xdg-desktop-portal \
 "
