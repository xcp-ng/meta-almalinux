# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anyhow"
PV = "1.0.99"
PR = "1.el10_0"
PACKAGES = " \
 rust-anyhow+backtrace-devel \
 rust-anyhow+default-devel \
 rust-anyhow+std-devel \
 rust-anyhow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anyhow-1.0.99-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b9f2dc29023514b8c0a7e18338b40e823dfba96f141ad84a642a29b830cb744"

URI_x86_64_v2_rust-anyhow+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+backtrace-devel-1.0.99-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+backtrace-devel}"
SRC_URI[x86_64_v2_rust-anyhow+backtrace-devel.sha256sum] = "222c40e45d6229fd0155f93d86b35c91244a5f74bcca0126c14ffe5647575b13"

URI_x86_64_v2_rust-anyhow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+default-devel-1.0.99-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+default-devel}"
SRC_URI[x86_64_v2_rust-anyhow+default-devel.sha256sum] = "82dcbc46eaebf387840e0246df145608314d4c02bbb50d8a6bd0605327ea074d"

URI_x86_64_v2_rust-anyhow+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow+std-devel-1.0.99-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow+std-devel}"
SRC_URI[x86_64_v2_rust-anyhow+std-devel.sha256sum] = "5f6da5bdb32bb1a5709e3bbeac390ad970642358499de62deef2db8c1f010ab8"

URI_x86_64_v2_rust-anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anyhow-devel-1.0.99-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anyhow-devel}"
SRC_URI[x86_64_v2_rust-anyhow-devel.sha256sum] = "4ec7e8a26a66c5b19b37a7c7255fcf8a5376ca0389de15967117872f49bd9147"

URI_aarch64_rust-anyhow+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+backtrace-devel-1.0.99-1.el10_0.noarch.rpm;name=aarch64_rust-anyhow+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+backtrace-devel}"
SRC_URI[aarch64_rust-anyhow+backtrace-devel.sha256sum] = "50c42ecb93feefad9d63195e3e1f7d972322aae8779a53730b536e81e6ff59c1"

URI_aarch64_rust-anyhow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+default-devel-1.0.99-1.el10_0.noarch.rpm;name=aarch64_rust-anyhow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+default-devel}"
SRC_URI[aarch64_rust-anyhow+default-devel.sha256sum] = "ad8bdb5ae797ca16d15c628f645e48c19096475dcece7affe7349493570baca7"

URI_aarch64_rust-anyhow+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow+std-devel-1.0.99-1.el10_0.noarch.rpm;name=aarch64_rust-anyhow+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow+std-devel}"
SRC_URI[aarch64_rust-anyhow+std-devel.sha256sum] = "e0655eef73bdb2c0eb27e04d9ed7dd079baa143cd7a62209b2ef294b31f143ea"

URI_aarch64_rust-anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anyhow-devel-1.0.99-1.el10_0.noarch.rpm;name=aarch64_rust-anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anyhow-devel}"
SRC_URI[aarch64_rust-anyhow-devel.sha256sum] = "f9537f5abb7220e40ddb683ab12e570a510ffe864c4ffd2bc2b4b6e58914b8c1"

RDEPENDS:rust-anyhow+backtrace-devel = " \
 cargo \
 rust-anyhow-devel \
 rust-backtrace+default-devel \
 "
RDEPENDS:rust-anyhow+default-devel = " \
 cargo \
 rust-anyhow+std-devel \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow+std-devel = " \
 cargo \
 rust-anyhow-devel \
 "
RDEPENDS:rust-anyhow-devel = " \
 cargo \
 rust \
 "
