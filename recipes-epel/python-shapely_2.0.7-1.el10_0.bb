# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-shapely"
PV = "2.0.7"
PR = "1.el10_0"
PACKAGES = " \
 python3-shapely \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-shapely-2.0.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43cae6a4c8f2dc2b8178b506b1fbe9fa6326f94941bc227361e21434b55fcf50"

URI_x86_64_v2_python3-shapely = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shapely-2.0.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-shapely;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shapely}"
SRC_URI[x86_64_v2_python3-shapely.sha256sum] = "9d94334fda6c7a9998f3d5fca276f8bf348ee60aeb2bdb9e923f11405bd08591"

URI_aarch64_python3-shapely = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shapely-2.0.7-1.el10_0.aarch64.rpm;name=aarch64_python3-shapely;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shapely}"
SRC_URI[aarch64_python3-shapely.sha256sum] = "8bdc4be65d7083b0c3cd90dc55e8e745ffc3fbca52412e9a4117c74903488aa0"

RDEPENDS:python3-shapely = " \
 geos \
 glibc \
 python3 \
 python3-numpy \
 "
