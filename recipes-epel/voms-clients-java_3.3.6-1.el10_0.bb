# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms-clients-java"
PV = "3.3.6"
PR = "1.el10_0"
PACKAGES = " \
 voms-clients-java \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/voms-clients-java-3.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f60035bb9b9be1219f02e14f52b27db512a1fb491bab9a8690d39b683713de2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-clients-java-3.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_voms-clients-java;unpack=0"
SRC_URI[x86_64_v2_voms-clients-java.sha256sum] = "9f10b70ee62679a8416d0e3a9aa8308db35ce8ba9f3dbf12a9fee5549c55ae21"
RPROVIDES:voms-clients-java:append:x86_64_v2 = " virtual/voms-clients"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/voms-clients-java-3.3.6-1.el10_0.noarch.rpm;name=aarch64_voms-clients-java;unpack=0"
SRC_URI[aarch64_voms-clients-java.sha256sum] = "6e9b789a84cdfd9acb72f4bae2983b7c71c12ca3cad30f137218e32e24c3b715"
RPROVIDES:voms-clients-java:append:aarch64 = " virtual/voms-clients"

RDEPENDS:voms-clients-java = " \
 alternatives \
 apache-commons-cli \
 apache-commons-io \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 virtual/java-headless_or_java-21-headless_or_java-25-headless \
 voms-api-java \
 "
