# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audex"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 audex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audex-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcb99c3be50854be79ba09f3ee0c9bcba52fde4b0cfa99d2365592d9eb7b0bfa"

URI_x86_64_v2_audex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audex-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audex}"
SRC_URI[x86_64_v2_audex.sha256sum] = "e56a8c3ec6dbbb25f8578915520565b20008294a4ebce10a83342627d802d04e"

URI_aarch64_audex = "${EPEL_MIRROR}/aarch64/Packages/a/audex-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_audex;unpack=0"
SRC_URI:append = " ${URI_aarch64_audex}"
SRC_URI[aarch64_audex.sha256sum] = "0dc761a46c9a88f9e636d30a9f5e3f7291d852757be97463800463943bb6e043"

RDEPENDS:audex = " \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 libcdio-paranoia \
 libkcddb \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
