# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmap"
PE = "4"
PV = "7.92"
PR = "3.el10"
PACKAGES = " \
 nmap \
 nmap-ncat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nmap-7.92-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdb8ca312fc01dc7725052b07ad6a4878f8bfb5eca5f57e074afe8e4675013bd"

URI_x86_64_v2_nmap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmap-7.92-3.el10.x86_64_v2.rpm;name=x86_64_v2_nmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmap}"
SRC_URI[x86_64_v2_nmap.sha256sum] = "fd97791c7649fd653dc9efea32d613c8812fca14a83a4e3db61eaffb3088c131"

URI_x86_64_v2_nmap-ncat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nmap-ncat-7.92-3.el10.x86_64_v2.rpm;name=x86_64_v2_nmap-ncat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmap-ncat}"
SRC_URI[x86_64_v2_nmap-ncat.sha256sum] = "ad37c70343c41c630dca441f226e38ac7ea0f7e774f241d85c58811a685da963"

URI_aarch64_nmap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmap-7.92-3.el10.aarch64.rpm;name=aarch64_nmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmap}"
SRC_URI[aarch64_nmap.sha256sum] = "305cbceb9104a1b20fdcd629d1dca75f37bf2b6b26037a7db6f35e64f4ea8887"

URI_aarch64_nmap-ncat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nmap-ncat-7.92-3.el10.aarch64.rpm;name=aarch64_nmap-ncat;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmap-ncat}"
SRC_URI[aarch64_nmap-ncat.sha256sum] = "1574c4ab0d8fbdf31485da1a8b19593814c905b4a8d3eec399dc5d9c22dd2f78"

RDEPENDS:nmap = " \
 glibc \
 libgcc \
 libpcap \
 libstdc++ \
 nmap-ncat \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:nmap-ncat = " \
 alternatives \
 bash \
 glibc \
 libpcap \
 openssl-libs \
 "
