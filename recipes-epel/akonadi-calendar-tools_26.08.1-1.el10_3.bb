# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar-tools"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-calendar-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-tools-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ee538d19c4e88510f5c459b8b2f9c6674f7e37c38cc8d4ecd6fa3124a5aef0f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-tools-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-tools;unpack=0"
SRC_URI[x86_64_v2_akonadi-calendar-tools.sha256sum] = "da0e64b9d027a044f4d952c0cbe821917675df448bf84ec7a27c1e77d98db02e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-tools-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadi-calendar-tools;unpack=0"
SRC_URI[aarch64_akonadi-calendar-tools.sha256sum] = "ee52c15bc27bb7e8518a9e2f045a1415a3daf3b02dcd868d97a27d9e9ca45ec2"

RDEPENDS:akonadi-calendar-tools = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kf6-kcalendarcore \
 kf6-kcoreaddons \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
