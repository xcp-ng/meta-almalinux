# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossterm0.27"
PV = "0.27.0"
PR = "3.el10_1"
PACKAGES = " \
 rust-crossterm0.27+bracketed-paste-devel \
 rust-crossterm0.27+default-devel \
 rust-crossterm0.27+event-stream-devel \
 rust-crossterm0.27+events-devel \
 rust-crossterm0.27+filedescriptor-devel \
 rust-crossterm0.27+serde-devel \
 rust-crossterm0.27+use-dev-tty-devel \
 rust-crossterm0.27-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossterm0.27-0.27.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66da0f4300a073dfba96fb8e5ce6922b47f49393dd67128c0dea956caf534a77"

URI_x86_64_v2_rust-crossterm0.27+bracketed-paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.27+bracketed-paste-devel-0.27.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.27+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.27+bracketed-paste-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.27+bracketed-paste-devel.sha256sum] = "43dbb24b3e840b0e03ad9ce9968928cb30052f1a1c2b07d873601b54a6465cfd"

URI_x86_64_v2_rust-crossterm0.27+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.27+default-devel-0.27.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.27+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.27+default-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.27+default-devel.sha256sum] = "3ffd63fd6b4566cd33c0a3625a29982dfa1cf1386c53b302e5ce7ac85e42bd01"

URI_x86_64_v2_rust-crossterm0.27+event-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.27+event-stream-devel-0.27.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.27+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.27+event-stream-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.27+event-stream-devel.sha256sum] = "937ef662bdc07135f2d4616fa4811bacd8d3d71fdc87fc123903bd0f185b9027"

URI_x86_64_v2_rust-crossterm0.27+events-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.27+events-devel-0.27.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.27+events-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.27+events-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.27+events-devel.sha256sum] = "dcc2816ba9eba3c189642b4c2ca13595706e50ad2dcab0401185c16ef0337ec3"

URI_x86_64_v2_rust-crossterm0.27+filedescriptor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.27+filedescriptor-devel-0.27.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.27+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.27+filedescriptor-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.27+filedescriptor-devel.sha256sum] = "6daf303354e4a2e8e85d543775da9696815c8f98e3fc9f30a487621cfc01a14d"

URI_x86_64_v2_rust-crossterm0.27+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.27+serde-devel-0.27.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.27+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.27+serde-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.27+serde-devel.sha256sum] = "5ea72a7c0caa61d0607fdee57f0a5ad5f87ab2c776114ffc306b172f359424b1"

URI_x86_64_v2_rust-crossterm0.27+use-dev-tty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.27+use-dev-tty-devel-0.27.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.27+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.27+use-dev-tty-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.27+use-dev-tty-devel.sha256sum] = "c44eac4b1558f5a978d950913435ed2006f262463aa3463ca0c9144ddf4da7e8"

URI_x86_64_v2_rust-crossterm0.27-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.27-devel-0.27.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.27-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.27-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.27-devel.sha256sum] = "8d5b9003871bd3ee8d1a11a8988960fabf5f2030d2804594125ca6b9dd0322df"

URI_aarch64_rust-crossterm0.27+bracketed-paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.27+bracketed-paste-devel-0.27.0-3.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.27+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.27+bracketed-paste-devel}"
SRC_URI[aarch64_rust-crossterm0.27+bracketed-paste-devel.sha256sum] = "336b7a5db25f9c0017c07615a6238217e7049eb60f1c0634f0fa611487d9791c"

URI_aarch64_rust-crossterm0.27+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.27+default-devel-0.27.0-3.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.27+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.27+default-devel}"
SRC_URI[aarch64_rust-crossterm0.27+default-devel.sha256sum] = "b28e8baab403ef9dd19f6ccf43b832e501d8151336388eafbaf64aa3fab5423e"

URI_aarch64_rust-crossterm0.27+event-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.27+event-stream-devel-0.27.0-3.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.27+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.27+event-stream-devel}"
SRC_URI[aarch64_rust-crossterm0.27+event-stream-devel.sha256sum] = "6a439a7d42f87c20b5ddef321f42944c71cf018eef1a1276082c330c2006dfc2"

URI_aarch64_rust-crossterm0.27+events-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.27+events-devel-0.27.0-3.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.27+events-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.27+events-devel}"
SRC_URI[aarch64_rust-crossterm0.27+events-devel.sha256sum] = "7c6a1dd94668c8cdb1590755b711bfad9556e9f01d79c8b9d0dfab0ff024bc05"

URI_aarch64_rust-crossterm0.27+filedescriptor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.27+filedescriptor-devel-0.27.0-3.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.27+filedescriptor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.27+filedescriptor-devel}"
SRC_URI[aarch64_rust-crossterm0.27+filedescriptor-devel.sha256sum] = "1ccbdd475ca10b053f1a08354e5e5451d3c8a453d8482721dde0651778b39d60"

URI_aarch64_rust-crossterm0.27+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.27+serde-devel-0.27.0-3.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.27+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.27+serde-devel}"
SRC_URI[aarch64_rust-crossterm0.27+serde-devel.sha256sum] = "0818a90697f8bb71c3feae7318ddc3d2c3fd8954d0b3cc24fa96e0c28417b3bb"

URI_aarch64_rust-crossterm0.27+use-dev-tty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.27+use-dev-tty-devel-0.27.0-3.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.27+use-dev-tty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.27+use-dev-tty-devel}"
SRC_URI[aarch64_rust-crossterm0.27+use-dev-tty-devel.sha256sum] = "ccdaf162f1fe545e478b0c1de8de177a852520a25b8a670f62864befde7d6de7"

URI_aarch64_rust-crossterm0.27-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.27-devel-0.27.0-3.el10_1.noarch.rpm;name=aarch64_rust-crossterm0.27-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.27-devel}"
SRC_URI[aarch64_rust-crossterm0.27-devel.sha256sum] = "a70eed8a5507946ee20798aaf1297e671c262ce70173e6a5c67d4aadc339b36e"

RDEPENDS:rust-crossterm0.27+bracketed-paste-devel = " \
 cargo \
 rust-crossterm0.27-devel \
 "
RDEPENDS:rust-crossterm0.27+default-devel = " \
 cargo \
 rust-crossterm0.27+bracketed-paste-devel \
 rust-crossterm0.27+events-devel \
 rust-crossterm0.27-devel \
 "
RDEPENDS:rust-crossterm0.27+event-stream-devel = " \
 cargo \
 rust-crossterm0.27+events-devel \
 rust-crossterm0.27-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-crossterm0.27+events-devel = " \
 cargo \
 rust-crossterm0.27-devel \
 rust-mio0.8+default-devel \
 rust-mio0.8+os-poll-devel \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+support-v0_8-devel \
 rust-signal-hook0.3+default-devel \
 "
RDEPENDS:rust-crossterm0.27+filedescriptor-devel = " \
 cargo \
 rust-crossterm0.27-devel \
 rust-filedescriptor+default-devel \
 "
RDEPENDS:rust-crossterm0.27+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-crossterm0.27-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-crossterm0.27+use-dev-tty-devel = " \
 cargo \
 rust-crossterm0.27+filedescriptor-devel \
 rust-crossterm0.27-devel \
 "
RDEPENDS:rust-crossterm0.27-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 rust-parking_lot+default-devel \
 "
