# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "greenboot-rs"
PV = "0.16.3"
PR = "0.el10"
PACKAGES = " \
 greenboot \
 greenboot-default-health-checks \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/greenboot-rs-0.16.3-0.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1828508524a5274b3b17e7919866af1cd5ec7294197938083c5c17e57b40693f"

URI_x86_64_v2_greenboot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-0.16.3-0.el10.x86_64_v2.rpm;name=x86_64_v2_greenboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_greenboot}"
SRC_URI[x86_64_v2_greenboot.sha256sum] = "4f2d59aadc9ed09afb8bed7000179a47f41ca93a17a5219a919d3c9c536f6adc"

URI_x86_64_v2_greenboot-default-health-checks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-default-health-checks-0.16.3-0.el10.x86_64_v2.rpm;name=x86_64_v2_greenboot-default-health-checks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_greenboot-default-health-checks}"
SRC_URI[x86_64_v2_greenboot-default-health-checks.sha256sum] = "e221e6ff3f686c4c2df9d8d7c87f3145a15ee6d318b91990b2a7d9e79100a3fb"

URI_aarch64_greenboot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-0.16.3-0.el10.aarch64.rpm;name=aarch64_greenboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_greenboot}"
SRC_URI[aarch64_greenboot.sha256sum] = "c53905c796b3ed7e2fdd6063a82038f3b1ba1e8d57967b8a438cc6e2fe5b6446"

URI_aarch64_greenboot-default-health-checks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-default-health-checks-0.16.3-0.el10.aarch64.rpm;name=aarch64_greenboot-default-health-checks;unpack=0"
SRC_URI:append = " ${URI_aarch64_greenboot-default-health-checks}"
SRC_URI[aarch64_greenboot-default-health-checks.sha256sum] = "96d779c24fdfef9a47f381a1a78aba23e782ee4f3e4eba24f58bb9db4767852d"

RDEPENDS:greenboot = " \
 bash \
 glibc \
 libgcc \
 pam \
 rpm-ostree \
 systemd \
 "
RDEPENDS:greenboot-default-health-checks = " \
 bash \
 greenboot \
 jq \
 util-linux \
 "
