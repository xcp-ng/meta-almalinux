# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xeve"
PV = "0.5.1"
PR = "5.el10_1"
PACKAGES = " \
 xeve \
 xeve-devel \
 xeve-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xeve-0.5.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "078866a86eb53570c6231de474ecb352f0aed35044c818d41e5827349a4dd97c"

URI_x86_64_v2_xeve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeve-0.5.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeve}"
SRC_URI[x86_64_v2_xeve.sha256sum] = "71d8f0fecdba56b5d393b0144820dd23d233ddf56ee68a0c18a67b20b7c12ac3"

URI_x86_64_v2_xeve-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeve-devel-0.5.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeve-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeve-devel}"
SRC_URI[x86_64_v2_xeve-devel.sha256sum] = "c6d46d57ece115e87c7f054eb0dc9c1c86f4ebb1766356999098363a850ebbbe"

URI_x86_64_v2_xeve-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xeve-libs-0.5.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xeve-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xeve-libs}"
SRC_URI[x86_64_v2_xeve-libs.sha256sum] = "7ec5c8f4c191d71d94bebf09f6b1953c899e660bd3d7b9419d7de06f8dbe0311"

URI_aarch64_xeve = "${EPEL_MIRROR}/aarch64/Packages/x/xeve-0.5.1-5.el10_1.aarch64.rpm;name=aarch64_xeve;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeve}"
SRC_URI[aarch64_xeve.sha256sum] = "6c21456165d87548cb894be683450f2ae4667f3015cf49f47d6740874076fd9a"

URI_aarch64_xeve-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xeve-devel-0.5.1-5.el10_1.aarch64.rpm;name=aarch64_xeve-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeve-devel}"
SRC_URI[aarch64_xeve-devel.sha256sum] = "2977f5c881d7e0c5e688f36fc0357904ee1cb141f6341be0aa0ddec7abbd724f"

URI_aarch64_xeve-libs = "${EPEL_MIRROR}/aarch64/Packages/x/xeve-libs-0.5.1-5.el10_1.aarch64.rpm;name=aarch64_xeve-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xeve-libs}"
SRC_URI[aarch64_xeve-libs.sha256sum] = "81d514de397d9f5f3f3c3ea46011d862122793fcb5f90fa82cd06328af2cdee1"

RDEPENDS:xeve = " \
 glibc \
 xeve-libs \
 "
RDEPENDS:xeve-devel = " \
 pkgconf-pkg-config \
 xeve-libs \
 "
RDEPENDS:xeve-libs = " \
 glibc \
 "
