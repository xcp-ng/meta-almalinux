# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "atkmm"
PV = "2.28.4"
PR = "4.el10_1"
PACKAGES = " \
 atkmm \
 atkmm-devel \
 atkmm-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/atkmm-2.28.4-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54021da13bdaceffaf7aeb6b943c70b1c56ffc58e4b23f090b05e5ea5665baa6"

URI_x86_64_v2_atkmm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atkmm-2.28.4-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atkmm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atkmm}"
SRC_URI[x86_64_v2_atkmm.sha256sum] = "dcb69a27abf440af7da24339b5e6bcce395891341d3f739ff77b1b29c78ed9e2"

URI_x86_64_v2_atkmm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atkmm-devel-2.28.4-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atkmm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atkmm-devel}"
SRC_URI[x86_64_v2_atkmm-devel.sha256sum] = "d7c0dc64c0c2283274b4c9832899fdf5a9a01c2a98e3382e630d2df76037024e"

URI_x86_64_v2_atkmm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atkmm-doc-2.28.4-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_atkmm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atkmm-doc}"
SRC_URI[x86_64_v2_atkmm-doc.sha256sum] = "a28a29a751a848ad2d88e704c3dfe557624e4053594601e58b2594d6a4d77a5d"

URI_aarch64_atkmm = "${EPEL_MIRROR}/aarch64/Packages/a/atkmm-2.28.4-4.el10_1.aarch64.rpm;name=aarch64_atkmm;unpack=0"
SRC_URI:append = " ${URI_aarch64_atkmm}"
SRC_URI[aarch64_atkmm.sha256sum] = "edc64fbd7d158ca237742d160bd39f4f2f9823661eacc2ebd5c279d8336cf01f"

URI_aarch64_atkmm-devel = "${EPEL_MIRROR}/aarch64/Packages/a/atkmm-devel-2.28.4-4.el10_1.aarch64.rpm;name=aarch64_atkmm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_atkmm-devel}"
SRC_URI[aarch64_atkmm-devel.sha256sum] = "63b22f1fc214bd6f13945ad5f16ae76517186461c528edcf14782b7e4f232ebd"

URI_aarch64_atkmm-doc = "${EPEL_MIRROR}/aarch64/Packages/a/atkmm-doc-2.28.4-4.el10_1.noarch.rpm;name=aarch64_atkmm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_atkmm-doc}"
SRC_URI[aarch64_atkmm-doc.sha256sum] = "86c360e5c34e95adedd72a7faef2cac32e6f1f43032f400e1053e1cbf3de6f7f"

RDEPENDS:atkmm = " \
 atk \
 glib2 \
 glibc \
 glibmm2.4 \
 libgcc \
 libsigc++20 \
 libstdc++ \
 "
RDEPENDS:atkmm-devel = " \
 atk-devel \
 atkmm \
 glibmm2.4-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:atkmm-doc = " \
 atkmm \
 glibmm2.4-doc \
 "
