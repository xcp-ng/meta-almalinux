# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grout"
PV = "0.14.2"
PR = "1.el10_2"
PACKAGES = " \
 grout \
 grout-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grout-0.14.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24b866e7dd596641dfae489d216c11373157a295aedffe1be3f0c12674afc7ff"

URI_x86_64_v2_grout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grout-0.14.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grout}"
SRC_URI[x86_64_v2_grout.sha256sum] = "d523f64a4477018b57e8a3073c0c1dd855ebb5be6290fecc9c1fe7d08e445fe9"

URI_x86_64_v2_grout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grout-devel-0.14.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grout-devel}"
SRC_URI[x86_64_v2_grout-devel.sha256sum] = "920af2e852871222539fcb42b8e448135951ee676a28d8c74795de605f11ac2e"

URI_aarch64_grout = "${EPEL_MIRROR}/aarch64/Packages/g/grout-0.14.2-1.el10_2.aarch64.rpm;name=aarch64_grout;unpack=0"
SRC_URI:append = " ${URI_aarch64_grout}"
SRC_URI[aarch64_grout.sha256sum] = "3508694e8e6b76fee449cee6d5d5d1b377f007e4fd87006947ab6750a8387805"

URI_aarch64_grout-devel = "${EPEL_MIRROR}/aarch64/Packages/g/grout-devel-0.14.2-1.el10_2.aarch64.rpm;name=aarch64_grout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_grout-devel}"
SRC_URI[aarch64_grout-devel.sha256sum] = "dd7c75ec1034b1b363102170b223ac780cb9d749d378d3fa092c3811bb64f31b"

RDEPENDS:grout = " \
 bash \
 glibc \
 libarchive \
 libecoli \
 libevent \
 libgcc \
 libibverbs \
 libmnl \
 libsmartcols \
 numactl-libs \
 "
RDEPENDS:grout-devel = " \
 grout \
 "
