# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-mobipocket"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdegraphics-mobipocket \
 kdegraphics-mobipocket-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-mobipocket-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46493672dedc6b1b88b54e14d5d9a58a0df9b045d90d77f558f64841a0503b91"

URI_x86_64_v2_kdegraphics-mobipocket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-mobipocket}"
SRC_URI[x86_64_v2_kdegraphics-mobipocket.sha256sum] = "1762479dfbf03f7cb92a65212f8fbc5178465b23c68b6ac20e336117ea421236"

URI_x86_64_v2_kdegraphics-mobipocket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-mobipocket-devel}"
SRC_URI[x86_64_v2_kdegraphics-mobipocket-devel.sha256sum] = "c4c768b06486f125fc65751d50ff6c2bef1c6157f9a9b834c73fa1f188d88466"

URI_aarch64_kdegraphics-mobipocket = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdegraphics-mobipocket;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-mobipocket}"
SRC_URI[aarch64_kdegraphics-mobipocket.sha256sum] = "c5d8083809cc4ca46d26390d525caae1e4031f36b605b99277d85e8d1574c4b3"

URI_aarch64_kdegraphics-mobipocket-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-mobipocket-devel}"
SRC_URI[aarch64_kdegraphics-mobipocket-devel.sha256sum] = "506b7eca918a9957dd19806fe3c4ce0505e44b3809bf164b706052088fafebe0"

RDEPENDS:kdegraphics-mobipocket = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdegraphics-mobipocket-devel = " \
 cmake-filesystem \
 kdegraphics-mobipocket \
 "
