# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iscsi-initiator-utils"
PV = "6.2.1.11"
PR = "4.git4b3e853.el10"
PACKAGES = " \
 iscsi-initiator-utils \
 iscsi-initiator-utils-iscsiuio \
 python3-iscsi-initiator-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iscsi-initiator-utils-6.2.1.11-4.git4b3e853.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bd0483280f34eb865d848bf18faeff4fecb7667be1333893b51c1c30db839032"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-6.2.1.11-4.git4b3e853.el10.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils;unpack=0"
SRC_URI[x86_64_v2_iscsi-initiator-utils.sha256sum] = "3f152ea6846741beca4243942a714540617e9fab7fb4947b5e3ca8ef35c6fed5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.11-4.git4b3e853.el10.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI[x86_64_v2_iscsi-initiator-utils-iscsiuio.sha256sum] = "7c310dba49e68cb0cbe22c1f03a731da6b29af1c3d03143ff718051c8cd63cdd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-iscsi-initiator-utils-6.2.1.11-4.git4b3e853.el10.x86_64_v2.rpm;name=x86_64_v2_python3-iscsi-initiator-utils;unpack=0"
SRC_URI[x86_64_v2_python3-iscsi-initiator-utils.sha256sum] = "8da821964d974d7c59ab8b7fecf96058daf828dbbb76c962b89822dac25893fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-6.2.1.11-4.git4b3e853.el10.aarch64.rpm;name=aarch64_iscsi-initiator-utils;unpack=0"
SRC_URI[aarch64_iscsi-initiator-utils.sha256sum] = "7582cc7a6983dfad9429cb87fe1389390b264bca4929b7f92776b23fc1b2d55d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.11-4.git4b3e853.el10.aarch64.rpm;name=aarch64_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI[aarch64_iscsi-initiator-utils-iscsiuio.sha256sum] = "23c76016ee8f1c7be8c56ae7d80262f8d05be32586b68a536cf2c54809761922"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-iscsi-initiator-utils-6.2.1.11-4.git4b3e853.el10.aarch64.rpm;name=aarch64_python3-iscsi-initiator-utils;unpack=0"
SRC_URI[aarch64_python3-iscsi-initiator-utils.sha256sum] = "4026607bfe1f2b15ae200b2638a2181f1f4765d1dcb1a6a0b1a5dd438ce3c160"

RDEPENDS:iscsi-initiator-utils = " \
 bash \
 glibc \
 iscsi-initiator-utils-iscsiuio \
 isns-utils-libs \
 kmod-libs \
 libmount \
 openssl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:iscsi-initiator-utils-iscsiuio = " \
 bash \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 systemd-libs \
 "
RDEPENDS:python3-iscsi-initiator-utils = " \
 glibc \
 iscsi-initiator-utils \
 python3 \
 "
