# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pathable"
PV = "0.4.4"
PR = "5.el10_1"
PACKAGES = " \
 python3-pathable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pathable-0.4.4-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58c0af9a137c8442362df0c20835fdec496f0030c0e3f4ac6b11b906d44c0142"

URI_x86_64_v2_python3-pathable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pathable-0.4.4-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pathable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pathable}"
SRC_URI[x86_64_v2_python3-pathable.sha256sum] = "4492fa15a472a34587f59042c7d17284000bfcc0eda2103f6ed18448105bef95"

URI_aarch64_python3-pathable = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pathable-0.4.4-5.el10_1.noarch.rpm;name=aarch64_python3-pathable;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pathable}"
SRC_URI[aarch64_python3-pathable.sha256sum] = "951c37fe184c549378111ae6e7a22187a7b834edc76a7767359c4dda6fa9a41b"

RDEPENDS:python3-pathable = " \
 python3 \
 "
