# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-cmt-cat"
PV = "26.03"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 intel-cmt-cat \
 intel-cmt-cat-devel \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/intel-cmt-cat-26.03-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52c4955120df2497a479e0da8c65b04726cf97035d139c0cc01eca05b8d7765f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/intel-cmt-cat-26.03-2.el10.x86_64_v2.rpm;name=x86_64_v2_intel-cmt-cat;unpack=0"
SRC_URI[x86_64_v2_intel-cmt-cat.sha256sum] = "d505bb19437aa6d22d78533bf915c95befa715f96b31621f468b996243b0ceeb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/intel-cmt-cat-devel-26.03-2.el10.x86_64_v2.rpm;name=x86_64_v2_intel-cmt-cat-devel;unpack=0"
SRC_URI[x86_64_v2_intel-cmt-cat-devel.sha256sum] = "fc1bce0f1b177ba020e4889d8035ed9d1b2324e2e9961fd3c085328cc7388193"

RDEPENDS:intel-cmt-cat = " \
 bash \
 glibc \
 "
RDEPENDS:intel-cmt-cat-devel = " \
 intel-cmt-cat \
 "
