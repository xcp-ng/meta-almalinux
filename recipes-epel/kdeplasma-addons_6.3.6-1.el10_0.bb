# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdeplasma-addons"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kate-krunner-plugin \
 kdeplasma-addons \
 kdeplasma-addons-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdeplasma-addons-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b3febe531091d8556305d86bc81b9d3362c68943fa22700df8e1781b780b664a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kate-krunner-plugin-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kate-krunner-plugin;unpack=0"
SRC_URI[x86_64_v2_kate-krunner-plugin.sha256sum] = "ce60abd766f04c9c7304887f3c7e6d4279ebcd35db9033b7fc148d7d45c382ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons;unpack=0"
SRC_URI[x86_64_v2_kdeplasma-addons.sha256sum] = "86c28dcfe16749b01a751d14ec9d733e822a309d07cade2b86bf039fa83074b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdeplasma-addons-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdeplasma-addons-devel;unpack=0"
SRC_URI[x86_64_v2_kdeplasma-addons-devel.sha256sum] = "89163033cb853bd28c6ec260ec5ef71cf4c5f3894f7b3fa6bcfdb2a20d31fdbe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kate-krunner-plugin-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kate-krunner-plugin;unpack=0"
SRC_URI[aarch64_kate-krunner-plugin.sha256sum] = "2b865eded623be9b4f9797ba12b5918a94c84b115b0efafdd0776e9aa879e3d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kdeplasma-addons;unpack=0"
SRC_URI[aarch64_kdeplasma-addons.sha256sum] = "6802c926fe5d8f1dfc2329e359486a95d77e1d64eeed124d3beb7c945efdca40"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdeplasma-addons-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kdeplasma-addons-devel;unpack=0"
SRC_URI[aarch64_kdeplasma-addons-devel.sha256sum] = "c08a114d6e3ddf186706fd4c39f8a4ad4eba3b274575168d6fa1f380cea6595d"

RDEPENDS:kate-krunner-plugin = " \
 glibc \
 kate \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-krunner \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kdeplasma-addons = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-kunitconversion \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libicu \
 libplasma \
 libstdc++ \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 qt6-qtwebengine \
 "
RDEPENDS:kdeplasma-addons-devel = " \
 cmake-filesystem \
 kdeplasma-addons \
 kf6-kcoreaddons-devel \
 qt6-qtbase-devel \
 "
