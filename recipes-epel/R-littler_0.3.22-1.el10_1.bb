# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-littler"
PV = "0.3.22"
PR = "1.el10_1"
PACKAGES = " \
 R-littler \
 R-littler-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-littler-0.3.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "103de532750bea2c2957a4fa1ebf87bb1bb32bc0defc73f689879329c5a59577"

URI_x86_64_v2_R-littler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-littler-0.3.22-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-littler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-littler}"
SRC_URI[x86_64_v2_R-littler.sha256sum] = "ffaef3456c57439e3db32fa218d2dfc132598473a857a7c8dc05dba663b22378"

URI_x86_64_v2_R-littler-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-littler-examples-0.3.22-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-littler-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-littler-examples}"
SRC_URI[x86_64_v2_R-littler-examples.sha256sum] = "63c24d0388021e106a0c7aec31b6b9d1360419d4e0df70c6e7cccfef548fb14c"

URI_aarch64_R-littler = "${EPEL_MIRROR}/aarch64/Packages/r/R-littler-0.3.22-1.el10_1.aarch64.rpm;name=aarch64_R-littler;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-littler}"
SRC_URI[aarch64_R-littler.sha256sum] = "a4e687c3fa923fa333e32f737f077ae9d9fa40dcfa59b0be7b0436df3a6893b4"

URI_aarch64_R-littler-examples = "${EPEL_MIRROR}/aarch64/Packages/r/R-littler-examples-0.3.22-1.el10_1.aarch64.rpm;name=aarch64_R-littler-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-littler-examples}"
SRC_URI[aarch64_R-littler-examples.sha256sum] = "c91ba3154a683c0d8caaf552784781ffe316c685c58b6a364c06b551679b91bf"

RDEPENDS:R-littler = " \
 R-core \
 glibc \
 "
RDEPENDS:R-littler-examples = " \
 R-littler \
 "
