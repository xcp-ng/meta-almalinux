# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-oxygen"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 oxygen-cursor-themes \
 plasma-oxygen \
 plasma-oxygen-qt6 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-oxygen-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1501fc82eb45b323503e3a2fd845c5e723ffb3be58654bda126ec494d0265328"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-cursor-themes-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-cursor-themes;unpack=0"
SRC_URI[x86_64_v2_oxygen-cursor-themes.sha256sum] = "f303d066a4b2728369d4ceadb7bbf1bce4064550ff312c0389eb93597bb9c874"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen;unpack=0"
SRC_URI[x86_64_v2_plasma-oxygen.sha256sum] = "0d6ed260135d840812e5202458a46795037480da22dbe7b3d5d87a3db8d00bcd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-oxygen-qt6-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-oxygen-qt6;unpack=0"
SRC_URI[x86_64_v2_plasma-oxygen-qt6.sha256sum] = "c712db08c2049066971bc5fc8ffcf23aa4360d3ea0fec12002d2fece8a0dcd3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oxygen-cursor-themes-6.7.5-1.el10_3.noarch.rpm;name=aarch64_oxygen-cursor-themes;unpack=0"
SRC_URI[aarch64_oxygen-cursor-themes.sha256sum] = "fc1e601a677f721403878da9a851273f8d24ad323cf9c6c908768315fe857f59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-oxygen;unpack=0"
SRC_URI[aarch64_plasma-oxygen.sha256sum] = "8516eaa1e850634eb17d322e36b718bdec14dbcbe8af30282285f1c71ae06dc1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-oxygen-qt6-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-oxygen-qt6;unpack=0"
SRC_URI[aarch64_plasma-oxygen-qt6.sha256sum] = "f329c749c1bb01b1fcec80ba64af346582ecab3c6c6948fe3d14a93119204e2d"

RDEPENDS:oxygen-cursor-themes = " \
 "
RDEPENDS:plasma-oxygen = " \
 glibc \
 kdecoration \
 kf6-filesystem \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 oxygen-cursor-themes \
 oxygen-icon-theme \
 oxygen-sounds \
 plasma-oxygen-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-oxygen-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
