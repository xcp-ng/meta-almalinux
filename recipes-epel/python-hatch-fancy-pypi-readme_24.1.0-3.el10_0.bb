# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hatch-fancy-pypi-readme"
PV = "24.1.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-hatch-fancy-pypi-readme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hatch-fancy-pypi-readme-24.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89435d945b774863f97d444834653af3c2ce5bd1433466c446878711abdd83ef"

URI_x86_64_v2_python3-hatch-fancy-pypi-readme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hatch-fancy-pypi-readme-24.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hatch-fancy-pypi-readme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hatch-fancy-pypi-readme}"
SRC_URI[x86_64_v2_python3-hatch-fancy-pypi-readme.sha256sum] = "9ee04de64457e7f14e98086f399322fc68f062641d1dc83682dda4d619589207"

URI_aarch64_python3-hatch-fancy-pypi-readme = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hatch-fancy-pypi-readme-24.1.0-3.el10_0.noarch.rpm;name=aarch64_python3-hatch-fancy-pypi-readme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hatch-fancy-pypi-readme}"
SRC_URI[aarch64_python3-hatch-fancy-pypi-readme.sha256sum] = "6fd39b4cc0c44f4af62b684204ec7ba296b36f5ed988b4a5379d927cdde7ce8c"

RDEPENDS:python3-hatch-fancy-pypi-readme = " \
 python3 \
 python3-hatchling \
 "
