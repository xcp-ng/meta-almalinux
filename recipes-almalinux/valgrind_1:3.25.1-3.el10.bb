# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valgrind"
PE = "1"
PV = "3.25.1"
PR = "3.el10"
PACKAGES = " \
 valgrind \
 valgrind-devel \
 valgrind-docs \
 valgrind-gdb \
 valgrind-scripts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valgrind-3.25.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1270c7d37da137208a92d42f1c82170f9b68b69e1c9979a2e71460061f47bf96"

URI_x86_64_v2_valgrind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-3.25.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind}"
SRC_URI[x86_64_v2_valgrind.sha256sum] = "f8d3364be7b468c7d2f35e486e19c337a94e5d1462024a3fa572137f884eb01e"

URI_x86_64_v2_valgrind-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-devel-3.25.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-devel}"
SRC_URI[x86_64_v2_valgrind-devel.sha256sum] = "63eb3d963a0a7de717d1ef772e01c9ab977ce3c79bae6b1a623680e745271a47"

URI_x86_64_v2_valgrind-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-docs-3.25.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-docs}"
SRC_URI[x86_64_v2_valgrind-docs.sha256sum] = "9cd964de9ea71cbbfa7bf45a36ebad052b35a36fea3404ce3782a7ecb5a5f817"

URI_x86_64_v2_valgrind-gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-gdb-3.25.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-gdb}"
SRC_URI[x86_64_v2_valgrind-gdb.sha256sum] = "92259e5c3a9ff2b084e2266f19bb3e5fe87ace020d6a8e1a5a5346e6c6652b41"

URI_x86_64_v2_valgrind-scripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-scripts-3.25.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-scripts}"
SRC_URI[x86_64_v2_valgrind-scripts.sha256sum] = "03a771557197b2346f979597188a2c8635e78dbd8bac81f83ee9002b9117ed79"

URI_aarch64_valgrind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-3.25.1-3.el10.aarch64.rpm;name=aarch64_valgrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind}"
SRC_URI[aarch64_valgrind.sha256sum] = "96fc2d39130c748a1b93c17d0a614c101f09d12ca7712f5dabc193d1592da686"

URI_aarch64_valgrind-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-devel-3.25.1-3.el10.aarch64.rpm;name=aarch64_valgrind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-devel}"
SRC_URI[aarch64_valgrind-devel.sha256sum] = "286a30acd3477036f2ac40ab80afb5eb19b61736af1376ffdf793854062e9ba9"

URI_aarch64_valgrind-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-docs-3.25.1-3.el10.aarch64.rpm;name=aarch64_valgrind-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-docs}"
SRC_URI[aarch64_valgrind-docs.sha256sum] = "fad9e9ecdc13ae6477cba9d200026a676fbb138731d783a6c89392ba81e60c96"

URI_aarch64_valgrind-gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-gdb-3.25.1-3.el10.aarch64.rpm;name=aarch64_valgrind-gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-gdb}"
SRC_URI[aarch64_valgrind-gdb.sha256sum] = "bee886b457b8f490547520edc65a4cb23e5919a01b001fa9dbda38f8db9d0046"

URI_aarch64_valgrind-scripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-scripts-3.25.1-3.el10.aarch64.rpm;name=aarch64_valgrind-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-scripts}"
SRC_URI[aarch64_valgrind-scripts.sha256sum] = "35f33e9e886e824d8d4b856736280e8a7efc96834962bab339740416e29a7640"

RDEPENDS:valgrind = " \
 glibc \
 "
RDEPENDS:valgrind-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:valgrind-docs = " \
 "
RDEPENDS:valgrind-gdb = " \
 glibc \
 libgcc \
 valgrind \
 "
RDEPENDS:valgrind-scripts = " \
 perl-interpreter \
 python3 \
 "
