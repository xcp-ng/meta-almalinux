# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-LDAP"
PE = "1"
PV = "0.68"
PR = "16.el10"
PACKAGES = " \
 perl-LDAP \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-LDAP-0.68-16.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f6621bcddba1e3e4b5328de88d2f35cbcc324c2c6b919cbaf9a7b8cd346f6243"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-LDAP-0.68-16.el10.noarch.rpm;name=x86_64_v2_perl-LDAP;unpack=0"
SRC_URI[x86_64_v2_perl-LDAP.sha256sum] = "84d58baa55e5ed317dd474f4fd014d9c2e2fffb8a5c0d29b4b1fb5e4d2038b05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-LDAP-0.68-16.el10.noarch.rpm;name=aarch64_perl-LDAP;unpack=0"
SRC_URI[aarch64_perl-LDAP.sha256sum] = "84d58baa55e5ed317dd474f4fd014d9c2e2fffb8a5c0d29b4b1fb5e4d2038b05"

RDEPENDS:perl-LDAP = " \
 perl-Authen-SASL \
 perl-Carp \
 perl-Convert-ASN1 \
 perl-Encode \
 perl-Exporter \
 perl-HTTP-Message \
 perl-HTTP-Negotiate \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-JSON \
 perl-LDAP \
 perl-LWP-MediaTypes \
 perl-MIME-Base64 \
 perl-Socket \
 perl-Text-Soundex \
 perl-Time-Local \
 perl-base \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 "
