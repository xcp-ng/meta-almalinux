# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcftools"
PV = "1.24"
PR = "2.el10_2"
PACKAGES = " \
 bcftools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bcftools-1.24-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a669ed90e8ddf0e5517f2492152255268c51d68c2356b2652fde86b45299c7f"

URI_x86_64_v2_bcftools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bcftools-1.24-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bcftools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcftools}"
SRC_URI[x86_64_v2_bcftools.sha256sum] = "acd1059a4c731d3f8dfb4ed66c8eb616cfc79fe77e51e685fcec15ae74beebfa"

URI_aarch64_bcftools = "${EPEL_MIRROR}/aarch64/Packages/b/bcftools-1.24-2.el10_2.aarch64.rpm;name=aarch64_bcftools;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcftools}"
SRC_URI[aarch64_bcftools.sha256sum] = "10f3307310a193a850512416edeb0b1ae4f31e57afd62d591f2f69dab0d4e262"

RDEPENDS:bcftools = " \
 glibc \
 gsl \
 htslib \
 perl-interpreter \
 perl-libs \
 python3 \
 "
