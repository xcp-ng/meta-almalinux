# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust2rpm-helper"
PV = "0.1.8"
PR = "1.el10_1"
PACKAGES = " \
 rust2rpm-helper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust2rpm-helper-0.1.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7836cf55e83f2a4fe62e445e074e0d62f970be2e92969d490970dcc98334edbc"

URI_x86_64_v2_rust2rpm-helper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust2rpm-helper-0.1.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rust2rpm-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust2rpm-helper}"
SRC_URI[x86_64_v2_rust2rpm-helper.sha256sum] = "a0e4b523da7a0682018e3695dba7dd89c7de616932a2bab040d0e9895dce50e2"

URI_aarch64_rust2rpm-helper = "${EPEL_MIRROR}/aarch64/Packages/r/rust2rpm-helper-0.1.8-1.el10_1.aarch64.rpm;name=aarch64_rust2rpm-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust2rpm-helper}"
SRC_URI[aarch64_rust2rpm-helper.sha256sum] = "543b0d60b2c1b3329a683774ec7cab0e9d64b736c7fa38ce9a92adbd581cbe65"

RDEPENDS:rust2rpm-helper = " \
 glibc \
 libgcc \
 "
