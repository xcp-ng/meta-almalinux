# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_chcon"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_chcon+default-devel \
 rust-uu_chcon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_chcon-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd38487bdf7f5b8b8edad667fc267a20de024f4194346b9529bc655d2576ede8"

URI_x86_64_v2_rust-uu_chcon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chcon+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chcon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chcon+default-devel}"
SRC_URI[x86_64_v2_rust-uu_chcon+default-devel.sha256sum] = "7ca99982fc1736f4bb9a59d751623d5d289c55bfa6ae03730c9b1ca8de04febc"

URI_x86_64_v2_rust-uu_chcon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chcon-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chcon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chcon-devel}"
SRC_URI[x86_64_v2_rust-uu_chcon-devel.sha256sum] = "699fdcf6ce79266207f3bd136fefa973b77627387fadc19ae7876479eda9e55d"

URI_aarch64_rust-uu_chcon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chcon+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chcon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chcon+default-devel}"
SRC_URI[aarch64_rust-uu_chcon+default-devel.sha256sum] = "5f3d9797be56326055b6a372ffdbb46d858f2e26005e7f6d4c2f5bd96602d1c2"

URI_aarch64_rust-uu_chcon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chcon-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chcon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chcon-devel}"
SRC_URI[aarch64_rust-uu_chcon-devel.sha256sum] = "1960824b588b3b85ed3e58488afaf74dfed28fa2cdadd09ca4e732125ba02aa3"

RDEPENDS:rust-uu_chcon+default-devel = " \
 cargo \
 rust-uu_chcon-devel \
 "
RDEPENDS:rust-uu_chcon-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-fts-sys+default-devel \
 rust-libc+default-devel \
 rust-selinux+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+perms-devel \
 "
