# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpart"
PV = "0.3"
PR = "22.el10_0"
PACKAGES = " \
 gpart \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gpart-0.3-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "80e357cc7d35151426464ffc682c1d41e5f0fb9fd9d91ec73266331e6a0086e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpart-0.3-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpart;unpack=0"
SRC_URI[x86_64_v2_gpart.sha256sum] = "6c7f6335ec8250a695472ee44b66f3c69787129a11d88edf7dd0e51d4984f6b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gpart-0.3-22.el10_0.aarch64.rpm;name=aarch64_gpart;unpack=0"
SRC_URI[aarch64_gpart.sha256sum] = "d2e78409f45b7c451b08b7a3e5d19f2548a3c9791eb3965894d2216ce42a3ad0"

RDEPENDS:gpart = " \
 glibc \
 "
