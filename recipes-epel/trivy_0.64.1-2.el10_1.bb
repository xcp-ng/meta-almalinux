# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trivy"
PV = "0.64.1"
PR = "2.el10_1"
PACKAGES = " \
 trivy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/trivy-0.64.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b14828a81e78b75df8cf2303a478de4feb5a180d2c94e9e77fefbe74e6134db3"

URI_x86_64_v2_trivy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/trivy-0.64.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_trivy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trivy}"
SRC_URI[x86_64_v2_trivy.sha256sum] = "d5c8686605b99a7d79a0cbd1afca2a533e6597fe606022c4eab91da1d058d642"

URI_aarch64_trivy = "${EPEL_MIRROR}/aarch64/Packages/t/trivy-0.64.1-2.el10_1.aarch64.rpm;name=aarch64_trivy;unpack=0"
SRC_URI:append = " ${URI_aarch64_trivy}"
SRC_URI[aarch64_trivy.sha256sum] = "64d29a5481540e2d9cd8f54f29aecd2b5cf4f71076440a4a9b0605de9d87f54f"

RDEPENDS:trivy = " \
 glibc \
 sqlite-libs \
 "
