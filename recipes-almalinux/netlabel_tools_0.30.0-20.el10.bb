# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netlabel_tools"
PV = "0.30.0"
PR = "20.el10"
PACKAGES = " \
 netlabel_tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/netlabel_tools-0.30.0-20.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "113e5efe900cd3460f351dc51f32d10d8bfb97cbe832fad3689de38d1cdc15ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/netlabel_tools-0.30.0-20.el10.x86_64_v2.rpm;name=x86_64_v2_netlabel_tools;unpack=0"
SRC_URI[x86_64_v2_netlabel_tools.sha256sum] = "a04d7b3c794ac94f70abc176ba78a723224b92afc2a482256697c669ce2b0ce6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/netlabel_tools-0.30.0-20.el10.aarch64.rpm;name=aarch64_netlabel_tools;unpack=0"
SRC_URI[aarch64_netlabel_tools.sha256sum] = "b5e4df81a7bb906c6eec5c69b03ff911d462858f4176d2626f9f286b69049349"

RDEPENDS:netlabel_tools = " \
 bash \
 glibc \
 libnl3 \
 systemd \
 "
