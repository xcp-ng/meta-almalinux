# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-netifaces"
PV = "0.11.0"
PR = "16.el10_3"
PACKAGES = " \
 python3-netifaces \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-netifaces-0.11.0-16.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f02cd3d5ed61e2960fb26c72d12955337fd0e00b02bfcb1ec9c7016faec45c21"

URI_x86_64_v2_python3-netifaces = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-netifaces-0.11.0-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-netifaces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-netifaces}"
SRC_URI[x86_64_v2_python3-netifaces.sha256sum] = "2ad2cfa1a7d0b0bdb07dc3704bba0636281b7456bdb714095626f30452197a76"

URI_aarch64_python3-netifaces = "${EPEL_MIRROR}/aarch64/Packages/p/python3-netifaces-0.11.0-16.el10_3.aarch64.rpm;name=aarch64_python3-netifaces;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-netifaces}"
SRC_URI[aarch64_python3-netifaces.sha256sum] = "ca7c06c5b43684611ce18413460ff70115faf8d50518e6e8d8d3fcfe30b2d937"

RDEPENDS:python3-netifaces = " \
 glibc \
 python3 \
 "
