# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-no-panic"
PV = "0.1.36"
PR = "1.el10_1"
PACKAGES = " \
 rust-no-panic+default-devel \
 rust-no-panic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-no-panic-0.1.36-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01cbf002bee6f1e1f956a6cc715eae20863111e54af882f899b0f70b5e9619c9"

URI_x86_64_v2_rust-no-panic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-panic+default-devel-0.1.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-no-panic+default-devel}"
SRC_URI[x86_64_v2_rust-no-panic+default-devel.sha256sum] = "48f3fd0d5be2a7ea442f659bf3b6f40db204d0739f2e300e9d001188b3a0990d"

URI_x86_64_v2_rust-no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-no-panic-devel-0.1.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-no-panic-devel}"
SRC_URI[x86_64_v2_rust-no-panic-devel.sha256sum] = "c568bedea731aac2c87fdf84c1a4bd234d6d05ac057994357eed4f8b4967ccb3"

URI_aarch64_rust-no-panic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-no-panic+default-devel-0.1.36-1.el10_1.noarch.rpm;name=aarch64_rust-no-panic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-no-panic+default-devel}"
SRC_URI[aarch64_rust-no-panic+default-devel.sha256sum] = "7511e543a8c18fca53aa8c9c632e9474f2a24456c2837f5c8da5915ceffe6568"

URI_aarch64_rust-no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-no-panic-devel-0.1.36-1.el10_1.noarch.rpm;name=aarch64_rust-no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-no-panic-devel}"
SRC_URI[aarch64_rust-no-panic-devel.sha256sum] = "b5b147e22aecc8001bd8751b36db16feeccc72ba7df1ff654a0c14473ffd2946"

RDEPENDS:rust-no-panic+default-devel = " \
 cargo \
 rust-no-panic-devel \
 "
RDEPENDS:rust-no-panic-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
