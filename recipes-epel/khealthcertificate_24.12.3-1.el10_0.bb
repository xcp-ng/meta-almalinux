# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khealthcertificate"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 khealthcertificate \
 khealthcertificate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khealthcertificate-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fcc745e9b3c49780c3d82b723ff52e7986ba25f85b7d100feec026d38c3ebba"

URI_x86_64_v2_khealthcertificate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khealthcertificate}"
SRC_URI[x86_64_v2_khealthcertificate.sha256sum] = "7005af97077bd46015404d984034bf325d022e2d84b5ee525714057255ba362d"

URI_x86_64_v2_khealthcertificate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khealthcertificate-devel}"
SRC_URI[x86_64_v2_khealthcertificate-devel.sha256sum] = "69f2388e5b5264fdfeb0e3de9c882ebf9d515bab2f6c41f052ab56555e4399e8"

URI_aarch64_khealthcertificate = "${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_khealthcertificate;unpack=0"
SRC_URI:append = " ${URI_aarch64_khealthcertificate}"
SRC_URI[aarch64_khealthcertificate.sha256sum] = "5ed345c03f38f0acd85d53b6f37c863960c4829e80bb23ffdf8d326435ac683f"

URI_aarch64_khealthcertificate-devel = "${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_khealthcertificate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_khealthcertificate-devel}"
SRC_URI[aarch64_khealthcertificate-devel.sha256sum] = "a9e4ded0fbcc880a5ffc969829b8e5b1d715d962c9f9e646d674e5ec4782add5"

RDEPENDS:khealthcertificate = " \
 glibc \
 kf6-karchive \
 kf6-kcodecs \
 kf6-ki18n \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:khealthcertificate-devel = " \
 cmake-filesystem \
 khealthcertificate \
 "
