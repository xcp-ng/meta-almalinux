# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-process"
PV = "2.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-async-process+default-devel \
 rust-async-process+tracing-devel \
 rust-async-process-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-process-2.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de6e153c132f48d7da50d95dbe588a1861a94e9b37a44a6f840cdd39c525f50e"

URI_x86_64_v2_rust-async-process+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-process+default-devel-2.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-process+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-process+default-devel}"
SRC_URI[x86_64_v2_rust-async-process+default-devel.sha256sum] = "66c4a2d9f3af8abebb90f74c1cc50b3cd21b4cce42c728cf480f4f6e645b40f1"

URI_x86_64_v2_rust-async-process+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-process+tracing-devel-2.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-process+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-process+tracing-devel}"
SRC_URI[x86_64_v2_rust-async-process+tracing-devel.sha256sum] = "e2670ad80064506c203fc71695a45d8b3698f33e63e32742c3406b10f4638aa4"

URI_x86_64_v2_rust-async-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-process-devel-2.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-process-devel}"
SRC_URI[x86_64_v2_rust-async-process-devel.sha256sum] = "68d10c57269a5cea725c3f4d4f9416b2ee15c6fb2979383abc102bdd8a59c1fd"

URI_aarch64_rust-async-process+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-process+default-devel-2.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-async-process+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-process+default-devel}"
SRC_URI[aarch64_rust-async-process+default-devel.sha256sum] = "d68edb995d1164ae8f65c5583c7d98f4701b354844fd937b83b2a3a7788f12e2"

URI_aarch64_rust-async-process+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-process+tracing-devel-2.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-async-process+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-process+tracing-devel}"
SRC_URI[aarch64_rust-async-process+tracing-devel.sha256sum] = "bea86048e385b8f27e309f76e235c543be3a9466e666b942c878bf263135728c"

URI_aarch64_rust-async-process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-process-devel-2.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-async-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-process-devel}"
SRC_URI[aarch64_rust-async-process-devel.sha256sum] = "e022cfe22544ef2310319b191cd965c3cd8eec065e7cf3af935885ffba0cdfd6"

RDEPENDS:rust-async-process+default-devel = " \
 cargo \
 rust-async-process-devel \
 "
RDEPENDS:rust-async-process+tracing-devel = " \
 cargo \
 rust-async-process-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-async-process-devel = " \
 cargo \
 rust \
 rust-async-channel+default-devel \
 rust-async-io+default-devel \
 rust-async-lock+default-devel \
 rust-async-signal+default-devel \
 rust-async-task+default-devel \
 rust-cfg-if+default-devel \
 rust-event-listener+default-devel \
 rust-futures-lite+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
