# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yubihsm-shell"
PV = "2.7.0"
PR = "3.el10_2"
PACKAGES = " \
 yubihsm-shell \
 yubihsm-shell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yubihsm-shell-2.7.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc8747d75b97adb30f598bae260bf233263a87abdc1a14776d0f6eab300a8ab1"

URI_x86_64_v2_yubihsm-shell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yubihsm-shell-2.7.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yubihsm-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yubihsm-shell}"
SRC_URI[x86_64_v2_yubihsm-shell.sha256sum] = "972f6daf379bfd5d957356073426bd62a74e04ab004513db1aa6a36e2c545900"

URI_x86_64_v2_yubihsm-shell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yubihsm-shell-devel-2.7.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yubihsm-shell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yubihsm-shell-devel}"
SRC_URI[x86_64_v2_yubihsm-shell-devel.sha256sum] = "dd4bf2d62d7d677c5fb14d45ae9f55a5ed1a5c25522ea79139791a9a186bdcba"

URI_aarch64_yubihsm-shell = "${EPEL_MIRROR}/aarch64/Packages/y/yubihsm-shell-2.7.0-3.el10_2.aarch64.rpm;name=aarch64_yubihsm-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_yubihsm-shell}"
SRC_URI[aarch64_yubihsm-shell.sha256sum] = "59ed16ef816bac73a6d7d093950ac4cd3db9651e43466d6ca16517a3d7604297"

URI_aarch64_yubihsm-shell-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yubihsm-shell-devel-2.7.0-3.el10_2.aarch64.rpm;name=aarch64_yubihsm-shell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yubihsm-shell-devel}"
SRC_URI[aarch64_yubihsm-shell-devel.sha256sum] = "4ea2c88055e6d6e54d8b16ca533ea26847fded9d611a79df366c41a30634bb7b"

RDEPENDS:yubihsm-shell = " \
 glibc \
 libedit \
 libusb1 \
 openssl-libs \
 pcsc-lite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:yubihsm-shell-devel = " \
 libcurl-devel \
 openssl-devel \
 pcsc-lite-devel \
 pkgconf-pkg-config \
 yubihsm-shell \
 "
