# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cramjam"
PV = "2.10.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-cramjam \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cramjam-2.10.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a92f0e3cd03f850463532b0ac9c72a613b920d3f5dd88c71904b570f19de19ea"

URI_x86_64_v2_python3-cramjam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cramjam-2.10.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-cramjam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cramjam}"
SRC_URI[x86_64_v2_python3-cramjam.sha256sum] = "b63e84b4ff9c3671689c3f7d6d1483067640bb155d8c65429359773752f17e49"

URI_aarch64_python3-cramjam = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cramjam-2.10.0-3.el10_1.aarch64.rpm;name=aarch64_python3-cramjam;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cramjam}"
SRC_URI[aarch64_python3-cramjam.sha256sum] = "494b4320aa0d6bbf867cf275d998923f55815e64af1d686e7df55663dac9d90a"

RDEPENDS:python3-cramjam = " \
 bzip2-libs \
 glibc \
 libgcc \
 libzstd \
 lz4-libs \
 python3 \
 xz-libs \
 "
