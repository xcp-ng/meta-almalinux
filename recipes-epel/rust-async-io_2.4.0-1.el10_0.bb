# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-io"
PV = "2.4.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-io+default-devel \
 rust-async-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-io-2.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a405fe60e8afc513df33dec53082a71e86815acda9123cd38cdbe217273c9a5"

URI_x86_64_v2_rust-async-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-io+default-devel-2.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-io+default-devel}"
SRC_URI[x86_64_v2_rust-async-io+default-devel.sha256sum] = "a917cf826205b1dec15fb49ebf135db940b0a5aefcd7b15bdc219d4eed6c5ff7"

URI_x86_64_v2_rust-async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-io-devel-2.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-io-devel}"
SRC_URI[x86_64_v2_rust-async-io-devel.sha256sum] = "ff92b0ed3e0fbccb33e9e5d8a1eab61927aaca8813ff8c76746fb1367c84d32d"

URI_aarch64_rust-async-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-io+default-devel-2.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-async-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-io+default-devel}"
SRC_URI[aarch64_rust-async-io+default-devel.sha256sum] = "2ab0deafa634f818d5a9ebd33e1dccadcb53bd6fb354a099a0162e747e7978d6"

URI_aarch64_rust-async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-io-devel-2.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-io-devel}"
SRC_URI[aarch64_rust-async-io-devel.sha256sum] = "da3bb6ca243bc8bd0ca678f55fc5ee7b317a9956b712773b59195d817439ec8b"

RDEPENDS:rust-async-io+default-devel = " \
 cargo \
 rust-async-io-devel \
 "
RDEPENDS:rust-async-io-devel = " \
 cargo \
 rust \
 rust-async-lock+default-devel \
 rust-cfg-if+default-devel \
 rust-concurrent-queue+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-lite-devel \
 rust-parking+default-devel \
 rust-polling+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-slab+default-devel \
 rust-tracing-devel \
 "
