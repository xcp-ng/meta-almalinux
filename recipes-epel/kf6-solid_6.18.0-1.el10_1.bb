# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-solid"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-solid \
 kf6-solid-devel \
 kf6-solid-doc \
 kf6-solid-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-solid-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f1c6f6a8eca7fb5972a59fecc9f68a05a6a1b9fbca0504c24f8222c7054e1b7"

URI_x86_64_v2_kf6-solid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid}"
SRC_URI[x86_64_v2_kf6-solid.sha256sum] = "28c5ed7542e50218746f7c947d59f4a094987c62bd3c28be3b0588ae356a3a4b"

URI_x86_64_v2_kf6-solid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-solid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-devel}"
SRC_URI[x86_64_v2_kf6-solid-devel.sha256sum] = "de64fcafed02eef86c9a020e23ca52cb269d57b03ca0fc331d201f846ae48eea"

URI_x86_64_v2_kf6-solid-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-solid-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-doc}"
SRC_URI[x86_64_v2_kf6-solid-doc.sha256sum] = "be078d49e69b20fde7d262a06eb20b2096e732a26fc7e2db11a47872b82f08e4"

URI_x86_64_v2_kf6-solid-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-solid-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-solid-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-solid-html}"
SRC_URI[x86_64_v2_kf6-solid-html.sha256sum] = "7051d836cdc20d243ae9cfd14f68eaf53d00f06d4eb191730769cb882d148722"

URI_aarch64_kf6-solid = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-solid;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid}"
SRC_URI[aarch64_kf6-solid.sha256sum] = "c563bd3a2ed17fb54e4af143c494e48485c748b270f6c6d898933ad77364cd3a"

URI_aarch64_kf6-solid-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-solid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-devel}"
SRC_URI[aarch64_kf6-solid-devel.sha256sum] = "030bd340059636a15008f05a9b50bf7f209cec1c24d7aa2b22699d016f471a98"

URI_aarch64_kf6-solid-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-solid-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-doc}"
SRC_URI[aarch64_kf6-solid-doc.sha256sum] = "af2859dab9ce4bdf3a062730a57b6ce60ae7a228af5a17973e381c05751ddb6f"

URI_aarch64_kf6-solid-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-solid-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-solid-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-solid-html}"
SRC_URI[aarch64_kf6-solid-html.sha256sum] = "3c109164a791578f6bc1c863386e4b2bbd5b4ba0ae5fa3fc669a3017a74b7676"

RDEPENDS:kf6-solid = " \
 glibc \
 kf6-filesystem \
 libimobiledevice \
 libmount \
 libplist \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
RDEPENDS:kf6-solid-devel = " \
 cmake-filesystem \
 kf6-solid \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-solid-doc = " \
 "
RDEPENDS:kf6-solid-html = " \
 "
