# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-csv"
PV = "1.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-csv+default-devel \
 rust-csv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-csv-1.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cee415c8ed6641d97d51d82a331fb2a7ebc823cec4ba5937313c398f73dbd63"

URI_x86_64_v2_rust-csv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv+default-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv+default-devel}"
SRC_URI[x86_64_v2_rust-csv+default-devel.sha256sum] = "8187bafd848b871f1149c61c060493c62fef27710fbcf650c2d140f11a4b79b8"

URI_x86_64_v2_rust-csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-csv-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-csv-devel}"
SRC_URI[x86_64_v2_rust-csv-devel.sha256sum] = "2ade0349b1feb2ee909771a62bf0b395c0b053c71fc8438671e34eb8d5d80b96"

URI_aarch64_rust-csv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv+default-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-csv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv+default-devel}"
SRC_URI[aarch64_rust-csv+default-devel.sha256sum] = "3563e7f5473fcee26098790f3cb2cc12d01c8877bd4a8c33f4314c92cec4cad1"

URI_aarch64_rust-csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-csv-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-csv-devel}"
SRC_URI[aarch64_rust-csv-devel.sha256sum] = "ba460e8809610099e3ba3cd7fbb00714146094835194bb8178337d3c4a4ba9a3"

RDEPENDS:rust-csv+default-devel = " \
 cargo \
 rust-csv-devel \
 "
RDEPENDS:rust-csv-devel = " \
 cargo \
 rust \
 rust-csv-core+default-devel \
 rust-itoa+default-devel \
 rust-ryu+default-devel \
 rust-serde_core+default-devel \
 "
