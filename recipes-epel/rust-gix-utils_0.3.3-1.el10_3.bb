# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-utils"
PV = "0.3.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-utils+bstr-devel \
 rust-gix-utils+default-devel \
 rust-gix-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-utils-0.3.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c88c3cc96c9543eed1d63884e46e2d2608b423cdf2ea24512de060a4b5f1d6ed"

URI_x86_64_v2_rust-gix-utils+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils+bstr-devel-0.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils+bstr-devel}"
SRC_URI[x86_64_v2_rust-gix-utils+bstr-devel.sha256sum] = "59d05b5c1e5ae4c3638bdca05d5f3b266f05a9806b4ef0dd898044cefd4e5bc1"

URI_x86_64_v2_rust-gix-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils+default-devel-0.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils+default-devel}"
SRC_URI[x86_64_v2_rust-gix-utils+default-devel.sha256sum] = "bcd31af6e39323cba1d8dbd9c72ed08ad5cb68bf2f621cd9c6f56a014b21a7b2"

URI_x86_64_v2_rust-gix-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-utils-devel-0.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-utils-devel}"
SRC_URI[x86_64_v2_rust-gix-utils-devel.sha256sum] = "a8ca84392aaaaaca2ed608fd099071fa18d6fd7e99595316c56ed5dc0a92f3cd"

URI_aarch64_rust-gix-utils+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils+bstr-devel-0.3.3-1.el10_3.noarch.rpm;name=aarch64_rust-gix-utils+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils+bstr-devel}"
SRC_URI[aarch64_rust-gix-utils+bstr-devel.sha256sum] = "d4f6c6505e4ded45328e426c2a2e7b23b64bb9cba132209db0ff522b13e157de"

URI_aarch64_rust-gix-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils+default-devel-0.3.3-1.el10_3.noarch.rpm;name=aarch64_rust-gix-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils+default-devel}"
SRC_URI[aarch64_rust-gix-utils+default-devel.sha256sum] = "a1adebf48d0e6c683591afc984c8454ed38899bd47a9b02dd78ad42168ee6ed8"

URI_aarch64_rust-gix-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-utils-devel-0.3.3-1.el10_3.noarch.rpm;name=aarch64_rust-gix-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-utils-devel}"
SRC_URI[aarch64_rust-gix-utils-devel.sha256sum] = "b08307ea3c4c1afb7bc9e055dd3d4d82f296ba49f549139d41d75405106bf790"

RDEPENDS:rust-gix-utils+bstr-devel = " \
 cargo \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-utils-devel \
 "
RDEPENDS:rust-gix-utils+default-devel = " \
 cargo \
 rust-gix-utils-devel \
 "
RDEPENDS:rust-gix-utils-devel = " \
 cargo \
 rust \
 rust-fastrand+default-devel \
 rust-unicode-normalization-devel \
 "
