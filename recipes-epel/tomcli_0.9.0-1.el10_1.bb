# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcli"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 tomcli \
 tomcli+tomli \
"
PACKAGES:aarch64 = " \
 tomcli \
 tomcli+all \
 tomcli+tomli \
 tomcli+tomlkit \
"

URI_src = "${EPELSRC_MIRROR}/Packages/t/tomcli-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4bb437c546aaff29723a97aa36c1d3af90b89915f505b3855986199468cb621"

URI_x86_64_v2_tomcli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomcli-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tomcli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcli}"
SRC_URI[x86_64_v2_tomcli.sha256sum] = "b1d4d04045af4a61406916a7c246da7f940b6b612ddf3f7ff6746ef54abe6162"

URI_x86_64_v2_tomcli+tomli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomcli+tomli-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tomcli+tomli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcli+tomli}"
SRC_URI[x86_64_v2_tomcli+tomli.sha256sum] = "bfa8893b82be1f1c21efb5c839bb5ddbe143ea99e196bc9267d3501ccc061e07"

URI_aarch64_tomcli = "${EPEL_MIRROR}/aarch64/Packages/t/tomcli-0.9.0-1.el10_1.noarch.rpm;name=aarch64_tomcli;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcli}"
SRC_URI[aarch64_tomcli.sha256sum] = "aaeea97060173960517638104cdbae2223257140bdaddfc4ee07e318e5f93d6e"

URI_aarch64_tomcli+all = "${EPEL_MIRROR}/aarch64/Packages/t/tomcli+all-0.9.0-1.el10_1.noarch.rpm;name=aarch64_tomcli+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcli+all}"
SRC_URI[aarch64_tomcli+all.sha256sum] = "3e7f2bce49e278995da45c0e98d01c701e5c0222940fb263e78a00f2b4b9d789"

URI_aarch64_tomcli+tomli = "${EPEL_MIRROR}/aarch64/Packages/t/tomcli+tomli-0.9.0-1.el10_1.noarch.rpm;name=aarch64_tomcli+tomli;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcli+tomli}"
SRC_URI[aarch64_tomcli+tomli.sha256sum] = "52f4dd57059f960f38a25b456f8b19e4fee88159e593c16817aa4296b949b7c0"
RPROVIDES:tomcli+tomli:aarch64 = "virtual/python3dist_tomcli_tomlkit___or_python3dist_tomcli_tomli__"

URI_aarch64_tomcli+tomlkit = "${EPEL_MIRROR}/aarch64/Packages/t/tomcli+tomlkit-0.9.0-1.el10_1.noarch.rpm;name=aarch64_tomcli+tomlkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcli+tomlkit}"
SRC_URI[aarch64_tomcli+tomlkit.sha256sum] = "d50715b7dccd9cf374f3e829e4c1fa34956d48d809cf59d67d3d203ceff0bf9b"
RPROVIDES:tomcli+tomlkit:aarch64 = "virtual/python3dist_tomcli_tomlkit___or_python3dist_tomcli_tomli__"

RDEPENDS:tomcli:x86_64_v2 = " \
 python3 \
 python3-click \
 tomcli+tomli \
"
RDEPENDS:tomcli:aarch64 = " \
 python3 \
 python3-click \
 virtual/python3dist_tomcli_tomlkit___or_python3dist_tomcli_tomli__ \
"
RDEPENDS:tomcli+tomli = " \
 python3 \
 python3-tomli-w \
 tomcli \
 "
RDEPENDS:tomcli+all = " \
 python3 \
 python3-tomlkit \
 tomcli \
 "
RDEPENDS:tomcli+tomlkit = " \
 python3 \
 python3-tomlkit \
 tomcli \
 "

PROVIDES:append:aarch64 = " rpm/virtual/python3dist_tomcli_tomlkit___or_python3dist_tomcli_tomli__"
