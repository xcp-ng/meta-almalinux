# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kturtle"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kturtle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kturtle-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffd48895dd4d05d5ea5337deba436700115aaa9dda9822d06839d5a4a166dbab"

URI_x86_64_v2_kturtle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kturtle-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kturtle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kturtle}"
SRC_URI[x86_64_v2_kturtle.sha256sum] = "7a48f1aa321e8eabeebce8d9cb542c03fc219d8e6fa2e37bb4b88650620ccd31"

URI_aarch64_kturtle = "${EPEL_MIRROR}/aarch64/Packages/k/kturtle-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kturtle;unpack=0"
SRC_URI:append = " ${URI_aarch64_kturtle}"
SRC_URI[aarch64_kturtle.sha256sum] = "9a7a8491164fbcdb43b00b9ad0f133622bf42f28802e289074e658108ea8b31a"

RDEPENDS:kturtle = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
