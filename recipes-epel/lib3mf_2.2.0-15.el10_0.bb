# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lib3mf"
PV = "2.2.0"
PR = "15.el10_0"
PACKAGES = " \
 lib3mf \
 lib3mf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lib3mf-2.2.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "222fcedb2d8fa38e0f73e3273dcc19e08237795fcdb738972ec402af8eaf4389"

URI_x86_64_v2_lib3mf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lib3mf-2.2.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lib3mf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lib3mf}"
SRC_URI[x86_64_v2_lib3mf.sha256sum] = "607b0de8cce8c729a951ebc384cc3e272ecc7c583f287efd41fbf6cc1fdd613d"

URI_x86_64_v2_lib3mf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lib3mf-devel-2.2.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lib3mf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lib3mf-devel}"
SRC_URI[x86_64_v2_lib3mf-devel.sha256sum] = "7b3f8d2c25ffd20b8c4277fdf34f08b6f7b38f87d4c7d888807be521be9345cc"

URI_aarch64_lib3mf = "${EPEL_MIRROR}/aarch64/Packages/l/lib3mf-2.2.0-15.el10_0.aarch64.rpm;name=aarch64_lib3mf;unpack=0"
SRC_URI:append = " ${URI_aarch64_lib3mf}"
SRC_URI[aarch64_lib3mf.sha256sum] = "29cd71cdd0154c9e8f26967360870843ec4613fb288b280ec539ae0e6f0771bd"

URI_aarch64_lib3mf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lib3mf-devel-2.2.0-15.el10_0.aarch64.rpm;name=aarch64_lib3mf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lib3mf-devel}"
SRC_URI[aarch64_lib3mf-devel.sha256sum] = "f6511b70e36d89c899a3c92b80c120f52a64112104fc25606fb0240a3de74362"

RDEPENDS:lib3mf = " \
 glibc \
 libgcc \
 libstdc++ \
 libzip \
 zlib-ng-compat \
 "
RDEPENDS:lib3mf-devel = " \
 lib3mf \
 pkgconf-pkg-config \
 "
