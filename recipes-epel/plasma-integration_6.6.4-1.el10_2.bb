# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-integration"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-integration \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-integration-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "892c3f7f56c78d88e65a3aee109d84881dd578c354eb478d743f8e7bc9cee77e"

URI_x86_64_v2_plasma-integration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-integration-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-integration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-integration}"
SRC_URI[x86_64_v2_plasma-integration.sha256sum] = "6bcfe30df7d890f00d513d9058a14620981c51aaf5c0982a60fa3f41a6226ac1"

URI_aarch64_plasma-integration = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-integration-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-integration;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-integration}"
SRC_URI[aarch64_plasma-integration.sha256sum] = "33d4afc1c801eef934ace5180ef50f6450559f0230fe29d9a5325fcb5cf1bb8b"

RDEPENDS:plasma-integration = " \
 breeze-cursor-theme \
 breeze-icon-theme \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 libXcursor \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-breeze \
 qqc2-breeze-style \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
