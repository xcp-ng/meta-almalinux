# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xorshift"
PV = "0.3.0"
PR = "10.el10_0"
PACKAGES = " \
 rust-rand_xorshift+default-devel \
 rust-rand_xorshift+serde-devel \
 rust-rand_xorshift+serde1-devel \
 rust-rand_xorshift-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xorshift-0.3.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8a123c012322833b65212de807d9a775bbb4c167f41e67f82c2a05bd595dcbb"

URI_x86_64_v2_rust-rand_xorshift+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift+default-devel-0.3.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift+default-devel.sha256sum] = "996cb86474ca7d08aee42478950920be02e1f34a3ca7d2ddd104dce45ab948c2"

URI_x86_64_v2_rust-rand_xorshift+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift+serde-devel-0.3.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift+serde-devel.sha256sum] = "aa9973897c042dc08578ddb0c346ae36eb7546b4c3117f7585d5f8a06c1595bc"

URI_x86_64_v2_rust-rand_xorshift+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift+serde1-devel-0.3.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift+serde1-devel.sha256sum] = "b4e75ff8d542da2bf7d7036e5403dd7749b631e712cafcef262ec894e83246e8"

URI_x86_64_v2_rust-rand_xorshift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift-devel-0.3.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift-devel.sha256sum] = "ee27fe2e4921108a2a3b95d29bd4d2bf5de0114db68c072c2abb2251994ce4d6"

URI_aarch64_rust-rand_xorshift+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift+default-devel-0.3.0-10.el10_0.noarch.rpm;name=aarch64_rust-rand_xorshift+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift+default-devel}"
SRC_URI[aarch64_rust-rand_xorshift+default-devel.sha256sum] = "4a56f051a54eb589ed31757166a21ec8ce32bf640f79c4b48d6af452b1ee158b"

URI_aarch64_rust-rand_xorshift+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift+serde-devel-0.3.0-10.el10_0.noarch.rpm;name=aarch64_rust-rand_xorshift+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift+serde-devel}"
SRC_URI[aarch64_rust-rand_xorshift+serde-devel.sha256sum] = "1b0fd529d5ecd078a8a92fca727a21b9cd14338d76304afc61d8852d605bc89b"

URI_aarch64_rust-rand_xorshift+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift+serde1-devel-0.3.0-10.el10_0.noarch.rpm;name=aarch64_rust-rand_xorshift+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift+serde1-devel}"
SRC_URI[aarch64_rust-rand_xorshift+serde1-devel.sha256sum] = "ae7dec095f924b6472e6cc20b58272017825421e51e1b3f64d9987bf220a1f1c"

URI_aarch64_rust-rand_xorshift-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift-devel-0.3.0-10.el10_0.noarch.rpm;name=aarch64_rust-rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift-devel}"
SRC_URI[aarch64_rust-rand_xorshift-devel.sha256sum] = "3e2657a86321d6efbc6728c49f087d4864ffaeaf54205c2d406710945693c700"

RDEPENDS:rust-rand_xorshift+default-devel = " \
 cargo \
 rust-rand_xorshift-devel \
 "
RDEPENDS:rust-rand_xorshift+serde-devel = " \
 cargo \
 rust-rand_xorshift-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rand_xorshift+serde1-devel = " \
 cargo \
 rust-rand_xorshift+serde-devel \
 rust-rand_xorshift-devel \
 "
RDEPENDS:rust-rand_xorshift-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
