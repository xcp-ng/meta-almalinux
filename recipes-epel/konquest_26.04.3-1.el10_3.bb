# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konquest"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 konquest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konquest-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b973eda5fa04309f34af9b86ec91dd8e260b0e3cfb843930af3c9e01b8db7ecb"

URI_x86_64_v2_konquest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konquest-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konquest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konquest}"
SRC_URI[x86_64_v2_konquest.sha256sum] = "c6c2386516f6d37fbc86de3560e79dc208e30c58699cf7b1bdd9c4e5b0b70198"

URI_aarch64_konquest = "${EPEL_MIRROR}/aarch64/Packages/k/konquest-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_konquest;unpack=0"
SRC_URI:append = " ${URI_aarch64_konquest}"
SRC_URI[aarch64_konquest.sha256sum] = "0a4585d493a80ee42212b4241acf99c12b648cc08d6b7e4f8a58f9bc32a7ab66"

RDEPENDS:konquest = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtscxml \
 qt6-qtsvg \
 "
