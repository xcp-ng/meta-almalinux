# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voikko-fi"
PV = "2.5"
PR = "8.el10"
PACKAGES = " \
 voikko-fi \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/voikko-fi-2.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fd27fab21b6148c141441eebad765428ccb78bc96b527bc15d756ccf41ea5d79"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/voikko-fi-2.5-8.el10.noarch.rpm;name=x86_64_v2_voikko-fi;unpack=0"
SRC_URI[x86_64_v2_voikko-fi.sha256sum] = "83742a62b569619988d055d4372035330f0f42e16e30aa7aa9daf766094b1a9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/voikko-fi-2.5-8.el10.noarch.rpm;name=aarch64_voikko-fi;unpack=0"
SRC_URI[aarch64_voikko-fi.sha256sum] = "83742a62b569619988d055d4372035330f0f42e16e30aa7aa9daf766094b1a9e"

RDEPENDS:voikko-fi = " \
 libvoikko \
 "
