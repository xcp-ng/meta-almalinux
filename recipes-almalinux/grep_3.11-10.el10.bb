# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grep"
PV = "3.11"
PR = "10.el10"
PACKAGES = " \
 grep \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/grep-3.11-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3745576ba23183034076504856d70d771b3c27cac662ef18fd5e01b8828a264f"

URI_x86_64_v2_grep = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grep-3.11-10.el10.x86_64_v2.rpm;name=x86_64_v2_grep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grep}"
SRC_URI[x86_64_v2_grep.sha256sum] = "b0c5ef874347ff443b763d42bbc7f102c7ed19ab01436839e163cd0f0f3a5f7a"

URI_aarch64_grep = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grep-3.11-10.el10.aarch64.rpm;name=aarch64_grep;unpack=0"
SRC_URI:append = " ${URI_aarch64_grep}"
SRC_URI[aarch64_grep.sha256sum] = "2d18c7cefb8fe1db50cae84f8efbab08b4935c33b296a9ffeab9ea7fcaef768e"

RDEPENDS:grep = " \
 bash \
 glibc \
 pcre2 \
 "
