# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgraphviewer"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kgraphviewer \
 kgraphviewer-devel \
 kgraphviewer-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgraphviewer-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2d6e886060ff9e0ec46f0e3edada22c0f94bdf9a2232604c74cf663932852de"

URI_x86_64_v2_kgraphviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgraphviewer}"
SRC_URI[x86_64_v2_kgraphviewer.sha256sum] = "a7458fa871ef99aadb92b6f3e33358f1b7f0b24d800558d17b3555259a17a344"

URI_x86_64_v2_kgraphviewer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgraphviewer-devel}"
SRC_URI[x86_64_v2_kgraphviewer-devel.sha256sum] = "ef59710742fe41ed57c4d74f4b352a8ee95794b015eb4ba2205c2f9ec89cf413"

URI_x86_64_v2_kgraphviewer-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgraphviewer-libs}"
SRC_URI[x86_64_v2_kgraphviewer-libs.sha256sum] = "d1980d6a8a8fce9f15ce1c5c4466b6b0f78305fd346c5b75d226a4806e36d6ac"

URI_aarch64_kgraphviewer = "${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kgraphviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgraphviewer}"
SRC_URI[aarch64_kgraphviewer.sha256sum] = "cae54ed460a96fadb9ff6cff937ae4a7ee5e22883ca3001b0385156b922a29dd"

URI_aarch64_kgraphviewer-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kgraphviewer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgraphviewer-devel}"
SRC_URI[aarch64_kgraphviewer-devel.sha256sum] = "3074a391c7fc49f369583692d2cf29584c0ed32f97421873ae186dc730cc8a72"

URI_aarch64_kgraphviewer-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kgraphviewer-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgraphviewer-libs}"
SRC_URI[aarch64_kgraphviewer-libs.sha256sum] = "fa82f00220044b130b7ed9572d85a8e6e29791f4352f57ff5c2097c70bc80b0e"

RDEPENDS:kgraphviewer = " \
 glibc \
 graphviz \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kgraphviewer-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kgraphviewer-devel = " \
 cmake \
 cmake-filesystem \
 kgraphviewer-libs \
 "
RDEPENDS:kgraphviewer-libs = " \
 glibc \
 graphviz \
 kde-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
