# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fontforge"
PV = "20230101"
PR = "15.el10_2"
PACKAGES = " \
 fontforge \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/fontforge-20230101-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d24d833a6e22ba3c62526c875e4f4084e64451d79f5fdb15c119e854fbf6c7e"

URI_x86_64_v2_fontforge = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fontforge-20230101-15.el10_2.x86_64_v2.rpm;name=x86_64_v2_fontforge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontforge}"
SRC_URI[x86_64_v2_fontforge.sha256sum] = "ef09e0929f2a68a676eaad02088db3dc51093fb7c14f3e5743aa02f13fbd3806"

URI_aarch64_fontforge = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fontforge-20230101-15.el10_2.aarch64.rpm;name=aarch64_fontforge;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontforge}"
SRC_URI[aarch64_fontforge.sha256sum] = "0c02c69b474217b43d2a2dc4adf484e77130d00b77d1b2f992d1e00c9e7e6c3f"

RDEPENDS:fontforge = " \
 cairo \
 freetype \
 giflib \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libgcc \
 libjpeg-turbo \
 libpng \
 libspiro \
 libstdc++ \
 libtiff \
 libxml2 \
 pango \
 potrace \
 python3 \
 python3-libs \
 readline \
 woff2 \
 xdg-utils \
 zlib-ng-compat \
 "
