# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "CCfits"
PV = "2.7"
PR = "3.el10_1"
PACKAGES = " \
 CCfits \
 CCfits-devel \
 CCfits-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/CCfits-2.7-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5cf060153d66a8cbe366bff077488a6d3c5afab506467c16637a8c07f441dc2"

URI_x86_64_v2_CCfits = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CCfits-2.7-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CCfits;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CCfits}"
SRC_URI[x86_64_v2_CCfits.sha256sum] = "38eea03d1980ac6c5b45ebbf0d4edbfdd2415f8629e956285a12d3ed7d4a4f22"

URI_x86_64_v2_CCfits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CCfits-devel-2.7-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CCfits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CCfits-devel}"
SRC_URI[x86_64_v2_CCfits-devel.sha256sum] = "8f974e3b25cc9ce4acf5cf4368556783744069252b568d5b564c0ba8889c555b"

URI_x86_64_v2_CCfits-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CCfits-doc-2.7-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_CCfits-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CCfits-doc}"
SRC_URI[x86_64_v2_CCfits-doc.sha256sum] = "869c309c1c1494cf84f3d43c755f195d9cc559ce1689892f3328f279dae04caa"

URI_aarch64_CCfits = "${EPEL_MIRROR}/aarch64/Packages/c/CCfits-2.7-3.el10_1.aarch64.rpm;name=aarch64_CCfits;unpack=0"
SRC_URI:append = " ${URI_aarch64_CCfits}"
SRC_URI[aarch64_CCfits.sha256sum] = "a8162f30e8e7208581ceef9d69f9df9a48c24a649959088b31cf46b0cb0a123f"

URI_aarch64_CCfits-devel = "${EPEL_MIRROR}/aarch64/Packages/c/CCfits-devel-2.7-3.el10_1.aarch64.rpm;name=aarch64_CCfits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_CCfits-devel}"
SRC_URI[aarch64_CCfits-devel.sha256sum] = "0d8abb5f1b9fcd92c64d5f06decc68fd5e518e866f52e8acb72d187e8c2be6b2"

URI_aarch64_CCfits-doc = "${EPEL_MIRROR}/aarch64/Packages/c/CCfits-doc-2.7-3.el10_1.noarch.rpm;name=aarch64_CCfits-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_CCfits-doc}"
SRC_URI[aarch64_CCfits-doc.sha256sum] = "53969f36722cfa04ee378dc0ac4e6aeedb48656efa1378bdf15d735521271274"

RDEPENDS:CCfits = " \
 cfitsio \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:CCfits-devel = " \
 CCfits \
 cfitsio-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:CCfits-doc = " \
 "
