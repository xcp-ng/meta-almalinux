# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kasts"
PV = "24.12.3"
PR = "2.el10_0"
PACKAGES = " \
 kasts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kasts-24.12.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cfbaa46f8949263900146d0c01b48ed9c89d6077fb3f90eeb217c6a109231c6"

URI_x86_64_v2_kasts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kasts-24.12.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kasts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kasts}"
SRC_URI[x86_64_v2_kasts.sha256sum] = "443aa14fecb905cb237d1aab0e2396c2e8af01e337e746388ded70796c9df0f4"

URI_aarch64_kasts = "${EPEL_MIRROR}/aarch64/Packages/k/kasts-24.12.3-2.el10_0.aarch64.rpm;name=aarch64_kasts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kasts}"
SRC_URI[aarch64_kasts.sha256sum] = "8be88605083128d0fef6a3d0c260c5c699dcc6c3f1ee1ef0a606d82f6c9a56aa"

RDEPENDS:kasts = " \
 glibc \
 kf6-breeze-icons \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-syndication \
 kf6-threadweaver \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qtkeychain-qt6 \
 taglib \
 "
