# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-urid-derive"
PV = "0.1.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-urid-derive+default-devel \
 rust-urid-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-urid-derive-0.1.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "443f9cceb35f2427f42c426d1f2ec1c1434b78d33778208a8db4dc32487b5e3e"

URI_x86_64_v2_rust-urid-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-urid-derive+default-devel-0.1.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-urid-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-urid-derive+default-devel}"
SRC_URI[x86_64_v2_rust-urid-derive+default-devel.sha256sum] = "7151914cf2d6827ca0a8ce4fa10324b34d5998cbff25fba185a8632be66e8562"

URI_x86_64_v2_rust-urid-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-urid-derive-devel-0.1.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-urid-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-urid-derive-devel}"
SRC_URI[x86_64_v2_rust-urid-derive-devel.sha256sum] = "17b2a96af14af626ae59bfd3fdfd8051deb86f19e9b7143a9bbf640f2a61aca3"

URI_aarch64_rust-urid-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-urid-derive+default-devel-0.1.1-3.el10_0.noarch.rpm;name=aarch64_rust-urid-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-urid-derive+default-devel}"
SRC_URI[aarch64_rust-urid-derive+default-devel.sha256sum] = "8d42a184e2c98b93d5aa8cde3f8584d55c6400ce379a3b1a9bd2b5076f38d142"

URI_aarch64_rust-urid-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-urid-derive-devel-0.1.1-3.el10_0.noarch.rpm;name=aarch64_rust-urid-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-urid-derive-devel}"
SRC_URI[aarch64_rust-urid-derive-devel.sha256sum] = "26e7f88d4d92480c13bde1f1a1e6760501c66f2fece5f870662b9088c4d0be5d"

RDEPENDS:rust-urid-derive+default-devel = " \
 cargo \
 rust-urid-derive-devel \
 "
RDEPENDS:rust-urid-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 rust-syn1+full-devel \
 "
