# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memmap2"
PV = "0.9.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-memmap2+default-devel \
 rust-memmap2+stable_deref_trait-devel \
 rust-memmap2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memmap2-0.9.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6f839c615c2803f2eb7074d4a7f4f9b254ecf079674d3053d1bed944872dec7"

URI_x86_64_v2_rust-memmap2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2+default-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2+default-devel}"
SRC_URI[x86_64_v2_rust-memmap2+default-devel.sha256sum] = "a4e7d9226c6eecd3105ff110a100f713fcba2825f98aa32dd13069195a0f6983"

URI_x86_64_v2_rust-memmap2+stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2+stable_deref_trait-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2+stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-memmap2+stable_deref_trait-devel.sha256sum] = "c26a15231a5ab75de23c23be5b7dba393afa56bece2d07492a7841ff60d8594d"

URI_x86_64_v2_rust-memmap2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memmap2-devel-0.9.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memmap2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memmap2-devel}"
SRC_URI[x86_64_v2_rust-memmap2-devel.sha256sum] = "c658da9275cf30764a1ba0f8924ecaf082688823bbc3719601c0724e39114efd"

URI_aarch64_rust-memmap2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2+default-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-memmap2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2+default-devel}"
SRC_URI[aarch64_rust-memmap2+default-devel.sha256sum] = "08b0a6a791c211b009c4bef650b54262257f022e28de31b04c4e9959626c8687"

URI_aarch64_rust-memmap2+stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2+stable_deref_trait-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-memmap2+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2+stable_deref_trait-devel}"
SRC_URI[aarch64_rust-memmap2+stable_deref_trait-devel.sha256sum] = "aab7cd03ac24d18351e44412eeceeeaf44bb3c92fe441c5cd34651e80c340b5d"

URI_aarch64_rust-memmap2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memmap2-devel-0.9.10-1.el10_1.noarch.rpm;name=aarch64_rust-memmap2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memmap2-devel}"
SRC_URI[aarch64_rust-memmap2-devel.sha256sum] = "cc38cc8dc9cf68847819d784ebcb7407a394766a165f801cd49feb97e23a711c"

RDEPENDS:rust-memmap2+default-devel = " \
 cargo \
 rust-memmap2-devel \
 "
RDEPENDS:rust-memmap2+stable_deref_trait-devel = " \
 cargo \
 rust-memmap2-devel \
 rust-stable_deref_trait+default-devel \
 "
RDEPENDS:rust-memmap2-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
