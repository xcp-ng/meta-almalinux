# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusty-fork"
PV = "0.3.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-rusty-fork+default-devel \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork+wait-timeout-devel \
 rust-rusty-fork-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rusty-fork-0.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ef8ec099b793af5a956cb8592da18e2d8a82962fae2aa2a9e9f30e3ebccf736"

URI_x86_64_v2_rust-rusty-fork+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork+default-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty-fork+default-devel}"
SRC_URI[x86_64_v2_rust-rusty-fork+default-devel.sha256sum] = "1888cc04c13d3b4f657a8d79df49cf4ca59563b1e4f6ea9e65ebc2c1b0140e65"

URI_x86_64_v2_rust-rusty-fork+timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork+timeout-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty-fork+timeout-devel}"
SRC_URI[x86_64_v2_rust-rusty-fork+timeout-devel.sha256sum] = "60a75b65b60971b8c889a587c83a70a0c1f00a3e1bf4360626ac4b9ee7ad333b"

URI_x86_64_v2_rust-rusty-fork+wait-timeout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork+wait-timeout-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork+wait-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty-fork+wait-timeout-devel}"
SRC_URI[x86_64_v2_rust-rusty-fork+wait-timeout-devel.sha256sum] = "dd7cdea43c20b3b7c51033c06910247c75725f4cb726b7c59caae1dc39d4c97e"

URI_x86_64_v2_rust-rusty-fork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rusty-fork-devel}"
SRC_URI[x86_64_v2_rust-rusty-fork-devel.sha256sum] = "29e4dd4f1be70832380833d13e7b98e8e121291c60af9b8f72585e628104f09c"

URI_aarch64_rust-rusty-fork+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork+default-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rusty-fork+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty-fork+default-devel}"
SRC_URI[aarch64_rust-rusty-fork+default-devel.sha256sum] = "0f8b0b10e0dc41b567902a6895529500334752146979f3e6ecf0dfed406ac93c"

URI_aarch64_rust-rusty-fork+timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork+timeout-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rusty-fork+timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty-fork+timeout-devel}"
SRC_URI[aarch64_rust-rusty-fork+timeout-devel.sha256sum] = "db587d10f696e5e7f93e798cdaafa00e21247826dce7c5e7fdb9001d5f73bf86"

URI_aarch64_rust-rusty-fork+wait-timeout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork+wait-timeout-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rusty-fork+wait-timeout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty-fork+wait-timeout-devel}"
SRC_URI[aarch64_rust-rusty-fork+wait-timeout-devel.sha256sum] = "de647fab0c3f9dbbc36cb4785863a3bccadf675545a76f5a97b82ee14b04a1c9"

URI_aarch64_rust-rusty-fork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-rusty-fork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rusty-fork-devel}"
SRC_URI[aarch64_rust-rusty-fork-devel.sha256sum] = "6dc9986e665e0e4532c3f29531f69d428c002bc2b05ea55129e2dedd7155bb35"

RDEPENDS:rust-rusty-fork+default-devel = " \
 cargo \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-rusty-fork+timeout-devel = " \
 cargo \
 rust-rusty-fork+wait-timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-rusty-fork+wait-timeout-devel = " \
 cargo \
 rust-rusty-fork-devel \
 rust-wait-timeout+default-devel \
 "
RDEPENDS:rust-rusty-fork-devel = " \
 cargo \
 rust-fnv+default-devel \
 rust-quick-error1+default-devel \
 rust-tempfile+default-devel \
 "
