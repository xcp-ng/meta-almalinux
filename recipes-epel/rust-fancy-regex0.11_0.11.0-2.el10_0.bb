# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fancy-regex0.11"
PV = "0.11.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-fancy-regex0.11+default-devel \
 rust-fancy-regex0.11+perf-cache-devel \
 rust-fancy-regex0.11+perf-devel \
 rust-fancy-regex0.11+perf-dfa-devel \
 rust-fancy-regex0.11+perf-inline-devel \
 rust-fancy-regex0.11+perf-literal-devel \
 rust-fancy-regex0.11+track_caller-devel \
 rust-fancy-regex0.11+unicode-devel \
 rust-fancy-regex0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fancy-regex0.11-0.11.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d62598d63456c16e0e0e15c1b4ed445810d884f241ed687a4226c5d740e51c36"

URI_x86_64_v2_rust-fancy-regex0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex0.11+default-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex0.11+default-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex0.11+default-devel.sha256sum] = "c7e349a43613167785d6aaf7f44f2c90cd897dc2d24cf668b177ed837006f83f"

URI_x86_64_v2_rust-fancy-regex0.11+perf-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex0.11+perf-cache-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex0.11+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex0.11+perf-cache-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex0.11+perf-cache-devel.sha256sum] = "40ec6d8d84f0078351db34af1e47b8c66c775246f39c75df797226afa215c7dc"

URI_x86_64_v2_rust-fancy-regex0.11+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex0.11+perf-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex0.11+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex0.11+perf-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex0.11+perf-devel.sha256sum] = "5a26f66c1aa6cad46e349cbea8a1defd846468be87739698c0e3ecec442fd0d7"

URI_x86_64_v2_rust-fancy-regex0.11+perf-dfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex0.11+perf-dfa-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex0.11+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex0.11+perf-dfa-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex0.11+perf-dfa-devel.sha256sum] = "3a1992794d1bd7fd0fba14f417b20019120c6d3b115b97a1be312c2561d350df"

URI_x86_64_v2_rust-fancy-regex0.11+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex0.11+perf-inline-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex0.11+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex0.11+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex0.11+perf-inline-devel.sha256sum] = "b39bc9faa2d0d30f95dfb71ddb5c009744042bb33825cc6d746e6ec24ff2ee04"

URI_x86_64_v2_rust-fancy-regex0.11+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex0.11+perf-literal-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex0.11+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex0.11+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex0.11+perf-literal-devel.sha256sum] = "a14cc84be630e4f0a3fbc2e89cf4ff2e19be256e04fdf5e837bbaec5c432bb13"

URI_x86_64_v2_rust-fancy-regex0.11+track_caller-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex0.11+track_caller-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex0.11+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex0.11+track_caller-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex0.11+track_caller-devel.sha256sum] = "4613c57cc1a79864b66d0bd04d7107962d0cef0bc32dfafc228f1c9437ce8e02"

URI_x86_64_v2_rust-fancy-regex0.11+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex0.11+unicode-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex0.11+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex0.11+unicode-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex0.11+unicode-devel.sha256sum] = "1a5b30db50a01908683336da31e784df6abcbc76ca64eec32a77b1b6e9f0d014"

URI_x86_64_v2_rust-fancy-regex0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex0.11-devel-0.11.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex0.11-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex0.11-devel.sha256sum] = "37db949b6cf85816dd138c0d87b5d383af008efa7d02b5d0cf35d4de8a2f2355"

URI_aarch64_rust-fancy-regex0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex0.11+default-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-fancy-regex0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex0.11+default-devel}"
SRC_URI[aarch64_rust-fancy-regex0.11+default-devel.sha256sum] = "9560b0f8ade64de081ec1aea35c4244b2671d4223bc091f3455521e7c8fefa0e"

URI_aarch64_rust-fancy-regex0.11+perf-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex0.11+perf-cache-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-fancy-regex0.11+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex0.11+perf-cache-devel}"
SRC_URI[aarch64_rust-fancy-regex0.11+perf-cache-devel.sha256sum] = "0b2af039861a2a129ae800f771326bed49de83660db144010e9a9ffd5de6c0dd"

URI_aarch64_rust-fancy-regex0.11+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex0.11+perf-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-fancy-regex0.11+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex0.11+perf-devel}"
SRC_URI[aarch64_rust-fancy-regex0.11+perf-devel.sha256sum] = "2c75bdd3af72c379603d7fa7326dba414dc18c94ff41ac021ab55dd148fbb8d7"

URI_aarch64_rust-fancy-regex0.11+perf-dfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex0.11+perf-dfa-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-fancy-regex0.11+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex0.11+perf-dfa-devel}"
SRC_URI[aarch64_rust-fancy-regex0.11+perf-dfa-devel.sha256sum] = "852304246b2318c8ff6f2363195470413bcb1e4d741ddf9113efacc5fc2603b7"

URI_aarch64_rust-fancy-regex0.11+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex0.11+perf-inline-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-fancy-regex0.11+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex0.11+perf-inline-devel}"
SRC_URI[aarch64_rust-fancy-regex0.11+perf-inline-devel.sha256sum] = "e7e0b4c594c43d3ecdc13cee60fea4f5b84c1d141993b4791735da8bb5a91cc5"

URI_aarch64_rust-fancy-regex0.11+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex0.11+perf-literal-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-fancy-regex0.11+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex0.11+perf-literal-devel}"
SRC_URI[aarch64_rust-fancy-regex0.11+perf-literal-devel.sha256sum] = "80a94127c4dcbade67005cb4d7b6da0a81dbbaa2c744b7115d4ab62aa2787c17"

URI_aarch64_rust-fancy-regex0.11+track_caller-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex0.11+track_caller-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-fancy-regex0.11+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex0.11+track_caller-devel}"
SRC_URI[aarch64_rust-fancy-regex0.11+track_caller-devel.sha256sum] = "14f50b7ae022d68d5b85f631a02820a68523e47375827b5ee5270ba38248e1ef"

URI_aarch64_rust-fancy-regex0.11+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex0.11+unicode-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-fancy-regex0.11+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex0.11+unicode-devel}"
SRC_URI[aarch64_rust-fancy-regex0.11+unicode-devel.sha256sum] = "ac5b20a9720eaa4b72630119b18f6b72d4d052a85038706d516eb5fa2e20c0be"

URI_aarch64_rust-fancy-regex0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex0.11-devel-0.11.0-2.el10_0.noarch.rpm;name=aarch64_rust-fancy-regex0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex0.11-devel}"
SRC_URI[aarch64_rust-fancy-regex0.11-devel.sha256sum] = "1e67d827c8329f3da979fe6cca531c002c28561be8f2a4299b80574899ab9ae5"

RDEPENDS:rust-fancy-regex0.11+default-devel = " \
 cargo \
 rust-fancy-regex0.11+perf-devel \
 rust-fancy-regex0.11+unicode-devel \
 rust-fancy-regex0.11-devel \
 "
RDEPENDS:rust-fancy-regex0.11+perf-cache-devel = " \
 cargo \
 rust-fancy-regex0.11-devel \
 rust-regex+perf-cache-devel \
 "
RDEPENDS:rust-fancy-regex0.11+perf-devel = " \
 cargo \
 rust-fancy-regex0.11-devel \
 rust-regex+perf-devel \
 "
RDEPENDS:rust-fancy-regex0.11+perf-dfa-devel = " \
 cargo \
 rust-fancy-regex0.11-devel \
 rust-regex+perf-dfa-devel \
 "
RDEPENDS:rust-fancy-regex0.11+perf-inline-devel = " \
 cargo \
 rust-fancy-regex0.11-devel \
 rust-regex+perf-inline-devel \
 "
RDEPENDS:rust-fancy-regex0.11+perf-literal-devel = " \
 cargo \
 rust-fancy-regex0.11-devel \
 rust-regex+perf-literal-devel \
 "
RDEPENDS:rust-fancy-regex0.11+track_caller-devel = " \
 cargo \
 rust-fancy-regex0.11-devel \
 "
RDEPENDS:rust-fancy-regex0.11+unicode-devel = " \
 cargo \
 rust-fancy-regex0.11-devel \
 rust-regex+unicode-devel \
 "
RDEPENDS:rust-fancy-regex0.11-devel = " \
 cargo \
 rust-bit-set0.5+default-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
