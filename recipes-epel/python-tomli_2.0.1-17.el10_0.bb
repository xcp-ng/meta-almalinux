# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tomli"
PV = "2.0.1"
PR = "17.el10_0"
PACKAGES = " \
 python3-tomli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tomli-2.0.1-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e7053ff047ecf4d94a55df6a0a9294bae2a88ad741d563c781d6826ca9e2f3d"

URI_x86_64_v2_python3-tomli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tomli-2.0.1-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tomli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tomli}"
SRC_URI[x86_64_v2_python3-tomli.sha256sum] = "dc190c3d85e51ad85d3d07c636c2f5fc208947893f609774dad8c45ec98e1249"

URI_aarch64_python3-tomli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tomli-2.0.1-17.el10_0.noarch.rpm;name=aarch64_python3-tomli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tomli}"
SRC_URI[aarch64_python3-tomli.sha256sum] = "fcc92299e686077775409c85e1f88735085420d2d322774b9e2358ee49b48c90"

RDEPENDS:python3-tomli = " \
 python3 \
 "
