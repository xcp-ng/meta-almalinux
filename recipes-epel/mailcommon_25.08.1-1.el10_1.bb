# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailcommon"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 mailcommon \
 mailcommon-devel \
 mailcommon-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mailcommon-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb1dee4995d9eafca62ab6931ed0e096697443e3b16ac2cda441f4625881c0db"

URI_x86_64_v2_mailcommon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon}"
SRC_URI[x86_64_v2_mailcommon.sha256sum] = "ba270bf8febe86b6e0c3bc23c306aa12c24f6bee609eebea4e58dbb742dd6171"

URI_x86_64_v2_mailcommon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon-devel}"
SRC_URI[x86_64_v2_mailcommon-devel.sha256sum] = "13dc2dd07301a54fdbe4fb4e920a74ce4955bd638ee4977d0560c734cb3e5394"

URI_x86_64_v2_mailcommon-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mailcommon-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon-doc}"
SRC_URI[x86_64_v2_mailcommon-doc.sha256sum] = "f6c638bbdf9db196f54c4ef4d408d9bc58c10e2882b0bbc1bbd937f2c1eebd20"

URI_aarch64_mailcommon = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_mailcommon;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon}"
SRC_URI[aarch64_mailcommon.sha256sum] = "1b077217ae67b7005f6695d082f65ee5548f843b46aa0f56d8ca304b3f65f295"

URI_aarch64_mailcommon-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_mailcommon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon-devel}"
SRC_URI[aarch64_mailcommon-devel.sha256sum] = "e9e40a213edd2fdeb7637ac2bfa20e8a2d9066ab6ea2dc5fec7a76e5e8e4f1fc"

URI_aarch64_mailcommon-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_mailcommon-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon-doc}"
SRC_URI[aarch64_mailcommon-doc.sha256sum] = "b4a37202fcb2787a6518e62e095d80f574429fe1d61223af6373ac692a523a64"

RDEPENDS:mailcommon = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgmepp \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libkleo \
 libstdc++ \
 mailimporter \
 messagelib \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
RDEPENDS:mailcommon-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib-devel \
 pimcommon-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailcommon-doc = " \
 "
