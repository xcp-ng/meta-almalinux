# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crun"
PV = "1.27"
PR = "1.el10_1"
PACKAGES = " \
 crun \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crun-1.27-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e27f308e7c0704a8dc0fcef21b69294373bba0a4d592ab266a4d5dc51130434f"

URI_x86_64_v2_crun = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crun-1.27-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_crun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crun}"
SRC_URI[x86_64_v2_crun.sha256sum] = "3e2819e4f54ac7ad6c27d8892a830323fb7b6d461896a2619f16798bc0d0abe8"

URI_aarch64_crun = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crun-1.27-1.el10_1.aarch64.rpm;name=aarch64_crun;unpack=0"
SRC_URI:append = " ${URI_aarch64_crun}"
SRC_URI[aarch64_crun.sha256sum] = "8b552fbf29a16b7aefe341dc0278c7ffec0ce9f39c57a02656887d055ac2caed"

RDEPENDS:crun = " \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 systemd-libs \
 "
