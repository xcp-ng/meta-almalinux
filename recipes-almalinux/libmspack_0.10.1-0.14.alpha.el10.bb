# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmspack"
PV = "0.10.1"
PR = "0.14.alpha.el10"
PACKAGES = " \
 libmspack \
 libmspack-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libmspack-0.10.1-0.14.alpha.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04a711acf72ec717c1f1fb2a35a1259ce911b89e9d4cce3745c956c0e927a823"

URI_x86_64_v2_libmspack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmspack-0.10.1-0.14.alpha.el10.x86_64_v2.rpm;name=x86_64_v2_libmspack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmspack}"
SRC_URI[x86_64_v2_libmspack.sha256sum] = "fabc588f64539d34fccdf68b27081f9a6a6bbabe6d6172d89f836bf28f025a5e"

URI_x86_64_v2_libmspack-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmspack-devel-0.10.1-0.14.alpha.el10.x86_64_v2.rpm;name=x86_64_v2_libmspack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmspack-devel}"
SRC_URI[x86_64_v2_libmspack-devel.sha256sum] = "b6e80ec6afda3b28d4ff68105adba65dd05ca96ef291f3cf447ae4949dfe0ed1"

URI_aarch64_libmspack = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmspack-0.10.1-0.14.alpha.el10.aarch64.rpm;name=aarch64_libmspack;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmspack}"
SRC_URI[aarch64_libmspack.sha256sum] = "4b8e02444481b81230ca2517ddf3c80c92e383dc61c9f6389a8c6808f9e4553c"

URI_aarch64_libmspack-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmspack-devel-0.10.1-0.14.alpha.el10.aarch64.rpm;name=aarch64_libmspack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmspack-devel}"
SRC_URI[aarch64_libmspack-devel.sha256sum] = "7239898bd5269e5dbee577c19a8f0b10f2c4bc275b8a8ac6207b0c7fe06aa66f"

RDEPENDS:libmspack = " \
 glibc \
 "
RDEPENDS:libmspack-devel = " \
 libmspack \
 pkgconf-pkg-config \
 "
