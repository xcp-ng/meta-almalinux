# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hspell-epel"
PV = "1.4"
PR = "22.el10_0"
PACKAGES = " \
 hspell \
 hspell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hspell-epel-1.4-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4988a8ef20b17bad5e5f5311238c99aad18ab943ae608551bbda28e65107c978"

URI_x86_64_v2_hspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hspell-1.4-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hspell}"
SRC_URI[x86_64_v2_hspell.sha256sum] = "43023466e9cae424a28fcd86ba2a0b5d8166f48e1fb6bc2c24e65cf7c134e36c"

URI_x86_64_v2_hspell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hspell-devel-1.4-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hspell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hspell-devel}"
SRC_URI[x86_64_v2_hspell-devel.sha256sum] = "60cae4045fe4f6f42df842b881eb77dc7cc908cf416493f2f862a4161e69f4e0"

URI_aarch64_hspell = "${EPEL_MIRROR}/aarch64/Packages/h/hspell-1.4-22.el10_0.aarch64.rpm;name=aarch64_hspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_hspell}"
SRC_URI[aarch64_hspell.sha256sum] = "8386119da064a7b8b3d109b91d2221ca839dd6957c84db25a074212839117fcc"

URI_aarch64_hspell-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hspell-devel-1.4-22.el10_0.aarch64.rpm;name=aarch64_hspell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hspell-devel}"
SRC_URI[aarch64_hspell-devel.sha256sum] = "e591c91f4e8a110d4f91596461f38567ab50207301deca905f91779071fafdda"

RDEPENDS:hspell = " \
 glibc \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-interpreter \
 perl-libs \
 zlib-ng-compat \
 "
RDEPENDS:hspell-devel = " \
 hspell \
 "
