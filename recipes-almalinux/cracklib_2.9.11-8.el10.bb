# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cracklib"
PV = "2.9.11"
PR = "8.el10"
PACKAGES = " \
 cracklib \
 cracklib-devel \
 cracklib-dicts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cracklib-2.9.11-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b703c19da3e25e7b10de586041606b439895ed33139171afdf7915e4baa5a419"

URI_x86_64_v2_cracklib = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cracklib-2.9.11-8.el10.x86_64_v2.rpm;name=x86_64_v2_cracklib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cracklib}"
SRC_URI[x86_64_v2_cracklib.sha256sum] = "d77056efc5d0dc97a5cdf9e892aafaa7cc9ae51b8ed28fa54b18c9115c9dbcb3"

URI_x86_64_v2_cracklib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cracklib-devel-2.9.11-8.el10.x86_64_v2.rpm;name=x86_64_v2_cracklib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cracklib-devel}"
SRC_URI[x86_64_v2_cracklib-devel.sha256sum] = "c22c99f75fee431f1e4f756e9cb6c0acfa7f3121881cacd46619cdb9f6cff522"

URI_x86_64_v2_cracklib-dicts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cracklib-dicts-2.9.11-8.el10.x86_64_v2.rpm;name=x86_64_v2_cracklib-dicts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cracklib-dicts}"
SRC_URI[x86_64_v2_cracklib-dicts.sha256sum] = "bd222838603c9a9eaa1e314ac3c4393dae0ba82c82fbd339c67fc6f73b50a49d"

URI_aarch64_cracklib = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cracklib-2.9.11-8.el10.aarch64.rpm;name=aarch64_cracklib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cracklib}"
SRC_URI[aarch64_cracklib.sha256sum] = "d317ef807f9fc704dc44aefcaeea3697d31c2bcd6a990ed6dc23f367a6303149"

URI_aarch64_cracklib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cracklib-devel-2.9.11-8.el10.aarch64.rpm;name=aarch64_cracklib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cracklib-devel}"
SRC_URI[aarch64_cracklib-devel.sha256sum] = "7f0fc56191b1cc6365824337d153d5acf64245aa963d96356d0120104ed879ba"

URI_aarch64_cracklib-dicts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cracklib-dicts-2.9.11-8.el10.aarch64.rpm;name=aarch64_cracklib-dicts;unpack=0"
SRC_URI:append = " ${URI_aarch64_cracklib-dicts}"
SRC_URI[aarch64_cracklib-dicts.sha256sum] = "f45a566fb9bb97ceb29a57aa577e924bcfded81994a69daaf7d99b9a36ae0a09"

RDEPENDS:cracklib = " \
 bash \
 glibc \
 gzip \
 zlib-ng-compat \
 "
RDEPENDS:cracklib-devel = " \
 cracklib \
 "
RDEPENDS:cracklib-dicts = " \
 cracklib \
 "
