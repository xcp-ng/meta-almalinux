# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyterlab-widgets"
PV = "3.0.14"
PR = "1.el10_1"
PACKAGES = " \
 python3-jupyterlab-widgets \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jupyterlab-widgets-3.0.14-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75359243414e9b064e1220b23b14a720647cbefd82c310ead3c5fd89336481c6"

URI_x86_64_v2_python3-jupyterlab-widgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyterlab-widgets-3.0.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyterlab-widgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyterlab-widgets}"
SRC_URI[x86_64_v2_python3-jupyterlab-widgets.sha256sum] = "c1622483e46ef149f41099d346c849993f8ad034b313be9e1a56442dfc09b073"

URI_aarch64_python3-jupyterlab-widgets = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyterlab-widgets-3.0.14-1.el10_1.noarch.rpm;name=aarch64_python3-jupyterlab-widgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyterlab-widgets}"
SRC_URI[aarch64_python3-jupyterlab-widgets.sha256sum] = "837848ef50e60fe3584faf0f5e2972e91d55bcd3d7ec1647bd611da359778ec2"

RDEPENDS:python3-jupyterlab-widgets = " \
 python-jupyter-filesystem \
 python3 \
 "
