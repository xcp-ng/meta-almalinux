# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lzop"
PV = "1.04"
PR = "16.el10"
PACKAGES = " \
 lzop \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lzop-1.04-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b5f7f3ac78952c39210c049c117959d2254a0a03ee1aa1cef4b511348f75d5f"

URI_x86_64_v2_lzop = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lzop-1.04-16.el10.x86_64_v2.rpm;name=x86_64_v2_lzop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lzop}"
SRC_URI[x86_64_v2_lzop.sha256sum] = "f2e20c749afc690e0986ba56e58f37884ce0444c0bf48fc0d1182826cf2ebf4d"

URI_aarch64_lzop = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lzop-1.04-16.el10.aarch64.rpm;name=aarch64_lzop;unpack=0"
SRC_URI:append = " ${URI_aarch64_lzop}"
SRC_URI[aarch64_lzop.sha256sum] = "6b953f328062273898705a5f8a62d65eea92707e6eb9fdf8cf7f159b24af28c0"

RDEPENDS:lzop = " \
 glibc \
 lzo \
 "
