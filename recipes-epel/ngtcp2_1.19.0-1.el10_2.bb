# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ngtcp2"
PV = "1.19.0"
PR = "1.el10_2"
PACKAGES = " \
 ngtcp2 \
 ngtcp2-crypto-gnutls \
 ngtcp2-crypto-gnutls-devel \
 ngtcp2-crypto-ossl \
 ngtcp2-crypto-ossl-devel \
 ngtcp2-devel \
 ngtcp2-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ngtcp2-1.19.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a0f84976d53b00640776ed8d4ebbcf5ef0390f23ab8205fc9ed781859f9e001"

URI_x86_64_v2_ngtcp2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-1.19.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2}"
SRC_URI[x86_64_v2_ngtcp2.sha256sum] = "2821825d4e6332325f92f4bb2d8068d888ee20ac3b55784b672db6c3f8de177b"

URI_x86_64_v2_ngtcp2-crypto-gnutls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-crypto-gnutls-1.19.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-crypto-gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-crypto-gnutls}"
SRC_URI[x86_64_v2_ngtcp2-crypto-gnutls.sha256sum] = "984f81534ba2b68081419a9c4a4d5338c2f2cf31e4a41ee98b09c19de2925320"

URI_x86_64_v2_ngtcp2-crypto-gnutls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-crypto-gnutls-devel-1.19.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-crypto-gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-crypto-gnutls-devel}"
SRC_URI[x86_64_v2_ngtcp2-crypto-gnutls-devel.sha256sum] = "903503afa666871a0142ea31f30ccfd74fdefda47f38cdedc2b4bf4577b355a8"

URI_x86_64_v2_ngtcp2-crypto-ossl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-crypto-ossl-1.19.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-crypto-ossl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-crypto-ossl}"
SRC_URI[x86_64_v2_ngtcp2-crypto-ossl.sha256sum] = "9ab184f171ae96c24d150838fe277de37a28cca1462e6c4a4deb08e2ac65bbbb"

URI_x86_64_v2_ngtcp2-crypto-ossl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-crypto-ossl-devel-1.19.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-crypto-ossl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-crypto-ossl-devel}"
SRC_URI[x86_64_v2_ngtcp2-crypto-ossl-devel.sha256sum] = "6a802426f5bf119f02cdead8632fc99e895802d2db8a97e3fee9f070e141f5c9"

URI_x86_64_v2_ngtcp2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-devel-1.19.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngtcp2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-devel}"
SRC_URI[x86_64_v2_ngtcp2-devel.sha256sum] = "c54cae3ab478761cbbd78693b00f211c7e382cd90530255790df037d193a57f2"

URI_x86_64_v2_ngtcp2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngtcp2-doc-1.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ngtcp2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngtcp2-doc}"
SRC_URI[x86_64_v2_ngtcp2-doc.sha256sum] = "081f9566f1140f4dbdc5ab1c97b5244ec3c0f1def172da08b78918473fa98d58"

URI_aarch64_ngtcp2 = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-1.19.0-1.el10_2.aarch64.rpm;name=aarch64_ngtcp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2}"
SRC_URI[aarch64_ngtcp2.sha256sum] = "48bec118406b19f572e83ec83bcac2b74ec5009ddf2e55a09c2c79746f6f998a"

URI_aarch64_ngtcp2-crypto-gnutls = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-crypto-gnutls-1.19.0-1.el10_2.aarch64.rpm;name=aarch64_ngtcp2-crypto-gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-crypto-gnutls}"
SRC_URI[aarch64_ngtcp2-crypto-gnutls.sha256sum] = "253ad4a0c98fdb4edd09d75bcfd0b85b484ca9cc8d769eb61f16cafdfc5f1206"

URI_aarch64_ngtcp2-crypto-gnutls-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-crypto-gnutls-devel-1.19.0-1.el10_2.aarch64.rpm;name=aarch64_ngtcp2-crypto-gnutls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-crypto-gnutls-devel}"
SRC_URI[aarch64_ngtcp2-crypto-gnutls-devel.sha256sum] = "0e0bf5e5a6f77e1fc9e7194fb6364e906f66cc7043fca7b17b13ec9be851b343"

URI_aarch64_ngtcp2-crypto-ossl = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-crypto-ossl-1.19.0-1.el10_2.aarch64.rpm;name=aarch64_ngtcp2-crypto-ossl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-crypto-ossl}"
SRC_URI[aarch64_ngtcp2-crypto-ossl.sha256sum] = "fdf9ccea5c5fc2c0adb5affc0d05704f9980e9304684f762f63cb29dc10a7bf4"

URI_aarch64_ngtcp2-crypto-ossl-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-crypto-ossl-devel-1.19.0-1.el10_2.aarch64.rpm;name=aarch64_ngtcp2-crypto-ossl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-crypto-ossl-devel}"
SRC_URI[aarch64_ngtcp2-crypto-ossl-devel.sha256sum] = "add100709c4b0e31ab3e77c11044902b6a395c0b6cf26dae314549c03e281948"

URI_aarch64_ngtcp2-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-devel-1.19.0-1.el10_2.aarch64.rpm;name=aarch64_ngtcp2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-devel}"
SRC_URI[aarch64_ngtcp2-devel.sha256sum] = "398cc56de5837d8ffc341328ce56a9da81abb9859b96276af9ee80adac21e840"

URI_aarch64_ngtcp2-doc = "${EPEL_MIRROR}/aarch64/Packages/n/ngtcp2-doc-1.19.0-1.el10_2.noarch.rpm;name=aarch64_ngtcp2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngtcp2-doc}"
SRC_URI[aarch64_ngtcp2-doc.sha256sum] = "b24d8f72cc9a358326c2d3d1a8233c180fe9dcef712c2012632dee6c6e2fc710"

RDEPENDS:ngtcp2 = " \
 glibc \
 "
RDEPENDS:ngtcp2-crypto-gnutls = " \
 glibc \
 gnutls \
 ngtcp2 \
 "
RDEPENDS:ngtcp2-crypto-gnutls-devel = " \
 gnutls-devel \
 ngtcp2 \
 ngtcp2-crypto-gnutls \
 ngtcp2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ngtcp2-crypto-ossl = " \
 glibc \
 ngtcp2 \
 openssl-libs \
 "
RDEPENDS:ngtcp2-crypto-ossl-devel = " \
 ngtcp2-crypto-ossl \
 ngtcp2-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ngtcp2-devel = " \
 ngtcp2 \
 pkgconf-pkg-config \
 "
RDEPENDS:ngtcp2-doc = " \
 ngtcp2 \
 "
