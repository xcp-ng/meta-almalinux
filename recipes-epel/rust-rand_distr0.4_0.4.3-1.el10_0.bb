# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_distr0.4"
PV = "0.4.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand_distr0.4+alloc-devel \
 rust-rand_distr0.4+default-devel \
 rust-rand_distr0.4+serde-devel \
 rust-rand_distr0.4+serde1-devel \
 rust-rand_distr0.4+std-devel \
 rust-rand_distr0.4+std_math-devel \
 rust-rand_distr0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_distr0.4-0.4.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b17aec988aa13d603bec740854098c449d6ac798e6ec176816122cc21dafa0a3"

URI_x86_64_v2_rust-rand_distr0.4+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.4+alloc-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.4+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.4+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.4+alloc-devel.sha256sum] = "f8d717ab767a4f30926e9d27b74b7ca9c6b710ff3854a0acebc3b94b6877ab1d"

URI_x86_64_v2_rust-rand_distr0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.4+default-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.4+default-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.4+default-devel.sha256sum] = "995062c684938edc52c7dd240fb050ec7cc65b7f76727723dbdcd711c88c2bf4"

URI_x86_64_v2_rust-rand_distr0.4+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.4+serde-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.4+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.4+serde-devel.sha256sum] = "62067c79862b18840ff1b75ce540cacea94840263ae131077d5daa895065f435"

URI_x86_64_v2_rust-rand_distr0.4+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.4+serde1-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.4+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.4+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.4+serde1-devel.sha256sum] = "3f6244d99a6744271569513d3f059b9f7e3d14ec32f20aa7b021052888b82458"

URI_x86_64_v2_rust-rand_distr0.4+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.4+std-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.4+std-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.4+std-devel.sha256sum] = "4a67cfceb18e88ada7da4aadbe0959704969e4592e7438f5729482c9c7ea7233"

URI_x86_64_v2_rust-rand_distr0.4+std_math-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.4+std_math-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.4+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.4+std_math-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.4+std_math-devel.sha256sum] = "c1d3bb57b6f62a4997d35e0f533a0e20c8dc45c44b11c15eb57bec157cadb9de"

URI_x86_64_v2_rust-rand_distr0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.4-devel-0.4.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.4-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.4-devel.sha256sum] = "81ad943cae2f8013b5937bbb059c43ea1c3b359cb6418823f143bfab2a88be63"

URI_aarch64_rust-rand_distr0.4+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.4+alloc-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr0.4+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.4+alloc-devel}"
SRC_URI[aarch64_rust-rand_distr0.4+alloc-devel.sha256sum] = "f249a0a14d9d19ed1077a9716c200b2fb0b70f1ca9df707b3499b860b977156f"

URI_aarch64_rust-rand_distr0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.4+default-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.4+default-devel}"
SRC_URI[aarch64_rust-rand_distr0.4+default-devel.sha256sum] = "a3ca2856a47b3d2c76ec0217f3af1dcec59e609aad33353789bc4d4bbbc9f69f"

URI_aarch64_rust-rand_distr0.4+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.4+serde-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.4+serde-devel}"
SRC_URI[aarch64_rust-rand_distr0.4+serde-devel.sha256sum] = "f32c9478e36ceb5876f6fc6bfbaec4da5d1ea2b094f6644e51d168b485bb740d"

URI_aarch64_rust-rand_distr0.4+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.4+serde1-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr0.4+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.4+serde1-devel}"
SRC_URI[aarch64_rust-rand_distr0.4+serde1-devel.sha256sum] = "07a899df8a80d9721aca1617d18f7fc82760909d50b78f2970ef6310c1e443bb"

URI_aarch64_rust-rand_distr0.4+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.4+std-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.4+std-devel}"
SRC_URI[aarch64_rust-rand_distr0.4+std-devel.sha256sum] = "dc770d50f766e469409f8e9fe73265ec29972010b2c365d85cbfdaffa5a16ed8"

URI_aarch64_rust-rand_distr0.4+std_math-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.4+std_math-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr0.4+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.4+std_math-devel}"
SRC_URI[aarch64_rust-rand_distr0.4+std_math-devel.sha256sum] = "122cff8d503fc3747828ace4533e62e0e3eb989348b004cbb8d538094239ec61"

URI_aarch64_rust-rand_distr0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.4-devel-0.4.3-1.el10_0.noarch.rpm;name=aarch64_rust-rand_distr0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.4-devel}"
SRC_URI[aarch64_rust-rand_distr0.4-devel.sha256sum] = "a782a9234e5c0d8fe76593a80863e4b908735157977d6cb23e80cd1209017b33"

RDEPENDS:rust-rand_distr0.4+alloc-devel = " \
 cargo \
 rust-rand0.8+alloc-devel \
 rust-rand_distr0.4-devel \
 "
RDEPENDS:rust-rand_distr0.4+default-devel = " \
 cargo \
 rust-rand_distr0.4+std-devel \
 rust-rand_distr0.4-devel \
 "
RDEPENDS:rust-rand_distr0.4+serde-devel = " \
 cargo \
 rust-rand_distr0.4-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_distr0.4+serde1-devel = " \
 cargo \
 rust-rand0.8+serde1-devel \
 rust-rand_distr0.4+serde-devel \
 rust-rand_distr0.4-devel \
 "
RDEPENDS:rust-rand_distr0.4+std-devel = " \
 cargo \
 rust-rand0.8+std-devel \
 rust-rand_distr0.4+alloc-devel \
 rust-rand_distr0.4-devel \
 "
RDEPENDS:rust-rand_distr0.4+std_math-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-rand_distr0.4-devel \
 "
RDEPENDS:rust-rand_distr0.4-devel = " \
 cargo \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 rust-rand0.8-devel \
 "
