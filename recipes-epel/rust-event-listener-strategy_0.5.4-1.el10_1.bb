# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-event-listener-strategy"
PV = "0.5.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-event-listener-strategy+default-devel \
 rust-event-listener-strategy+portable-atomic-devel \
 rust-event-listener-strategy+std-devel \
 rust-event-listener-strategy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-event-listener-strategy-0.5.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b0c8a44f185b3a429ac74999739f6d80c04efb8f69c5aad82fd258b1a26bb48"

URI_x86_64_v2_rust-event-listener-strategy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-strategy+default-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-strategy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-strategy+default-devel}"
SRC_URI[x86_64_v2_rust-event-listener-strategy+default-devel.sha256sum] = "144968b71e4e66a67dd32c98771672d509af477f9070088c8f38298001cb120b"

URI_x86_64_v2_rust-event-listener-strategy+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-strategy+portable-atomic-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-strategy+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-strategy+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-event-listener-strategy+portable-atomic-devel.sha256sum] = "2e2e053406b2940f31d09913407d91313588b65463ba119e194c41525ef89413"

URI_x86_64_v2_rust-event-listener-strategy+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-strategy+std-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-strategy+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-strategy+std-devel}"
SRC_URI[x86_64_v2_rust-event-listener-strategy+std-devel.sha256sum] = "53a91e28a7fe00bc1e20d2a54703941129ef8d33fc53fd36ecc2261495cdfd79"

URI_x86_64_v2_rust-event-listener-strategy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-strategy-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-strategy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-strategy-devel}"
SRC_URI[x86_64_v2_rust-event-listener-strategy-devel.sha256sum] = "12eeb3397726a730c438a5c1fd6b1a1293b089ff1730caf2c7766fe8014c9e88"

URI_aarch64_rust-event-listener-strategy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-strategy+default-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener-strategy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-strategy+default-devel}"
SRC_URI[aarch64_rust-event-listener-strategy+default-devel.sha256sum] = "e7460ba791efb7bc4ded9561c105eedee8717b0f65fcb513fe5ca8984dab6d70"

URI_aarch64_rust-event-listener-strategy+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-strategy+portable-atomic-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener-strategy+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-strategy+portable-atomic-devel}"
SRC_URI[aarch64_rust-event-listener-strategy+portable-atomic-devel.sha256sum] = "a577ab9dfdb95aba51cc9319c4c275e62ef18ac8fc01afe185114b3a7cd2d800"

URI_aarch64_rust-event-listener-strategy+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-strategy+std-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener-strategy+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-strategy+std-devel}"
SRC_URI[aarch64_rust-event-listener-strategy+std-devel.sha256sum] = "5a2f99dbccb9355552ca8436770ef412406413f7a8862479668ed528efe59cc7"

URI_aarch64_rust-event-listener-strategy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-strategy-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-event-listener-strategy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-strategy-devel}"
SRC_URI[aarch64_rust-event-listener-strategy-devel.sha256sum] = "c02cff70ae1236ece1a9e0fce005339df0f2e05d05356b52c20d171ddf59b56e"

RDEPENDS:rust-event-listener-strategy+default-devel = " \
 cargo \
 rust-event-listener-strategy+std-devel \
 rust-event-listener-strategy-devel \
 "
RDEPENDS:rust-event-listener-strategy+portable-atomic-devel = " \
 cargo \
 rust-event-listener+portable-atomic-devel \
 rust-event-listener-strategy-devel \
 "
RDEPENDS:rust-event-listener-strategy+std-devel = " \
 cargo \
 rust-event-listener+std-devel \
 rust-event-listener-strategy-devel \
 "
RDEPENDS:rust-event-listener-strategy-devel = " \
 cargo \
 rust \
 rust-event-listener-devel \
 rust-pin-project-lite+default-devel \
 "
