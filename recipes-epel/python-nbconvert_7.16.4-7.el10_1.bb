# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nbconvert"
PV = "7.16.4"
PR = "7.el10_1"
PACKAGES = " \
 python3-nbconvert \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nbconvert-7.16.4-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a16e586d488f1a38c15a457d4688b6d57d466c3e5766eeaf3bb01240d9597ae"

URI_x86_64_v2_python3-nbconvert = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nbconvert-7.16.4-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nbconvert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nbconvert}"
SRC_URI[x86_64_v2_python3-nbconvert.sha256sum] = "c818d2cfe8794d3b42535d08cfedde80fb4e9b34aef8d5563dea4f4edc63a4fa"

URI_aarch64_python3-nbconvert = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nbconvert-7.16.4-7.el10_1.noarch.rpm;name=aarch64_python3-nbconvert;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nbconvert}"
SRC_URI[aarch64_python3-nbconvert.sha256sum] = "9cc1278673b5a87a1e460bca62235839ecb046228f4fdef03ca7de8a8d9df6c6"

RDEPENDS:python3-nbconvert = " \
 python3 \
 python3-beautifulsoup4 \
 python3-bleach \
 python3-defusedxml \
 python3-jinja2 \
 python3-jupyter-core \
 python3-jupyterlab_pygments \
 python3-markupsafe \
 python3-mistune \
 python3-nbclient \
 python3-nbformat \
 python3-packaging \
 python3-pandocfilters \
 python3-pygments \
 python3-tinycss2 \
 python3-traitlets \
 "
