# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nx-libs"
PV = "3.5.99.27"
PR = "6.el10_2"
PACKAGES = " \
 libNX_X11 \
 libNX_X11-devel \
 libXcomp \
 libXcomp-devel \
 libXcompshad \
 libXcompshad-devel \
 nx-libs \
 nx-libs-devel \
 nx-proto-devel \
 nxagent \
 nxdialog \
 nxproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nx-libs-3.5.99.27-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6751c1e2df30ae93e29686b72b139c7ae449415bdf5ff84eb2adeb1c59a9308"

URI_x86_64_v2_libNX_X11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libNX_X11-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libNX_X11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libNX_X11}"
SRC_URI[x86_64_v2_libNX_X11.sha256sum] = "df939eab437ff310e3a38416ac15f641518e8c6d3d65bac479305653cc4b8a03"

URI_x86_64_v2_libNX_X11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libNX_X11-devel-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libNX_X11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libNX_X11-devel}"
SRC_URI[x86_64_v2_libNX_X11-devel.sha256sum] = "89f7135988712cc1c3a1e3bac22e4389b7b29e1dde90b345a6cf8fd7ea0bbe93"

URI_x86_64_v2_libXcomp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcomp-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcomp}"
SRC_URI[x86_64_v2_libXcomp.sha256sum] = "edbad7be48ede009aca2c1ded4e8d435fe5f3d5e00844ed80c3c07fa2dec9ff0"

URI_x86_64_v2_libXcomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcomp-devel-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcomp-devel}"
SRC_URI[x86_64_v2_libXcomp-devel.sha256sum] = "deb76a99a31a1b0a4e8f92016a0eb00dfe1d9650ad495880d02b8e87807601b4"

URI_x86_64_v2_libXcompshad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcompshad-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcompshad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcompshad}"
SRC_URI[x86_64_v2_libXcompshad.sha256sum] = "45160027b8f7d53d6086f78d12e3063d8f8850eceac9bbbf9ad757ceadf10b7d"

URI_x86_64_v2_libXcompshad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXcompshad-devel-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXcompshad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXcompshad-devel}"
SRC_URI[x86_64_v2_libXcompshad-devel.sha256sum] = "b2df2521b47ac6b09902a469125d536b1a4597ef40da4a75184226679578c8b5"

URI_x86_64_v2_nx-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nx-libs-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nx-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nx-libs}"
SRC_URI[x86_64_v2_nx-libs.sha256sum] = "e33ff3100c1f1c3c8e7a58d16f3ec961c4a44d16f72040f1a0d8baf7a3bc846e"

URI_x86_64_v2_nx-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nx-libs-devel-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nx-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nx-libs-devel}"
SRC_URI[x86_64_v2_nx-libs-devel.sha256sum] = "5c6e2a95ac7114c906bf135e5334050dccb9f8c0a68a14a5782e0a37730cfb56"

URI_x86_64_v2_nx-proto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nx-proto-devel-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nx-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nx-proto-devel}"
SRC_URI[x86_64_v2_nx-proto-devel.sha256sum] = "3072547f90aa823c37d3c79929b816f00faf271e8bae9f735f25938523caa0ab"

URI_x86_64_v2_nxagent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nxagent-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nxagent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxagent}"
SRC_URI[x86_64_v2_nxagent.sha256sum] = "1401103fdc0bb8f05f645437938ba726d52441b9569e7897ccb0d45e44a23ec7"

URI_x86_64_v2_nxdialog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nxdialog-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nxdialog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxdialog}"
SRC_URI[x86_64_v2_nxdialog.sha256sum] = "35e49af1605d0452d819ee7b2e14fcb3799477c279c2fcb563a183e14fcf3279"

URI_x86_64_v2_nxproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nxproxy-3.5.99.27-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nxproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nxproxy}"
SRC_URI[x86_64_v2_nxproxy.sha256sum] = "012a41aea49ef662d11f715ff2d5d1bc83466518530440b4aa2b74e1363c939c"

URI_aarch64_libNX_X11 = "${EPEL_MIRROR}/aarch64/Packages/l/libNX_X11-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_libNX_X11;unpack=0"
SRC_URI:append = " ${URI_aarch64_libNX_X11}"
SRC_URI[aarch64_libNX_X11.sha256sum] = "b5f23032ec3ef0dde2e2de08a80d131a81eb851e6d00fbe048e62143311f2758"

URI_aarch64_libNX_X11-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libNX_X11-devel-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_libNX_X11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libNX_X11-devel}"
SRC_URI[aarch64_libNX_X11-devel.sha256sum] = "d0db7000dc154d781d501a269420f3f1583f5ded7c58392f10abc817cf68d021"

URI_aarch64_libXcomp = "${EPEL_MIRROR}/aarch64/Packages/l/libXcomp-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_libXcomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcomp}"
SRC_URI[aarch64_libXcomp.sha256sum] = "010a5832613ade5858cd03b35d70cff52472812a05125a6d3d2861d3761925e9"

URI_aarch64_libXcomp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXcomp-devel-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_libXcomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcomp-devel}"
SRC_URI[aarch64_libXcomp-devel.sha256sum] = "02da06b5dbd6f25215961c81949e8e65d4b7d08b626c6d6cd0df42406d7518c5"

URI_aarch64_libXcompshad = "${EPEL_MIRROR}/aarch64/Packages/l/libXcompshad-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_libXcompshad;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcompshad}"
SRC_URI[aarch64_libXcompshad.sha256sum] = "ae2b153f23521d7f50f859753cd394367bf0079801923586a572963da281767f"

URI_aarch64_libXcompshad-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXcompshad-devel-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_libXcompshad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXcompshad-devel}"
SRC_URI[aarch64_libXcompshad-devel.sha256sum] = "22add794d95b152c3581c47b9f6cbc3388548f09f9da80b89e57254bf83c103a"

URI_aarch64_nx-libs = "${EPEL_MIRROR}/aarch64/Packages/n/nx-libs-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_nx-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nx-libs}"
SRC_URI[aarch64_nx-libs.sha256sum] = "77c944f98d8070b6996bd051585bd0563a58a682f06c277d9d5b86812467ecbc"

URI_aarch64_nx-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nx-libs-devel-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_nx-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nx-libs-devel}"
SRC_URI[aarch64_nx-libs-devel.sha256sum] = "2a318cabb2bdb3ad50c720c38f814013b5692acee42b1afa2dfda901ab942133"

URI_aarch64_nx-proto-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nx-proto-devel-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_nx-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nx-proto-devel}"
SRC_URI[aarch64_nx-proto-devel.sha256sum] = "9d4d56810bf39589da39b8139cdbbf43bdc7104e603387d72c92bfef38e3b5fb"

URI_aarch64_nxagent = "${EPEL_MIRROR}/aarch64/Packages/n/nxagent-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_nxagent;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxagent}"
SRC_URI[aarch64_nxagent.sha256sum] = "a697067e0131e7f00da2fee2e202011b13758f012c05f49bc7ca5c4645eedff9"

URI_aarch64_nxdialog = "${EPEL_MIRROR}/aarch64/Packages/n/nxdialog-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_nxdialog;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxdialog}"
SRC_URI[aarch64_nxdialog.sha256sum] = "b4e24bab9df6989a425c99fc28ee2adb93aea7cc87032497fe23101178d30feb"

URI_aarch64_nxproxy = "${EPEL_MIRROR}/aarch64/Packages/n/nxproxy-3.5.99.27-6.el10_2.aarch64.rpm;name=aarch64_nxproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_nxproxy}"
SRC_URI[aarch64_nxproxy.sha256sum] = "f58515e09357c519f8f8dfc5025bad46a5798b122667fb071edf90686bddcdba"

RDEPENDS:libNX_X11 = " \
 glibc \
 libXcomp \
 libXdmcp \
 libjpeg-turbo \
 libpng \
 nx-libs \
 zlib-ng-compat \
 "
RDEPENDS:libNX_X11-devel = " \
 libNX_X11 \
 nx-proto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libXcomp = " \
 glibc \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 nx-libs \
 zlib-ng-compat \
 "
RDEPENDS:libXcomp-devel = " \
 libX11-devel \
 libXcomp \
 libpng-devel \
 nx-proto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libXcompshad = " \
 glibc \
 libNX_X11 \
 libX11 \
 libXcomp \
 libXdamage \
 libXdmcp \
 libXext \
 libXfixes \
 libXrandr \
 libXtst \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 nx-libs \
 zlib-ng-compat \
 "
RDEPENDS:libXcompshad-devel = " \
 libNX_X11-devel \
 libX11-devel \
 libXcomp-devel \
 libXcompshad \
 nx-libs-devel \
 nx-proto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nx-libs = " \
 "
RDEPENDS:nx-libs-devel = " \
 libNX_X11-devel \
 nx-libs \
 nx-proto-devel \
 "
RDEPENDS:nx-proto-devel = " \
 "
RDEPENDS:nxagent = " \
 glibc \
 libNX_X11 \
 libX11 \
 libXcomp \
 libXcomposite \
 libXcompshad \
 libXdmcp \
 libXext \
 libXfixes \
 libXfont2 \
 libXinerama \
 libXpm \
 libXrender \
 libgcc \
 libjpeg-turbo \
 libpng \
 libtirpc \
 libxml2 \
 pixman \
 zlib-ng-compat \
 "
RDEPENDS:nxdialog = " \
 python3 \
 "
RDEPENDS:nxproxy = " \
 glibc \
 libXcomp \
 "
