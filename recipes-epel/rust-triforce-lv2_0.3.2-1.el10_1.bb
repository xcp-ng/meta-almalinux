# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-triforce-lv2"
PV = "0.3.2"
PR = "1.el10_1"
PACKAGES = " \
 lv2-triforce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-triforce-lv2-0.3.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e7dd6a4a0a91c35305b0a9626c6a2128ed7584750f2f5df85a207e4c50ac5c2"

URI_x86_64_v2_lv2-triforce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lv2-triforce-0.3.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lv2-triforce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lv2-triforce}"
SRC_URI[x86_64_v2_lv2-triforce.sha256sum] = "eb59437bc451c06702d4b849df0f2189e173724303cc961be4276789dac603e2"

URI_aarch64_lv2-triforce = "${EPEL_MIRROR}/aarch64/Packages/l/lv2-triforce-0.3.2-1.el10_1.aarch64.rpm;name=aarch64_lv2-triforce;unpack=0"
SRC_URI:append = " ${URI_aarch64_lv2-triforce}"
SRC_URI[aarch64_lv2-triforce.sha256sum] = "98783de994715058eafe54fb57a0c869487e16b67e77adf66a4125c741ad2391"

RDEPENDS:lv2-triforce = " \
 glibc \
 libgcc \
 lv2 \
 "
