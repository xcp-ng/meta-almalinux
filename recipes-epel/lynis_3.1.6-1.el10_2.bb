# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lynis"
PV = "3.1.6"
PR = "1.el10_2"
PACKAGES = " \
 lynis \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lynis-3.1.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6db129e18b3cfc3eebaff2572b13e9e3c2f522e226fdb99a20994fb6891dfdd8"

URI_x86_64_v2_lynis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lynis-3.1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_lynis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lynis}"
SRC_URI[x86_64_v2_lynis.sha256sum] = "c6700abee0c58a214549b83e0ecbf94228d06505e457d02fd67acb7323e917c1"

URI_aarch64_lynis = "${EPEL_MIRROR}/aarch64/Packages/l/lynis-3.1.6-1.el10_2.noarch.rpm;name=aarch64_lynis;unpack=0"
SRC_URI:append = " ${URI_aarch64_lynis}"
SRC_URI[aarch64_lynis.sha256sum] = "1d56b54eefb66718d95deec72a963244ace05faf2f4356bb57ef24bc082837e6"

RDEPENDS:lynis = " \
 audit \
 bash \
 e2fsprogs \
 kmod \
 "
