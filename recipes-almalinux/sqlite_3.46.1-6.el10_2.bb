# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sqlite"
PV = "3.46.1"
PR = "6.el10_2"
PACKAGES = " \
 sqlite \
 sqlite-devel \
 sqlite-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sqlite-3.46.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ad5683d18fc712b5bc0ce1db363456a8433c05b80678912fbe2e30f78e0030be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-3.46.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_sqlite;unpack=0"
SRC_URI[x86_64_v2_sqlite.sha256sum] = "7007c70dd0690d506723a6a1e3afcdbfb3392f7825544223afaecde07edf8718"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-devel-3.46.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_sqlite-devel;unpack=0"
SRC_URI[x86_64_v2_sqlite-devel.sha256sum] = "5d53eaef7408b6197a194c5ee9e6078f11a083dcf9596b056de9402edc7d6300"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sqlite-libs-3.46.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_sqlite-libs;unpack=0"
SRC_URI[x86_64_v2_sqlite-libs.sha256sum] = "51aa6837357d2201989fe9c15654c9854c1f02a91e503a19372743ec7f00b4c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-3.46.1-6.el10_2.aarch64.rpm;name=aarch64_sqlite;unpack=0"
SRC_URI[aarch64_sqlite.sha256sum] = "1a8fa785179c7a1cb9542b60f479ed66c87e21ade11145c3999910772a792caf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-devel-3.46.1-6.el10_2.aarch64.rpm;name=aarch64_sqlite-devel;unpack=0"
SRC_URI[aarch64_sqlite-devel.sha256sum] = "8310015493a3114f342b37db03d33c805de32c68b5ec234bab7a12377c6cf71a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sqlite-libs-3.46.1-6.el10_2.aarch64.rpm;name=aarch64_sqlite-libs;unpack=0"
SRC_URI[aarch64_sqlite-libs.sha256sum] = "e63ba95d09d17e86d16752ade472827928031ca609322412c4f9b7ba8d0d8920"

RDEPENDS:sqlite = " \
 glibc \
 readline \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:sqlite-devel = " \
 pkgconf-pkg-config \
 sqlite \
 sqlite-libs \
 "
RDEPENDS:sqlite-libs = " \
 glibc \
 zlib-ng-compat \
 "
