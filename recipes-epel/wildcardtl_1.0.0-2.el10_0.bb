# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wildcardtl"
PV = "1.0.0"
PR = "2.el10_0"
PACKAGES = " \
 wildcardtl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wildcardtl-1.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d076ba8185696d438b592b1118965a2dcbbf5f156ca3970b9233e80329c65f6c"

URI_x86_64_v2_wildcardtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wildcardtl-devel-1.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_wildcardtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wildcardtl-devel}"
SRC_URI[x86_64_v2_wildcardtl-devel.sha256sum] = "19d179b0994cd9bc095207a58e70d7f697aabdf189130b51b0d0a97b392f48c3"

URI_aarch64_wildcardtl-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wildcardtl-devel-1.0.0-2.el10_0.noarch.rpm;name=aarch64_wildcardtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wildcardtl-devel}"
SRC_URI[aarch64_wildcardtl-devel.sha256sum] = "948a49fc84cc217ab7a3e2f0618df1f0e42666da91b9b263d14f2803a7f26f6f"

RDEPENDS:wildcardtl-devel = " \
 "
