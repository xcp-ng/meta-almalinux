# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "davix"
PV = "0.8.9"
PR = "1.el10_0"
PACKAGES = " \
 davix \
 davix-devel \
 davix-doc \
 davix-libs \
 davix-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/davix-0.8.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "573946b1ca812dafec2e154d749431da974ec81ddba398f54ab1375e98d85458"

URI_x86_64_v2_davix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/davix-0.8.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_davix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_davix}"
SRC_URI[x86_64_v2_davix.sha256sum] = "4ac0eba31a150d8ecc3f4fa68358f92133644e4610daa3c7d67acf79bae5e84a"

URI_x86_64_v2_davix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/davix-devel-0.8.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_davix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_davix-devel}"
SRC_URI[x86_64_v2_davix-devel.sha256sum] = "5340226369b514757fd6f9b83ae3f3f60e87fc1d81ef11c3430564503d0ebb64"

URI_x86_64_v2_davix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/davix-doc-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_davix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_davix-doc}"
SRC_URI[x86_64_v2_davix-doc.sha256sum] = "775a14b9b9f058cda13ae9b7b5f62647d09276149185ade100292a8bb680a258"

URI_x86_64_v2_davix-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/davix-libs-0.8.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_davix-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_davix-libs}"
SRC_URI[x86_64_v2_davix-libs.sha256sum] = "de3e1a593ff084a5439185cdbae497107a0e9342a7bdbbac44b3f944ad051de8"

URI_x86_64_v2_davix-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/davix-tests-0.8.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_davix-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_davix-tests}"
SRC_URI[x86_64_v2_davix-tests.sha256sum] = "cffedeec265acf417aa8988b1d839e9afdb1e3da14eb0f008f4d8d47dac5f1d5"

URI_aarch64_davix = "${EPEL_MIRROR}/aarch64/Packages/d/davix-0.8.9-1.el10_0.aarch64.rpm;name=aarch64_davix;unpack=0"
SRC_URI:append = " ${URI_aarch64_davix}"
SRC_URI[aarch64_davix.sha256sum] = "d51399632584b454e347cae3fb60cbb09632d9a6cfe83aa94ededb17dd0ba542"

URI_aarch64_davix-devel = "${EPEL_MIRROR}/aarch64/Packages/d/davix-devel-0.8.9-1.el10_0.aarch64.rpm;name=aarch64_davix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_davix-devel}"
SRC_URI[aarch64_davix-devel.sha256sum] = "937b785f0539107898cbade6ba7b47ebc6ae87c2d2ba8cdf988fa550f66b6c3d"

URI_aarch64_davix-doc = "${EPEL_MIRROR}/aarch64/Packages/d/davix-doc-0.8.9-1.el10_0.noarch.rpm;name=aarch64_davix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_davix-doc}"
SRC_URI[aarch64_davix-doc.sha256sum] = "1ba3a67cb2fe206804ca3568aa64f27b5074deeb5bce2abb734fab0a7ad8a508"

URI_aarch64_davix-libs = "${EPEL_MIRROR}/aarch64/Packages/d/davix-libs-0.8.9-1.el10_0.aarch64.rpm;name=aarch64_davix-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_davix-libs}"
SRC_URI[aarch64_davix-libs.sha256sum] = "986eaf0d774ec8255513c9d9db18bf96d7abeb10830b61bde0933b7ef8eeda1e"

URI_aarch64_davix-tests = "${EPEL_MIRROR}/aarch64/Packages/d/davix-tests-0.8.9-1.el10_0.aarch64.rpm;name=aarch64_davix-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_davix-tests}"
SRC_URI[aarch64_davix-tests.sha256sum] = "af290586c747727ee14457e33cb32f1875c477967e46f32cb6f036b01a5d9b9b"

RDEPENDS:davix = " \
 davix-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:davix-devel = " \
 davix-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:davix-doc = " \
 "
RDEPENDS:davix-libs = " \
 glibc \
 gsoap \
 libgcc \
 libstdc++ \
 libuuid \
 libxml2 \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:davix-tests = " \
 davix-libs \
 glibc \
 gtest \
 libgcc \
 libstdc++ \
 "
