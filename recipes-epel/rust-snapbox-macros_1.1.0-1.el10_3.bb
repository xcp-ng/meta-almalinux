# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snapbox-macros"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-snapbox-macros+color-devel \
 rust-snapbox-macros+debug-devel \
 rust-snapbox-macros+default-devel \
 rust-snapbox-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snapbox-macros-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "134f162fc192b33b23ffedcd2a7fb39ab51b7e8062ddba0f1388196a9f8006aa"

URI_x86_64_v2_rust-snapbox-macros+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros+color-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros+color-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros+color-devel.sha256sum] = "d94b0e5b47a5df8aa95077e502672e3142afa0c3181ec1bf3be9d390e04176ff"

URI_x86_64_v2_rust-snapbox-macros+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros+debug-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros+debug-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros+debug-devel.sha256sum] = "ed86a670dfbcf669b13b2ec71de8d1bd5adf597e972337a0f11bf8854f516d30"

URI_x86_64_v2_rust-snapbox-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros+default-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros+default-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros+default-devel.sha256sum] = "16b725aeb59c55b9465fb665101dd6df1e5027c185f7c54fc90f933aa779541e"

URI_x86_64_v2_rust-snapbox-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros-devel.sha256sum] = "b7ef877b4f29d33487f4c15883f2b5eb100ebb22067fea8410e3cb3675adba6b"

URI_aarch64_rust-snapbox-macros+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros+color-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox-macros+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros+color-devel}"
SRC_URI[aarch64_rust-snapbox-macros+color-devel.sha256sum] = "941fad7ee7c0d744e1a7fc3b200c58557600825e48ce26f12e1f1082d1500c75"

URI_aarch64_rust-snapbox-macros+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros+debug-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox-macros+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros+debug-devel}"
SRC_URI[aarch64_rust-snapbox-macros+debug-devel.sha256sum] = "bea5085a632dae0f12ef0844f4c325d4f8bcd1b170faf870bbab1db406d41850"

URI_aarch64_rust-snapbox-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros+default-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros+default-devel}"
SRC_URI[aarch64_rust-snapbox-macros+default-devel.sha256sum] = "925112bdb2d9798f462d504908b84544d03aec1760ebafa350095e2c2a3dada0"

URI_aarch64_rust-snapbox-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-snapbox-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros-devel}"
SRC_URI[aarch64_rust-snapbox-macros-devel.sha256sum] = "94caf98c00ae897aeb20db9cba7b00e4452f5a7986926734c8c8ddb580d7ca99"

RDEPENDS:rust-snapbox-macros+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox-macros-devel \
 "
RDEPENDS:rust-snapbox-macros+debug-devel = " \
 cargo \
 rust-snapbox-macros-devel \
 "
RDEPENDS:rust-snapbox-macros+default-devel = " \
 cargo \
 rust-snapbox-macros-devel \
 "
RDEPENDS:rust-snapbox-macros-devel = " \
 cargo \
 rust \
 "
