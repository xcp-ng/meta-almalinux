# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipset"
PV = "7.22"
PR = "12.el10"
PACKAGES = " \
 ipset \
 ipset-devel \
 ipset-libs \
 ipset-service \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ipset-7.22-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b27b0bfd9acaec49b879aa220909509f7ac4f68636289da4ec865d7ffebc31e4"

URI_x86_64_v2_ipset = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-7.22-12.el10.x86_64_v2.rpm;name=x86_64_v2_ipset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset}"
SRC_URI[x86_64_v2_ipset.sha256sum] = "00fd9c2cae25939d8156b3372ac8aabc6f38ad5a0246b85a6160654decf37819"

URI_x86_64_v2_ipset-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ipset-devel-7.22-12.el10.x86_64_v2.rpm;name=x86_64_v2_ipset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset-devel}"
SRC_URI[x86_64_v2_ipset-devel.sha256sum] = "cb4332704447302fc00010f633711bdbc1da356d1d5e0c8977450077f187058c"

URI_x86_64_v2_ipset-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ipset-libs-7.22-12.el10.x86_64_v2.rpm;name=x86_64_v2_ipset-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset-libs}"
SRC_URI[x86_64_v2_ipset-libs.sha256sum] = "6d5e92633cbaf9594f90bad9a804fb61128ca0b7aa568e23f884e231b7ac9a45"

URI_x86_64_v2_ipset-service = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipset-service-7.22-12.el10.noarch.rpm;name=x86_64_v2_ipset-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipset-service}"
SRC_URI[x86_64_v2_ipset-service.sha256sum] = "adb246367e354f888596f9cf81f85abf079b20feb41dd833e419a165fa124041"

URI_aarch64_ipset = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-7.22-12.el10.aarch64.rpm;name=aarch64_ipset;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset}"
SRC_URI[aarch64_ipset.sha256sum] = "86fc1fca6898840860ba44f278a746f1a36e39c23d16d46e5ccf295c97d8c212"

URI_aarch64_ipset-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ipset-devel-7.22-12.el10.aarch64.rpm;name=aarch64_ipset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset-devel}"
SRC_URI[aarch64_ipset-devel.sha256sum] = "67ba70fac8b778b9d58b702bc30da41bd4aa5b0676f4c798edd75ed0796a73a9"

URI_aarch64_ipset-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ipset-libs-7.22-12.el10.aarch64.rpm;name=aarch64_ipset-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset-libs}"
SRC_URI[aarch64_ipset-libs.sha256sum] = "ed595400eefed2365cde7eaa86f39d862b35ec03e909e1b9d9ce71b09742f0da"

URI_aarch64_ipset-service = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipset-service-7.22-12.el10.noarch.rpm;name=aarch64_ipset-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipset-service}"
SRC_URI[aarch64_ipset-service.sha256sum] = "adb246367e354f888596f9cf81f85abf079b20feb41dd833e419a165fa124041"

RDEPENDS:ipset = " \
 bash \
 glibc \
 ipset-libs \
 "
RDEPENDS:ipset-devel = " \
 ipset-libs \
 kernel-headers \
 libmnl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ipset-libs = " \
 glibc \
 libmnl \
 "
RDEPENDS:ipset-service = " \
 bash \
 ipset \
 iptables-nft-services \
 systemd \
 "
