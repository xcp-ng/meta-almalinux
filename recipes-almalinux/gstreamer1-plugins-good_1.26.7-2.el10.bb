# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-good"
PV = "1.26.7"
PR = "2.el10"
PACKAGES = " \
 gstreamer1-plugins-good \
 gstreamer1-plugins-good-gtk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-good-1.26.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ef0e173e2810c5c7eeb82879f118f38dee37b27e82682bff48efb518516aad5"

URI_x86_64_v2_gstreamer1-plugins-good = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-1.26.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-good}"
SRC_URI[x86_64_v2_gstreamer1-plugins-good.sha256sum] = "68502e74fc97be5dea5df000f5df59c990cf9eb35ebaa902cca228dcc36399b9"

URI_x86_64_v2_gstreamer1-plugins-good-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-gtk-1.26.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-good-gtk}"
SRC_URI[x86_64_v2_gstreamer1-plugins-good-gtk.sha256sum] = "b6707b5956e877499f2b5c7a72b5c48c2b75e0d2d8178af6a094fe37af5d01eb"

URI_aarch64_gstreamer1-plugins-good = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-1.26.7-2.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-good;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-good}"
SRC_URI[aarch64_gstreamer1-plugins-good.sha256sum] = "85ea20aaacbe807f731b2e10b2be02d8350dcc62772313d2fc4b9a4e2f90b350"

URI_aarch64_gstreamer1-plugins-good-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-gtk-1.26.7-2.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-good-gtk}"
SRC_URI[aarch64_gstreamer1-plugins-good-gtk.sha256sum] = "e68d1523a34d745cdca390aa4cf11a902ca3eebd477e31bfc5f9d4df515b0b85"

RDEPENDS:gstreamer1-plugins-good = " \
 bzip2-libs \
 cairo \
 cairo-gobject \
 flac-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXtst \
 libgcc \
 libgudev \
 libjpeg-turbo \
 libpng \
 libshout \
 libstdc++ \
 libv4l \
 libvpx \
 libxml2 \
 mpg123-libs \
 openssl-libs \
 orc \
 pulseaudio-libs \
 speex \
 taglib \
 twolame-libs \
 wavpack \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-good-gtk = " \
 cairo \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 gtk3 \
 "
