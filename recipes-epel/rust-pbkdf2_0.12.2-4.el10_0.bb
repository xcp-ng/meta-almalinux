# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pbkdf2"
PV = "0.12.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-pbkdf2+default-devel \
 rust-pbkdf2+hmac-devel \
 rust-pbkdf2+parallel-devel \
 rust-pbkdf2+password-hash-devel \
 rust-pbkdf2+rayon-devel \
 rust-pbkdf2+sha1-devel \
 rust-pbkdf2+sha2-devel \
 rust-pbkdf2+simple-devel \
 rust-pbkdf2+std-devel \
 rust-pbkdf2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pbkdf2-0.12.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec277fcaa089245a37aeda31dfcdfb31be4f9af6442451292352d009c5379035"

URI_x86_64_v2_rust-pbkdf2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+default-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+default-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+default-devel.sha256sum] = "5f958b2595c1cc95462fea83ae80418f634872d98e1d3194270a687ccf315cf8"

URI_x86_64_v2_rust-pbkdf2+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+hmac-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+hmac-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+hmac-devel.sha256sum] = "b629687b8239b734ba900eb75993c72622be68778d4477a42268601f0cc37eaf"

URI_x86_64_v2_rust-pbkdf2+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+parallel-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+parallel-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+parallel-devel.sha256sum] = "c448e71692279e4fbfabc1e10e267f26c3f6293846227cae1ec3686dff7d8d86"

URI_x86_64_v2_rust-pbkdf2+password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+password-hash-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+password-hash-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+password-hash-devel.sha256sum] = "41e04307de8b96aca540e49ff83f034b08fbb5d2d98bfbb44ac657b8b4089259"

URI_x86_64_v2_rust-pbkdf2+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+rayon-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+rayon-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+rayon-devel.sha256sum] = "40a4416974eb7da1a73af5238b821e3906745bc6074c471ddcda80253dd67878"

URI_x86_64_v2_rust-pbkdf2+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+sha1-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+sha1-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+sha1-devel.sha256sum] = "7d851c4ae668f99374e1674c349bbf1f479e2ed83f8eb1ae16cc8fe07586e221"

URI_x86_64_v2_rust-pbkdf2+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+sha2-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+sha2-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+sha2-devel.sha256sum] = "9855b6eb00f2efcd613a5df319c97dc56e4ce7064249ed146e690c8216348a6c"

URI_x86_64_v2_rust-pbkdf2+simple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+simple-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+simple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+simple-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+simple-devel.sha256sum] = "22de12338127168108ab6d9784a9fc0acf81b913d91abc15f1e7bffbe3b8d7c4"

URI_x86_64_v2_rust-pbkdf2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2+std-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2+std-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2+std-devel.sha256sum] = "4ddee2362953e80b6e82846f3d047eadbd860433da0e6b80b04ce3108983571a"

URI_x86_64_v2_rust-pbkdf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pbkdf2-devel-0.12.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pbkdf2-devel}"
SRC_URI[x86_64_v2_rust-pbkdf2-devel.sha256sum] = "86e402fdda0daba396a7f098757b43cb0398726daa464f9b32941484c8ef1d90"

URI_aarch64_rust-pbkdf2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+default-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+default-devel}"
SRC_URI[aarch64_rust-pbkdf2+default-devel.sha256sum] = "7c89c5cce194d55cde37d72d586e7997df73176390ff28733791cb435b43181c"

URI_aarch64_rust-pbkdf2+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+hmac-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+hmac-devel}"
SRC_URI[aarch64_rust-pbkdf2+hmac-devel.sha256sum] = "e30b17b6b028f528bcfe188675361b963cbf8279082623ac49ffabb4372f7a11"

URI_aarch64_rust-pbkdf2+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+parallel-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+parallel-devel}"
SRC_URI[aarch64_rust-pbkdf2+parallel-devel.sha256sum] = "ea497b9fa1e8e350ec3382740e898776e63a883aa197d2a5e773f33693bc7e97"

URI_aarch64_rust-pbkdf2+password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+password-hash-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+password-hash-devel}"
SRC_URI[aarch64_rust-pbkdf2+password-hash-devel.sha256sum] = "840a94aad75303bcb33d78fedff2398a1240813ef6746bb2c4f865b161c8df80"

URI_aarch64_rust-pbkdf2+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+rayon-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+rayon-devel}"
SRC_URI[aarch64_rust-pbkdf2+rayon-devel.sha256sum] = "f1f7aded93b52feb53e1463796cdaad6ae22a58fe013c8882996e75f5ffc4665"

URI_aarch64_rust-pbkdf2+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+sha1-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+sha1-devel}"
SRC_URI[aarch64_rust-pbkdf2+sha1-devel.sha256sum] = "447c6ad95f1e8b43e650a62d6ff9611b5c735bdfda95169734cfebb689480908"

URI_aarch64_rust-pbkdf2+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+sha2-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+sha2-devel}"
SRC_URI[aarch64_rust-pbkdf2+sha2-devel.sha256sum] = "1ca5c15a5bf59ce7975c769793df6f5d173736f62a285933a942b6a9136f6cc1"

URI_aarch64_rust-pbkdf2+simple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+simple-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2+simple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+simple-devel}"
SRC_URI[aarch64_rust-pbkdf2+simple-devel.sha256sum] = "bc1aa860232563896eccdb5fbc7bc323a8e7dfc67b97ca532122f9f3dce30666"

URI_aarch64_rust-pbkdf2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2+std-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2+std-devel}"
SRC_URI[aarch64_rust-pbkdf2+std-devel.sha256sum] = "96ff9c2d806def62a6cc426eccac86fbf5afbf7284366b050edb6a8ed1065a63"

URI_aarch64_rust-pbkdf2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pbkdf2-devel-0.12.2-4.el10_0.noarch.rpm;name=aarch64_rust-pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pbkdf2-devel}"
SRC_URI[aarch64_rust-pbkdf2-devel.sha256sum] = "89c6dd7630fa980da60f0d5e0ccd9d4e5fabc51f98300e0c9d646f14dfff2fe6"

RDEPENDS:rust-pbkdf2+default-devel = " \
 cargo \
 rust-pbkdf2+hmac-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+hmac-devel = " \
 cargo \
 rust-hmac-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+parallel-devel = " \
 cargo \
 rust-pbkdf2+rayon-devel \
 rust-pbkdf2+std-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+password-hash-devel = " \
 cargo \
 rust-password-hash+rand_core-devel \
 rust-password-hash-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+rayon-devel = " \
 cargo \
 rust-pbkdf2-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-pbkdf2+sha1-devel = " \
 cargo \
 rust-pbkdf2-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-pbkdf2+sha2-devel = " \
 cargo \
 rust-pbkdf2-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-pbkdf2+simple-devel = " \
 cargo \
 rust-pbkdf2+hmac-devel \
 rust-pbkdf2+password-hash-devel \
 rust-pbkdf2+sha2-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2+std-devel = " \
 cargo \
 rust-password-hash+rand_core-devel \
 rust-password-hash+std-devel \
 rust-password-hash-devel \
 rust-pbkdf2-devel \
 "
RDEPENDS:rust-pbkdf2-devel = " \
 cargo \
 rust \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
