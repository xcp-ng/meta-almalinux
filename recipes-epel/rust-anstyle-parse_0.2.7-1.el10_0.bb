# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-parse"
PV = "0.2.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-anstyle-parse+core-devel \
 rust-anstyle-parse+default-devel \
 rust-anstyle-parse+utf8-devel \
 rust-anstyle-parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-parse-0.2.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3e5ca33bbdfa24e66062fedc6d9dfc00b4004011e1f3891d51c963519bc9389"

URI_x86_64_v2_rust-anstyle-parse+core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse+core-devel-0.2.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse+core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse+core-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse+core-devel.sha256sum] = "f53115e048e40ba8ddbfd8e7aab434471d32e420c9ed2bdc873b6b601b2a60cc"

URI_x86_64_v2_rust-anstyle-parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse+default-devel-0.2.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse+default-devel.sha256sum] = "3933dc72acf507b9e12dab8274b6ae07ea4febc4e133c24241ef9a43a7dc5ea3"

URI_x86_64_v2_rust-anstyle-parse+utf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse+utf8-devel-0.2.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse+utf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse+utf8-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse+utf8-devel.sha256sum] = "587b71bc320a626d35a4440e622e0d70c93619cdd03284b1c9c1284d66031978"

URI_x86_64_v2_rust-anstyle-parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse-devel-0.2.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse-devel.sha256sum] = "c33ead22b664944faa4f3b0ab16fd18c6f76ae27a28bf934957ec36b55c961c5"

URI_aarch64_rust-anstyle-parse+core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse+core-devel-0.2.7-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-parse+core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse+core-devel}"
SRC_URI[aarch64_rust-anstyle-parse+core-devel.sha256sum] = "b9b11edd56e4ae27c2d4a3e24ecd99e13c2d4d1dcef705ebb6f1d7d6c10483bf"

URI_aarch64_rust-anstyle-parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse+default-devel-0.2.7-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse+default-devel}"
SRC_URI[aarch64_rust-anstyle-parse+default-devel.sha256sum] = "52dda4926a997fda3a994d2f0f68907cb6a214ff168ba02fe10e0e80da90dbf6"

URI_aarch64_rust-anstyle-parse+utf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse+utf8-devel-0.2.7-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-parse+utf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse+utf8-devel}"
SRC_URI[aarch64_rust-anstyle-parse+utf8-devel.sha256sum] = "c12daf92fa34bdfe82aa504ad7b3e9eeefc8fd22a0d4c10e3750088e305eaf12"

URI_aarch64_rust-anstyle-parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse-devel-0.2.7-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse-devel}"
SRC_URI[aarch64_rust-anstyle-parse-devel.sha256sum] = "9f9c56c679db1a25f1d30d4f984f45480304d4e5259a97f192a2ce4ce8f0d3b8"

RDEPENDS:rust-anstyle-parse+core-devel = " \
 cargo \
 rust-anstyle-parse-devel \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-anstyle-parse+default-devel = " \
 cargo \
 rust-anstyle-parse+utf8-devel \
 rust-anstyle-parse-devel \
 "
RDEPENDS:rust-anstyle-parse+utf8-devel = " \
 cargo \
 rust-anstyle-parse-devel \
 rust-utf8parse+default-devel \
 "
RDEPENDS:rust-anstyle-parse-devel = " \
 cargo \
 rust \
 "
