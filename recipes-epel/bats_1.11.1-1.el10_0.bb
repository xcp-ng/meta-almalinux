# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bats"
PV = "1.11.1"
PR = "1.el10_0"
PACKAGES = " \
 bats \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bats-1.11.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3aeab87bff741897ea842211c858a427f6ff0904d27476b1c63cf5d267754b2"

URI_x86_64_v2_bats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bats-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bats}"
SRC_URI[x86_64_v2_bats.sha256sum] = "943adc88e4bc24a63df4264429d5364f40a4133560f92bf9997e632ed2f9a8d2"

URI_aarch64_bats = "${EPEL_MIRROR}/aarch64/Packages/b/bats-1.11.1-1.el10_0.noarch.rpm;name=aarch64_bats;unpack=0"
SRC_URI:append = " ${URI_aarch64_bats}"
SRC_URI[aarch64_bats.sha256sum] = "9c1664c4f0a614b549cb04cda1676b27d5b133a8b007b8ddd4c24b526225f57d"

RDEPENDS:bats = " \
 bash \
 parallel \
 "
