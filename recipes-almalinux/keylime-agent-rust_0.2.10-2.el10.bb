# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keylime-agent-rust"
PV = "0.2.10"
PR = "2.el10"
PACKAGES = " \
 keylime-agent-rust \
 keylime-agent-rust-common \
 keylime-agent-rust-ima-emulator \
 keylime-agent-rust-push \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keylime-agent-rust-0.2.10-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f3ca7734cca68ce21ca045e4ab2e71b1e6b5f085afb0af992c0e91e105bedd1b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-0.2.10-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust;unpack=0"
SRC_URI[x86_64_v2_keylime-agent-rust.sha256sum] = "87f88075cdd841242a4b9c5544d462639e9715c204101a858ad33b1c24d6d86b"
RPROVIDES:keylime-agent-rust:append:x86_64_v2 = " virtual/keylime-agent"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-common-0.2.10-2.el10.noarch.rpm;name=x86_64_v2_keylime-agent-rust-common;unpack=0"
SRC_URI[x86_64_v2_keylime-agent-rust-common.sha256sum] = "eeb39a2f3c04b19fcde603cf947a9278b943915d8f08b8b3c9586c8771e93e46"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-ima-emulator-0.2.10-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust-ima-emulator;unpack=0"
SRC_URI[x86_64_v2_keylime-agent-rust-ima-emulator.sha256sum] = "6021c05a4a53b6f2d02c0345f26e88d83ce7693dcb573ed1651ad18077c659c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-push-0.2.10-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust-push;unpack=0"
SRC_URI[x86_64_v2_keylime-agent-rust-push.sha256sum] = "0cf1aa98ae3e4616b860493f245437864d259721f7662d2fbd9d513004e4b2b2"
RPROVIDES:keylime-agent-rust-push:append:x86_64_v2 = " virtual/keylime-agent"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-0.2.10-2.el10.aarch64.rpm;name=aarch64_keylime-agent-rust;unpack=0"
SRC_URI[aarch64_keylime-agent-rust.sha256sum] = "392983cbb44db1b758224dc640fc10b78795d6fc9860487438425e0d69dddfc2"
RPROVIDES:keylime-agent-rust:append:aarch64 = " virtual/keylime-agent"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-common-0.2.10-2.el10.noarch.rpm;name=aarch64_keylime-agent-rust-common;unpack=0"
SRC_URI[aarch64_keylime-agent-rust-common.sha256sum] = "eeb39a2f3c04b19fcde603cf947a9278b943915d8f08b8b3c9586c8771e93e46"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-ima-emulator-0.2.10-2.el10.aarch64.rpm;name=aarch64_keylime-agent-rust-ima-emulator;unpack=0"
SRC_URI[aarch64_keylime-agent-rust-ima-emulator.sha256sum] = "f0c8bf4c6e3618a9eb2f36e655c5ea08d2f3cebe33e8e623615e1f5f9ac49050"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-push-0.2.10-2.el10.aarch64.rpm;name=aarch64_keylime-agent-rust-push;unpack=0"
SRC_URI[aarch64_keylime-agent-rust-push.sha256sum] = "c0c21d2196eedb6f553b686530064f784658cf9ad807521de757112f9df295f2"
RPROVIDES:keylime-agent-rust-push:append:aarch64 = " virtual/keylime-agent"

RDEPENDS:keylime-agent-rust = " \
 bash \
 glibc \
 keylime-agent-rust-common \
 keylime-agent-rust-ima-emulator \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 util-linux-core \
 "
RDEPENDS:keylime-agent-rust-common = " \
 "
RDEPENDS:keylime-agent-rust-ima-emulator = " \
 glibc \
 keylime-agent-rust-common \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:keylime-agent-rust-push = " \
 glibc \
 keylime-agent-rust-common \
 keylime-agent-rust-ima-emulator \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 util-linux-core \
 "
