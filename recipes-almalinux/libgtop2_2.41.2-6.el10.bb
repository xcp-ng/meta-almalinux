# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgtop2"
PV = "2.41.2"
PR = "6.el10"
PACKAGES = " \
 libgtop2 \
 libgtop2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libgtop2-2.41.2-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e536ff07f1870ee8cad8c3995a35182ac7444434a462a0bf6d4ae1663afb0ae"

URI_x86_64_v2_libgtop2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgtop2-2.41.2-6.el10.x86_64_v2.rpm;name=x86_64_v2_libgtop2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgtop2}"
SRC_URI[x86_64_v2_libgtop2.sha256sum] = "55cb0f7898abc45883a44cd2f0f9a2eef5425cf07945f297e9a38090e8ecc3da"

URI_x86_64_v2_libgtop2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgtop2-devel-2.41.2-6.el10.x86_64_v2.rpm;name=x86_64_v2_libgtop2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgtop2-devel}"
SRC_URI[x86_64_v2_libgtop2-devel.sha256sum] = "fba8375d33fd4b389d0413de541eff05cbbeef1c8b4cf7c75a4d0ef082708c77"

URI_aarch64_libgtop2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgtop2-2.41.2-6.el10.aarch64.rpm;name=aarch64_libgtop2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgtop2}"
SRC_URI[aarch64_libgtop2.sha256sum] = "34c2a43761dee1f4e0fb3f7a9108f314726e7e180db95a15345bc420ec577172"

URI_aarch64_libgtop2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgtop2-devel-2.41.2-6.el10.aarch64.rpm;name=aarch64_libgtop2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgtop2-devel}"
SRC_URI[aarch64_libgtop2-devel.sha256sum] = "8a28c731ee86e796177fe9de4e6cca9eb24f4f65aa75ca73416745615a90e885"

RDEPENDS:libgtop2 = " \
 glib2 \
 glibc \
 "
RDEPENDS:libgtop2-devel = " \
 glib2-devel \
 libgtop2 \
 pkgconf-pkg-config \
 "
