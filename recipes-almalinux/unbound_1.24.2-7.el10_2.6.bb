# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unbound"
PV = "1.24.2"
PR = "7.el10_2.6"
PACKAGES = " \
 python3-unbound \
 unbound \
 unbound-anchor \
 unbound-devel \
 unbound-dracut \
 unbound-libs \
 unbound-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/unbound-1.24.2-7.el10_2.6.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9ec4e85f319d7fa43df8daeae633b02d0edf1d4a62d8f5775bb0aca2cc7b692e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-unbound-1.24.2-7.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_python3-unbound;unpack=0"
SRC_URI[x86_64_v2_python3-unbound.sha256sum] = "dc8b35d2ce5728d3950ba2925cbec6ff4f4ab50d584a31fa0189e73625491644"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-1.24.2-7.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_unbound;unpack=0"
SRC_URI[x86_64_v2_unbound.sha256sum] = "04203b1dbde2aa0ff084f51dd03cc31fc01bf76d73df8a13976b0331559de6e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-anchor-1.24.2-7.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_unbound-anchor;unpack=0"
SRC_URI[x86_64_v2_unbound-anchor.sha256sum] = "ca80b232f3413555d24e3d55a49c1ca9ba2748e06ded2f8d01d9b771ba657b58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/unbound-devel-1.24.2-7.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_unbound-devel;unpack=0"
SRC_URI[x86_64_v2_unbound-devel.sha256sum] = "a7bc9a05dea83edb17ed26792ff70dd85cd29c4f8f7532591a93d01f8c127a92"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-dracut-1.24.2-7.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_unbound-dracut;unpack=0"
SRC_URI[x86_64_v2_unbound-dracut.sha256sum] = "5150abe291ebde3daa550a154f1f588a82edd16394ed9b267673e4959dc86fdf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-libs-1.24.2-7.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_unbound-libs;unpack=0"
SRC_URI[x86_64_v2_unbound-libs.sha256sum] = "369b0fd1a4e1cbf99e2485a7dd1720a8ff3024d4525dea2b37c6419b34cdbd0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-utils-1.24.2-7.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_unbound-utils;unpack=0"
SRC_URI[x86_64_v2_unbound-utils.sha256sum] = "2a9185ae9b4e83971e665a740c1c8b9f3d324ff6f9f5069d88aff4bfc43dc255"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-unbound-1.24.2-7.el10_2.6.aarch64.rpm;name=aarch64_python3-unbound;unpack=0"
SRC_URI[aarch64_python3-unbound.sha256sum] = "3759eda539b5f4ee298f405b8e7b89162d32554dc92caf94c949a64f916fa36c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-1.24.2-7.el10_2.6.aarch64.rpm;name=aarch64_unbound;unpack=0"
SRC_URI[aarch64_unbound.sha256sum] = "798f30c3d0d46b1d5d0a6e6b79878d213930b63fafba1afa6637ddefe0108235"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-anchor-1.24.2-7.el10_2.6.aarch64.rpm;name=aarch64_unbound-anchor;unpack=0"
SRC_URI[aarch64_unbound-anchor.sha256sum] = "c7701fbe4870402ef57cce11fe77d430fe5d137f6e64709d5d36492056a68461"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/unbound-devel-1.24.2-7.el10_2.6.aarch64.rpm;name=aarch64_unbound-devel;unpack=0"
SRC_URI[aarch64_unbound-devel.sha256sum] = "8f0ef7275ba2f2a407680bd904d246073c77b1f5dca7c3c65939e51826d3e26e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-dracut-1.24.2-7.el10_2.6.aarch64.rpm;name=aarch64_unbound-dracut;unpack=0"
SRC_URI[aarch64_unbound-dracut.sha256sum] = "1ad138c06cc854e6e0e4bcb2a2512d7ebd8d46c96235b2c3b486bb3f58cec86b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-libs-1.24.2-7.el10_2.6.aarch64.rpm;name=aarch64_unbound-libs;unpack=0"
SRC_URI[aarch64_unbound-libs.sha256sum] = "69cd86427a2a9930ea84df54379330906ec09623a72b1a4bb4d441fc78ab66f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-utils-1.24.2-7.el10_2.6.aarch64.rpm;name=aarch64_unbound-utils;unpack=0"
SRC_URI[aarch64_unbound-utils.sha256sum] = "55680678e1212f2c118069dd25ea2efe1d790395971333e579a8d71115d3ce5d"

RDEPENDS:python3-unbound = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3 \
 python3-libs \
 systemd-libs \
 unbound-libs \
 "
RDEPENDS:unbound = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl \
 openssl-libs \
 protobuf-c \
 python3-libs \
 systemd-libs \
 unbound-anchor \
 unbound-libs \
 "
RDEPENDS:unbound-anchor = " \
 bash \
 expat \
 glibc \
 openssl-libs \
 unbound-libs \
 "
RDEPENDS:unbound-devel = " \
 libevent-devel \
 openssl-devel \
 pkgconf-pkg-config \
 python3-devel \
 unbound-libs \
 "
RDEPENDS:unbound-dracut = " \
 bash \
 dracut \
 unbound \
 "
RDEPENDS:unbound-libs = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3-libs \
 shadow-utils \
 systemd-libs \
 "
RDEPENDS:unbound-utils = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 python3-libs \
 unbound-libs \
 "
