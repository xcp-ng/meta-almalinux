# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pymongo"
PV = "4.8.0"
PR = "1.el10_1"
PACKAGES = " \
 python-pymongo-doc \
 python3-bson \
 python3-pymongo \
 python3-pymongo+ocsp \
 python3-pymongo+snappy \
 python3-pymongo+zstd \
 python3-pymongo-gridfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pymongo-4.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca035b4a451cfb43061a58010c6761ab5e2bf041dfba5e8be69da2caec9ccf71"

URI_x86_64_v2_python-pymongo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pymongo-doc-4.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-pymongo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pymongo-doc}"
SRC_URI[x86_64_v2_python-pymongo-doc.sha256sum] = "568b85cc9fa6d298503d9ed2baf3d10ed0ef842703f7a0b79dfa857daa8f8380"

URI_x86_64_v2_python3-bson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bson-4.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-bson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bson}"
SRC_URI[x86_64_v2_python3-bson.sha256sum] = "3aee790c38a28e49af6c9efbe15f8441b45d3c6e023725ec3e23f41e3145b17d"

URI_x86_64_v2_python3-pymongo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo-4.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo}"
SRC_URI[x86_64_v2_python3-pymongo.sha256sum] = "769aa1b63f310c38545564952891e84e492677b3686c0d505e354c8936eda67e"

URI_x86_64_v2_python3-pymongo+ocsp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo+ocsp-4.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo+ocsp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo+ocsp}"
SRC_URI[x86_64_v2_python3-pymongo+ocsp.sha256sum] = "65c5b23a475ee21304d888b55263e4d9cc2fbc2d1cd6d6aef2d5ee103b8d6eb5"

URI_x86_64_v2_python3-pymongo+snappy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo+snappy-4.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo+snappy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo+snappy}"
SRC_URI[x86_64_v2_python3-pymongo+snappy.sha256sum] = "b468948bca2a41087f0a3fc8dfe3946a366afae0f266a316eb31927cc01b4505"

URI_x86_64_v2_python3-pymongo+zstd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo+zstd-4.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo+zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo+zstd}"
SRC_URI[x86_64_v2_python3-pymongo+zstd.sha256sum] = "f5122c8d347037467681e3e35422e7860bd38b9d119c57eea16f469d58779083"

URI_x86_64_v2_python3-pymongo-gridfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo-gridfs-4.8.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo-gridfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo-gridfs}"
SRC_URI[x86_64_v2_python3-pymongo-gridfs.sha256sum] = "fb45dc8d001d924a6557e980b4c6ea46337acd69a1c60cb6eea378133f6be912"

URI_aarch64_python-pymongo-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pymongo-doc-4.8.0-1.el10_1.noarch.rpm;name=aarch64_python-pymongo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pymongo-doc}"
SRC_URI[aarch64_python-pymongo-doc.sha256sum] = "21b9b415a00475c3c749d79eb5ae2d5faaf66c8f6d32616a1cfa1275d633f80f"

URI_aarch64_python3-bson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bson-4.8.0-1.el10_1.aarch64.rpm;name=aarch64_python3-bson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bson}"
SRC_URI[aarch64_python3-bson.sha256sum] = "4600f84a9848f418df41183508d3b30b3aa0d848888a1488ec2309ddce307033"

URI_aarch64_python3-pymongo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo-4.8.0-1.el10_1.aarch64.rpm;name=aarch64_python3-pymongo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo}"
SRC_URI[aarch64_python3-pymongo.sha256sum] = "233301b4119656180ca1cf2ab55c78ba07defff64dc3c5793b062da4057aa2be"

URI_aarch64_python3-pymongo+ocsp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo+ocsp-4.8.0-1.el10_1.aarch64.rpm;name=aarch64_python3-pymongo+ocsp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo+ocsp}"
SRC_URI[aarch64_python3-pymongo+ocsp.sha256sum] = "fca3480d1bfa9a67d9c6af9b96f305ca379be70b65089ab250287ca7369a0acc"

URI_aarch64_python3-pymongo+snappy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo+snappy-4.8.0-1.el10_1.aarch64.rpm;name=aarch64_python3-pymongo+snappy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo+snappy}"
SRC_URI[aarch64_python3-pymongo+snappy.sha256sum] = "f89354475801d12bb4181d96d5c4918dee3df19f5229057980f808bb5eb67657"

URI_aarch64_python3-pymongo+zstd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo+zstd-4.8.0-1.el10_1.aarch64.rpm;name=aarch64_python3-pymongo+zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo+zstd}"
SRC_URI[aarch64_python3-pymongo+zstd.sha256sum] = "5a3a268fd2b7c873ee6fb5ceb88cfcf130b434676c36405c799f2d569e423bd1"

URI_aarch64_python3-pymongo-gridfs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo-gridfs-4.8.0-1.el10_1.aarch64.rpm;name=aarch64_python3-pymongo-gridfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo-gridfs}"
SRC_URI[aarch64_python3-pymongo-gridfs.sha256sum] = "d91eb5efcce789d4d5afe182d89623c22002bf28b3da183e6033b234623e0946"

RDEPENDS:python-pymongo-doc = " \
 "
RDEPENDS:python3-bson = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-pymongo = " \
 glibc \
 python3 \
 python3-bson \
 python3-dns \
 "
RDEPENDS:python3-pymongo+ocsp = " \
 python3 \
 python3-cryptography \
 python3-pyOpenSSL \
 python3-pymongo \
 python3-requests \
 python3-service-identity \
 "
RDEPENDS:python3-pymongo+snappy = " \
 python3 \
 python3-pymongo \
 python3-snappy \
 "
RDEPENDS:python3-pymongo+zstd = " \
 python3 \
 python3-pymongo \
 python3-zstandard \
 "
RDEPENDS:python3-pymongo-gridfs = " \
 python3 \
 python3-pymongo \
 "
