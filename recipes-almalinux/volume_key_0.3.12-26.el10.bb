# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "volume_key"
PV = "0.3.12"
PR = "26.el10"
PACKAGES = " \
 python3-volume_key \
 volume_key \
 volume_key-devel \
 volume_key-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/volume_key-0.3.12-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "608a57a6e4d92a1296f6689a9b381fe42f9520b4cd3d4dbc6fb9d13b25a7cbc5"

URI_x86_64_v2_python3-volume_key = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-volume_key-0.3.12-26.el10.x86_64_v2.rpm;name=x86_64_v2_python3-volume_key;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-volume_key}"
SRC_URI[x86_64_v2_python3-volume_key.sha256sum] = "a13fa13f763311dd02c5e097d758fdb33509cd8c7fe0d406cc1893ed60d2a1c7"

URI_x86_64_v2_volume_key = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/volume_key-0.3.12-26.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key}"
SRC_URI[x86_64_v2_volume_key.sha256sum] = "acf2423425bb00d4f52461faafc54ef63304e91971005ba96cc232347963ade7"

URI_x86_64_v2_volume_key-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/volume_key-devel-0.3.12-26.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key-devel}"
SRC_URI[x86_64_v2_volume_key-devel.sha256sum] = "ae218ca6ccda30d28c1431abbd6716c1fe4c1ca9d9d48ec328d026b799974575"

URI_x86_64_v2_volume_key-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/volume_key-libs-0.3.12-26.el10.x86_64_v2.rpm;name=x86_64_v2_volume_key-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_volume_key-libs}"
SRC_URI[x86_64_v2_volume_key-libs.sha256sum] = "189766087279e50d0dbecf07e1e6cecb4645cf0dd28fb998f86a748da28f2899"

URI_aarch64_python3-volume_key = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-volume_key-0.3.12-26.el10.aarch64.rpm;name=aarch64_python3-volume_key;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-volume_key}"
SRC_URI[aarch64_python3-volume_key.sha256sum] = "3c2b64f9959720c158086bc997bd8f44c9fb1aac8a4473654595f691eaced6b5"

URI_aarch64_volume_key = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/volume_key-0.3.12-26.el10.aarch64.rpm;name=aarch64_volume_key;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key}"
SRC_URI[aarch64_volume_key.sha256sum] = "bb4c48e95c23107a50bfebe24d234d372ed53befe136180e86ef692949a2236f"

URI_aarch64_volume_key-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/volume_key-devel-0.3.12-26.el10.aarch64.rpm;name=aarch64_volume_key-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key-devel}"
SRC_URI[aarch64_volume_key-devel.sha256sum] = "7740d60b032014180254c612cad5724556363a903c1f02327237841e799f7e48"

URI_aarch64_volume_key-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/volume_key-libs-0.3.12-26.el10.aarch64.rpm;name=aarch64_volume_key-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_volume_key-libs}"
SRC_URI[aarch64_volume_key-libs.sha256sum] = "ede1b24041a86fc93fb49b0716e2d8cf12d11cdeaec801f898b2d9c911b3ed94"

RDEPENDS:python3-volume_key = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 libblkid \
 nspr \
 nss \
 nss-util \
 python3 \
 volume_key-libs \
 "
RDEPENDS:volume_key = " \
 glib2 \
 glibc \
 nspr \
 nss \
 volume_key-libs \
 "
RDEPENDS:volume_key-devel = " \
 volume_key-libs \
 "
RDEPENDS:volume_key-libs = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 libblkid \
 nspr \
 nss \
 nss-util \
 sequoia-sq \
 "
