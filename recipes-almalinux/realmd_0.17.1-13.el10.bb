# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "realmd"
PV = "0.17.1"
PR = "13.el10"
PACKAGES = " \
 realmd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/realmd-0.17.1-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a9474ef0f381087ec20f11a1257d7229e610eb21894e26a754045b4c64e1c9d"

URI_x86_64_v2_realmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realmd-0.17.1-13.el10.x86_64_v2.rpm;name=x86_64_v2_realmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_realmd}"
SRC_URI[x86_64_v2_realmd.sha256sum] = "bbbaff638c52280503da8a03eef6a91d2690f9336e7800bc19eac532817e64c2"

URI_aarch64_realmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realmd-0.17.1-13.el10.aarch64.rpm;name=aarch64_realmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_realmd}"
SRC_URI[aarch64_realmd.sha256sum] = "7557369c39c212352f83a9d7ae5863d43ebba43b315abf28f758faa6091c5553"

RDEPENDS:realmd = " \
 authselect \
 bash \
 glib2 \
 glibc \
 krb5-libs \
 openldap \
 polkit \
 polkit-libs \
 systemd-libs \
 "
