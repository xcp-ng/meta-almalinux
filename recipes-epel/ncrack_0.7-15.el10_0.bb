# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncrack"
PV = "0.7"
PR = "15.el10_0"
PACKAGES = " \
 ncrack \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/ncrack-0.7-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "beeb1c71788fb4f25a95fb071131786cfc71549b66263323f64689aa48cd956d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ncrack-0.7-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ncrack;unpack=0"
SRC_URI[x86_64_v2_ncrack.sha256sum] = "3b3f98898fe821ffd953ce88c601559496dc7d2688eeb49d40951431af2d8406"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/ncrack-0.7-15.el10_0.aarch64.rpm;name=aarch64_ncrack;unpack=0"
SRC_URI[aarch64_ncrack.sha256sum] = "69d21eae2e3864aaa72ce37a44889ec7a1a0e4820843f0128bad6c39f736729f"

RDEPENDS:ncrack = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
