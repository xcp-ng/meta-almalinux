# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-yuin-goldmark"
PV = "1.7.8"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-yuin-goldmark-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-yuin-goldmark-1.7.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bec0139cf94a8da722926cb72d30e532df001c88df5a45450b951e2fed7e315"

URI_x86_64_v2_golang-github-yuin-goldmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-yuin-goldmark-devel-1.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-yuin-goldmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-yuin-goldmark-devel}"
SRC_URI[x86_64_v2_golang-github-yuin-goldmark-devel.sha256sum] = "c8a50896f9b77cfef3cc64f7fcef345160b6d26b4b509982663dd17ec7f780c4"

URI_aarch64_golang-github-yuin-goldmark-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-yuin-goldmark-devel-1.7.8-1.el10_0.noarch.rpm;name=aarch64_golang-github-yuin-goldmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-yuin-goldmark-devel}"
SRC_URI[aarch64_golang-github-yuin-goldmark-devel.sha256sum] = "bf11c8e5786ee0f8cf6e7c57302b0050bc21c7e49f2457af0eacf31afe617de8"

RDEPENDS:golang-github-yuin-goldmark-devel = " \
 go-filesystem \
 "
