# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lldpad"
PV = "1.1.1"
PR = "4.gitf1dd9eb.el10"
PACKAGES = " \
 lldpad \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lldpad-1.1.1-4.gitf1dd9eb.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a26df11e392271060cbb076936c523a410427f9053b415be9bc6a8c2c53f9550"

URI_x86_64_v2_lldpad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lldpad-1.1.1-4.gitf1dd9eb.el10.x86_64_v2.rpm;name=x86_64_v2_lldpad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldpad}"
SRC_URI[x86_64_v2_lldpad.sha256sum] = "b1571b6ad358f90c891ff300d446aaab62fae586f1df6c6f242acb0a065b1513"

URI_aarch64_lldpad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lldpad-1.1.1-4.gitf1dd9eb.el10.aarch64.rpm;name=aarch64_lldpad;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldpad}"
SRC_URI[aarch64_lldpad.sha256sum] = "07ced24b4c88519f55810bd7f0094f3968a6df1b0771ff1a428e0521de97dd2f"

RDEPENDS:lldpad = " \
 bash \
 glibc \
 libconfig \
 libnl3 \
 readline \
 systemd \
 "
