# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tagsoup"
PV = "1.2.1"
PR = "35.el10_0"
PACKAGES = " \
 tagsoup \
 tagsoup-javadoc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tagsoup-1.2.1-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1116f8d929c6ee93fc30317002fd45a9a792ee7c0d41e57de203b6e9d19df058"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tagsoup-1.2.1-35.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_tagsoup;unpack=0"
SRC_URI[x86_64_v2_tagsoup.sha256sum] = "5eb277da98931a02a09fbb4091779aa2d7e0872a472ddb588f62e68a99edaad0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tagsoup-javadoc-1.2.1-35.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_tagsoup-javadoc;unpack=0"
SRC_URI[x86_64_v2_tagsoup-javadoc.sha256sum] = "de5dd3f7e113c1badaa475a96f4dfca9086bb04b76001f4f6834e26185a07542"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tagsoup-1.2.1-35.el10_0.noarch.rpm;name=aarch64_tagsoup;unpack=0"
SRC_URI[aarch64_tagsoup.sha256sum] = "7beada7ec1c90984348f6dfb5b756c8927586e455eda0ba79208a49e86225323"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tagsoup-javadoc-1.2.1-35.el10_0.noarch.rpm;name=aarch64_tagsoup-javadoc;unpack=0"
SRC_URI[aarch64_tagsoup-javadoc.sha256sum] = "514aeb00086d870e580e261d57fcf2394e4473213aea3ea6b8432afe17378b53"

RDEPENDS:tagsoup = " \
 javapackages-filesystem \
 "
RDEPENDS:tagsoup-javadoc = " \
 javapackages-tools \
 "
