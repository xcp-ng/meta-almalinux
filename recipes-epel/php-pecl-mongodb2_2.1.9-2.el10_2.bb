# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb2"
PV = "2.1.9"
PR = "2.el10_2"
PACKAGES = " \
 php-pecl-mongodb2 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb2-2.1.9-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6ed0d2da6aec7901ca430f6385f2d4aea34812216fb4ffc27acc2cf492df82f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb2-2.1.9-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb2;unpack=0"
SRC_URI[x86_64_v2_php-pecl-mongodb2.sha256sum] = "021f865f9766373b14482516ab8d91651f8555d868ec0c1d16cb656128b3ef50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb2-2.1.9-2.el10_2.aarch64.rpm;name=aarch64_php-pecl-mongodb2;unpack=0"
SRC_URI[aarch64_php-pecl-mongodb2.sha256sum] = "2624b1a3baa42591d0476350190038f59957def18a465435b7846d0b9ecaf6f6"

RDEPENDS:php-pecl-mongodb2:x86_64_v2 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 virtual/php-json_x86-64_ \
"
RDEPENDS:php-pecl-mongodb2:aarch64 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 virtual/php-json_aarch-64_ \
"
