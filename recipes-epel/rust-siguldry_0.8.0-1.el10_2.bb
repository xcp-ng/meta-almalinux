# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-siguldry"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-siguldry+cli-devel \
 rust-siguldry+default-devel \
 rust-siguldry+server-devel \
 rust-siguldry+sigul-client-devel \
 rust-siguldry-devel \
 siguldry \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-siguldry-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02f4b1d70968667cd505a69f8a9d09f78f6d587fda34431605c0c26978f2c38a"

URI_x86_64_v2_rust-siguldry+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+cli-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry+cli-devel}"
SRC_URI[x86_64_v2_rust-siguldry+cli-devel.sha256sum] = "92490f368e473d15a7c2229b2948e79321d19140191e5a5c21fceedd93eff1a6"

URI_x86_64_v2_rust-siguldry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+default-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry+default-devel}"
SRC_URI[x86_64_v2_rust-siguldry+default-devel.sha256sum] = "f3795c23d22a21b3b2f3d3a57ff630e7b8a048c6b174f86801125df28f2d3240"

URI_x86_64_v2_rust-siguldry+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+server-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry+server-devel}"
SRC_URI[x86_64_v2_rust-siguldry+server-devel.sha256sum] = "e10ba3e652bf51776db58ad6355fa11f67c5fb324044bdc663c57abd4ac20b8d"

URI_x86_64_v2_rust-siguldry+sigul-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+sigul-client-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+sigul-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry+sigul-client-devel}"
SRC_URI[x86_64_v2_rust-siguldry+sigul-client-devel.sha256sum] = "0713ec0e6561a5ac07ed88ed027a0b056644f4decd9c1ce1629dd0bc160263cb"

URI_x86_64_v2_rust-siguldry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry-devel}"
SRC_URI[x86_64_v2_rust-siguldry-devel.sha256sum] = "b50c05f9d1604e64b38759a2d05eec90a6a98c32d12e769b6c44ade937de992d"

URI_x86_64_v2_siguldry = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/siguldry-0.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_siguldry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_siguldry}"
SRC_URI[x86_64_v2_siguldry.sha256sum] = "d8b11e7e7d84b0768da6be7b9011b2701cfed1da4ff13a875fe1aae560e0beff"

URI_aarch64_rust-siguldry+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+cli-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-siguldry+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry+cli-devel}"
SRC_URI[aarch64_rust-siguldry+cli-devel.sha256sum] = "58ae6b60968b3f9a36268d5598d8f7d4b591ee2a47b7de11dae921f41d9a2e05"

URI_aarch64_rust-siguldry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+default-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-siguldry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry+default-devel}"
SRC_URI[aarch64_rust-siguldry+default-devel.sha256sum] = "858d96988379698fb6786881e2cbdea38f1fce1f89e6184b58e7067c872bb716"

URI_aarch64_rust-siguldry+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+server-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-siguldry+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry+server-devel}"
SRC_URI[aarch64_rust-siguldry+server-devel.sha256sum] = "6a75569bcb9115e2125a31c35ca9db04ed08040588ef0257873e77fac90a56b7"

URI_aarch64_rust-siguldry+sigul-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+sigul-client-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-siguldry+sigul-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry+sigul-client-devel}"
SRC_URI[aarch64_rust-siguldry+sigul-client-devel.sha256sum] = "a4ee0edb5355df3224b110613b2186eece73109eb0c62dce657a6db84ed380c5"

URI_aarch64_rust-siguldry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-siguldry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry-devel}"
SRC_URI[aarch64_rust-siguldry-devel.sha256sum] = "bff188653a4ca4bdef45db6dc78fbc2fd7ba746fcda9f29dc321c3c6885044fe"

URI_aarch64_siguldry = "${EPEL_MIRROR}/aarch64/Packages/s/siguldry-0.8.0-1.el10_2.aarch64.rpm;name=aarch64_siguldry;unpack=0"
SRC_URI:append = " ${URI_aarch64_siguldry}"
SRC_URI[aarch64_siguldry.sha256sum] = "5ba240f4329f132e255131d86181b1adeb4c6d5ca36b286c5382c9360e8f7475"

RDEPENDS:rust-siguldry+cli-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+usage-devel \
 rust-clap-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+process-devel \
 rust-rustix+stdio-devel \
 rust-rustix+termios-devel \
 rust-siguldry-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-siguldry+default-devel = " \
 cargo \
 rust-siguldry+cli-devel \
 rust-siguldry+server-devel \
 rust-siguldry-devel \
 "
RDEPENDS:rust-siguldry+server-devel = " \
 cargo \
 rust-cryptoki+default-devel \
 rust-rustix+default-devel \
 rust-rustix+stdio-devel \
 rust-rustix+termios-devel \
 rust-siguldry-devel \
 rust-sqlx+default-devel \
 rust-sqlx+macros-devel \
 rust-sqlx+migrate-devel \
 rust-sqlx+runtime-tokio-devel \
 rust-sqlx+sqlite-unbundled-devel \
 "
RDEPENDS:rust-siguldry+sigul-client-devel = " \
 cargo \
 rust-siguldry-devel \
 "
RDEPENDS:rust-siguldry-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-asn1+default-devel \
 rust-bytes+default-devel \
 rust-hex+default-devel \
 rust-libc+default-devel \
 rust-openssl+default-devel \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-openpgp-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+signal-devel \
 rust-tokio+time-devel \
 rust-tokio-openssl+default-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util+rt-devel \
 rust-toml+default-devel \
 rust-tracing+default-devel \
 rust-uuid+default-devel \
 rust-uuid+serde-devel \
 rust-uuid+v7-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+std-devel \
 "
RDEPENDS:siguldry = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
