# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemviews"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kitemviews \
 kf6-kitemviews-devel \
 kf6-kitemviews-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemviews-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e29d5e8bb0b7ad68c4934ec921af2c65a08cfc53f5a81c88f0bdb9d3863d254f"

URI_x86_64_v2_kf6-kitemviews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews}"
SRC_URI[x86_64_v2_kf6-kitemviews.sha256sum] = "b9fc3bd7a8b272211f01c9ec67e22c8d22048439177f198f0b2a791161609282"

URI_x86_64_v2_kf6-kitemviews-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-devel}"
SRC_URI[x86_64_v2_kf6-kitemviews-devel.sha256sum] = "e6863177ffb8cf3d7a1d0b71467ee4aa94d21d39c67fccfcd0ad4df48c7d5737"

URI_x86_64_v2_kf6-kitemviews-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemviews-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-doc}"
SRC_URI[x86_64_v2_kf6-kitemviews-doc.sha256sum] = "ca2638384b3e794c3625285ffd7045811056d57d96801994be82835ed8bbd86e"

URI_aarch64_kf6-kitemviews = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kitemviews;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews}"
SRC_URI[aarch64_kf6-kitemviews.sha256sum] = "4a63c8e9a3f19ab3d4b0baa2100c11b4c59a9568c060cb5a45f75e84b57d968f"

URI_aarch64_kf6-kitemviews-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kitemviews-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-devel}"
SRC_URI[aarch64_kf6-kitemviews-devel.sha256sum] = "6970ad8efd9834e5457dae0a0502df59ba52600f2b7857369fedaad92d530bd9"

URI_aarch64_kf6-kitemviews-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kitemviews-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-doc}"
SRC_URI[aarch64_kf6-kitemviews-doc.sha256sum] = "8c09f98e83dd99cfbd98e70e7292d6398102ce5dc78434afc31d072713b457e2"

RDEPENDS:kf6-kitemviews = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kitemviews \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-doc = " \
 "
