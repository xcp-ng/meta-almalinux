# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lebe"
PV = "0.5.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-lebe+default-devel \
 rust-lebe-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-lebe-0.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "405c0b6f7b9d82b7e81b6f09010c2b9097eb4dfbb5f4a4ce1dc4b90f454858d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lebe+default-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lebe+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lebe+default-devel.sha256sum] = "811747094df19ee0723258c659e7e7e6e26e505233d12a01d6fc9174086347b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lebe-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lebe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-lebe-devel.sha256sum] = "77bcdafa9fcb2be75deb89f7dc80a38eae4b119dcda1b937a9cb61d9b63ca836"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lebe+default-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-lebe+default-devel;unpack=0"
SRC_URI[aarch64_rust-lebe+default-devel.sha256sum] = "b56c84f975267b2d58942b241de4da698628d37bf0bf820eba5f1d40c9a72b6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-lebe-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-lebe-devel;unpack=0"
SRC_URI[aarch64_rust-lebe-devel.sha256sum] = "eb210ca916730c19fbf5d4628552a4c83a0a30eb3fadc73682146885cd20d9c9"

RDEPENDS:rust-lebe+default-devel = " \
 cargo \
 rust-lebe-devel \
 "
RDEPENDS:rust-lebe-devel = " \
 cargo \
 rust \
 "
