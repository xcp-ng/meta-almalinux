# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rdiff-backup"
PV = "2.2.6"
PR = "17.el10_3"
PACKAGES = " \
 rdiff-backup \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rdiff-backup-2.2.6-17.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "35189310dbcac70e8cfa443fd1177037dc5c0b91236e3fc4709dd0743b9bbc5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rdiff-backup-2.2.6-17.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rdiff-backup;unpack=0"
SRC_URI[x86_64_v2_rdiff-backup.sha256sum] = "81131b698c66589b5d0d9055dd2f1e8de13a36d0c3e83a0b334a4c92ed424ff1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rdiff-backup-2.2.6-17.el10_3.aarch64.rpm;name=aarch64_rdiff-backup;unpack=0"
SRC_URI[aarch64_rdiff-backup.sha256sum] = "2fcd2fe6d5b59bcd5186ee1fc199b95d7420ace856d26a5fc6ad89249628bef4"

RDEPENDS:rdiff-backup = " \
 glibc \
 librsync \
 python3 \
 python3-pyyaml \
 "
