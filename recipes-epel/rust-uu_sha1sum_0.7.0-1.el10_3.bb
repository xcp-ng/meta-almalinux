# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_sha1sum"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_sha1sum+default-devel \
 rust-uu_sha1sum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_sha1sum-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3b5454606e2d2d5bfcf932e952950fb77bcdfbf3758c3f2f78e4a57ee0afd06"

URI_x86_64_v2_rust-uu_sha1sum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha1sum+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha1sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha1sum+default-devel}"
SRC_URI[x86_64_v2_rust-uu_sha1sum+default-devel.sha256sum] = "caaf7a6660f76cd33c3106e9e01c7e5fddde137d789e20bfa64827c303e3317b"

URI_x86_64_v2_rust-uu_sha1sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha1sum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha1sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha1sum-devel}"
SRC_URI[x86_64_v2_rust-uu_sha1sum-devel.sha256sum] = "b0c7cfc7789b81dcf1a08893c72689a3ce45cd5d738d0b81e047d3baabf75679"

URI_aarch64_rust-uu_sha1sum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha1sum+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha1sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha1sum+default-devel}"
SRC_URI[aarch64_rust-uu_sha1sum+default-devel.sha256sum] = "a6202274047a27a4b68641d8965e199d9a7dbf0d8a680562f7ac677334a203d2"

URI_aarch64_rust-uu_sha1sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha1sum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha1sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha1sum-devel}"
SRC_URI[aarch64_rust-uu_sha1sum-devel.sha256sum] = "441713818ef4594b94492442a5ecacd1688ac9731ca3731aa559873f5d01bacc"

RDEPENDS:rust-uu_sha1sum+default-devel = " \
 cargo \
 rust-uu_sha1sum-devel \
 "
RDEPENDS:rust-uu_sha1sum-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uu_checksum_common+default-devel \
 rust-uucore+checksum-devel \
 rust-uucore+default-devel \
 rust-uucore+encoding-devel \
 rust-uucore+hardware-devel \
 rust-uucore+sum-devel \
 "
