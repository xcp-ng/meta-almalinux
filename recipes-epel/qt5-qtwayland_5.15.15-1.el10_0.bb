# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtwayland"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtwayland \
 qt5-qtwayland-devel \
 qt5-qtwayland-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtwayland-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93adcd57d40209929f283ac296f11c997ad807ba46bd012471e34f5d4b480a1d"

URI_x86_64_v2_qt5-qtwayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland}"
SRC_URI[x86_64_v2_qt5-qtwayland.sha256sum] = "6e53515cea557de982d0615a203c6950a3d959f99d0f2d0b67fac5d64b5b1249"

URI_x86_64_v2_qt5-qtwayland-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland-devel}"
SRC_URI[x86_64_v2_qt5-qtwayland-devel.sha256sum] = "117143766eb0f9aeb01be631a5c71a9f177fc4a994a5beeb3eb485ba88cb2420"

URI_x86_64_v2_qt5-qtwayland-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtwayland-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtwayland-examples}"
SRC_URI[x86_64_v2_qt5-qtwayland-examples.sha256sum] = "3646b69f55a1123e29e134961cd1c9035451f00ae6cd4d5a81e57e44cf81dbe2"

URI_aarch64_qt5-qtwayland = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland}"
SRC_URI[aarch64_qt5-qtwayland.sha256sum] = "0340e752275c7831c05b7aa22f1fda5a92d9eebc097c4886d80802f3948eb735"

URI_aarch64_qt5-qtwayland-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland-devel}"
SRC_URI[aarch64_qt5-qtwayland-devel.sha256sum] = "6695ef7da7cece6ce153a5cb7aad0a93a2e604b184a7926040c7df562bbf0bee"

URI_aarch64_qt5-qtwayland-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtwayland-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtwayland-examples}"
SRC_URI[aarch64_qt5-qtwayland-examples.sha256sum] = "6b0134b11ca5216c301903fa9506abac07d8d98ba8aa3b48e5b03f1af141d860"

RDEPENDS:qt5-qtwayland = " \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 libX11 \
 libXcomposite \
 libglvnd-egl \
 libglvnd-glx \
 libstdc++ \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libxkbcommon \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtwayland-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtwayland \
 "
RDEPENDS:qt5-qtwayland-examples = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwayland \
 "
