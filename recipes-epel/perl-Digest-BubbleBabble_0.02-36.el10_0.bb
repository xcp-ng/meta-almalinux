# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Digest-BubbleBabble"
PV = "0.02"
PR = "36.el10_0"
PACKAGES = " \
 perl-Digest-BubbleBabble \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Digest-BubbleBabble-0.02-36.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b211c262aa806a48b8987a93f415caa36a553a67c61bed2be00e746ad3fa0eb6"

URI_x86_64_v2_perl-Digest-BubbleBabble = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Digest-BubbleBabble-0.02-36.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Digest-BubbleBabble;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Digest-BubbleBabble}"
SRC_URI[x86_64_v2_perl-Digest-BubbleBabble.sha256sum] = "f7be6ee16d6a646ad8b8add690ddf7d380370d1658d888fa54f7715ffe08f234"

URI_aarch64_perl-Digest-BubbleBabble = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Digest-BubbleBabble-0.02-36.el10_0.noarch.rpm;name=aarch64_perl-Digest-BubbleBabble;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Digest-BubbleBabble}"
SRC_URI[aarch64_perl-Digest-BubbleBabble.sha256sum] = "1c53922950fce98f1b68c3952ddaa9571dc48cd984ed0282c5d770aa430f67e5"

RDEPENDS:perl-Digest-BubbleBabble = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
