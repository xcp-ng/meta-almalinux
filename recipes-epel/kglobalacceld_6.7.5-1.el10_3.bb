# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kglobalacceld"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kglobalacceld \
 kglobalacceld-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kglobalacceld-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3af07b315b2d36b51a495f08d6176246f7a251912fdfbf07498cb1c2b026c147"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kglobalacceld-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kglobalacceld;unpack=0"
SRC_URI[x86_64_v2_kglobalacceld.sha256sum] = "770ee7dac5caec7c6141bdddea918da0e413c76d79cc34f64588745c0a3793c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kglobalacceld-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kglobalacceld-devel;unpack=0"
SRC_URI[x86_64_v2_kglobalacceld-devel.sha256sum] = "451be3cf229df51d85a927264fe102491177be86c2eeab1cb2f215e3f0bfeed6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kglobalacceld-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kglobalacceld;unpack=0"
SRC_URI[aarch64_kglobalacceld.sha256sum] = "555c0ba81469f7174ad98e7ebf1f68234253f418c9d06264fd140907423c9b7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kglobalacceld-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kglobalacceld-devel;unpack=0"
SRC_URI[aarch64_kglobalacceld-devel.sha256sum] = "147918ff2ee522bb38ba3063fbf6926c3eaf6d680e78ad4ceb67573d40a01b40"

RDEPENDS:kglobalacceld = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kwindowsystem \
 libX11 \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 xcb-util-keysyms \
 "
RDEPENDS:kglobalacceld-devel = " \
 cmake-filesystem \
 kglobalacceld \
 qt6-qtbase-devel \
 "
