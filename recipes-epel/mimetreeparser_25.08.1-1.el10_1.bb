# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimetreeparser"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 mimetreeparser \
 mimetreeparser-devel \
 mimetreeparser-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mimetreeparser-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2afc798940ec2e3bd4d3ebd6751437883f079be3f69e1c050640ac0f9a8e8c3c"

URI_x86_64_v2_mimetreeparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser}"
SRC_URI[x86_64_v2_mimetreeparser.sha256sum] = "0761c35fc2089d25594284495a7c2826b31f2776ea0d189bfe5ef2bcf46aad4b"

URI_x86_64_v2_mimetreeparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser-devel}"
SRC_URI[x86_64_v2_mimetreeparser-devel.sha256sum] = "ce4734269d73282db5f27f1cb9997426f547449569a0d6e9023e8fd5c229119e"

URI_x86_64_v2_mimetreeparser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mimetreeparser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimetreeparser-doc}"
SRC_URI[x86_64_v2_mimetreeparser-doc.sha256sum] = "08efe1b952868c74e436469b0c56ba534b449834b8877ea413b750c0b9e8a313"

URI_aarch64_mimetreeparser = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_mimetreeparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser}"
SRC_URI[aarch64_mimetreeparser.sha256sum] = "f48e442f0bdc77d5030598d3d0860961dc95c4a3fdf71a1df250858d69ada5fc"

URI_aarch64_mimetreeparser-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_mimetreeparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser-devel}"
SRC_URI[aarch64_mimetreeparser-devel.sha256sum] = "14b2265ada4fd8480411c311b3c26f51bd201ee0c06b68166c9f857784abd3c6"

URI_aarch64_mimetreeparser-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_mimetreeparser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimetreeparser-doc}"
SRC_URI[aarch64_mimetreeparser-doc.sha256sum] = "ff7ba74c64b3eaaef14133a121c6ec2f0147710bfa530e8fc9ba1496ea5fb4ab"

RDEPENDS:mimetreeparser = " \
 glibc \
 gpgmepp \
 kf6-kcalendarcore \
 kf6-kcolorscheme \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kmbox \
 kmime \
 libkleo \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:mimetreeparser-devel = " \
 cmake-filesystem \
 mimetreeparser \
 "
RDEPENDS:mimetreeparser-doc = " \
 "
