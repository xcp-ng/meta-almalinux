# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-des"
PV = "0.8.1"
PR = "7.el10_0"
PACKAGES = " \
 rust-des+default-devel \
 rust-des+zeroize-devel \
 rust-des-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-des-0.8.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "564eaaab591e130afa91cde1a2834034d1b1e116b8e494a4df36ebcb3bb26013"

URI_x86_64_v2_rust-des+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-des+default-devel-0.8.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-des+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-des+default-devel}"
SRC_URI[x86_64_v2_rust-des+default-devel.sha256sum] = "31879e4de581e2300b023758f4a0d67a708402cb63196e583cad1ebc06f498e2"

URI_x86_64_v2_rust-des+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-des+zeroize-devel-0.8.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-des+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-des+zeroize-devel}"
SRC_URI[x86_64_v2_rust-des+zeroize-devel.sha256sum] = "5eb01924f980e37a70f59bf0faa2f43dac6461973138e07461fbba8ca24fd5fc"

URI_x86_64_v2_rust-des-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-des-devel-0.8.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-des-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-des-devel}"
SRC_URI[x86_64_v2_rust-des-devel.sha256sum] = "fd9d9e28e3d2d6442514294bbab27d99e13405a3efefc550327be208deed897d"

URI_aarch64_rust-des+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-des+default-devel-0.8.1-7.el10_0.noarch.rpm;name=aarch64_rust-des+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-des+default-devel}"
SRC_URI[aarch64_rust-des+default-devel.sha256sum] = "a0301535360f2e430b85a6470d074dee250dbc8279b8dd7db49d91c5e8bed8b4"

URI_aarch64_rust-des+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-des+zeroize-devel-0.8.1-7.el10_0.noarch.rpm;name=aarch64_rust-des+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-des+zeroize-devel}"
SRC_URI[aarch64_rust-des+zeroize-devel.sha256sum] = "313d3f108768b7c87553aba31f0e0a8cc47ecc2e2f725820af06c04bbb5b8f97"

URI_aarch64_rust-des-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-des-devel-0.8.1-7.el10_0.noarch.rpm;name=aarch64_rust-des-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-des-devel}"
SRC_URI[aarch64_rust-des-devel.sha256sum] = "0382360a03bea87ef82511e18ab57f244807cfc7918fc24c5e6868954692a6d9"

RDEPENDS:rust-des+default-devel = " \
 cargo \
 rust-des-devel \
 "
RDEPENDS:rust-des+zeroize-devel = " \
 cargo \
 rust-cipher+zeroize-devel \
 rust-des-devel \
 "
RDEPENDS:rust-des-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 "
