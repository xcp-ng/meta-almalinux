# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sortedcontainers"
PV = "2.4.0"
PR = "19.el10_0"
PACKAGES = " \
 python-sortedcontainers-doc \
 python3-sortedcontainers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sortedcontainers-2.4.0-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04ed3c5c68a01771c5457888c6a1f85335f6718b597a50aea615cf3c6dd86324"

URI_x86_64_v2_python-sortedcontainers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-sortedcontainers-doc-2.4.0-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-sortedcontainers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-sortedcontainers-doc}"
SRC_URI[x86_64_v2_python-sortedcontainers-doc.sha256sum] = "0d559b9da99c62e427aa2d7622cacd87bbb4b37b819464144d69224646466b6c"

URI_x86_64_v2_python3-sortedcontainers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sortedcontainers-2.4.0-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sortedcontainers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sortedcontainers}"
SRC_URI[x86_64_v2_python3-sortedcontainers.sha256sum] = "110eb75ba60e8b7c22f28b2fea5040c4659ea53fb0015ebc67a9bee32a25b697"

URI_aarch64_python-sortedcontainers-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-sortedcontainers-doc-2.4.0-19.el10_0.noarch.rpm;name=aarch64_python-sortedcontainers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-sortedcontainers-doc}"
SRC_URI[aarch64_python-sortedcontainers-doc.sha256sum] = "170e86907d0018a0999811dc4748fb8d365abf36e0c9b7f3b899c2d3abff2b78"

URI_aarch64_python3-sortedcontainers = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sortedcontainers-2.4.0-19.el10_0.noarch.rpm;name=aarch64_python3-sortedcontainers;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sortedcontainers}"
SRC_URI[aarch64_python3-sortedcontainers.sha256sum] = "2166487a63942073d19e5908c28056b3bd41b8b4326be9d9a43d453f93f7a1f5"

RDEPENDS:python-sortedcontainers-doc = " \
 "
RDEPENDS:python3-sortedcontainers = " \
 python3 \
 "
