# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcron"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kcron \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcron-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b2e016d3b44cc9de1ed413ea7eaa15a608cb6ff0c50374ded32cf2e29b936a5"

URI_x86_64_v2_kcron = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcron-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcron}"
SRC_URI[x86_64_v2_kcron.sha256sum] = "e7a748a33e07690925e878715638abd6bdb6509ffb1a4861eb6da7aea1ac54ae"

URI_aarch64_kcron = "${EPEL_MIRROR}/aarch64/Packages/k/kcron-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kcron;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcron}"
SRC_URI[aarch64_kcron.sha256sum] = "0ff9b26cd9590596328d89e35a0432a3d1f7d0d4caf73251f637511747d99393"

RDEPENDS:kcron = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
