# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-mime"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-mime \
 akonadi-mime-devel \
 akonadi-mime-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akonadi-mime-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fe1b959b0ec7032c823eb4bebef359a408c9c5439543499ef790a5e60ebf2775"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime;unpack=0"
SRC_URI[x86_64_v2_akonadi-mime.sha256sum] = "74c0b66951022b86cecfe45aa8400e70a4c9edd26244f67834c3bed97dde9ce3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime-devel;unpack=0"
SRC_URI[x86_64_v2_akonadi-mime-devel.sha256sum] = "a3fb089bb97d00182d6a2326f0e6ba6df6209571833cc6e0a28e0be8197ac1e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-mime-doc;unpack=0"
SRC_URI[x86_64_v2_akonadi-mime-doc.sha256sum] = "464ecce2b5a522b9af80405df4b75f2329788e1fdad8dafaf9e8810cf8fd1cd9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadi-mime;unpack=0"
SRC_URI[aarch64_akonadi-mime.sha256sum] = "a406be2111c86ada2f07abd56b8ed871732644d5b9055799d476a4ffbe4482e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadi-mime-devel;unpack=0"
SRC_URI[aarch64_akonadi-mime-devel.sha256sum] = "957468408461c451b024e8147979f5b710a933a427fb6896c7e4fecd30187a3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_akonadi-mime-doc;unpack=0"
SRC_URI[aarch64_akonadi-mime-doc.sha256sum] = "46105c8f169f85b3dd3c542046ba856990ad91d73b36502a1de38910ec95c859"

RDEPENDS:akonadi-mime = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kmime \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:akonadi-mime-devel = " \
 akonadi-mime \
 akonadi-server-devel \
 cmake-filesystem \
 "
RDEPENDS:akonadi-mime-doc = " \
 "
