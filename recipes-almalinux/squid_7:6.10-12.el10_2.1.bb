# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squid"
PE = "7"
PV = "6.10"
PR = "12.el10_2.1"
PACKAGES = " \
 squid \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/squid-6.10-12.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a43cde51bb48ffc47b36e318a5cf3e038343e838496c6a56977672c0b2d97073"

URI_x86_64_v2_squid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/squid-6.10-12.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_squid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squid}"
SRC_URI[x86_64_v2_squid.sha256sum] = "30afc414ae83f7897feaa57bfa1743cf3ee3cc63c6c39955a14e78e11a486ac6"

URI_aarch64_squid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/squid-6.10-12.el10_2.1.aarch64.rpm;name=aarch64_squid;unpack=0"
SRC_URI:append = " ${URI_aarch64_squid}"
SRC_URI[aarch64_squid.sha256sum] = "ebac07cd9c70af8f616511bc4536598048fa95f4b89e3f1df59482205de8ab42"

RDEPENDS:squid = " \
 bash \
 cyrus-sasl-lib \
 gawk \
 glibc \
 httpd-filesystem \
 krb5-libs \
 libcap \
 libcom_err \
 libecap \
 libgcc \
 libstdc++ \
 libtdb \
 libtool-ltdl \
 libxcrypt \
 openldap \
 openssl-libs \
 pam-libs \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-English \
 perl-File-Basename \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IPC-Open3 \
 perl-Pod-Usage \
 perl-URI \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-vars \
 shadow-utils \
 systemd \
 systemd-libs \
 "
