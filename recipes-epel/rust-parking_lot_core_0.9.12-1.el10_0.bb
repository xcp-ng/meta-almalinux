# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-parking_lot_core"
PV = "0.9.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-parking_lot_core+backtrace-devel \
 rust-parking_lot_core+deadlock_detection-devel \
 rust-parking_lot_core+default-devel \
 rust-parking_lot_core+nightly-devel \
 rust-parking_lot_core+petgraph-devel \
 rust-parking_lot_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-parking_lot_core-0.9.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2122fdd9a86115ffd26d20f32fcf06d3439bec25c1090c9a5a79027cfbd5c0e9"

URI_x86_64_v2_rust-parking_lot_core+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+backtrace-devel-0.9.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+backtrace-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+backtrace-devel.sha256sum] = "2b7a26cbe9b79dcae12ddccf3de13d81dca7c21e5030a813873e4266d3a919a0"

URI_x86_64_v2_rust-parking_lot_core+deadlock_detection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+deadlock_detection-devel-0.9.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+deadlock_detection-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+deadlock_detection-devel.sha256sum] = "8a98c8626e209b40a2904d65f8c390f5653dadd3cbc7cd2567d5fb2bb99b1ced"

URI_x86_64_v2_rust-parking_lot_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+default-devel-0.9.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+default-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+default-devel.sha256sum] = "be82cdb7f0fc1b4c551792cc76a7ee9ef4200d0de1d44fb7e1da4c69c06ab185"

URI_x86_64_v2_rust-parking_lot_core+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+nightly-devel-0.9.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+nightly-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+nightly-devel.sha256sum] = "0666c1adcae58671074cb4ceb551db82812c6fbcf2e0a0ae8cf8920056464b0a"

URI_x86_64_v2_rust-parking_lot_core+petgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core+petgraph-devel-0.9.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core+petgraph-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core+petgraph-devel.sha256sum] = "7a356d8433d77e889f27a11205dbfa7293e92eb30ff77fd8cfaf0c4357341be5"

URI_x86_64_v2_rust-parking_lot_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parking_lot_core-devel-0.9.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parking_lot_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parking_lot_core-devel}"
SRC_URI[x86_64_v2_rust-parking_lot_core-devel.sha256sum] = "252360ba48a288c080cc568aa738cd6faba27cdc244d6546b3952699c322fa10"

URI_aarch64_rust-parking_lot_core+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+backtrace-devel-0.9.12-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot_core+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+backtrace-devel}"
SRC_URI[aarch64_rust-parking_lot_core+backtrace-devel.sha256sum] = "3e67f7a160f152f692712d5ca051c10267c839815a71bbb82f280cc7efba102e"

URI_aarch64_rust-parking_lot_core+deadlock_detection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+deadlock_detection-devel-0.9.12-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot_core+deadlock_detection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+deadlock_detection-devel}"
SRC_URI[aarch64_rust-parking_lot_core+deadlock_detection-devel.sha256sum] = "7020a81cf8e84fb29a221daeb6003450196ca7c3ef8169a9b2352acdf05736b8"

URI_aarch64_rust-parking_lot_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+default-devel-0.9.12-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+default-devel}"
SRC_URI[aarch64_rust-parking_lot_core+default-devel.sha256sum] = "aed1581ee7905d34c8d8edd6a156357c72e143381c3c98dc50ea01d9a5e60444"

URI_aarch64_rust-parking_lot_core+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+nightly-devel-0.9.12-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot_core+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+nightly-devel}"
SRC_URI[aarch64_rust-parking_lot_core+nightly-devel.sha256sum] = "cd2870d22b0576892d905437e323a0e608285dfd4b774bb54d5f7243722579d9"

URI_aarch64_rust-parking_lot_core+petgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core+petgraph-devel-0.9.12-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot_core+petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core+petgraph-devel}"
SRC_URI[aarch64_rust-parking_lot_core+petgraph-devel.sha256sum] = "c29cf3fa783cf70d643857ca7dc06b6ded6fbf82f12f9676577c0ec16d97b231"

URI_aarch64_rust-parking_lot_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parking_lot_core-devel-0.9.12-1.el10_0.noarch.rpm;name=aarch64_rust-parking_lot_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parking_lot_core-devel}"
SRC_URI[aarch64_rust-parking_lot_core-devel.sha256sum] = "ac736326b3f881d427587b113d3a34da6394489983f672f49511e5708673581c"

RDEPENDS:rust-parking_lot_core+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-parking_lot_core+deadlock_detection-devel = " \
 cargo \
 rust-parking_lot_core+backtrace-devel \
 rust-parking_lot_core+petgraph-devel \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-parking_lot_core+default-devel = " \
 cargo \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-parking_lot_core+nightly-devel = " \
 cargo \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-parking_lot_core+petgraph-devel = " \
 cargo \
 rust-parking_lot_core-devel \
 rust-petgraph0.6+default-devel \
 "
RDEPENDS:rust-parking_lot_core-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-smallvec+default-devel \
 "
