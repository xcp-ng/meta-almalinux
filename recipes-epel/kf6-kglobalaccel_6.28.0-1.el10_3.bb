# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kglobalaccel"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kglobalaccel \
 kf6-kglobalaccel-devel \
 kf6-kglobalaccel-doc \
 kf6-kglobalaccel-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kglobalaccel-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9aa704a18dc8d1177c3432521d9bc252aff93c8c07ebb8fd891f306ab2f09e8e"

URI_x86_64_v2_kf6-kglobalaccel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel}"
SRC_URI[x86_64_v2_kf6-kglobalaccel.sha256sum] = "3ff7232fba774634070b02b0365ec182024d508e5d78258fe869d7039ac1c2ee"

URI_x86_64_v2_kf6-kglobalaccel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kglobalaccel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-devel}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-devel.sha256sum] = "465fcb01564436d5f0f1cc8a69db2cbc70b9eaf5314a83d37225833dc0f9b849"

URI_x86_64_v2_kf6-kglobalaccel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kglobalaccel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-doc}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-doc.sha256sum] = "c46cbc509b3116e3aa6cb05d30b22a6c1bc944f50d5b4cee578f7e3e173231f3"

URI_x86_64_v2_kf6-kglobalaccel-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kglobalaccel-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kglobalaccel-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kglobalaccel-html}"
SRC_URI[x86_64_v2_kf6-kglobalaccel-html.sha256sum] = "2bdbe4f64682b0a7ac27d78cc2f502980ca8c433bb1e06ffb1d47b6354b5e76f"

URI_aarch64_kf6-kglobalaccel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kglobalaccel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel}"
SRC_URI[aarch64_kf6-kglobalaccel.sha256sum] = "7776b056cb31ab4f6137249950149a398e7ec59f7565b9b96de9611075e78382"

URI_aarch64_kf6-kglobalaccel-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kglobalaccel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-devel}"
SRC_URI[aarch64_kf6-kglobalaccel-devel.sha256sum] = "86f5533d031941d54895ec3d0b5efe10bfbcab3ab23e946fdd337822d2816d2f"

URI_aarch64_kf6-kglobalaccel-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kglobalaccel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-doc}"
SRC_URI[aarch64_kf6-kglobalaccel-doc.sha256sum] = "1c9279d03f03d7e07da7100008e20ae6c04612e607c19387eaa16a34b4420fa9"

URI_aarch64_kf6-kglobalaccel-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kglobalaccel-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kglobalaccel-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kglobalaccel-html}"
SRC_URI[aarch64_kf6-kglobalaccel-html.sha256sum] = "7ef0c4c8c892804a0f1a0b821de766a267288d05d6e316383ed4ce5a3dca7414"

RDEPENDS:kf6-kglobalaccel = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kglobalaccel-devel = " \
 cmake-filesystem \
 kf6-kglobalaccel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kglobalaccel-doc = " \
 "
RDEPENDS:kf6-kglobalaccel-html = " \
 "
