# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-annotate-snippets"
PV = "0.12.16"
PR = "1.el10_2"
PACKAGES = " \
 rust-annotate-snippets+default-devel \
 rust-annotate-snippets+simd-devel \
 rust-annotate-snippets+std-devel \
 rust-annotate-snippets+testing-colors-devel \
 rust-annotate-snippets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-annotate-snippets-0.12.16-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e6e5f01a884ba4c610eeceda09367136a8991c540a4d0e732ba2303fa394d06"

URI_x86_64_v2_rust-annotate-snippets+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+default-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+default-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+default-devel.sha256sum] = "e7ad2cd74f404634ae4aa9a7d3d1622df8aff551f2301ad8badbb9cb30bc852e"

URI_x86_64_v2_rust-annotate-snippets+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+simd-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+simd-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+simd-devel.sha256sum] = "c1289b441aeb5e571cfe65d136e00a88bb2f626f5cd7d90d605c98ecf5064333"

URI_x86_64_v2_rust-annotate-snippets+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+std-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+std-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+std-devel.sha256sum] = "f9e90ce4dd1c27332c0cfa0465e86cf0d0c959ef4c4f7747ee14902a429553cc"

URI_x86_64_v2_rust-annotate-snippets+testing-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+testing-colors-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+testing-colors-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+testing-colors-devel.sha256sum] = "f887ed3bf374b885425aefb5983a82d9d7b59c8e717a9ebcec70ed1faa0386e1"

URI_x86_64_v2_rust-annotate-snippets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets-devel.sha256sum] = "534c7d43b32260971f91e4f5d6cd1aaca2a310a9a1f782a308e4900022e8d309"

URI_aarch64_rust-annotate-snippets+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+default-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+default-devel}"
SRC_URI[aarch64_rust-annotate-snippets+default-devel.sha256sum] = "65c292e733585281b6acf3f30acce6439cc4849cbd439d1af6f9bbe454582341"

URI_aarch64_rust-annotate-snippets+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+simd-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+simd-devel}"
SRC_URI[aarch64_rust-annotate-snippets+simd-devel.sha256sum] = "15026213d282a1b5a35f65073ceee867b61b23b3010317fe02f1e653df18288b"

URI_aarch64_rust-annotate-snippets+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+std-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+std-devel}"
SRC_URI[aarch64_rust-annotate-snippets+std-devel.sha256sum] = "7ca2fec777ac6492ade40cfd6955fdf77e123a9a222cf06bb2bd5ec4b52afbf3"

URI_aarch64_rust-annotate-snippets+testing-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+testing-colors-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+testing-colors-devel}"
SRC_URI[aarch64_rust-annotate-snippets+testing-colors-devel.sha256sum] = "1a2008b31b1bbf4dd6cab523b32eb7619f71d5649ea7a7bb1ccb066defcf050c"

URI_aarch64_rust-annotate-snippets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets-devel}"
SRC_URI[aarch64_rust-annotate-snippets-devel.sha256sum] = "641c3d9e2a2ab221b8fb8e445ac119d28e4b708c59a1ae18719e39bccfd323c4"

RDEPENDS:rust-annotate-snippets+default-devel = " \
 cargo \
 rust-annotate-snippets+std-devel \
 rust-annotate-snippets-devel \
 "
RDEPENDS:rust-annotate-snippets+simd-devel = " \
 cargo \
 rust-annotate-snippets-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-annotate-snippets+std-devel = " \
 cargo \
 rust-annotate-snippets-devel \
 rust-anstyle+std-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-annotate-snippets+testing-colors-devel = " \
 cargo \
 rust-annotate-snippets-devel \
 "
RDEPENDS:rust-annotate-snippets-devel = " \
 cargo \
 rust \
 rust-anstyle-devel \
 rust-unicode-width+default-devel \
 "
