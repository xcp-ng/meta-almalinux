# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-doc-comment"
PV = "0.3.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-doc-comment+default-devel \
 rust-doc-comment+no_core-devel \
 rust-doc-comment+old_macros-devel \
 rust-doc-comment-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-doc-comment-0.3.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07a7c8932646e3bc668ad315fd5cc417a8142cf0598e0ed86b3a231ce71bbb53"

URI_x86_64_v2_rust-doc-comment+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment+default-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment+default-devel}"
SRC_URI[x86_64_v2_rust-doc-comment+default-devel.sha256sum] = "34f9e10a815fe0a50bb6b9e89caeedfebd3255769413766cf0041fcde97a5352"

URI_x86_64_v2_rust-doc-comment+no_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment+no_core-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment+no_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment+no_core-devel}"
SRC_URI[x86_64_v2_rust-doc-comment+no_core-devel.sha256sum] = "0ce70a5a08bf53660bcca3354fa8255a27bf68ef7a4ab834e8b1ed559a510849"

URI_x86_64_v2_rust-doc-comment+old_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment+old_macros-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment+old_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment+old_macros-devel}"
SRC_URI[x86_64_v2_rust-doc-comment+old_macros-devel.sha256sum] = "44289c9a330b8b683ebfd641334426fa284a2b80c82d3177aa40396584c24318"

URI_x86_64_v2_rust-doc-comment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-doc-comment-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-doc-comment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-doc-comment-devel}"
SRC_URI[x86_64_v2_rust-doc-comment-devel.sha256sum] = "15f4e3155ab5a8dd747b17dc7789c7b1a3433fa492835b3b2db72767745a110a"

URI_aarch64_rust-doc-comment+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment+default-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-doc-comment+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment+default-devel}"
SRC_URI[aarch64_rust-doc-comment+default-devel.sha256sum] = "70254fcc18e8960f0274a11621e0b6733bc2677aa0e77242f185ae9df8e00b47"

URI_aarch64_rust-doc-comment+no_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment+no_core-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-doc-comment+no_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment+no_core-devel}"
SRC_URI[aarch64_rust-doc-comment+no_core-devel.sha256sum] = "5e485697e1a51a407f5ed5464eb6d7fbce23a0a4f26c7763a62535b742733bc7"

URI_aarch64_rust-doc-comment+old_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment+old_macros-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-doc-comment+old_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment+old_macros-devel}"
SRC_URI[aarch64_rust-doc-comment+old_macros-devel.sha256sum] = "ed1f3231476f58e053b6971c3715b61534f6a5284c9f5ff8cfa3296506dc236b"

URI_aarch64_rust-doc-comment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-doc-comment-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_rust-doc-comment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-doc-comment-devel}"
SRC_URI[aarch64_rust-doc-comment-devel.sha256sum] = "eb7285aacb2bcdf833673b914367fef767342fdcaec3308e52f5805920e63c48"

RDEPENDS:rust-doc-comment+default-devel = " \
 cargo \
 rust-doc-comment-devel \
 "
RDEPENDS:rust-doc-comment+no_core-devel = " \
 cargo \
 rust-doc-comment-devel \
 "
RDEPENDS:rust-doc-comment+old_macros-devel = " \
 cargo \
 rust-doc-comment-devel \
 "
RDEPENDS:rust-doc-comment-devel = " \
 cargo \
 "
