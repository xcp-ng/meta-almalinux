# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat"
PE = "1"
PV = "10.1.49"
PR = "4.el10_2.alma.1"
PACKAGES = " \
 tomcat \
 tomcat-admin-webapps \
 tomcat-docs-webapp \
 tomcat-el-5.0-api \
 tomcat-jsp-3.1-api \
 tomcat-lib \
 tomcat-servlet-6.0-api \
 tomcat-webapps \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat-10.1.49-4.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5cac2416691b2d0f0b982e32c46bfe887bdb9d4c575da67418051b6210cd4815"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-10.1.49-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat;unpack=0"
SRC_URI[x86_64_v2_tomcat.sha256sum] = "05f66cc8b41b005142502d651ba514eded6e74fadebc4bdc6c0d92950d6879df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-admin-webapps-10.1.49-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-admin-webapps;unpack=0"
SRC_URI[x86_64_v2_tomcat-admin-webapps.sha256sum] = "7c7acfc2c6790f4c32d6cdaf0b0ebdfa664f793a282af54ec03f3852621bb52f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-docs-webapp-10.1.49-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-docs-webapp;unpack=0"
SRC_URI[x86_64_v2_tomcat-docs-webapp.sha256sum] = "d77aa50850c7291ba9872ee696549bcb39f63510d6dcf156bfa5d47ae3113c12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-el-5.0-api-10.1.49-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-el-5.0-api;unpack=0"
SRC_URI[x86_64_v2_tomcat-el-5.0-api.sha256sum] = "4df179b81ca2db0f43fec568ccc75a8679fffe363fec2fb6561e4f02955b8ae7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-jsp-3.1-api-10.1.49-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-jsp-3.1-api;unpack=0"
SRC_URI[x86_64_v2_tomcat-jsp-3.1-api.sha256sum] = "a6fc4fb2bc554f7fe792d34fef93212e54a6708c02ec0a9ef3f40adf76158df1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-lib-10.1.49-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-lib;unpack=0"
SRC_URI[x86_64_v2_tomcat-lib.sha256sum] = "1ef407ca747b0004e12dfb23f976be66e723a1e587ab0958cba13bdb751f2505"
RPROVIDES:tomcat-lib:append:x86_64_v2 = " virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-servlet-6.0-api-10.1.49-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-servlet-6.0-api;unpack=0"
SRC_URI[x86_64_v2_tomcat-servlet-6.0-api.sha256sum] = "3b705c8b7203a1082a75a9137b187f792afaaf227daf36911e2dbeccf5e0f1b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-webapps-10.1.49-4.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat-webapps;unpack=0"
SRC_URI[x86_64_v2_tomcat-webapps.sha256sum] = "3039facea1830d6007abf1fdc9482c06d32fcb2fb13da8d1c71963066f81e351"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-10.1.49-4.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat;unpack=0"
SRC_URI[aarch64_tomcat.sha256sum] = "05f66cc8b41b005142502d651ba514eded6e74fadebc4bdc6c0d92950d6879df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-admin-webapps-10.1.49-4.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-admin-webapps;unpack=0"
SRC_URI[aarch64_tomcat-admin-webapps.sha256sum] = "7c7acfc2c6790f4c32d6cdaf0b0ebdfa664f793a282af54ec03f3852621bb52f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-docs-webapp-10.1.49-4.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-docs-webapp;unpack=0"
SRC_URI[aarch64_tomcat-docs-webapp.sha256sum] = "d77aa50850c7291ba9872ee696549bcb39f63510d6dcf156bfa5d47ae3113c12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-el-5.0-api-10.1.49-4.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-el-5.0-api;unpack=0"
SRC_URI[aarch64_tomcat-el-5.0-api.sha256sum] = "4df179b81ca2db0f43fec568ccc75a8679fffe363fec2fb6561e4f02955b8ae7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-jsp-3.1-api-10.1.49-4.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-jsp-3.1-api;unpack=0"
SRC_URI[aarch64_tomcat-jsp-3.1-api.sha256sum] = "a6fc4fb2bc554f7fe792d34fef93212e54a6708c02ec0a9ef3f40adf76158df1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-lib-10.1.49-4.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-lib;unpack=0"
SRC_URI[aarch64_tomcat-lib.sha256sum] = "1ef407ca747b0004e12dfb23f976be66e723a1e587ab0958cba13bdb751f2505"
RPROVIDES:tomcat-lib:append:aarch64 = " virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-servlet-6.0-api-10.1.49-4.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-servlet-6.0-api;unpack=0"
SRC_URI[aarch64_tomcat-servlet-6.0-api.sha256sum] = "3b705c8b7203a1082a75a9137b187f792afaaf227daf36911e2dbeccf5e0f1b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-webapps-10.1.49-4.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat-webapps;unpack=0"
SRC_URI[aarch64_tomcat-webapps.sha256sum] = "3039facea1830d6007abf1fdc9482c06d32fcb2fb13da8d1c71963066f81e351"

RDEPENDS:tomcat = " \
 bash \
 javapackages-tools \
 shadow-utils \
 systemd \
 tomcat-lib \
 virtual/java-headless_or_java-25-headless \
 "
RDEPENDS:tomcat-admin-webapps = " \
 tomcat \
 "
RDEPENDS:tomcat-docs-webapp = " \
 tomcat \
 "
RDEPENDS:tomcat-el-5.0-api = " \
 javapackages-filesystem \
 "
RDEPENDS:tomcat-jsp-3.1-api = " \
 javapackages-filesystem \
 tomcat-el-5.0-api \
 tomcat-servlet-6.0-api \
 "
RDEPENDS:tomcat-lib = " \
 ecj \
 javapackages-filesystem \
 tomcat-el-5.0-api \
 tomcat-jsp-3.1-api \
 tomcat-servlet-6.0-api \
 virtual/coreutils \
 "
RDEPENDS:tomcat-servlet-6.0-api = " \
 javapackages-filesystem \
 "
RDEPENDS:tomcat-webapps = " \
 tomcat \
 "
