# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-xkbregistry"
PV = "0.3"
PR = "3.el10"
PACKAGES = " \
 python3-xkbregistry \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-xkbregistry-0.3-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f77ebac972ec60f8d8d3c0fdcf1f6376003f5c64ca1e22cb17ef56275a36d9a7"

URI_x86_64_v2_python3-xkbregistry = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-xkbregistry-0.3-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-xkbregistry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xkbregistry}"
SRC_URI[x86_64_v2_python3-xkbregistry.sha256sum] = "4ffd866a91ea9cbaa87a5133e9fa1608391ff9ee007d17ef2db1c2b8c00800dd"

URI_aarch64_python3-xkbregistry = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-xkbregistry-0.3-3.el10.aarch64.rpm;name=aarch64_python3-xkbregistry;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xkbregistry}"
SRC_URI[aarch64_python3-xkbregistry.sha256sum] = "560ce9bb5ab505090b921a184e0c44cde504bba57296932b83fca78da16df4de"

RDEPENDS:python3-xkbregistry = " \
 glibc \
 libxkbcommon \
 python3 \
 python3-cffi \
 "
