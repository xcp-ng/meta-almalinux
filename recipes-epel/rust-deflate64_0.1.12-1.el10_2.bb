# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deflate64"
PV = "0.1.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-deflate64+checkpoint-devel \
 rust-deflate64+default-devel \
 rust-deflate64-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deflate64-0.1.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77bbcb46b7d2ad36caaf8357ba3ee5d65b7e8b0f19b821c12afb6ecf8f857d6c"

URI_x86_64_v2_rust-deflate64+checkpoint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64+checkpoint-devel-0.1.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64+checkpoint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64+checkpoint-devel}"
SRC_URI[x86_64_v2_rust-deflate64+checkpoint-devel.sha256sum] = "47cde18faf72557f8a02204ce38971eb158b1d2058b70a1131f460b78fc8b5a3"

URI_x86_64_v2_rust-deflate64+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64+default-devel-0.1.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64+default-devel}"
SRC_URI[x86_64_v2_rust-deflate64+default-devel.sha256sum] = "fb756496f90ab829c096dd2c176399e974c166ba1595add073b2e8aa0a023b9f"

URI_x86_64_v2_rust-deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64-devel-0.1.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64-devel}"
SRC_URI[x86_64_v2_rust-deflate64-devel.sha256sum] = "c9746b7fcdc5d9977a98bd7b04907bee3f07cd8ec3b213ff899e3b3f4b45f122"

URI_aarch64_rust-deflate64+checkpoint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64+checkpoint-devel-0.1.12-1.el10_2.noarch.rpm;name=aarch64_rust-deflate64+checkpoint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64+checkpoint-devel}"
SRC_URI[aarch64_rust-deflate64+checkpoint-devel.sha256sum] = "320aaebe268a9c370322e4d38815d2ed3c975bd767d64487acabcaade34d13d4"

URI_aarch64_rust-deflate64+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64+default-devel-0.1.12-1.el10_2.noarch.rpm;name=aarch64_rust-deflate64+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64+default-devel}"
SRC_URI[aarch64_rust-deflate64+default-devel.sha256sum] = "9b2c2926b6baded704f4c30479e8ec729855fe2ab047a587a7a0b32eb6f6c4c2"

URI_aarch64_rust-deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64-devel-0.1.12-1.el10_2.noarch.rpm;name=aarch64_rust-deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64-devel}"
SRC_URI[aarch64_rust-deflate64-devel.sha256sum] = "620b88cbffa4245960104b82fb0f7c0022e777c541bb1bc9b592ec452d44a3c7"

RDEPENDS:rust-deflate64+checkpoint-devel = " \
 cargo \
 rust-deflate64-devel \
 "
RDEPENDS:rust-deflate64+default-devel = " \
 cargo \
 rust-deflate64-devel \
 "
RDEPENDS:rust-deflate64-devel = " \
 cargo \
 "
