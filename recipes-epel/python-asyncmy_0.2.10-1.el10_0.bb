# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-asyncmy"
PV = "0.2.10"
PR = "1.el10_0"
PACKAGES = " \
 python3-asyncmy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-asyncmy-0.2.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "770a3b4b230dec89e374f99978b96e46b4688b838bd67aeab826638639641a0c"

URI_x86_64_v2_python3-asyncmy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-asyncmy-0.2.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-asyncmy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-asyncmy}"
SRC_URI[x86_64_v2_python3-asyncmy.sha256sum] = "f7e391a472aa505ac9111e483410861eb2897e398fb93aa59e0efa05aa3791ce"

URI_aarch64_python3-asyncmy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-asyncmy-0.2.10-1.el10_0.aarch64.rpm;name=aarch64_python3-asyncmy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-asyncmy}"
SRC_URI[aarch64_python3-asyncmy.sha256sum] = "32abea17e529e6e353bfb3ae527db2bda3c5828099e0062ff93dfe11fbcba048"

RDEPENDS:python3-asyncmy = " \
 glibc \
 python3 \
 "
