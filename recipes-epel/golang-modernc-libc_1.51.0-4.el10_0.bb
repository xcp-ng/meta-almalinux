# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-modernc-libc"
PV = "1.51.0"
PR = "4.el10_0"
PACKAGES = " \
 golang-modernc-libc \
 golang-modernc-libc-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-modernc-libc-1.51.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cd3ea178397a515d64fd3413430def813db5b4af0fc91d90609149435d2a4044"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-modernc-libc-1.51.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-modernc-libc;unpack=0"
SRC_URI[x86_64_v2_golang-modernc-libc.sha256sum] = "f4d29e4a738d1a682ffca9acb0d62891351aa816c6f87d9fdcc696b002302e71"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-modernc-libc-devel-1.51.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-modernc-libc-devel;unpack=0"
SRC_URI[x86_64_v2_golang-modernc-libc-devel.sha256sum] = "9dcc6d4750aa86cbdfe23403f013bb956bd4216bc726121d0319776de9c04b25"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-modernc-libc-1.51.0-4.el10_0.aarch64.rpm;name=aarch64_golang-modernc-libc;unpack=0"
SRC_URI[aarch64_golang-modernc-libc.sha256sum] = "95a21f2dd80c6fa6d343ec5e32e6bb6ccf0826fefda26d136dca186843e7227c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-modernc-libc-devel-1.51.0-4.el10_0.noarch.rpm;name=aarch64_golang-modernc-libc-devel;unpack=0"
SRC_URI[aarch64_golang-modernc-libc-devel.sha256sum] = "4925dc71eae9c8aaff54e9673368bf28117dd2a5698972f983a781c34497dcdd"

RDEPENDS:golang-modernc-libc = " \
 "
RDEPENDS:golang-modernc-libc-devel = " \
 go-filesystem \
 golang-github-dustin-humanize-devel \
 golang-github-google-uuid-devel \
 golang-modernc-mathutil-devel \
 golang-modernc-memory-devel \
 golang-x-sys-devel \
 "
