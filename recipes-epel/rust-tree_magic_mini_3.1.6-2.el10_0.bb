# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree_magic_mini"
PV = "3.1.6"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree_magic_mini+default-devel \
 rust-tree_magic_mini+with-gpl-data-devel \
 rust-tree_magic_mini-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree_magic_mini-3.1.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6dd782181144d7a90df9786b7453974da5acd0c6fb25acf1ea266407778f3b14"

URI_x86_64_v2_rust-tree_magic_mini+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_mini+default-devel-3.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_mini+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_mini+default-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_mini+default-devel.sha256sum] = "3cd6fff070474afd66275c04e5e07db0367ec6d0ba5aebed0d29e04066d5fc78"

URI_x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_mini+with-gpl-data-devel-3.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_mini+with-gpl-data-devel.sha256sum] = "5824f8f1e4264e168e805712f95a97ce59f9126696029046ff1c8580a0167245"

URI_x86_64_v2_rust-tree_magic_mini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_mini-devel-3.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_mini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_mini-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_mini-devel.sha256sum] = "4f5ecf583385b485ee38844c443cd533c8e1450fbac973da756458525cd356d8"

URI_aarch64_rust-tree_magic_mini+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_mini+default-devel-3.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-tree_magic_mini+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_mini+default-devel}"
SRC_URI[aarch64_rust-tree_magic_mini+default-devel.sha256sum] = "27809f0a002a9425864b44b9a15136b6ba16a1e66ce2752cb1cf6271c61bf81f"

URI_aarch64_rust-tree_magic_mini+with-gpl-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_mini+with-gpl-data-devel-3.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-tree_magic_mini+with-gpl-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_mini+with-gpl-data-devel}"
SRC_URI[aarch64_rust-tree_magic_mini+with-gpl-data-devel.sha256sum] = "6742e6558fbea0be9742c64fecae22dff583a3a85803fe2eb285e50681d787d2"

URI_aarch64_rust-tree_magic_mini-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_mini-devel-3.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-tree_magic_mini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_mini-devel}"
SRC_URI[aarch64_rust-tree_magic_mini-devel.sha256sum] = "0cd5a5e78aa80b6c864aff107cd3fa061f59e9e9c6ca4f3a3393cda829e3fb27"

RDEPENDS:rust-tree_magic_mini+default-devel = " \
 cargo \
 rust-tree_magic_mini-devel \
 "
RDEPENDS:rust-tree_magic_mini+with-gpl-data-devel = " \
 cargo \
 rust-tree_magic_db+default-devel \
 rust-tree_magic_mini-devel \
 "
RDEPENDS:rust-tree_magic_mini-devel = " \
 cargo \
 rust-fnv+default-devel \
 rust-memchr+default-devel \
 rust-nom+default-devel \
 rust-once_cell+default-devel \
 rust-petgraph0.6+default-devel \
 "
