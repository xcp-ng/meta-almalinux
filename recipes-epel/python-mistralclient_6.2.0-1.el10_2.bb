# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mistralclient"
PV = "6.2.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-mistralclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mistralclient-6.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39d6828533df89d6db959638825bfdf91d129a1c9a350aed2040682fa5a6adb5"

URI_x86_64_v2_python3-mistralclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mistralclient-6.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mistralclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mistralclient}"
SRC_URI[x86_64_v2_python3-mistralclient.sha256sum] = "b4952763bd17ce648b5c8f258e665c7a06bdb1a45e5c1fb4a3d6d147b3a50e1d"

URI_aarch64_python3-mistralclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mistralclient-6.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-mistralclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mistralclient}"
SRC_URI[aarch64_python3-mistralclient.sha256sum] = "20f5d6c45bd787a22caf7193c40ed79b4a9c1369583712f42ab059bfc115386e"

RDEPENDS:python3-mistralclient = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-pyyaml \
 python3-requests \
 python3-stevedore \
 "
