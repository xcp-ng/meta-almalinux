# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mirmon"
PV = "2.11"
PR = "19.el10_0"
PACKAGES = " \
 mirmon \
 mirmon-httpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mirmon-2.11-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acffc47e8d55b1240c43b13ef3de05ae2a33d3269d56ebbe9f14365e72560ef3"

URI_x86_64_v2_mirmon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mirmon-2.11-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mirmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mirmon}"
SRC_URI[x86_64_v2_mirmon.sha256sum] = "f133d4228dc39de71b9e2e4583ec5f559ff9694a9d4c7378ebec15570c2756bc"

URI_x86_64_v2_mirmon-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mirmon-httpd-2.11-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mirmon-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mirmon-httpd}"
SRC_URI[x86_64_v2_mirmon-httpd.sha256sum] = "d88aefbe0e5e07a6f983f458ebcc566c145b6c3d03a739174222f4148c6e6e6a"

URI_aarch64_mirmon = "${EPEL_MIRROR}/aarch64/Packages/m/mirmon-2.11-19.el10_0.noarch.rpm;name=aarch64_mirmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_mirmon}"
SRC_URI[aarch64_mirmon.sha256sum] = "d0eb295df4fbb52464720ebc6a8f0d501a06d495fb9b88e79b2dc94237a3ba38"

URI_aarch64_mirmon-httpd = "${EPEL_MIRROR}/aarch64/Packages/m/mirmon-httpd-2.11-19.el10_0.noarch.rpm;name=aarch64_mirmon-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_mirmon-httpd}"
SRC_URI[aarch64_mirmon-httpd.sha256sum] = "0d202fc3616ba07e0ffa6d9d78b99ca2c66ac205ffe9a08495995d7e6fbca9c1"

RDEPENDS:mirmon = " \
 perl-Exporter \
 perl-Getopt-Long \
 perl-IO \
 perl-Net \
 perl-base \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:mirmon-httpd = " \
 httpd \
 mirmon \
 "
