# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-sagikazarmark-slog-shim"
PV = "0.1.0"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-sagikazarmark-slog-shim-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-sagikazarmark-slog-shim-0.1.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3d30d0dd1c63d08bedce878fc82eb29f9b47f9f637b73084ba2f09d62817b0e"

URI_x86_64_v2_golang-github-sagikazarmark-slog-shim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-sagikazarmark-slog-shim-devel-0.1.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-sagikazarmark-slog-shim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-sagikazarmark-slog-shim-devel}"
SRC_URI[x86_64_v2_golang-github-sagikazarmark-slog-shim-devel.sha256sum] = "f09f2bf6edc4f1a437ef247d2e647e88e0b48f6a868045b5423d71efbc9b2e59"

URI_aarch64_golang-github-sagikazarmark-slog-shim-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-sagikazarmark-slog-shim-devel-0.1.0-4.el10_0.noarch.rpm;name=aarch64_golang-github-sagikazarmark-slog-shim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-sagikazarmark-slog-shim-devel}"
SRC_URI[aarch64_golang-github-sagikazarmark-slog-shim-devel.sha256sum] = "6075b21b1cca225a2ee509f6a3513069c24b8d792af647b24e9577b5041fa56f"

RDEPENDS:golang-github-sagikazarmark-slog-shim-devel = " \
 go-filesystem \
 "
