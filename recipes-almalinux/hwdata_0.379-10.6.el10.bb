# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hwdata"
PV = "0.379"
PR = "10.6.el10"
PACKAGES = " \
 hwdata \
 hwdata-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/hwdata-0.379-10.6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1234fe8f3ba653f12f830c9d6fa5681e643b0cc53ae0a9d0702ab64213281a6"

URI_x86_64_v2_hwdata = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/hwdata-0.379-10.6.el10.noarch.rpm;name=x86_64_v2_hwdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwdata}"
SRC_URI[x86_64_v2_hwdata.sha256sum] = "dcfb1db8ea351bf598e79ef228ed46b10780f09029a68507cd3cdd07f60b5d95"

URI_x86_64_v2_hwdata-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/hwdata-devel-0.379-10.6.el10.noarch.rpm;name=x86_64_v2_hwdata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hwdata-devel}"
SRC_URI[x86_64_v2_hwdata-devel.sha256sum] = "3abca6b7dc160cd20eed9f1bfc0b7a63dde349587bb7327495c836cb0f2da59b"

URI_aarch64_hwdata = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/hwdata-0.379-10.6.el10.noarch.rpm;name=aarch64_hwdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwdata}"
SRC_URI[aarch64_hwdata.sha256sum] = "dcfb1db8ea351bf598e79ef228ed46b10780f09029a68507cd3cdd07f60b5d95"

URI_aarch64_hwdata-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/hwdata-devel-0.379-10.6.el10.noarch.rpm;name=aarch64_hwdata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hwdata-devel}"
SRC_URI[aarch64_hwdata-devel.sha256sum] = "3abca6b7dc160cd20eed9f1bfc0b7a63dde349587bb7327495c836cb0f2da59b"

RDEPENDS:hwdata = " \
 "
RDEPENDS:hwdata-devel = " \
 hwdata \
 pkgconf-pkg-config \
 "
