# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hanwen-fuse-2"
PV = "2.4.0"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-hanwen-fuse-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hanwen-fuse-2-2.4.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03da2f7c165847fb89aaf906aad416c9c32d5aabc6db3b2cb05725b3003ce670"

URI_x86_64_v2_golang-github-hanwen-fuse-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hanwen-fuse-2-devel-2.4.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hanwen-fuse-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hanwen-fuse-2-devel}"
SRC_URI[x86_64_v2_golang-github-hanwen-fuse-2-devel.sha256sum] = "af6509d3d9db5a7c7472b9e63f262251e39a4c5760ad0e6c6cae5a242ab22a61"

URI_aarch64_golang-github-hanwen-fuse-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hanwen-fuse-2-devel-2.4.0-4.el10_0.noarch.rpm;name=aarch64_golang-github-hanwen-fuse-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hanwen-fuse-2-devel}"
SRC_URI[aarch64_golang-github-hanwen-fuse-2-devel.sha256sum] = "9c5b9e6e8168e69353555a2cfbf1cae4e234f68eb2536327a060c44203ae5711"

RDEPENDS:golang-github-hanwen-fuse-2-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
