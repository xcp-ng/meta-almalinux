# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-vishvananda-netns"
PV = "0"
PR = "0.35.20220917git18c4f42.el10_0"
PACKAGES = " \
 golang-github-vishvananda-netns-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-vishvananda-netns-0-0.35.20220917git18c4f42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85420f3adffc430966c46afcc48f9258468a11754abd4863ccd1b658f205c235"

URI_aarch64_golang-github-vishvananda-netns-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-vishvananda-netns-devel-0-0.35.20220917git18c4f42.el10_0.noarch.rpm;name=aarch64_golang-github-vishvananda-netns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-vishvananda-netns-devel}"
SRC_URI[aarch64_golang-github-vishvananda-netns-devel.sha256sum] = "f81a5bb7d2e11307804c6b58a9dbfb03125c5eb38f585b47dfdecea39b45608d"

RDEPENDS:golang-github-vishvananda-netns-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
