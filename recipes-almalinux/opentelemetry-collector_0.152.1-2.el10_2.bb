# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentelemetry-collector"
PV = "0.152.1"
PR = "2.el10_2"
PACKAGES = " \
 opentelemetry-collector \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/opentelemetry-collector-0.152.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fb3c7775a284037f88910be32672bd26e8beaaa415d965ca7cf55b7155742608"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/opentelemetry-collector-0.152.1-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_opentelemetry-collector;unpack=0"
SRC_URI[x86_64_v2_opentelemetry-collector.sha256sum] = "99e8a49c054cecbffde21a9c9cfa86bced22fa2756cc4ddc44f238155500465b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/opentelemetry-collector-0.152.1-2.el10_2.aarch64.rpm;name=aarch64_opentelemetry-collector;unpack=0"
SRC_URI[aarch64_opentelemetry-collector.sha256sum] = "cf94ec4cff1f34a54a86e37227b95f639774affc9ee1ca94f3cf40cab9a8e377"

RDEPENDS:opentelemetry-collector = " \
 bash \
 glibc \
 glibc-common \
 shadow-utils \
 systemd \
 util-linux \
 "
