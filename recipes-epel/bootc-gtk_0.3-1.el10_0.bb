# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bootc-gtk"
PV = "0.3"
PR = "1.el10_0"
PACKAGES = " \
 bootc-gtk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bootc-gtk-0.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "465ee1862e36225c33e3507b5aef2587bd82ce4423d95b84bfe9f09533799a1e"

URI_x86_64_v2_bootc-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bootc-gtk-0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bootc-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bootc-gtk}"
SRC_URI[x86_64_v2_bootc-gtk.sha256sum] = "5f76130e98b23488d53b0bbef591e8f3f2fb8cd34e8a1f1fba24bdb739222a5d"

URI_aarch64_bootc-gtk = "${EPEL_MIRROR}/aarch64/Packages/b/bootc-gtk-0.3-1.el10_0.noarch.rpm;name=aarch64_bootc-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_bootc-gtk}"
SRC_URI[aarch64_bootc-gtk.sha256sum] = "99fda5e0afea41a7145687439992aed1e3611f00e255f1fba0ecfba255c381e2"

RDEPENDS:bootc-gtk = " \
 bootc \
 gtk4 \
 hicolor-icon-theme \
 libadwaita \
 python3 \
 python3-gobject \
 "
