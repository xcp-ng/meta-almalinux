# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive_more-impl"
PV = "2.0.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-derive_more-impl+add-devel \
 rust-derive_more-impl+add_assign-devel \
 rust-derive_more-impl+as_ref-devel \
 rust-derive_more-impl+constructor-devel \
 rust-derive_more-impl+debug-devel \
 rust-derive_more-impl+default-devel \
 rust-derive_more-impl+deref-devel \
 rust-derive_more-impl+deref_mut-devel \
 rust-derive_more-impl+display-devel \
 rust-derive_more-impl+error-devel \
 rust-derive_more-impl+from-devel \
 rust-derive_more-impl+from_str-devel \
 rust-derive_more-impl+full-devel \
 rust-derive_more-impl+index-devel \
 rust-derive_more-impl+index_mut-devel \
 rust-derive_more-impl+into-devel \
 rust-derive_more-impl+into_iterator-devel \
 rust-derive_more-impl+is_variant-devel \
 rust-derive_more-impl+mul-devel \
 rust-derive_more-impl+mul_assign-devel \
 rust-derive_more-impl+not-devel \
 rust-derive_more-impl+sum-devel \
 rust-derive_more-impl+testing-helpers-devel \
 rust-derive_more-impl+try_from-devel \
 rust-derive_more-impl+try_into-devel \
 rust-derive_more-impl+try_unwrap-devel \
 rust-derive_more-impl+unwrap-devel \
 rust-derive_more-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive_more-impl-2.0.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05d412665693c3b1086ce9795106720d7ce57c01969a2fb5b2448f89b7adbb05"

URI_x86_64_v2_rust-derive_more-impl+add-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+add-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+add-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+add-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+add-devel.sha256sum] = "c500053eeb58760a72735832936ea6c94a800b00f593a8ebc4cfa2f2649046c1"

URI_x86_64_v2_rust-derive_more-impl+add_assign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+add_assign-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+add_assign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+add_assign-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+add_assign-devel.sha256sum] = "765c40c8fb2dc5159021da5db582b080ee5307b73d87e8b5e1a8cbc3b4e7b22b"

URI_x86_64_v2_rust-derive_more-impl+as_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+as_ref-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+as_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+as_ref-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+as_ref-devel.sha256sum] = "8c2d3555e5f3d6d42135c2aca1382464c2ec6370532ac949eebd571e5911643a"

URI_x86_64_v2_rust-derive_more-impl+constructor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+constructor-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+constructor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+constructor-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+constructor-devel.sha256sum] = "fdcee5ce3d237cfbd8b22c816e6f60798fee4f3c62c091c746ddc11db968aaf0"

URI_x86_64_v2_rust-derive_more-impl+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+debug-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+debug-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+debug-devel.sha256sum] = "29e2b299a1781be8d5a6e2dd7b1fb275144cddbb938f90923171f358d8aa25c6"

URI_x86_64_v2_rust-derive_more-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+default-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+default-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+default-devel.sha256sum] = "6163c9a4f1ecd74dd5b9cf8e2766e0cac318807d215eac67f6989afecbe25db5"

URI_x86_64_v2_rust-derive_more-impl+deref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+deref-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+deref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+deref-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+deref-devel.sha256sum] = "f62b65d221c5e7da241dd457d6397d49fffbd52067c7febb389aaaf79fae4e12"

URI_x86_64_v2_rust-derive_more-impl+deref_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+deref_mut-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+deref_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+deref_mut-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+deref_mut-devel.sha256sum] = "830ea68528ffc6883ef1d42ae113b01c7ccd45b8d1c7e94c95512367a7d3c2c2"

URI_x86_64_v2_rust-derive_more-impl+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+display-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+display-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+display-devel.sha256sum] = "26efd103a48341f6db51b2d93f5e359efd70e3b9864d480607daf60d101c14c8"

URI_x86_64_v2_rust-derive_more-impl+error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+error-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+error-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+error-devel.sha256sum] = "38917651033e7de05752e237de7399c7a92bb699c7629d4a75288e833717ac56"

URI_x86_64_v2_rust-derive_more-impl+from-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+from-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+from-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+from-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+from-devel.sha256sum] = "9f6158866a31c715b9fc00571d896ade95ee21f85680668529f78cc59396aac1"

URI_x86_64_v2_rust-derive_more-impl+from_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+from_str-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+from_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+from_str-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+from_str-devel.sha256sum] = "c4b10d2ff89ed46a98a7f7a4bd485c00a0b4a60e6d3efb32499e4ff1dac144d3"

URI_x86_64_v2_rust-derive_more-impl+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+full-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+full-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+full-devel.sha256sum] = "cf0e83246a95f86659bfee31a04e51bce50d3f947358c8493fe331f721b15e69"

URI_x86_64_v2_rust-derive_more-impl+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+index-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+index-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+index-devel.sha256sum] = "f02c65e15ac6cadf255bb1342057c2c16698680999fcbd1e8c6e72818073277f"

URI_x86_64_v2_rust-derive_more-impl+index_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+index_mut-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+index_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+index_mut-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+index_mut-devel.sha256sum] = "afdce997eb56d2647f5c0d088a1d51fe94f0017eaa01bfb59cbf6d0bfb02ad9a"

URI_x86_64_v2_rust-derive_more-impl+into-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+into-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+into-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+into-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+into-devel.sha256sum] = "8f7bde785d8414df40c1d44e8c6c6d1524bde4bd5639663eca76160227b44ddb"

URI_x86_64_v2_rust-derive_more-impl+into_iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+into_iterator-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+into_iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+into_iterator-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+into_iterator-devel.sha256sum] = "4a93c5855215a74aa783aa5ab8e0b63ab42a400ff0c215a0b711f814165bd8af"

URI_x86_64_v2_rust-derive_more-impl+is_variant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+is_variant-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+is_variant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+is_variant-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+is_variant-devel.sha256sum] = "2804f30b2fe7774e9350f5b4ca0bc560794c5ac1cb61edc44496e758db912478"

URI_x86_64_v2_rust-derive_more-impl+mul-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+mul-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+mul-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+mul-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+mul-devel.sha256sum] = "3ea752c7ca3d34e5a4ef932ffa1ad9b1d281531ab64147f389546d234a17bdc7"

URI_x86_64_v2_rust-derive_more-impl+mul_assign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+mul_assign-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+mul_assign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+mul_assign-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+mul_assign-devel.sha256sum] = "6d7ff9548c0194599f0b8fed8b97f8846e0b97a4aef0d75bd683c739098d4b04"

URI_x86_64_v2_rust-derive_more-impl+not-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+not-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+not-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+not-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+not-devel.sha256sum] = "5f7f8321fe36231a93d0f0865424348be9af3f6e29d686dde73f94cb03badcd3"

URI_x86_64_v2_rust-derive_more-impl+sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+sum-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+sum-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+sum-devel.sha256sum] = "a71516a44a2855850cab8499504346ef2e3dbcfe19ddedca6efd85ef4186f46f"

URI_x86_64_v2_rust-derive_more-impl+testing-helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+testing-helpers-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+testing-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+testing-helpers-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+testing-helpers-devel.sha256sum] = "be007000f67eae8b0d4fcfdb0315184bd76ce326b03fec60b6f44b3b2f42c82b"

URI_x86_64_v2_rust-derive_more-impl+try_from-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+try_from-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+try_from-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+try_from-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+try_from-devel.sha256sum] = "c21f9d7b431aa980bc08887b96169cdc8321f81a196ef6dfd5dbb0167418dcb9"

URI_x86_64_v2_rust-derive_more-impl+try_into-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+try_into-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+try_into-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+try_into-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+try_into-devel.sha256sum] = "4f6d2d0a553c3ae0f8f1d73c266020254bcc12ff307182294ccb9675b3d77dc5"

URI_x86_64_v2_rust-derive_more-impl+try_unwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+try_unwrap-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+try_unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+try_unwrap-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+try_unwrap-devel.sha256sum] = "0135006ac92e4d8cd8766893ed1cdc42ebb54fbf36a9198daf58a76814efaa91"

URI_x86_64_v2_rust-derive_more-impl+unwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+unwrap-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+unwrap-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+unwrap-devel.sha256sum] = "9e9444b49b2d50dae2269187cbb60fae91ee351fa088853f1639b5814c40417a"

URI_x86_64_v2_rust-derive_more-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl-devel-2.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl-devel.sha256sum] = "4aab686f9bd2349cc246905db63bf058d844bbae8e1c7f047a9c9ccbcfaaee06"

URI_aarch64_rust-derive_more-impl+add-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+add-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+add-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+add-devel}"
SRC_URI[aarch64_rust-derive_more-impl+add-devel.sha256sum] = "62c1c09512a42f2449d58eb497f734f6cbc48897cbcb1993d1cde182cc912a95"

URI_aarch64_rust-derive_more-impl+add_assign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+add_assign-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+add_assign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+add_assign-devel}"
SRC_URI[aarch64_rust-derive_more-impl+add_assign-devel.sha256sum] = "a985dcb00432346af1eda4f7b0d8780866a2737b9fb6e08fdf82d8925c58a0c8"

URI_aarch64_rust-derive_more-impl+as_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+as_ref-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+as_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+as_ref-devel}"
SRC_URI[aarch64_rust-derive_more-impl+as_ref-devel.sha256sum] = "c87aac9ac66dc4739f10708e37d28cd8bfe96ddfc485acf9f44799f04f487125"

URI_aarch64_rust-derive_more-impl+constructor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+constructor-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+constructor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+constructor-devel}"
SRC_URI[aarch64_rust-derive_more-impl+constructor-devel.sha256sum] = "d43ad97d9f919e390f746cbe7e41fec37d2a60125d6d588b0799ff3011d2e808"

URI_aarch64_rust-derive_more-impl+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+debug-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+debug-devel}"
SRC_URI[aarch64_rust-derive_more-impl+debug-devel.sha256sum] = "9c5c7769c32909147441fdb444f9cd82e1cb443a02121598f98a03112101cd20"

URI_aarch64_rust-derive_more-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+default-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+default-devel}"
SRC_URI[aarch64_rust-derive_more-impl+default-devel.sha256sum] = "83dc1e088d7b5e26e4cf7dcbc9581233b59ed5cd1ece0328b49a6a6478b7a64e"

URI_aarch64_rust-derive_more-impl+deref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+deref-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+deref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+deref-devel}"
SRC_URI[aarch64_rust-derive_more-impl+deref-devel.sha256sum] = "be2a97f2e13d74fd86c4efe8d46f9b55903b47f73b1985fae012c12de006aaf5"

URI_aarch64_rust-derive_more-impl+deref_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+deref_mut-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+deref_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+deref_mut-devel}"
SRC_URI[aarch64_rust-derive_more-impl+deref_mut-devel.sha256sum] = "4e0cb0969c039d65d02fc20b9bbf16b7f937a7591e404ab9887bd6d3e7e63f61"

URI_aarch64_rust-derive_more-impl+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+display-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+display-devel}"
SRC_URI[aarch64_rust-derive_more-impl+display-devel.sha256sum] = "26072c6a794b2197cb225c956b3f44bc2ebb083f1dce0339bd6e7a541140fa12"

URI_aarch64_rust-derive_more-impl+error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+error-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+error-devel}"
SRC_URI[aarch64_rust-derive_more-impl+error-devel.sha256sum] = "1c8688ce1adc4f93516c20f74b55a8aa7d44d898f0c4ce6fa90b0860046c7465"

URI_aarch64_rust-derive_more-impl+from-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+from-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+from-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+from-devel}"
SRC_URI[aarch64_rust-derive_more-impl+from-devel.sha256sum] = "f7139ad516285208981374908a030eefc3a71a013a86eeed8d4f7603327a7761"

URI_aarch64_rust-derive_more-impl+from_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+from_str-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+from_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+from_str-devel}"
SRC_URI[aarch64_rust-derive_more-impl+from_str-devel.sha256sum] = "b5d7b6b646ec7b64ba278d8ead89905acf9dec1ba09821150e04b91691458eb3"

URI_aarch64_rust-derive_more-impl+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+full-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+full-devel}"
SRC_URI[aarch64_rust-derive_more-impl+full-devel.sha256sum] = "eda48c55fe6db8a8aa08a4ccf3fe987d245bbdd75f4c2896ff1b504b21ad4eb3"

URI_aarch64_rust-derive_more-impl+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+index-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+index-devel}"
SRC_URI[aarch64_rust-derive_more-impl+index-devel.sha256sum] = "5223263166ecbd2bfd300121ce629ffee2968de4dc5080dbd89368298b817d53"

URI_aarch64_rust-derive_more-impl+index_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+index_mut-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+index_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+index_mut-devel}"
SRC_URI[aarch64_rust-derive_more-impl+index_mut-devel.sha256sum] = "bba31b98b5db47c28e6347464ca28f6bb7bf456fd81a1b943c2ad7fc762be3b1"

URI_aarch64_rust-derive_more-impl+into-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+into-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+into-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+into-devel}"
SRC_URI[aarch64_rust-derive_more-impl+into-devel.sha256sum] = "21de388a19e01203eb83af477b9a9ee830f69d543dde24106a16b8f5d7fb6ec9"

URI_aarch64_rust-derive_more-impl+into_iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+into_iterator-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+into_iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+into_iterator-devel}"
SRC_URI[aarch64_rust-derive_more-impl+into_iterator-devel.sha256sum] = "ba27ba3253b111013db28ba6665729b125b971955916242df13d4dcbc8cdb2a5"

URI_aarch64_rust-derive_more-impl+is_variant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+is_variant-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+is_variant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+is_variant-devel}"
SRC_URI[aarch64_rust-derive_more-impl+is_variant-devel.sha256sum] = "ed0c4b21320e18a803214f5615ba823e92e3cc0ca6cb6a32f60992f7938cd1f2"

URI_aarch64_rust-derive_more-impl+mul-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+mul-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+mul-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+mul-devel}"
SRC_URI[aarch64_rust-derive_more-impl+mul-devel.sha256sum] = "7894ab32a18337cda7c65dff1a7742e8542ba75c0cbdc7af13dd0374d86e90f6"

URI_aarch64_rust-derive_more-impl+mul_assign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+mul_assign-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+mul_assign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+mul_assign-devel}"
SRC_URI[aarch64_rust-derive_more-impl+mul_assign-devel.sha256sum] = "44091ae80613080443e1ad8c14d09b2323562228d40a5313c1a00328aa47339d"

URI_aarch64_rust-derive_more-impl+not-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+not-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+not-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+not-devel}"
SRC_URI[aarch64_rust-derive_more-impl+not-devel.sha256sum] = "72689c14a837860cd201bc13362933e13f0feaaba502471828694eedb82b7a50"

URI_aarch64_rust-derive_more-impl+sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+sum-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+sum-devel}"
SRC_URI[aarch64_rust-derive_more-impl+sum-devel.sha256sum] = "50d82c7d8c23dfe4a0aeed2dbe793d42b2cb7996d40e8da93ebc8a043e410395"

URI_aarch64_rust-derive_more-impl+testing-helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+testing-helpers-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+testing-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+testing-helpers-devel}"
SRC_URI[aarch64_rust-derive_more-impl+testing-helpers-devel.sha256sum] = "284285a23d2f87470c61bfbcb91c8bdcabac3eff5ac3707b949461a3f4329f5a"

URI_aarch64_rust-derive_more-impl+try_from-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+try_from-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+try_from-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+try_from-devel}"
SRC_URI[aarch64_rust-derive_more-impl+try_from-devel.sha256sum] = "57c542b0c92549cc601a6fd3848238a6c558e73f13a16ba65cf7ad1917c631be"

URI_aarch64_rust-derive_more-impl+try_into-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+try_into-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+try_into-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+try_into-devel}"
SRC_URI[aarch64_rust-derive_more-impl+try_into-devel.sha256sum] = "441b4726488badab2161ab2d46c01d72c8d039bc047c2e3b451834158c5c7aa9"

URI_aarch64_rust-derive_more-impl+try_unwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+try_unwrap-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+try_unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+try_unwrap-devel}"
SRC_URI[aarch64_rust-derive_more-impl+try_unwrap-devel.sha256sum] = "708d1bba64f9aeea79f0a548bdbff8eb6796f15cff2d1114ab537f983025c8a4"

URI_aarch64_rust-derive_more-impl+unwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+unwrap-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl+unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+unwrap-devel}"
SRC_URI[aarch64_rust-derive_more-impl+unwrap-devel.sha256sum] = "d5acf1d8a179a457e2dadf930d687d5e527fdd9f96c9cf928c94d5e675b44a81"

URI_aarch64_rust-derive_more-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl-devel-2.0.1-2.el10_2.noarch.rpm;name=aarch64_rust-derive_more-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl-devel}"
SRC_URI[aarch64_rust-derive_more-impl-devel.sha256sum] = "6c2bbccb5201b176a062513ad1449df8032573b468e6a3d384e461082fcdb792"

RDEPENDS:rust-derive_more-impl+add-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+add_assign-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+as_ref-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 rust-syn+visit-devel \
 "
RDEPENDS:rust-derive_more-impl+constructor-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+debug-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 rust-unicode-xid+default-devel \
 "
RDEPENDS:rust-derive_more-impl+default-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+deref-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+deref_mut-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+display-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 rust-unicode-xid+default-devel \
 "
RDEPENDS:rust-derive_more-impl+error-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+from-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+from_str-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+full-devel = " \
 cargo \
 rust-derive_more-impl+add-devel \
 rust-derive_more-impl+add_assign-devel \
 rust-derive_more-impl+as_ref-devel \
 rust-derive_more-impl+constructor-devel \
 rust-derive_more-impl+debug-devel \
 rust-derive_more-impl+deref-devel \
 rust-derive_more-impl+deref_mut-devel \
 rust-derive_more-impl+display-devel \
 rust-derive_more-impl+error-devel \
 rust-derive_more-impl+from-devel \
 rust-derive_more-impl+from_str-devel \
 rust-derive_more-impl+index-devel \
 rust-derive_more-impl+index_mut-devel \
 rust-derive_more-impl+into-devel \
 rust-derive_more-impl+into_iterator-devel \
 rust-derive_more-impl+is_variant-devel \
 rust-derive_more-impl+mul-devel \
 rust-derive_more-impl+mul_assign-devel \
 rust-derive_more-impl+not-devel \
 rust-derive_more-impl+sum-devel \
 rust-derive_more-impl+try_from-devel \
 rust-derive_more-impl+try_into-devel \
 rust-derive_more-impl+try_unwrap-devel \
 rust-derive_more-impl+unwrap-devel \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+index-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+index_mut-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+into-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+into_iterator-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+is_variant-devel = " \
 cargo \
 rust-convert_case0.7+default-devel \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+mul-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+mul_assign-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+not-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+sum-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+testing-helpers-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-rustc_version+default-devel \
 "
RDEPENDS:rust-derive_more-impl+try_from-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+try_into-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+try_unwrap-devel = " \
 cargo \
 rust-convert_case0.7+default-devel \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+unwrap-devel = " \
 cargo \
 rust-convert_case0.7+default-devel \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
