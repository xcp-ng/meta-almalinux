# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom"
PV = "0.3.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-getrandom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom-0.3.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5645522d90c2f9ff4ba5ea57a7b4c6bd50b057ad4854261b08318a760effaeb1"

URI_x86_64_v2_rust-getrandom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+default-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom+default-devel.sha256sum] = "e0b8ca5b82c7f99d6fdc2684bf6492b49f6adf8859f3063e0c2df4e5a8d74112"

URI_x86_64_v2_rust-getrandom+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+std-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom+std-devel.sha256sum] = "e0c48683bfd2ffff492256fcbf7f2429d74869e5a9db9a18ac435e382631ade8"

URI_x86_64_v2_rust-getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom-devel}"
SRC_URI[x86_64_v2_rust-getrandom-devel.sha256sum] = "bae72a5f1fce69dbc28d9839442f966ddd1821c2ff191c135d138a112e9038da"

URI_aarch64_rust-getrandom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+default-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-getrandom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+default-devel}"
SRC_URI[aarch64_rust-getrandom+default-devel.sha256sum] = "2047c09cc1bc9d0064b957c6aed712fc8f0e0fb70da8fbcc116ca44a217b73ba"

URI_aarch64_rust-getrandom+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+std-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-getrandom+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+std-devel}"
SRC_URI[aarch64_rust-getrandom+std-devel.sha256sum] = "2bda2c9cad32fcfc1dbc8d2b216e5ebbd0f78a1b0dcc8d89dca5d81441c815dc"

URI_aarch64_rust-getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom-devel}"
SRC_URI[aarch64_rust-getrandom-devel.sha256sum] = "fba869b3ff1a477e94bf0d215e9af2cf46b74d81aabcf496d95f69b50d9ffba8"

RDEPENDS:rust-getrandom+default-devel = " \
 cargo \
 rust-getrandom-devel \
 "
RDEPENDS:rust-getrandom+std-devel = " \
 cargo \
 rust-getrandom-devel \
 "
RDEPENDS:rust-getrandom-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
