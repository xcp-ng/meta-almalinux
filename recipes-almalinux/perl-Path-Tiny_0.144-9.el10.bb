# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Path-Tiny"
PV = "0.144"
PR = "9.el10"
PACKAGES = " \
 perl-Path-Tiny \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Path-Tiny-0.144-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bdb77eee2aa5959e39800aadfe5d5f9a9571c297eda0d7ea8ccf4b34986a9810"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Path-Tiny-0.144-9.el10.noarch.rpm;name=x86_64_v2_perl-Path-Tiny;unpack=0"
SRC_URI[x86_64_v2_perl-Path-Tiny.sha256sum] = "090ae1a8a8f986c299a394bb5824d217c5ce1f8439231d361aeb51f151c7b605"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Path-Tiny-0.144-9.el10.noarch.rpm;name=aarch64_perl-Path-Tiny;unpack=0"
SRC_URI[aarch64_perl-Path-Tiny.sha256sum] = "090ae1a8a8f986c299a394bb5824d217c5ce1f8439231d361aeb51f151c7b605"

RDEPENDS:perl-Path-Tiny = " \
 perl-Carp \
 perl-Digest \
 perl-Digest-SHA \
 perl-Encode \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-PathTools \
 perl-Unicode-UTF8 \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-threads \
 "
