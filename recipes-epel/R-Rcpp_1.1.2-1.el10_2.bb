# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-Rcpp"
PV = "1.1.2"
PR = "1.el10_2"
PACKAGES = " \
 R-Rcpp \
 R-Rcpp-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-Rcpp-1.1.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88ab3df88c84808a63450361aca7bd74bf56ed159d2def44d3d4f032e5c44d9b"

URI_x86_64_v2_R-Rcpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-Rcpp-1.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-Rcpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-Rcpp}"
SRC_URI[x86_64_v2_R-Rcpp.sha256sum] = "67854ad6620a81d953647277c7706d7608a904eb803a707812814098224f9690"

URI_x86_64_v2_R-Rcpp-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-Rcpp-examples-1.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-Rcpp-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-Rcpp-examples}"
SRC_URI[x86_64_v2_R-Rcpp-examples.sha256sum] = "98988d4be81aa0c9456b7fd10c833baffa8ae3a8d30ecabeb4921159407d924b"

URI_aarch64_R-Rcpp = "${EPEL_MIRROR}/aarch64/Packages/r/R-Rcpp-1.1.2-1.el10_2.aarch64.rpm;name=aarch64_R-Rcpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-Rcpp}"
SRC_URI[aarch64_R-Rcpp.sha256sum] = "e153738681c31053a57f162c6fa4f911a38c6035011601690df7ac3b1cf468c2"

URI_aarch64_R-Rcpp-examples = "${EPEL_MIRROR}/aarch64/Packages/r/R-Rcpp-examples-1.1.2-1.el10_2.aarch64.rpm;name=aarch64_R-Rcpp-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-Rcpp-examples}"
SRC_URI[aarch64_R-Rcpp-examples.sha256sum] = "f77cf6bcc9b0a7938f780e9e982d876f5eed986437edd8b4afb05ddd5fa4519e"

RDEPENDS:R-Rcpp = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:R-Rcpp-examples = " \
 R-Rcpp \
 R-littler \
 bash \
 "
