# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-annex"
PV = "10.20250320"
PR = "1.el10_0"
PACKAGES = " \
 ghc-file-io \
 ghc-file-io-devel \
 ghc-file-io-doc \
 ghc-file-io-prof \
 git-annex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-annex-10.20250320-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "147fca9127983bfff8ce3e3cca768d5cefb0cb51b849d6266f5ec839c6ad860a"

URI_x86_64_v2_ghc-file-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-file-io-0.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-file-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-file-io}"
SRC_URI[x86_64_v2_ghc-file-io.sha256sum] = "5317dc8dbf17a68910736e60211d9e9dc67975f8d3b69e6e171c038bd0598b42"

URI_x86_64_v2_ghc-file-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-file-io-devel-0.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-file-io-devel}"
SRC_URI[x86_64_v2_ghc-file-io-devel.sha256sum] = "2b95feb7be7c1a4d4e840b626686a8f7353f868df5240ba163d04ada9020a967"

URI_x86_64_v2_ghc-file-io-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-file-io-doc-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-file-io-doc}"
SRC_URI[x86_64_v2_ghc-file-io-doc.sha256sum] = "0d7e55d3a8dbdcda37342b6487da2bd6a307f7c09cfe7b7ae0ed14f65fb7d4a5"

URI_x86_64_v2_ghc-file-io-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-file-io-prof-0.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-file-io-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-file-io-prof}"
SRC_URI[x86_64_v2_ghc-file-io-prof.sha256sum] = "94889080606099f5f1f98b41eefe083e18d26965583758a99ab142f37cac5df3"

URI_x86_64_v2_git-annex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-annex-10.20250320-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-annex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-annex}"
SRC_URI[x86_64_v2_git-annex.sha256sum] = "f91a6d060cf74f47e9a4e5683a6f99106c07f7690011ed338d5738e33469412e"

URI_aarch64_ghc-file-io = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-file-io-0.1.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-file-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-file-io}"
SRC_URI[aarch64_ghc-file-io.sha256sum] = "094e80b64b8a6d9b899ebb612489c9145f498293f4355c2920466d5e0284b20e"

URI_aarch64_ghc-file-io-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-file-io-devel-0.1.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-file-io-devel}"
SRC_URI[aarch64_ghc-file-io-devel.sha256sum] = "e8893af4cd4542dd0dbd0d6c3b40f478fda81693cb27ed78c39073b1ad0dfc31"

URI_aarch64_ghc-file-io-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-file-io-doc-0.1.5-1.el10_0.noarch.rpm;name=aarch64_ghc-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-file-io-doc}"
SRC_URI[aarch64_ghc-file-io-doc.sha256sum] = "2e025eda05e9a6b27b6f0b42331678c70a01d677ef382b4bc99fd671c07ad666"

URI_aarch64_ghc-file-io-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-file-io-prof-0.1.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-file-io-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-file-io-prof}"
SRC_URI[aarch64_ghc-file-io-prof.sha256sum] = "26013bc9cbe202b057f91c7a5d5408b601a6d61c92ee6cd78aa3b756734c7d8c"

URI_aarch64_git-annex = "${EPEL_MIRROR}/aarch64/Packages/g/git-annex-10.20250320-1.el10_0.aarch64.rpm;name=aarch64_git-annex;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-annex}"
SRC_URI[aarch64_git-annex.sha256sum] = "6755d9fd7cf36c2ea8ff843cf7ee37597ff3f0da91b73b763ab7e912eca6dd2d"

RDEPENDS:ghc-file-io = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-file-io-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-file-io \
 ghc-filepath-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-file-io-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-file-io-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-file-io-devel \
 ghc-filepath-prof \
 ghc-unix-prof \
 "
RDEPENDS:git-annex = " \
 file-libs \
 git-core \
 glibc \
 gmp \
 libffi \
 libyaml \
 sqlite-libs \
 zlib-ng-compat \
 "
