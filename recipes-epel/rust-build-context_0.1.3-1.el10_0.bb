# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-build-context"
PV = "0.1.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-build-context+default-devel \
 rust-build-context-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-build-context-0.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c47015449a02310c692aab9ba7c89819900d29a6a2e58f18838b651e031f3874"

URI_x86_64_v2_rust-build-context+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-build-context+default-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-build-context+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-build-context+default-devel}"
SRC_URI[x86_64_v2_rust-build-context+default-devel.sha256sum] = "75a669b303c7205e647921150e967b6076a30415bdb7ad7fa1018e934dfc584f"

URI_x86_64_v2_rust-build-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-build-context-devel-0.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-build-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-build-context-devel}"
SRC_URI[x86_64_v2_rust-build-context-devel.sha256sum] = "74799002333ff83611350433ba12a18a3dcc2598cffa2e7f385c099f39848210"

URI_aarch64_rust-build-context+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-build-context+default-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-build-context+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-build-context+default-devel}"
SRC_URI[aarch64_rust-build-context+default-devel.sha256sum] = "b0c1127da1f28ec6d5450be8b695af019136dba4b2ff771d89eaa25fe9952a90"

URI_aarch64_rust-build-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-build-context-devel-0.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-build-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-build-context-devel}"
SRC_URI[aarch64_rust-build-context-devel.sha256sum] = "fc2ad921360678cdf09a8f20e8dfe1f9831eea157f0b017e97d6a74df1d82476"

RDEPENDS:rust-build-context+default-devel = " \
 cargo \
 rust-build-context-devel \
 "
RDEPENDS:rust-build-context-devel = " \
 cargo \
 rust \
 "
