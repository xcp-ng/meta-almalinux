# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fetch-crl"
PV = "3.0.23"
PR = "6.el10_0"
PACKAGES = " \
 fetch-crl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fetch-crl-3.0.23-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04f0a844aa2d0523a6bc3d315886eed4f1e0c35669dc2e59cb80f06f90bc32df"

URI_x86_64_v2_fetch-crl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fetch-crl-3.0.23-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fetch-crl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fetch-crl}"
SRC_URI[x86_64_v2_fetch-crl.sha256sum] = "dc5ccefefb76d42c12d7c47a734979926a4187cc4262091ce3434b9442d5667c"

URI_aarch64_fetch-crl = "${EPEL_MIRROR}/aarch64/Packages/f/fetch-crl-3.0.23-6.el10_0.noarch.rpm;name=aarch64_fetch-crl;unpack=0"
SRC_URI:append = " ${URI_aarch64_fetch-crl}"
SRC_URI[aarch64_fetch-crl.sha256sum] = "cc11014c6d2122c4edd7a6267b1cd1dcb1986c60aa9110c0fa57898d4dd83291"

RDEPENDS:fetch-crl = " \
 bash \
 openssl \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-LWP-Protocol-https \
 perl-POSIX \
 perl-Sys-Syslog \
 perl-Time-Local \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 systemd \
 "
