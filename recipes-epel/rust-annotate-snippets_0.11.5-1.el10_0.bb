# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-annotate-snippets"
PV = "0.11.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-annotate-snippets+default-devel \
 rust-annotate-snippets+memchr-devel \
 rust-annotate-snippets+simd-devel \
 rust-annotate-snippets+testing-colors-devel \
 rust-annotate-snippets-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-annotate-snippets-0.11.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc33fff0451e6a26b0342d29f52d2ffa370575b1947f918f1cb9be6b93b1d510"

URI_x86_64_v2_rust-annotate-snippets+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+default-devel-0.11.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+default-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+default-devel.sha256sum] = "3d2a9d426505923d87acef1598580c968e65f5a207ef9f24389140d39e13def3"

URI_x86_64_v2_rust-annotate-snippets+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+memchr-devel-0.11.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+memchr-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+memchr-devel.sha256sum] = "e11bf804fcccf58f8a88fba486538410e5f04906b892d561fedc8bb52d51e2a1"

URI_x86_64_v2_rust-annotate-snippets+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+simd-devel-0.11.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+simd-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+simd-devel.sha256sum] = "0a474152a9127cbb85cab61d74fa1ebe1d7fdffb94c6d7a46ab0d2eff3597700"

URI_x86_64_v2_rust-annotate-snippets+testing-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets+testing-colors-devel-0.11.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets+testing-colors-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets+testing-colors-devel.sha256sum] = "97f01002b82c8beae193cd1c42893c5b665123dfbc557869d0bd3548e3796e24"

URI_x86_64_v2_rust-annotate-snippets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets-devel-0.11.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets-devel.sha256sum] = "ad9c79a3a5b99a7b1c4549307bfef514b4fc3fd5a604195bba7cf0dbe77592f4"

URI_aarch64_rust-annotate-snippets+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+default-devel-0.11.5-1.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+default-devel}"
SRC_URI[aarch64_rust-annotate-snippets+default-devel.sha256sum] = "bd51c2e6683aa339c1827d86af05dec1f260d7fa3dd33d917d09f51e04184a40"

URI_aarch64_rust-annotate-snippets+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+memchr-devel-0.11.5-1.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+memchr-devel}"
SRC_URI[aarch64_rust-annotate-snippets+memchr-devel.sha256sum] = "9fcee930530da6c669d6a2422ed8c233da6cf6893a71d24ecd9c50a5de1ee73e"

URI_aarch64_rust-annotate-snippets+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+simd-devel-0.11.5-1.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+simd-devel}"
SRC_URI[aarch64_rust-annotate-snippets+simd-devel.sha256sum] = "06a12ba75444f7f39414887a3898caa204853199a326541d910d6a7e4b837135"

URI_aarch64_rust-annotate-snippets+testing-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets+testing-colors-devel-0.11.5-1.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets+testing-colors-devel}"
SRC_URI[aarch64_rust-annotate-snippets+testing-colors-devel.sha256sum] = "9733cc664b32efa068bd6489ccfb7ca4a36237a689703d48b4b938664b1faca2"

URI_aarch64_rust-annotate-snippets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets-devel-0.11.5-1.el10_0.noarch.rpm;name=aarch64_rust-annotate-snippets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets-devel}"
SRC_URI[aarch64_rust-annotate-snippets-devel.sha256sum] = "ce7f9022ddf95670e9acd2fd605bc55663b5f199f1c1c90271f8b08359f50593"

RDEPENDS:rust-annotate-snippets+default-devel = " \
 cargo \
 rust-annotate-snippets-devel \
 "
RDEPENDS:rust-annotate-snippets+memchr-devel = " \
 cargo \
 rust-annotate-snippets-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-annotate-snippets+simd-devel = " \
 cargo \
 rust-annotate-snippets+memchr-devel \
 rust-annotate-snippets-devel \
 "
RDEPENDS:rust-annotate-snippets+testing-colors-devel = " \
 cargo \
 rust-annotate-snippets-devel \
 "
RDEPENDS:rust-annotate-snippets-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-unicode-width+default-devel \
 "
