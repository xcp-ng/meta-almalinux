# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyter-core"
PV = "5.7.2"
PR = "8.el10_0"
PACKAGES = " \
 python-jupyter-filesystem \
 python3-jupyter-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jupyter-core-5.7.2-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7163eeea7ed3b26f98360c9b791c28dae60f07cb89d4215f7c503e557f264763"

URI_x86_64_v2_python-jupyter-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-jupyter-filesystem-5.7.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-jupyter-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-jupyter-filesystem}"
SRC_URI[x86_64_v2_python-jupyter-filesystem.sha256sum] = "b516fd9b4836170a4336fd10dffbd5b1e889fed1957a995b707c4a4c651cf1ca"

URI_x86_64_v2_python3-jupyter-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyter-core-5.7.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyter-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyter-core}"
SRC_URI[x86_64_v2_python3-jupyter-core.sha256sum] = "b49b33a6da9da5f6815d20465c38cb196061af21b9f37453afa36e685574aa4c"

URI_aarch64_python-jupyter-filesystem = "${EPEL_MIRROR}/aarch64/Packages/p/python-jupyter-filesystem-5.7.2-8.el10_0.noarch.rpm;name=aarch64_python-jupyter-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-jupyter-filesystem}"
SRC_URI[aarch64_python-jupyter-filesystem.sha256sum] = "f8f551ec9d6c57542d5a67b62952db3d7373ab01b7e8520b2cb6afb53a5a178e"

URI_aarch64_python3-jupyter-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyter-core-5.7.2-8.el10_0.noarch.rpm;name=aarch64_python3-jupyter-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyter-core}"
SRC_URI[aarch64_python3-jupyter-core.sha256sum] = "1bddfe2aa02f70f6b334af9a83c3b96f98dbcb527d7ae025195a6c7e95647a26"

RDEPENDS:python-jupyter-filesystem = " \
 "
RDEPENDS:python3-jupyter-core = " \
 python3 \
 python3-platformdirs \
 python3-traitlets \
 "
