# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-core"
PV = "0.1.36"
PR = "1.el10_1"
PACKAGES = " \
 rust-tracing-core+default-devel \
 rust-tracing-core+once_cell-devel \
 rust-tracing-core+std-devel \
 rust-tracing-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-core-0.1.36-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2da4261b8b7d7536f269f22b8c48037e0ee7fadd0d40cca9601a4f40d5ff77c1"

URI_x86_64_v2_rust-tracing-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core+default-devel-0.1.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-core+default-devel.sha256sum] = "7008c4d2c4fcc2303402b6da0319b65b5d319017a35725bd0af5b808a5507fcd"

URI_x86_64_v2_rust-tracing-core+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core+once_cell-devel-0.1.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core+once_cell-devel}"
SRC_URI[x86_64_v2_rust-tracing-core+once_cell-devel.sha256sum] = "5a210802ccc8369859c56cc1c62b4935e26917ef129a77939e2aa4e3b7fbe0ee"

URI_x86_64_v2_rust-tracing-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core+std-devel-0.1.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core+std-devel}"
SRC_URI[x86_64_v2_rust-tracing-core+std-devel.sha256sum] = "65a00fb6dcb6ed271bb8c6d20a7d91ad62b6d5027bee2c68d2d94524ad2e1d63"

URI_x86_64_v2_rust-tracing-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-core-devel-0.1.36-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-core-devel}"
SRC_URI[x86_64_v2_rust-tracing-core-devel.sha256sum] = "ca224467f16f344796b75923461b12f3939776b8605fea4b6d6cf247a89c5ad2"

URI_aarch64_rust-tracing-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core+default-devel-0.1.36-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core+default-devel}"
SRC_URI[aarch64_rust-tracing-core+default-devel.sha256sum] = "f7a92f6caea6b0af1621914831b25929c9fb03e982008cc50337d116e9f0391f"

URI_aarch64_rust-tracing-core+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core+once_cell-devel-0.1.36-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-core+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core+once_cell-devel}"
SRC_URI[aarch64_rust-tracing-core+once_cell-devel.sha256sum] = "9fb946107d5ab37db3fc2fb30ca4e31f7d25f61bee05038c54de18bcd15fd497"

URI_aarch64_rust-tracing-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core+std-devel-0.1.36-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core+std-devel}"
SRC_URI[aarch64_rust-tracing-core+std-devel.sha256sum] = "acb8db25e8bcf1ccdc9d32020c02dc0e0e83872e7642b2a1d583e4c2f21a879a"

URI_aarch64_rust-tracing-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-core-devel-0.1.36-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-core-devel}"
SRC_URI[aarch64_rust-tracing-core-devel.sha256sum] = "5636fc8266f557d3fa120c427bedd5429b7137e47287e0889ef9f2cedf1825a7"

RDEPENDS:rust-tracing-core+default-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-core-devel \
 "
RDEPENDS:rust-tracing-core+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-tracing-core-devel \
 "
RDEPENDS:rust-tracing-core+std-devel = " \
 cargo \
 rust-tracing-core+once_cell-devel \
 rust-tracing-core-devel \
 "
RDEPENDS:rust-tracing-core-devel = " \
 cargo \
 rust \
 "
