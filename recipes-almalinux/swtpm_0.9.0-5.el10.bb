# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "swtpm"
PV = "0.9.0"
PR = "5.el10"
PACKAGES = " \
 swtpm \
 swtpm-libs \
 swtpm-selinux \
 swtpm-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/swtpm-0.9.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90cf488bfa79d0d70cc92458e6983bdfac7c4f666b08bca1d1deab7462bd9c2c"

URI_x86_64_v2_swtpm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-0.9.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_swtpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swtpm}"
SRC_URI[x86_64_v2_swtpm.sha256sum] = "4d84604ad8e0e2b616ec98036612d370c1b50e986b3f5ef726b2e87bb4f25d9a"

URI_x86_64_v2_swtpm-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-libs-0.9.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_swtpm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swtpm-libs}"
SRC_URI[x86_64_v2_swtpm-libs.sha256sum] = "9c1988541581949ec55b4bca293c2064c97cf6af98ec3c8282fe10f276b1d892"

URI_x86_64_v2_swtpm-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-selinux-0.9.0-5.el10.noarch.rpm;name=x86_64_v2_swtpm-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swtpm-selinux}"
SRC_URI[x86_64_v2_swtpm-selinux.sha256sum] = "18a3762c4d4cf1192c640060b542314f159558ac4b11815af75928e47f3a658d"

URI_x86_64_v2_swtpm-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/swtpm-tools-0.9.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_swtpm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swtpm-tools}"
SRC_URI[x86_64_v2_swtpm-tools.sha256sum] = "0ef3c87070c1e2084164bbc8e34208bc46ebf9a433f2c9259dcff19f6d5e5c36"

URI_aarch64_swtpm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-0.9.0-5.el10.aarch64.rpm;name=aarch64_swtpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_swtpm}"
SRC_URI[aarch64_swtpm.sha256sum] = "3b68f051ab2666cab479d331bac5b7e8bc1650a769c5a52d920e1fa3cdf6f2d5"

URI_aarch64_swtpm-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-libs-0.9.0-5.el10.aarch64.rpm;name=aarch64_swtpm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_swtpm-libs}"
SRC_URI[aarch64_swtpm-libs.sha256sum] = "a5cd3b20a6048a2ff1639fbfc23150f03e886502e0c5fe0711ee7c0784b6872e"

URI_aarch64_swtpm-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-selinux-0.9.0-5.el10.noarch.rpm;name=aarch64_swtpm-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_swtpm-selinux}"
SRC_URI[aarch64_swtpm-selinux.sha256sum] = "18a3762c4d4cf1192c640060b542314f159558ac4b11815af75928e47f3a658d"

URI_aarch64_swtpm-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/swtpm-tools-0.9.0-5.el10.aarch64.rpm;name=aarch64_swtpm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_swtpm-tools}"
SRC_URI[aarch64_swtpm-tools.sha256sum] = "b0dc510a511b3b878cb0f87d9416515bcab4d4223eb8998ede7e170124c1ad6c"

RDEPENDS:swtpm = " \
 glibc \
 libtpms \
 swtpm-libs \
 swtpm-selinux \
 "
RDEPENDS:swtpm-libs = " \
 glib2 \
 glibc \
 libseccomp \
 libtpms \
 openssl-libs \
 "
RDEPENDS:swtpm-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 swtpm \
 "
RDEPENDS:swtpm-tools = " \
 bash \
 glib2 \
 glibc \
 gmp \
 gnutls \
 gnutls-utils \
 json-glib \
 libgcc \
 libtasn1 \
 openssl-libs \
 swtpm \
 tpm2-tss \
 "
