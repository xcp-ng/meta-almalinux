# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-oid-registry"
PV = "0.7.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-oid-registry+crypto-devel \
 rust-oid-registry+default-devel \
 rust-oid-registry+kdf-devel \
 rust-oid-registry+ms_spc-devel \
 rust-oid-registry+nist_algs-devel \
 rust-oid-registry+pkcs1-devel \
 rust-oid-registry+pkcs12-devel \
 rust-oid-registry+pkcs7-devel \
 rust-oid-registry+pkcs9-devel \
 rust-oid-registry+registry-devel \
 rust-oid-registry+x500-devel \
 rust-oid-registry+x509-devel \
 rust-oid-registry+x962-devel \
 rust-oid-registry-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-oid-registry-0.7.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9d7f2c9fa82e58aeb38a94ced2b1064a0993cdaf810dff319d4c83a718928e4"

URI_x86_64_v2_rust-oid-registry+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+crypto-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+crypto-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+crypto-devel.sha256sum] = "1231b526571846c4b8ad9dfc7f624be3b83333a64dea9e3b1b45dc5ab2d0534b"

URI_x86_64_v2_rust-oid-registry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+default-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+default-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+default-devel.sha256sum] = "d7ea042b4ce7b747cbebf8c88eadcb15e4fb6d315d84d9345ee7aa33c6f16cc3"

URI_x86_64_v2_rust-oid-registry+kdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+kdf-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+kdf-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+kdf-devel.sha256sum] = "3265a08a78b92df5f6cc0f9784459b60570ae36e0f73aef15aa5e29c6e3c7423"

URI_x86_64_v2_rust-oid-registry+ms_spc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+ms_spc-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+ms_spc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+ms_spc-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+ms_spc-devel.sha256sum] = "1414eb3dcc9e2a2d2b46fd492ebd60eeffc21692272745bf4e30dbf4d969ee63"

URI_x86_64_v2_rust-oid-registry+nist_algs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+nist_algs-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+nist_algs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+nist_algs-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+nist_algs-devel.sha256sum] = "45d5a64af24d93883dcb27f1184153e64a3c0896e0ea789b95674fd4429ae720"

URI_x86_64_v2_rust-oid-registry+pkcs1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs1-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs1-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs1-devel.sha256sum] = "00010b7290221e0f4ef5a17581df50ffc106cf631aff045c54b37ef3c23178f1"

URI_x86_64_v2_rust-oid-registry+pkcs12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs12-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs12-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs12-devel.sha256sum] = "03e28c3c8a5873b554004a163140e3382994587c8fef7feb02292fafc1cfb4af"

URI_x86_64_v2_rust-oid-registry+pkcs7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs7-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs7-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs7-devel.sha256sum] = "eee2449e2a72dcbafc5c1986918fb393ddb44a292e8aee669dffb5093f465a84"

URI_x86_64_v2_rust-oid-registry+pkcs9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs9-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs9-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs9-devel.sha256sum] = "172bdcb0ff87e0aba88050bf511c4ac53253d0c5c45c61e41cb8703ad817e7bb"

URI_x86_64_v2_rust-oid-registry+registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+registry-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+registry-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+registry-devel.sha256sum] = "9172b1565601f1ff9117b5dd512f12172e88ad3385a9368951d8f5376d94a7c0"

URI_x86_64_v2_rust-oid-registry+x500-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+x500-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+x500-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+x500-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+x500-devel.sha256sum] = "1b0fedd152851172b1d449880203a20434dc64dc46e2b83a5b42bb9a916246bf"

URI_x86_64_v2_rust-oid-registry+x509-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+x509-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+x509-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+x509-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+x509-devel.sha256sum] = "41fe3d8e412a91958b0b2c31a6f9a0fea915034e10d6755099e71870f7ffccbc"

URI_x86_64_v2_rust-oid-registry+x962-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+x962-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+x962-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+x962-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+x962-devel.sha256sum] = "885a2239e9b3b6880916d5d432fe244d019275954614dab9f55293e502cbfade"

URI_x86_64_v2_rust-oid-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry-devel}"
SRC_URI[x86_64_v2_rust-oid-registry-devel.sha256sum] = "34249bc611a8dba9259c942d443db337b4c602c0c327b8b0b73083bde539a422"

URI_aarch64_rust-oid-registry+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+crypto-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+crypto-devel}"
SRC_URI[aarch64_rust-oid-registry+crypto-devel.sha256sum] = "a2ce5214bbf93fd60499cd29011ca5dde1b4128384a9c648abd6b6afc80f04e1"

URI_aarch64_rust-oid-registry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+default-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+default-devel}"
SRC_URI[aarch64_rust-oid-registry+default-devel.sha256sum] = "8bed3824da459458b5ca36fd46af23d7a7df6cd1b8333c77813bb9d68a5b0e21"

URI_aarch64_rust-oid-registry+kdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+kdf-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+kdf-devel}"
SRC_URI[aarch64_rust-oid-registry+kdf-devel.sha256sum] = "7267344db5ca97ac0c95e1537064e648cde6c63e091b3a75691e78efe2315422"

URI_aarch64_rust-oid-registry+ms_spc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+ms_spc-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+ms_spc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+ms_spc-devel}"
SRC_URI[aarch64_rust-oid-registry+ms_spc-devel.sha256sum] = "c137ba7ffc57379bc806c3db9e8d20979bca7c16feab49dce6e02bb87a9fd1a7"

URI_aarch64_rust-oid-registry+nist_algs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+nist_algs-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+nist_algs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+nist_algs-devel}"
SRC_URI[aarch64_rust-oid-registry+nist_algs-devel.sha256sum] = "096ee3490af5886f49ce75bcdd27464bcb925a68a252dcc5049e495d9ec9cb11"

URI_aarch64_rust-oid-registry+pkcs1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs1-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs1-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs1-devel.sha256sum] = "02cb7689bd575648d67763b257fc85ef8f6199f858dc1f4051db238f508e6ee0"

URI_aarch64_rust-oid-registry+pkcs12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs12-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+pkcs12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs12-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs12-devel.sha256sum] = "9edec447d5f0feecc8f9b599ef83da1537def3ed37dbba0e239ee09b2ee111b3"

URI_aarch64_rust-oid-registry+pkcs7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs7-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+pkcs7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs7-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs7-devel.sha256sum] = "229ab87215ba93579a5709b5e9aa039f78ce250872a426afdab3682d7859ee1c"

URI_aarch64_rust-oid-registry+pkcs9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs9-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+pkcs9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs9-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs9-devel.sha256sum] = "cc732de792ab3f53c1bed5c49389d1d1d6ae9384746658c481fae656a700145a"

URI_aarch64_rust-oid-registry+registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+registry-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+registry-devel}"
SRC_URI[aarch64_rust-oid-registry+registry-devel.sha256sum] = "adedb1ec5b04fcf4abcd7be2214c4f026987a64ba4ff1df158d1260e7e6ff86f"

URI_aarch64_rust-oid-registry+x500-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+x500-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+x500-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+x500-devel}"
SRC_URI[aarch64_rust-oid-registry+x500-devel.sha256sum] = "ebdd75386a9ba70759c5cd01b89f4e533927bf7712b75f4ec870c7b7da595e41"

URI_aarch64_rust-oid-registry+x509-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+x509-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+x509-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+x509-devel}"
SRC_URI[aarch64_rust-oid-registry+x509-devel.sha256sum] = "77f7daa91b50708179c48279b231e91c27f2be3231486896f48cd3ab7d4c9caa"

URI_aarch64_rust-oid-registry+x962-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+x962-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry+x962-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+x962-devel}"
SRC_URI[aarch64_rust-oid-registry+x962-devel.sha256sum] = "6322a5d92ecd78574d19447e22e26a943333b71747103f0146fed8139c603244"

URI_aarch64_rust-oid-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-oid-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry-devel}"
SRC_URI[aarch64_rust-oid-registry-devel.sha256sum] = "8cac4e4f4a6d68e6922d440c2eaaf1dc590ed190bc0f3c5adda209e588e5b268"

RDEPENDS:rust-oid-registry+crypto-devel = " \
 cargo \
 rust-oid-registry+kdf-devel \
 rust-oid-registry+nist_algs-devel \
 rust-oid-registry+pkcs1-devel \
 rust-oid-registry+pkcs12-devel \
 rust-oid-registry+pkcs7-devel \
 rust-oid-registry+pkcs9-devel \
 rust-oid-registry+x962-devel \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+default-devel = " \
 cargo \
 rust-oid-registry+registry-devel \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+kdf-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+ms_spc-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+nist_algs-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs1-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs12-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs7-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs9-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+registry-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+x500-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+x509-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+x962-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry-devel = " \
 cargo \
 rust \
 rust-asn1-rs+default-devel \
 "
