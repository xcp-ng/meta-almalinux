# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "build-helper-maven-plugin"
PV = "3.5.0"
PR = "6.el10"
PACKAGES = " \
 build-helper-maven-plugin \
 build-helper-maven-plugin-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/build-helper-maven-plugin-3.5.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cfbad1de0d9b2d80ced910b2d68ac1efc8820d452a3db6943c9ff590612bdf3"

URI_x86_64_v2_build-helper-maven-plugin = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/build-helper-maven-plugin-3.5.0-6.el10.noarch.rpm;name=x86_64_v2_build-helper-maven-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_build-helper-maven-plugin}"
SRC_URI[x86_64_v2_build-helper-maven-plugin.sha256sum] = "3ca74b8baebe29bdc943f26578e10157a72cfda0e80697b3781f2839a9133a0e"

URI_x86_64_v2_build-helper-maven-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/build-helper-maven-plugin-javadoc-3.5.0-6.el10.noarch.rpm;name=x86_64_v2_build-helper-maven-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_build-helper-maven-plugin-javadoc}"
SRC_URI[x86_64_v2_build-helper-maven-plugin-javadoc.sha256sum] = "877a0251c43747794a4ecc89cd25b769965d575ddf33981dbf54fd9373cfe020"

URI_aarch64_build-helper-maven-plugin = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/build-helper-maven-plugin-3.5.0-6.el10.noarch.rpm;name=aarch64_build-helper-maven-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_build-helper-maven-plugin}"
SRC_URI[aarch64_build-helper-maven-plugin.sha256sum] = "3ca74b8baebe29bdc943f26578e10157a72cfda0e80697b3781f2839a9133a0e"

URI_aarch64_build-helper-maven-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/build-helper-maven-plugin-javadoc-3.5.0-6.el10.noarch.rpm;name=aarch64_build-helper-maven-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_build-helper-maven-plugin-javadoc}"
SRC_URI[aarch64_build-helper-maven-plugin-javadoc.sha256sum] = "877a0251c43747794a4ecc89cd25b769965d575ddf33981dbf54fd9373cfe020"

RDEPENDS:build-helper-maven-plugin = " \
 javapackages-filesystem \
 maven-file-management \
 plexus-utils \
 slf4j \
 "
RDEPENDS:build-helper-maven-plugin-javadoc = " \
 javapackages-filesystem \
 "
