# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "f41-backgrounds"
PV = "41.0.2"
PR = "1.el10_0"
PACKAGES = " \
 f41-backgrounds \
 f41-backgrounds-base \
 f41-backgrounds-budgie \
 f41-backgrounds-gnome \
 f41-backgrounds-kde \
 f41-backgrounds-mate \
 f41-backgrounds-xfce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/f41-backgrounds-41.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9394753e0a3a556f9f76b3a27eea4dff981ef9669a0fb289232a0945bf607498"

URI_x86_64_v2_f41-backgrounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f41-backgrounds-41.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f41-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f41-backgrounds}"
SRC_URI[x86_64_v2_f41-backgrounds.sha256sum] = "61a7017a91ef123cebb0f1b204e1c4d6818036b5d32aa558fa547c41428ce4b0"

URI_x86_64_v2_f41-backgrounds-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f41-backgrounds-base-41.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f41-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f41-backgrounds-base}"
SRC_URI[x86_64_v2_f41-backgrounds-base.sha256sum] = "bdda16e3a9e1e7c4f9285a57190ab3a97bd14e3b9c0e2a6861b2677f7d63ba05"

URI_x86_64_v2_f41-backgrounds-budgie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f41-backgrounds-budgie-41.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f41-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f41-backgrounds-budgie}"
SRC_URI[x86_64_v2_f41-backgrounds-budgie.sha256sum] = "b319824c37aa55fd220981b06d1170c106a357ebbba3dbb58329986ee247ede2"

URI_x86_64_v2_f41-backgrounds-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f41-backgrounds-gnome-41.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f41-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f41-backgrounds-gnome}"
SRC_URI[x86_64_v2_f41-backgrounds-gnome.sha256sum] = "ce4f284cebdb6d6b35bab6130f71b9101106824ae3bd965b6cf7fab41b7c1973"

URI_x86_64_v2_f41-backgrounds-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f41-backgrounds-kde-41.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f41-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f41-backgrounds-kde}"
SRC_URI[x86_64_v2_f41-backgrounds-kde.sha256sum] = "b080ca32148590e012540eb1972189ad9bcebf5712a43db5bfec137107bbd070"

URI_x86_64_v2_f41-backgrounds-mate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f41-backgrounds-mate-41.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f41-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f41-backgrounds-mate}"
SRC_URI[x86_64_v2_f41-backgrounds-mate.sha256sum] = "75bbf8ad1394eeb93ad1c70ee8c18aaab48ed96c88dca8994a4689ec5b61bb04"

URI_x86_64_v2_f41-backgrounds-xfce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/f41-backgrounds-xfce-41.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_f41-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_f41-backgrounds-xfce}"
SRC_URI[x86_64_v2_f41-backgrounds-xfce.sha256sum] = "4cde0e79ac449791fa130e17af07f2e82a27d4d7d4793303c12b35e6d7eae78a"

URI_aarch64_f41-backgrounds = "${EPEL_MIRROR}/aarch64/Packages/f/f41-backgrounds-41.0.2-1.el10_0.noarch.rpm;name=aarch64_f41-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_f41-backgrounds}"
SRC_URI[aarch64_f41-backgrounds.sha256sum] = "e2d2af0aa7c502cbf1c67f341e07a175fb8c9a1df53a1d8ede82e876e5214214"

URI_aarch64_f41-backgrounds-base = "${EPEL_MIRROR}/aarch64/Packages/f/f41-backgrounds-base-41.0.2-1.el10_0.noarch.rpm;name=aarch64_f41-backgrounds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_f41-backgrounds-base}"
SRC_URI[aarch64_f41-backgrounds-base.sha256sum] = "9af753c724f474d76389f4603d1f0616e6fdb6b7d62959ec38680d3e3485d2a0"

URI_aarch64_f41-backgrounds-budgie = "${EPEL_MIRROR}/aarch64/Packages/f/f41-backgrounds-budgie-41.0.2-1.el10_0.noarch.rpm;name=aarch64_f41-backgrounds-budgie;unpack=0"
SRC_URI:append = " ${URI_aarch64_f41-backgrounds-budgie}"
SRC_URI[aarch64_f41-backgrounds-budgie.sha256sum] = "e1a2a141e2cda633178fc20ef1dbe0ff53a6f16e37e6216fe434f08e845c090e"

URI_aarch64_f41-backgrounds-gnome = "${EPEL_MIRROR}/aarch64/Packages/f/f41-backgrounds-gnome-41.0.2-1.el10_0.noarch.rpm;name=aarch64_f41-backgrounds-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_f41-backgrounds-gnome}"
SRC_URI[aarch64_f41-backgrounds-gnome.sha256sum] = "82935162f690b4d32572effaccb67ff0f7e2d1bcc22a9ad863408f6e3971b630"

URI_aarch64_f41-backgrounds-kde = "${EPEL_MIRROR}/aarch64/Packages/f/f41-backgrounds-kde-41.0.2-1.el10_0.noarch.rpm;name=aarch64_f41-backgrounds-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_f41-backgrounds-kde}"
SRC_URI[aarch64_f41-backgrounds-kde.sha256sum] = "ea7a35259bd48b491af7d68eede3973889e161b8a70f941b8abf71d4f00c3ae8"

URI_aarch64_f41-backgrounds-mate = "${EPEL_MIRROR}/aarch64/Packages/f/f41-backgrounds-mate-41.0.2-1.el10_0.noarch.rpm;name=aarch64_f41-backgrounds-mate;unpack=0"
SRC_URI:append = " ${URI_aarch64_f41-backgrounds-mate}"
SRC_URI[aarch64_f41-backgrounds-mate.sha256sum] = "6f5e208b0fa6e0afda7974ec95d62f69e7dd340e3f059f0287c3ec2fc30bd1ed"

URI_aarch64_f41-backgrounds-xfce = "${EPEL_MIRROR}/aarch64/Packages/f/f41-backgrounds-xfce-41.0.2-1.el10_0.noarch.rpm;name=aarch64_f41-backgrounds-xfce;unpack=0"
SRC_URI:append = " ${URI_aarch64_f41-backgrounds-xfce}"
SRC_URI[aarch64_f41-backgrounds-xfce.sha256sum] = "376bf53aaddc11a2b9809bb77fcda4c8f663bf790271779a7eb66a2e6d4fcfe0"

RDEPENDS:f41-backgrounds = " \
 f41-backgrounds-budgie \
 f41-backgrounds-gnome \
 f41-backgrounds-kde \
 f41-backgrounds-mate \
 f41-backgrounds-xfce \
 "
RDEPENDS:f41-backgrounds-base = " \
 "
RDEPENDS:f41-backgrounds-budgie = " \
 f41-backgrounds-base \
 "
RDEPENDS:f41-backgrounds-gnome = " \
 f41-backgrounds-base \
 "
RDEPENDS:f41-backgrounds-kde = " \
 f41-backgrounds-base \
 kde-filesystem \
 "
RDEPENDS:f41-backgrounds-mate = " \
 f41-backgrounds-base \
 "
RDEPENDS:f41-backgrounds-xfce = " \
 f41-backgrounds-base \
 "
