# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tox-uv"
PV = "1.25.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-tox-uv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tox-uv-1.25.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e5419dd4d988c62d001eafff2e55a852eb047f506ec127b1f3bebb9b9a12926"

URI_x86_64_v2_python3-tox-uv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tox-uv-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tox-uv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tox-uv}"
SRC_URI[x86_64_v2_python3-tox-uv.sha256sum] = "07445448360407be004d1da614119d327a8c9cfb13d7be5a5968d1071d958e58"

URI_aarch64_python3-tox-uv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tox-uv-1.25.0-1.el10_0.noarch.rpm;name=aarch64_python3-tox-uv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tox-uv}"
SRC_URI[aarch64_python3-tox-uv.sha256sum] = "50c456c5ff57ff8be5848e7a42ddca0faa9b2ec0d82330e1c418e21f9ebfab6a"

RDEPENDS:python3-tox-uv = " \
 python3 \
 python3-packaging \
 python3-uv \
 tox \
 "
