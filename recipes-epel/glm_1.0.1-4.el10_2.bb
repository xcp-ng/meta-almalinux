# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glm"
PV = "1.0.1"
PR = "4.el10_2"
PACKAGES = " \
 glm-devel \
 glm-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glm-1.0.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5b969ad5cef4da5d2dd9aa45b80ccf077010a13ed7c9dcda3fbefebe1d739f9"

URI_x86_64_v2_glm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glm-devel-1.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_glm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glm-devel}"
SRC_URI[x86_64_v2_glm-devel.sha256sum] = "a58f1a932a1bb24ba3c9caf974961a5ce4c36403bc9cd8045a3d5f5284fb12c0"

URI_x86_64_v2_glm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glm-doc-1.0.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_glm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glm-doc}"
SRC_URI[x86_64_v2_glm-doc.sha256sum] = "036972e4df3bc296b34a3090a42579c13b590adc7eee8b2f7123088f74a40d8a"

URI_aarch64_glm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/glm-devel-1.0.1-4.el10_2.noarch.rpm;name=aarch64_glm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glm-devel}"
SRC_URI[aarch64_glm-devel.sha256sum] = "10e470658923c7a56ff00c83b31a818173b96b093684546209f9e21ccd1682a9"

URI_aarch64_glm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/glm-doc-1.0.1-4.el10_2.noarch.rpm;name=aarch64_glm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glm-doc}"
SRC_URI[aarch64_glm-doc.sha256sum] = "5c258468e998f10e474c431cb264706f7d16fbb50d52698ef7d78a55fedd9cdd"

RDEPENDS:glm-devel = " \
 cmake-filesystem \
 "
RDEPENDS:glm-doc = " \
 "
