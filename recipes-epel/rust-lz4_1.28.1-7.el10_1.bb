# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lz4"
PV = "1.28.1"
PR = "7.el10_1"
PACKAGES = " \
 rust-lz4+default-devel \
 rust-lz4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lz4-1.28.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5a5ea7a42522d30f393c20961cd6ff6911bd9d878cc25d0e8b93fb7989a7285"

URI_x86_64_v2_rust-lz4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lz4+default-devel-1.28.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lz4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lz4+default-devel}"
SRC_URI[x86_64_v2_rust-lz4+default-devel.sha256sum] = "a91a5d2d012c55a5384660012342552c82786c9037cb456990f11166b93b53bb"

URI_x86_64_v2_rust-lz4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lz4-devel-1.28.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lz4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lz4-devel}"
SRC_URI[x86_64_v2_rust-lz4-devel.sha256sum] = "84ef5de4bd7f792955c627666594d0272caf5ff966eb78c08fbdb63c9fd895aa"

URI_aarch64_rust-lz4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lz4+default-devel-1.28.1-7.el10_1.noarch.rpm;name=aarch64_rust-lz4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lz4+default-devel}"
SRC_URI[aarch64_rust-lz4+default-devel.sha256sum] = "c0944b004fcf55a13e58701f26f46d5728ec1d786f62b2193b6134869e117e22"

URI_aarch64_rust-lz4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lz4-devel-1.28.1-7.el10_1.noarch.rpm;name=aarch64_rust-lz4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lz4-devel}"
SRC_URI[aarch64_rust-lz4-devel.sha256sum] = "20fedf95b6185c1e4c476636f76bef727ad977ede4435c207239ea138b24c469"

RDEPENDS:rust-lz4+default-devel = " \
 cargo \
 rust-lz4-devel \
 "
RDEPENDS:rust-lz4-devel = " \
 cargo \
 rust-lz4-sys+default-devel \
 "
