# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "containers-common"
PE = "6"
PV = "6.0"
PR = "2.el10"
PACKAGES = " \
 containers-common \
 containers-common-extra \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/containers-common-6.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbe716c6f30b6464f1398a7f4404e9eef9b3c403110524474656e4e39992c2af"

URI_x86_64_v2_containers-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-6.0-2.el10.noarch.rpm;name=x86_64_v2_containers-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_containers-common}"
SRC_URI[x86_64_v2_containers-common.sha256sum] = "9586a1da9a0495cd5dccfae92e3a98772cbe21683704b73d249220865cc1a50a"

URI_x86_64_v2_containers-common-extra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-extra-6.0-2.el10.noarch.rpm;name=x86_64_v2_containers-common-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_containers-common-extra}"
SRC_URI[x86_64_v2_containers-common-extra.sha256sum] = "cdf0e995d37fe09858df5a62d21c699ef41486b3a627c659310fcf22941927da"

URI_aarch64_containers-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-6.0-2.el10.noarch.rpm;name=aarch64_containers-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_containers-common}"
SRC_URI[aarch64_containers-common.sha256sum] = "9586a1da9a0495cd5dccfae92e3a98772cbe21683704b73d249220865cc1a50a"

URI_aarch64_containers-common-extra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-extra-6.0-2.el10.noarch.rpm;name=aarch64_containers-common-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_containers-common-extra}"
SRC_URI[aarch64_containers-common-extra.sha256sum] = "cdf0e995d37fe09858df5a62d21c699ef41486b3a627c659310fcf22941927da"

RDEPENDS:containers-common = " \
 bash \
 container-selinux \
 netavark \
 "
RDEPENDS:containers-common-extra = " \
 containers-common \
 netavark \
 nftables \
 passt \
 virtual/oci-runtime \
 "
