# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio"
PV = "1.53.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio+bytes-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+full-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+libc-devel \
 rust-tokio+macros-devel \
 rust-tokio+mio-devel \
 rust-tokio+net-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio+socket2-devel \
 rust-tokio+sync-devel \
 rust-tokio+test-util-devel \
 rust-tokio+time-devel \
 rust-tokio+tokio-macros-devel \
 rust-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-1.53.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6592403b5d09c613ce0058dcb13d64e125b7bc958575a5406449a93a23f1b3e"

URI_x86_64_v2_rust-tokio+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+bytes-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+bytes-devel}"
SRC_URI[x86_64_v2_rust-tokio+bytes-devel.sha256sum] = "066451fef91771779de3a8f45b9cc82d856dc7b2e6a912cddfff5da771c45f55"

URI_x86_64_v2_rust-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+default-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-tokio+default-devel.sha256sum] = "edc1ce8958a6fc74c9840e0aafd61f278153b33fbd22b5dafba65783d11d89a3"

URI_x86_64_v2_rust-tokio+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+fs-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+fs-devel}"
SRC_URI[x86_64_v2_rust-tokio+fs-devel.sha256sum] = "8a6070177b7c55684cb28dad2ae7a6636de9fccc72ab6fb6f8a7cbdf8513b9c6"

URI_x86_64_v2_rust-tokio+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+full-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+full-devel}"
SRC_URI[x86_64_v2_rust-tokio+full-devel.sha256sum] = "1fcaf8217307ecd83e76e6d8e4a772c9b1cd1109cc590025bc35e29b3841da46"

URI_x86_64_v2_rust-tokio+io-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+io-std-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+io-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+io-std-devel}"
SRC_URI[x86_64_v2_rust-tokio+io-std-devel.sha256sum] = "ccda2a617e34f0ce627eecee8b5fcd30e16827ff4b38b04c707f74bb08733a51"

URI_x86_64_v2_rust-tokio+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+io-util-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio+io-util-devel.sha256sum] = "65a3ad863c1b2cb27937d7796270978870abea357f9f4857dfd8d76382c3668a"

URI_x86_64_v2_rust-tokio+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+libc-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+libc-devel}"
SRC_URI[x86_64_v2_rust-tokio+libc-devel.sha256sum] = "ec8cab68108493c6743cbf3f0a6505cc9dbd51fe6296fa8aa7e256219702af04"

URI_x86_64_v2_rust-tokio+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+macros-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+macros-devel}"
SRC_URI[x86_64_v2_rust-tokio+macros-devel.sha256sum] = "a83a0c216b7561c7f8dd1a3f4f1b3739b7bbe0b1f836e03fcd349a0cd60adaee"

URI_x86_64_v2_rust-tokio+mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+mio-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+mio-devel}"
SRC_URI[x86_64_v2_rust-tokio+mio-devel.sha256sum] = "2d4f7dc7098346ae892ee24e3bc0ad8453486f772e0ff12d0be17c7930cb9c62"

URI_x86_64_v2_rust-tokio+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+net-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+net-devel}"
SRC_URI[x86_64_v2_rust-tokio+net-devel.sha256sum] = "1538b1aecec0b4958c09c500c12a1406943acb511de6f9b69cc7dbc4e3f3f3e6"

URI_x86_64_v2_rust-tokio+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+parking_lot-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-tokio+parking_lot-devel.sha256sum] = "a3d63aedf5f25f9a71aa63e0061e5360c17863a603c677fee20eb2ce2244bdd8"

URI_x86_64_v2_rust-tokio+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+process-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+process-devel}"
SRC_URI[x86_64_v2_rust-tokio+process-devel.sha256sum] = "7f1c983db117bd6b02617ff0355e7ff05ed1e48344fd986f49b421457999b8a2"

URI_x86_64_v2_rust-tokio+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+rt-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio+rt-devel.sha256sum] = "46d4ef39d5fbb0518d2698c10e87bd546ee27e70cba369817cda4f33689b8c81"

URI_x86_64_v2_rust-tokio+rt-multi-thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+rt-multi-thread-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+rt-multi-thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+rt-multi-thread-devel}"
SRC_URI[x86_64_v2_rust-tokio+rt-multi-thread-devel.sha256sum] = "af913654af484878f6abb52dd23950562ddbeebdd476c75ae596ca5dec8be2df"

URI_x86_64_v2_rust-tokio+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+signal-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+signal-devel}"
SRC_URI[x86_64_v2_rust-tokio+signal-devel.sha256sum] = "25749db21fc98f23ebd3c112c28af05233183f7905468b8cc6a424e70f994cc7"

URI_x86_64_v2_rust-tokio+signal-hook-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+signal-hook-registry-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+signal-hook-registry-devel}"
SRC_URI[x86_64_v2_rust-tokio+signal-hook-registry-devel.sha256sum] = "51ea774cbad46427660571384ad0af147afafbd8350462a2af1e59d5534e654f"

URI_x86_64_v2_rust-tokio+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+socket2-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+socket2-devel}"
SRC_URI[x86_64_v2_rust-tokio+socket2-devel.sha256sum] = "5686c12ac318404967758e47b367767e74a623dc8909e554a4aa56b68767fb45"

URI_x86_64_v2_rust-tokio+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+sync-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+sync-devel}"
SRC_URI[x86_64_v2_rust-tokio+sync-devel.sha256sum] = "bdd9f659c78f85327d88db6c5d4281337271c0c34087040ae248c030d721ab33"

URI_x86_64_v2_rust-tokio+test-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+test-util-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+test-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+test-util-devel}"
SRC_URI[x86_64_v2_rust-tokio+test-util-devel.sha256sum] = "92d1ee06155eeee29a5c490a1670ffaf0218fafb80e51fa3885f9ae25d6bdbaf"

URI_x86_64_v2_rust-tokio+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+time-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+time-devel}"
SRC_URI[x86_64_v2_rust-tokio+time-devel.sha256sum] = "5df82d5948adb97bb7d99a7a4a0efec94738db45f2d61aedbe731787ba66019c"

URI_x86_64_v2_rust-tokio+tokio-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+tokio-macros-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+tokio-macros-devel}"
SRC_URI[x86_64_v2_rust-tokio+tokio-macros-devel.sha256sum] = "982113ea14a8450e7cfbe904615ff54a750b35728a6b89d9d0348ed6f9b26bcd"

URI_x86_64_v2_rust-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-devel-1.53.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-devel}"
SRC_URI[x86_64_v2_rust-tokio-devel.sha256sum] = "ae45a0a454798d866269040545b8e1b25d050c4737fda4f1aa5181804e6afbc7"

URI_aarch64_rust-tokio+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+bytes-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+bytes-devel}"
SRC_URI[aarch64_rust-tokio+bytes-devel.sha256sum] = "50f24c600264b03e8535b8df3a06b4fed30e6f237da22c7e1e70f1ab796abb18"

URI_aarch64_rust-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+default-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+default-devel}"
SRC_URI[aarch64_rust-tokio+default-devel.sha256sum] = "6aa3fd56ff92d58a30cc5f6524daec03433b571c03d4a745dd4835c948c55a4a"

URI_aarch64_rust-tokio+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+fs-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+fs-devel}"
SRC_URI[aarch64_rust-tokio+fs-devel.sha256sum] = "b2c6c573f8b2233cc13055bb223903612f211516123ba17f197b788f403b8f37"

URI_aarch64_rust-tokio+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+full-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+full-devel}"
SRC_URI[aarch64_rust-tokio+full-devel.sha256sum] = "8a99f8e47783fb79fe6834236f7955a1aafbfdd59d22966e888ff88f73e1d0a0"

URI_aarch64_rust-tokio+io-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+io-std-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+io-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+io-std-devel}"
SRC_URI[aarch64_rust-tokio+io-std-devel.sha256sum] = "431e47aa742becdcf83a9f1bbd1bce4f5724465c520888bf2ee5d363a645ee72"

URI_aarch64_rust-tokio+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+io-util-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+io-util-devel}"
SRC_URI[aarch64_rust-tokio+io-util-devel.sha256sum] = "4854e0e1b6a70f9a232d54c4f56f5ac0268d91f16f070f0525c0a0c9301f7a07"

URI_aarch64_rust-tokio+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+libc-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+libc-devel}"
SRC_URI[aarch64_rust-tokio+libc-devel.sha256sum] = "2f48b5018942a3dde4e3a1d168f2d6b581ea8faef44eac674922af68929dd029"

URI_aarch64_rust-tokio+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+macros-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+macros-devel}"
SRC_URI[aarch64_rust-tokio+macros-devel.sha256sum] = "bd4ca69a72863d7532ae50c29d7d899410ac81f4328b0a23780226840a1a5739"

URI_aarch64_rust-tokio+mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+mio-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+mio-devel}"
SRC_URI[aarch64_rust-tokio+mio-devel.sha256sum] = "16822b355269fcb5913526c1774490a4ad17db2bdd5edd861071efea217a7a89"

URI_aarch64_rust-tokio+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+net-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+net-devel}"
SRC_URI[aarch64_rust-tokio+net-devel.sha256sum] = "5a384568dc31ad629d611981a74afa01772724b227240d75057dfe02c3eaf565"

URI_aarch64_rust-tokio+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+parking_lot-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+parking_lot-devel}"
SRC_URI[aarch64_rust-tokio+parking_lot-devel.sha256sum] = "ed9c628d4719a1b81ac31d4b69a28d0cff88a7c098abd19a7c6d5617e47954fa"

URI_aarch64_rust-tokio+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+process-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+process-devel}"
SRC_URI[aarch64_rust-tokio+process-devel.sha256sum] = "bb0424620ac3e14d3b502db008c8a4fec92d5273980fd2e478bc78583a53ca70"

URI_aarch64_rust-tokio+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+rt-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+rt-devel}"
SRC_URI[aarch64_rust-tokio+rt-devel.sha256sum] = "12316d3c39a67ebba259582d86ec61078f0632b1d7efa7095d81d14048b58266"

URI_aarch64_rust-tokio+rt-multi-thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+rt-multi-thread-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+rt-multi-thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+rt-multi-thread-devel}"
SRC_URI[aarch64_rust-tokio+rt-multi-thread-devel.sha256sum] = "3bafebb2659d79e55b6652ea72532e34f121043bf9dd8ef51e4ec704fd8490e9"

URI_aarch64_rust-tokio+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+signal-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+signal-devel}"
SRC_URI[aarch64_rust-tokio+signal-devel.sha256sum] = "311bb1ee36fc0f26d745d3596a2eb7800261bce515d46ae44f1c847ceeab1b7b"

URI_aarch64_rust-tokio+signal-hook-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+signal-hook-registry-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+signal-hook-registry-devel}"
SRC_URI[aarch64_rust-tokio+signal-hook-registry-devel.sha256sum] = "1f5821e6d846959dec0a36780d26fe7a29dae9e80ff8d97ee4259c7f55ccc318"

URI_aarch64_rust-tokio+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+socket2-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+socket2-devel}"
SRC_URI[aarch64_rust-tokio+socket2-devel.sha256sum] = "479fcbe8154fd34244689dfe0f732f908eaef363cecf48aa94fa60b00d5a4714"

URI_aarch64_rust-tokio+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+sync-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+sync-devel}"
SRC_URI[aarch64_rust-tokio+sync-devel.sha256sum] = "e906254b097acce00b82961e38b08de0855f252c9f5a41e7100532dd2b5b5c95"

URI_aarch64_rust-tokio+test-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+test-util-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+test-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+test-util-devel}"
SRC_URI[aarch64_rust-tokio+test-util-devel.sha256sum] = "4c690aedf687c8393af068b35c988f95a18ff1abf0151f71086f944999f53844"

URI_aarch64_rust-tokio+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+time-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+time-devel}"
SRC_URI[aarch64_rust-tokio+time-devel.sha256sum] = "5d8b93421efb577a605bd183a01f9cf069ea28ef1e7f90f2076a4fb76b341dd1"

URI_aarch64_rust-tokio+tokio-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+tokio-macros-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio+tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+tokio-macros-devel}"
SRC_URI[aarch64_rust-tokio+tokio-macros-devel.sha256sum] = "a150fd1e825a7a9493995d6e9949250aeb003d91d1bb9d842f020da71f8e1902"

URI_aarch64_rust-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-devel-1.53.1-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-devel}"
SRC_URI[aarch64_rust-tokio-devel.sha256sum] = "69fa3b95b72de6397561bcfa3477999bdd7b71ad39f9c2edc11a56abc27a41dd"

RDEPENDS:rust-tokio+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+default-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+fs-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+full-devel = " \
 cargo \
 rust-tokio+fs-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+io-std-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+io-util-devel = " \
 cargo \
 rust-tokio+bytes-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+macros-devel = " \
 cargo \
 rust-tokio+tokio-macros-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+mio-devel = " \
 cargo \
 rust-mio-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+net-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+libc-devel \
 rust-tokio+socket2-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+process-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+bytes-devel \
 rust-tokio+libc-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+rt-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+rt-multi-thread-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+signal-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+libc-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+signal-hook-registry-devel = " \
 cargo \
 rust-signal-hook-registry+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+socket2-devel = " \
 cargo \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+sync-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+test-util-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+time-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+tokio-macros-devel = " \
 cargo \
 rust-tokio-devel \
 rust-tokio-macros+default-devel \
 "
RDEPENDS:rust-tokio-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 "
