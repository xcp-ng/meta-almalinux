# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sql-builder"
PV = "3.1.1"
PR = "4.el10_3"
PACKAGES = " \
 rust-sql-builder+default-devel \
 rust-sql-builder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sql-builder-3.1.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5427347804a94e21ce8a2775feed5f78303f5d76a5737e9fbd17d108c7312d86"

URI_x86_64_v2_rust-sql-builder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sql-builder+default-devel-3.1.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sql-builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sql-builder+default-devel}"
SRC_URI[x86_64_v2_rust-sql-builder+default-devel.sha256sum] = "c93f802bfb005c650beebcfe009d2517fd7566b34865953ea5726458c82b0250"

URI_x86_64_v2_rust-sql-builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sql-builder-devel-3.1.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sql-builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sql-builder-devel}"
SRC_URI[x86_64_v2_rust-sql-builder-devel.sha256sum] = "8b7be133240b4f92085aadf62588da35399ee96d437227b538250ee387fca052"

URI_aarch64_rust-sql-builder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sql-builder+default-devel-3.1.1-4.el10_3.noarch.rpm;name=aarch64_rust-sql-builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sql-builder+default-devel}"
SRC_URI[aarch64_rust-sql-builder+default-devel.sha256sum] = "cd40f0f751d9b2d5b2bdc16568188a5242549db400c8d5463a3e04dd17b5ee94"

URI_aarch64_rust-sql-builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sql-builder-devel-3.1.1-4.el10_3.noarch.rpm;name=aarch64_rust-sql-builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sql-builder-devel}"
SRC_URI[aarch64_rust-sql-builder-devel.sha256sum] = "b930ae3281c40d3f0a22e45a8ffc3272b6c4c8b274e1ba8e634803796532fd4a"

RDEPENDS:rust-sql-builder+default-devel = " \
 cargo \
 rust-sql-builder-devel \
 "
RDEPENDS:rust-sql-builder-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-thiserror1+default-devel \
 "
