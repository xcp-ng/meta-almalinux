# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hostname"
PV = "0.4.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-hostname+default-devel \
 rust-hostname+set-devel \
 rust-hostname-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hostname-0.4.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa618faea0d7939a388dc3dedc0f31f035bbaa3bdcdf9843fb90dd7dee091f2c"

URI_x86_64_v2_rust-hostname+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hostname+default-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hostname+default-devel}"
SRC_URI[x86_64_v2_rust-hostname+default-devel.sha256sum] = "cb8f01ad58468a896183980385bc63c8f527a9b1887801bf51ed8b69d8b94349"

URI_x86_64_v2_rust-hostname+set-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hostname+set-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hostname+set-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hostname+set-devel}"
SRC_URI[x86_64_v2_rust-hostname+set-devel.sha256sum] = "044c6c5604a1b643e2c423e32393ef3ea18e43534335f6f15f218d8bdba6814c"

URI_x86_64_v2_rust-hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hostname-devel-0.4.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hostname-devel}"
SRC_URI[x86_64_v2_rust-hostname-devel.sha256sum] = "d202bc3bab45f6f90f72ad015976d59e16be2330bfd72280fef04f33e72cc8be"

URI_aarch64_rust-hostname+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hostname+default-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-hostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hostname+default-devel}"
SRC_URI[aarch64_rust-hostname+default-devel.sha256sum] = "47d79e8779b37d8edd7a5895c9d1555c8860ddb5c2018536c95fbed2bb93b43e"

URI_aarch64_rust-hostname+set-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hostname+set-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-hostname+set-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hostname+set-devel}"
SRC_URI[aarch64_rust-hostname+set-devel.sha256sum] = "68f70bdace5783e2ce6b78dd4e8c7712b7181f010049482aa8f097fa4c7a1adb"

URI_aarch64_rust-hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hostname-devel-0.4.2-1.el10_3.noarch.rpm;name=aarch64_rust-hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hostname-devel}"
SRC_URI[aarch64_rust-hostname-devel.sha256sum] = "dee4d0095b71dfb48dd6c4a348e4d70966f72b0900cec77876345be21c1b4dfe"

RDEPENDS:rust-hostname+default-devel = " \
 cargo \
 rust-hostname-devel \
 "
RDEPENDS:rust-hostname+set-devel = " \
 cargo \
 rust-hostname-devel \
 "
RDEPENDS:rust-hostname-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
