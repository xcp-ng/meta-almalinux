# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spamassassin-dqs"
PV = "1.5.1"
PR = "4.el10_0"
PACKAGES = " \
 spamassassin-dqs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/spamassassin-dqs-1.5.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f5ba4be31d4bdb08a125b8a057468bc5bfdbeb2043e1a56ed0cfe3bf25664e7a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamassassin-dqs-1.5.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_spamassassin-dqs;unpack=0"
SRC_URI[x86_64_v2_spamassassin-dqs.sha256sum] = "017ffc9722cc936afc392acefb5368294436ce001d0b3ffabf43b1f4a33c8284"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/spamassassin-dqs-1.5.1-4.el10_0.noarch.rpm;name=aarch64_spamassassin-dqs;unpack=0"
SRC_URI[aarch64_spamassassin-dqs.sha256sum] = "2d0593737d1f181f6919b01fe6ac71e7ac39f2850b116ebcd4941f70fde0be52"

RDEPENDS:spamassassin-dqs = " \
 bash \
 perl-Digest-SHA \
 perl-Net-DNS \
 perl-Socket \
 perl-libs \
 spamassassin \
 "
