# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "igt-gpu-tools"
PV = "2.4"
PR = "1.el10_3"
PACKAGES = " \
 igt-gpu-tools \
 igt-gpu-tools-devel \
 igt-gpu-tools-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/igt-gpu-tools-2.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10f903a61df802a03e8355f6e40f9081051ac07fdfe6c234ae82134387f2c314"

URI_x86_64_v2_igt-gpu-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/igt-gpu-tools-2.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_igt-gpu-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_igt-gpu-tools}"
SRC_URI[x86_64_v2_igt-gpu-tools.sha256sum] = "483e393a3733b0b92121bb04cc564c029fff3c874b91a2da1bc2d9f5764a3e77"

URI_x86_64_v2_igt-gpu-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/igt-gpu-tools-devel-2.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_igt-gpu-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_igt-gpu-tools-devel}"
SRC_URI[x86_64_v2_igt-gpu-tools-devel.sha256sum] = "4032f932ded1a3a8632760356492f0c2470269d9ad1e8669afebc9a6cad948db"

URI_x86_64_v2_igt-gpu-tools-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/igt-gpu-tools-docs-2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_igt-gpu-tools-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_igt-gpu-tools-docs}"
SRC_URI[x86_64_v2_igt-gpu-tools-docs.sha256sum] = "03207010fdba215cc2e4293ea530d89c35b9bfe06d1c238a677236f2fa9c7a45"

URI_aarch64_igt-gpu-tools = "${EPEL_MIRROR}/aarch64/Packages/i/igt-gpu-tools-2.4-1.el10_3.aarch64.rpm;name=aarch64_igt-gpu-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_igt-gpu-tools}"
SRC_URI[aarch64_igt-gpu-tools.sha256sum] = "5a16259bf7c0c77006a42b58139e166fbeede3ec5a65e40c42e7f43bf0ac4a39"

URI_aarch64_igt-gpu-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/i/igt-gpu-tools-devel-2.4-1.el10_3.aarch64.rpm;name=aarch64_igt-gpu-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_igt-gpu-tools-devel}"
SRC_URI[aarch64_igt-gpu-tools-devel.sha256sum] = "722e496e80cb5f3a4b8547bc5ce057c5ffd8acf72436341e6eafcc42f780a9a6"

URI_aarch64_igt-gpu-tools-docs = "${EPEL_MIRROR}/aarch64/Packages/i/igt-gpu-tools-docs-2.4-1.el10_3.noarch.rpm;name=aarch64_igt-gpu-tools-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_igt-gpu-tools-docs}"
SRC_URI[aarch64_igt-gpu-tools-docs.sha256sum] = "45a60d8eb7e9319e75c2b85086028ad762f631704b84188eeedc0da6bf4a8066"

RDEPENDS:igt-gpu-tools = " \
 alsa-lib \
 bash \
 cairo \
 elfutils-libs \
 glib2 \
 glibc \
 gsl \
 jansson \
 kmod-libs \
 libdrm \
 liboping \
 libpciaccess \
 libunwind \
 pciutils-libs \
 perl-interpreter \
 pixman \
 procps-ng \
 python3 \
 systemd-libs \
 xmlrpc-c \
 xmlrpc-c-client \
 zlib-ng-compat \
 "
RDEPENDS:igt-gpu-tools-devel = " \
 igt-gpu-tools \
 libdrm-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:igt-gpu-tools-docs = " \
 "
