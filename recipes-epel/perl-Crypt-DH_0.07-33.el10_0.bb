# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-DH"
PV = "0.07"
PR = "33.el10_0"
PACKAGES = " \
 perl-Crypt-DH \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-DH-0.07-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c951f009490d3e75f5e5ea6b1e54aab237a26f74bc748a157a6f3d74191fdc3"

URI_x86_64_v2_perl-Crypt-DH = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-DH-0.07-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-DH;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-DH}"
SRC_URI[x86_64_v2_perl-Crypt-DH.sha256sum] = "ef0b673f6a8e68cceb504796c5662b2358bfa57c08866b2374ee3342af7f93c9"

URI_aarch64_perl-Crypt-DH = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-DH-0.07-33.el10_0.noarch.rpm;name=aarch64_perl-Crypt-DH;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-DH}"
SRC_URI[aarch64_perl-Crypt-DH.sha256sum] = "2156057f545091421049f25cc43e879f003f0376839ce91043828c63b72afdce"

RDEPENDS:perl-Crypt-DH = " \
 perl-Math-BigInt \
 perl-Math-BigInt-GMP \
 perl-libs \
 "
