# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parse-Yapp"
PV = "1.21"
PR = "21.el10"
PACKAGES = " \
 perl-Parse-Yapp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Parse-Yapp-1.21-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b67efeeed5c34469d363c7746b3ad8774584d4628a588459650f7c489bb086f"

URI_x86_64_v2_perl-Parse-Yapp = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Parse-Yapp-1.21-21.el10.noarch.rpm;name=x86_64_v2_perl-Parse-Yapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parse-Yapp}"
SRC_URI[x86_64_v2_perl-Parse-Yapp.sha256sum] = "ed5a151a239e3c65e8c511a6a38885f459a9c997a77ecf885bc00e689c6be518"

URI_aarch64_perl-Parse-Yapp = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Parse-Yapp-1.21-21.el10.noarch.rpm;name=aarch64_perl-Parse-Yapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parse-Yapp}"
SRC_URI[aarch64_perl-Parse-Yapp.sha256sum] = "ed5a151a239e3c65e8c511a6a38885f459a9c997a77ecf885bc00e689c6be518"

RDEPENDS:perl-Parse-Yapp = " \
 perl-Carp \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-Parse-Yapp \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
