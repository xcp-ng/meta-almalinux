# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "accessibility-inspector"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 accessibility-inspector \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/accessibility-inspector-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7bb696a7a3bec4c668647251fc22f85fbaae837f3a51092779d29c7d7e73f144"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/accessibility-inspector-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_accessibility-inspector;unpack=0"
SRC_URI[x86_64_v2_accessibility-inspector.sha256sum] = "1666ed07ad82eb91c64b4d6542758bfb0774c8b07aa3a51cf50636e014fb80bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/accessibility-inspector-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_accessibility-inspector;unpack=0"
SRC_URI[aarch64_accessibility-inspector.sha256sum] = "4260dbeba75a143a4f0d004d7b99d31b727808685c0d87d271d7f1e6d59d9a27"

RDEPENDS:accessibility-inspector = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
