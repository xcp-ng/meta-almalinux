# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thunderbird"
PV = "140.16.0"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 thunderbird \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/thunderbird-140.16.0-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2cff22c7e1836cddfa4482033ae5a894472e13a20de4cb03986f8911625fd355"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/thunderbird-140.16.0-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_thunderbird;unpack=0"
SRC_URI[x86_64_v2_thunderbird.sha256sum] = "266eed225b96520716ccce9b735e97f2d88c5ebaaacece069aa9cf3b39302ee1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/thunderbird-140.16.0-1.el10_2.alma.1.aarch64.rpm;name=aarch64_thunderbird;unpack=0"
SRC_URI[aarch64_thunderbird.sha256sum] = "c117e902cbab13ceee707e2d5ae9f7c0b7d3629e0fb5a16a3f63988051d18493"

RDEPENDS:thunderbird = " \
 alsa-lib \
 atk \
 bash \
 bzip2-libs \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
