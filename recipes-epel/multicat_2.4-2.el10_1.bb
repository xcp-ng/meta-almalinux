# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "multicat"
PV = "2.4"
PR = "2.el10_1"
PACKAGES = " \
 multicat \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/multicat-2.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7cb75062569743c554c4526e876375e540d97802c0cfcf59c794e79c95a4798c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/multicat-2.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_multicat;unpack=0"
SRC_URI[x86_64_v2_multicat.sha256sum] = "d20a0fa9522be82f5d0d78cb09b6e1429f87be9e405bd29706a5d940ad7ee7c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/multicat-2.4-2.el10_1.aarch64.rpm;name=aarch64_multicat;unpack=0"
SRC_URI[aarch64_multicat.sha256sum] = "0cb559ab9835395d4b1df186bfd06f0085ad31685390cd7f5a7c360cb88b998d"

RDEPENDS:multicat = " \
 glibc \
 "
