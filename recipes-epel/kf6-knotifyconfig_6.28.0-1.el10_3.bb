# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifyconfig"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-knotifyconfig \
 kf6-knotifyconfig-devel \
 kf6-knotifyconfig-doc \
 kf6-knotifyconfig-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifyconfig-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cabe4157b14b6930a0e0ee631ba3b165ee98437d260253e12ed6d1b92dede360"

URI_x86_64_v2_kf6-knotifyconfig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig}"
SRC_URI[x86_64_v2_kf6-knotifyconfig.sha256sum] = "db3e7954ffa1c27f8a0d192d4b7af4e8471d7b576064a17400b4b1bcf740784f"

URI_x86_64_v2_kf6-knotifyconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifyconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-devel}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-devel.sha256sum] = "ac1066f14e9a334ccf7ff88394dd2ee4c2c54090c18b5305d52b8f011215689c"

URI_x86_64_v2_kf6-knotifyconfig-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifyconfig-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-doc}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-doc.sha256sum] = "874e64b3bd7c558765294948d84c3c76ed038af88aadd23415eab1cdde7ea73b"

URI_x86_64_v2_kf6-knotifyconfig-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifyconfig-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifyconfig-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifyconfig-html}"
SRC_URI[x86_64_v2_kf6-knotifyconfig-html.sha256sum] = "84867bb593986f21225f5d7a8400c2f84f5494963afca784675a1eca83ab4dc6"

URI_aarch64_kf6-knotifyconfig = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knotifyconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig}"
SRC_URI[aarch64_kf6-knotifyconfig.sha256sum] = "c07b925289731e5406ae189a951b81635a7c8a7e724f27ac17368e4b580ce48b"

URI_aarch64_kf6-knotifyconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knotifyconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-devel}"
SRC_URI[aarch64_kf6-knotifyconfig-devel.sha256sum] = "2d3ac9eaa71e7525fad4b758d39e58a64fbdc98f2afe625cf6727d14f9b6e587"

URI_aarch64_kf6-knotifyconfig-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knotifyconfig-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-doc}"
SRC_URI[aarch64_kf6-knotifyconfig-doc.sha256sum] = "977e64f07cd3754ebf066eec45d41b9e162bab31df6cb97087fbc1e43a961b33"

URI_aarch64_kf6-knotifyconfig-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifyconfig-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knotifyconfig-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifyconfig-html}"
SRC_URI[aarch64_kf6-knotifyconfig-html.sha256sum] = "de8a5600fd9c38879160d2f3719f64015549b7f34de6a734dc5273751bca8626"

RDEPENDS:kf6-knotifyconfig = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knotifyconfig-devel = " \
 cmake-filesystem \
 kf6-knotifyconfig \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifyconfig-doc = " \
 "
RDEPENDS:kf6-knotifyconfig-html = " \
 "
