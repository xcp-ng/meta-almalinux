# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rest"
PV = "0.9.1"
PR = "11.el10_2.1"
PACKAGES = " \
 rest \
 rest-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rest-0.9.1-11.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "753631f7b909eab31ba6bdb4e014c9d6bc93ef191fe2c1a92324fcab37cabcf7"

URI_x86_64_v2_rest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rest-0.9.1-11.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_rest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rest}"
SRC_URI[x86_64_v2_rest.sha256sum] = "0e956b3aa3e4eb3f723552ce9a22fdfff0b7b3c0d3c777f41ae39b1a2d06426c"

URI_x86_64_v2_rest-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rest-devel-0.9.1-11.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_rest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rest-devel}"
SRC_URI[x86_64_v2_rest-devel.sha256sum] = "56a74b4ca40aca89527fb23ca840155283384cd1df96a849e77bb2b4acfc3a24"

URI_aarch64_rest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rest-0.9.1-11.el10_2.1.aarch64.rpm;name=aarch64_rest;unpack=0"
SRC_URI:append = " ${URI_aarch64_rest}"
SRC_URI[aarch64_rest.sha256sum] = "8b4c2fe56b3d0726e1f1d5c587b2d6c4070be05db907c94a8d57a325dbac6148"

URI_aarch64_rest-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rest-devel-0.9.1-11.el10_2.1.aarch64.rpm;name=aarch64_rest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rest-devel}"
SRC_URI[aarch64_rest-devel.sha256sum] = "4c2be9ca7760af39c9a0241dc7ee3cac301fd663e3879e425b1d8b34ecaca1db"

RDEPENDS:rest = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 libxml2 \
 "
RDEPENDS:rest-devel = " \
 glib2-devel \
 json-glib-devel \
 libsoup3-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 rest \
 rest-devel \
 "
