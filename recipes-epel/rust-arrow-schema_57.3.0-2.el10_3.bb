# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-schema"
PV = "57.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-arrow-schema+bitflags-devel \
 rust-arrow-schema+canonical_extension_types-devel \
 rust-arrow-schema+default-devel \
 rust-arrow-schema+ffi-devel \
 rust-arrow-schema+serde-devel \
 rust-arrow-schema-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-schema-57.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a1f0e3b9d57d5b0900927ded7bd5a13da3a61986c1ec2fc6b6a7108e2b9821a"

URI_x86_64_v2_rust-arrow-schema+bitflags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-schema+bitflags-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-schema+bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-schema+bitflags-devel}"
SRC_URI[x86_64_v2_rust-arrow-schema+bitflags-devel.sha256sum] = "c4d0e375da0a2e498d57f9c9ff3956af322100dd09c98300b6bc29f6aa9977d9"

URI_x86_64_v2_rust-arrow-schema+canonical_extension_types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-schema+canonical_extension_types-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-schema+canonical_extension_types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-schema+canonical_extension_types-devel}"
SRC_URI[x86_64_v2_rust-arrow-schema+canonical_extension_types-devel.sha256sum] = "7827e887848151b12a310a6d54d3a7e6312526799270db84f549a9ba4551b4e2"

URI_x86_64_v2_rust-arrow-schema+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-schema+default-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-schema+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-schema+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-schema+default-devel.sha256sum] = "410538ba627fcd4c4854bc430ef8fd69e9dd2fecd1b2335e7f741239662f2dd5"

URI_x86_64_v2_rust-arrow-schema+ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-schema+ffi-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-schema+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-schema+ffi-devel}"
SRC_URI[x86_64_v2_rust-arrow-schema+ffi-devel.sha256sum] = "f5ce100a4ecdbd47257ae5774e4fc50cce8b93f952f90212ca5e5404af1ac60a"

URI_x86_64_v2_rust-arrow-schema+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-schema+serde-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-schema+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-schema+serde-devel}"
SRC_URI[x86_64_v2_rust-arrow-schema+serde-devel.sha256sum] = "a50e722ba6096a42b73a5ceeee549956e49a7b6f08a7f5131eeb87a6eae2dac2"

URI_x86_64_v2_rust-arrow-schema-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-schema-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-schema-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-schema-devel}"
SRC_URI[x86_64_v2_rust-arrow-schema-devel.sha256sum] = "56b9b1c21170942c2e4b0bc69333ad0ef32b329bd1a1b91354ba66ffe1812d2f"

URI_aarch64_rust-arrow-schema+bitflags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-schema+bitflags-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-schema+bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-schema+bitflags-devel}"
SRC_URI[aarch64_rust-arrow-schema+bitflags-devel.sha256sum] = "570f0c8f858fc60c97ccb856e75319c9504e0387cf602fc252ce8a12449dd563"

URI_aarch64_rust-arrow-schema+canonical_extension_types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-schema+canonical_extension_types-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-schema+canonical_extension_types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-schema+canonical_extension_types-devel}"
SRC_URI[aarch64_rust-arrow-schema+canonical_extension_types-devel.sha256sum] = "851c4fac62db4ee80232dddd1d4411865da63a6fa4e19f4bda557e121154b1c0"

URI_aarch64_rust-arrow-schema+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-schema+default-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-schema+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-schema+default-devel}"
SRC_URI[aarch64_rust-arrow-schema+default-devel.sha256sum] = "f13a093a8168480670311b96f0aaefdfff0e515722d961ce3e5c858beaa92146"

URI_aarch64_rust-arrow-schema+ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-schema+ffi-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-schema+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-schema+ffi-devel}"
SRC_URI[aarch64_rust-arrow-schema+ffi-devel.sha256sum] = "f83e12aca4ee6b6afaca9c4809a6f605892ac0d74a95dd6fd14f04a18df3e23d"

URI_aarch64_rust-arrow-schema+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-schema+serde-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-schema+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-schema+serde-devel}"
SRC_URI[aarch64_rust-arrow-schema+serde-devel.sha256sum] = "0006e7786972daaceb0bf3eb2d35411db4273819e298af13ed2e134162750bfb"

URI_aarch64_rust-arrow-schema-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-schema-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-schema-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-schema-devel}"
SRC_URI[aarch64_rust-arrow-schema-devel.sha256sum] = "b42d23e8424748639a42bb352474335137b8f2a7e2105cb764c3aea03d3665be"

RDEPENDS:rust-arrow-schema+bitflags-devel = " \
 cargo \
 rust-arrow-schema-devel \
 rust-bitflags-devel \
 "
RDEPENDS:rust-arrow-schema+canonical_extension_types-devel = " \
 cargo \
 rust-arrow-schema-devel \
 rust-serde_core+rc-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-arrow-schema+default-devel = " \
 cargo \
 rust-arrow-schema-devel \
 "
RDEPENDS:rust-arrow-schema+ffi-devel = " \
 cargo \
 rust-arrow-schema+bitflags-devel \
 rust-arrow-schema-devel \
 "
RDEPENDS:rust-arrow-schema+serde-devel = " \
 cargo \
 rust-arrow-schema-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-serde_core+rc-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-arrow-schema-devel = " \
 cargo \
 rust \
 "
