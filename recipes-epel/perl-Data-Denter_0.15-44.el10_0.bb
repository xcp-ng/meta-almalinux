# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Denter"
PV = "0.15"
PR = "44.el10_0"
PACKAGES = " \
 perl-Data-Denter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Denter-0.15-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0fcef1f52fd20b4c880071b458eb810649ccf1c2df96885ea64e28516888b81"

URI_x86_64_v2_perl-Data-Denter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Denter-0.15-44.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Denter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Denter}"
SRC_URI[x86_64_v2_perl-Data-Denter.sha256sum] = "87649ebd9fc5e2d236717e10f0200649115865ddf2bfd006816e06ba32b8c94e"

URI_aarch64_perl-Data-Denter = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Denter-0.15-44.el10_0.noarch.rpm;name=aarch64_perl-Data-Denter;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Denter}"
SRC_URI[aarch64_perl-Data-Denter.sha256sum] = "64152805a1b853e0469e08ae18cb7038fdb8e917ab5fd1de4c253bf361955f13"

RDEPENDS:perl-Data-Denter = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
