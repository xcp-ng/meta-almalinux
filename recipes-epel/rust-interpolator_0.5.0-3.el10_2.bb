# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-interpolator"
PV = "0.5.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-interpolator+debug-devel \
 rust-interpolator+default-devel \
 rust-interpolator+iter-devel \
 rust-interpolator+number-devel \
 rust-interpolator+pointer-devel \
 rust-interpolator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-interpolator-0.5.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b38a49c1916cf20ae8821cf346c7a1bf0b3b5dd24486a15ed70fc4a1693d3a8"

URI_x86_64_v2_rust-interpolator+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interpolator+debug-devel-0.5.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interpolator+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interpolator+debug-devel}"
SRC_URI[x86_64_v2_rust-interpolator+debug-devel.sha256sum] = "b49e8936ad125bd98dec01c5481bf26f227d227c48e10b5e6b661204c9d5db3d"

URI_x86_64_v2_rust-interpolator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interpolator+default-devel-0.5.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interpolator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interpolator+default-devel}"
SRC_URI[x86_64_v2_rust-interpolator+default-devel.sha256sum] = "e13b8b4c5332065f68fc53520e53e7089b2953b6e79877aaa1d111d7553ebcad"

URI_x86_64_v2_rust-interpolator+iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interpolator+iter-devel-0.5.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interpolator+iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interpolator+iter-devel}"
SRC_URI[x86_64_v2_rust-interpolator+iter-devel.sha256sum] = "a63dd2dabf78c63aee13ae2e5969cdf5d995eb0536a594fb342e28293547a10c"

URI_x86_64_v2_rust-interpolator+number-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interpolator+number-devel-0.5.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interpolator+number-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interpolator+number-devel}"
SRC_URI[x86_64_v2_rust-interpolator+number-devel.sha256sum] = "fd548a09d8d47b564b8f021184f11a94bd6bce353a8b2377922e59b45d8faa34"

URI_x86_64_v2_rust-interpolator+pointer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interpolator+pointer-devel-0.5.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interpolator+pointer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interpolator+pointer-devel}"
SRC_URI[x86_64_v2_rust-interpolator+pointer-devel.sha256sum] = "f818f6c035017ff4bf9f81592e3ce5866352d6422eb559231ef4d37c181ce200"

URI_x86_64_v2_rust-interpolator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-interpolator-devel-0.5.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-interpolator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-interpolator-devel}"
SRC_URI[x86_64_v2_rust-interpolator-devel.sha256sum] = "35b473e1d30655250015cc968bda4bc9703ae87527010c139e77d57e87185752"

URI_aarch64_rust-interpolator+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interpolator+debug-devel-0.5.0-3.el10_2.noarch.rpm;name=aarch64_rust-interpolator+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interpolator+debug-devel}"
SRC_URI[aarch64_rust-interpolator+debug-devel.sha256sum] = "68f88340f146c709d182e6285678f0e6c39500c8aaf9664d54165a6d8f9e39bb"

URI_aarch64_rust-interpolator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interpolator+default-devel-0.5.0-3.el10_2.noarch.rpm;name=aarch64_rust-interpolator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interpolator+default-devel}"
SRC_URI[aarch64_rust-interpolator+default-devel.sha256sum] = "3a50d9586086ddb1d52bed27b379d205cf7c453e5b40e355ced874318c8f73a4"

URI_aarch64_rust-interpolator+iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interpolator+iter-devel-0.5.0-3.el10_2.noarch.rpm;name=aarch64_rust-interpolator+iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interpolator+iter-devel}"
SRC_URI[aarch64_rust-interpolator+iter-devel.sha256sum] = "c914c0c9a228e1f201c27f1ee9c594ef40a324c99dd30da986ab1dc9634a9a19"

URI_aarch64_rust-interpolator+number-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interpolator+number-devel-0.5.0-3.el10_2.noarch.rpm;name=aarch64_rust-interpolator+number-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interpolator+number-devel}"
SRC_URI[aarch64_rust-interpolator+number-devel.sha256sum] = "d41b30cf448e0504d5aea1cbf51ba8b66f0db30b06baaee1113aacfdd9a96a41"

URI_aarch64_rust-interpolator+pointer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interpolator+pointer-devel-0.5.0-3.el10_2.noarch.rpm;name=aarch64_rust-interpolator+pointer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interpolator+pointer-devel}"
SRC_URI[aarch64_rust-interpolator+pointer-devel.sha256sum] = "eca3f70a299588db2824907c171ecce5ba0f03cbf06c837b8623e799d36561b7"

URI_aarch64_rust-interpolator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-interpolator-devel-0.5.0-3.el10_2.noarch.rpm;name=aarch64_rust-interpolator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-interpolator-devel}"
SRC_URI[aarch64_rust-interpolator-devel.sha256sum] = "3866fbb4b701d3a6754c8fdc689eaddf45934082dd34bdba75fde515b0b3d10d"

RDEPENDS:rust-interpolator+debug-devel = " \
 cargo \
 rust-interpolator-devel \
 "
RDEPENDS:rust-interpolator+default-devel = " \
 cargo \
 rust-interpolator-devel \
 "
RDEPENDS:rust-interpolator+iter-devel = " \
 cargo \
 rust-interpolator-devel \
 "
RDEPENDS:rust-interpolator+number-devel = " \
 cargo \
 rust-interpolator-devel \
 "
RDEPENDS:rust-interpolator+pointer-devel = " \
 cargo \
 rust-interpolator-devel \
 "
RDEPENDS:rust-interpolator-devel = " \
 cargo \
 "
