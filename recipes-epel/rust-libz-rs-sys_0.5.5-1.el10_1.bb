# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-rs-sys"
PV = "0.5.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-libz-rs-sys+c-allocator-devel \
 rust-libz-rs-sys+custom-prefix-devel \
 rust-libz-rs-sys+default-devel \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+semver-prefix-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys+testing-prefix-devel \
 rust-libz-rs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-rs-sys-0.5.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec1baf3c598dbb76a83c8efa01b262f0b4e13614d7fd35cdfcc50b4dc95f2b90"

URI_x86_64_v2_rust-libz-rs-sys+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+c-allocator-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "35fe5846a30d7e6531180eebd2eb650598375c3d3be8c0c31e3548000ba0816e"

URI_x86_64_v2_rust-libz-rs-sys+custom-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+custom-prefix-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+custom-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "47068550d8f52bc4f426f0dacbe7fb0d74543feb44186fe0c09e836896d9d258"

URI_x86_64_v2_rust-libz-rs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+default-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+default-devel.sha256sum] = "19768310542100c262814d1609c8a1d90111f2a3772d5926698fc57245ed1aa0"

URI_x86_64_v2_rust-libz-rs-sys+export-symbols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+export-symbols-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+export-symbols-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "e0f894a75bc993c47fce4b215139ffb87eabf25ff7d3108050836af3bf494fa9"

URI_x86_64_v2_rust-libz-rs-sys+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+rust-allocator-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "547e36d1d3aa160819cbee52d1d0deb31f363c84929298ef337935fb49e3bc40"

URI_x86_64_v2_rust-libz-rs-sys+semver-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+semver-prefix-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+semver-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "76f5d8523c4a793d7842bc93c66d5742852d8b5f71d499285121f4e70db0a2ad"

URI_x86_64_v2_rust-libz-rs-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+std-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+std-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+std-devel.sha256sum] = "1b0b4120739b93ececf914e5bc9cc775fcbc751cccf49a050e0b7b3af1537a72"

URI_x86_64_v2_rust-libz-rs-sys+testing-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys+testing-prefix-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys+testing-prefix-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "c4b05713312b8f460e2a31873fb2b351bd7336f4ed0dcab345f56767583f5d4b"

URI_x86_64_v2_rust-libz-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-rs-sys-devel-0.5.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-rs-sys-devel.sha256sum] = "a84f427bbc436c9db3b902989c92c2e0fec53d8e7a66f45da79073517e8ac7d2"

URI_aarch64_rust-libz-rs-sys+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+c-allocator-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-libz-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+c-allocator-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+c-allocator-devel.sha256sum] = "9f0db892f13cb5a106ba2ca533f180914b555488fdf7f38a90b94b899916c578"

URI_aarch64_rust-libz-rs-sys+custom-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+custom-prefix-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-libz-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+custom-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+custom-prefix-devel.sha256sum] = "5f98e5417c61d41ec465b1360a18d743e2ef6649338bf8571712b0a6dc963817"

URI_aarch64_rust-libz-rs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+default-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-libz-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+default-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+default-devel.sha256sum] = "6010b2964324f4bb0e9dda0738ff3d28e37d216762581c836ad2436b229db3f4"

URI_aarch64_rust-libz-rs-sys+export-symbols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+export-symbols-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-libz-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+export-symbols-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+export-symbols-devel.sha256sum] = "ba142690c2c6e899946719c7d14b2fc7287f123949d26903ee701a8d554507d8"

URI_aarch64_rust-libz-rs-sys+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+rust-allocator-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-libz-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+rust-allocator-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+rust-allocator-devel.sha256sum] = "71ea2b7f13a7928e761d8ed6e9b97d9d93a974ca91865c7c45afe54d55647fe4"

URI_aarch64_rust-libz-rs-sys+semver-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+semver-prefix-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-libz-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+semver-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+semver-prefix-devel.sha256sum] = "d651597dcf519a742ccdad62ee2e9fa45defc12f2b7cb07cd81afe9e195b8d80"

URI_aarch64_rust-libz-rs-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+std-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-libz-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+std-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+std-devel.sha256sum] = "58918bc3ef7beeb943b0ac1602194fb981068e7cf254950dafe5d51388777c65"

URI_aarch64_rust-libz-rs-sys+testing-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys+testing-prefix-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-libz-rs-sys+testing-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys+testing-prefix-devel}"
SRC_URI[aarch64_rust-libz-rs-sys+testing-prefix-devel.sha256sum] = "9f1dba79ee2cd0c1a633cee1e843681abe0c92e0ed68b385c9a7235ce58b9093"

URI_aarch64_rust-libz-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-rs-sys-devel-0.5.5-1.el10_1.noarch.rpm;name=aarch64_rust-libz-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-rs-sys-devel}"
SRC_URI[aarch64_rust-libz-rs-sys-devel.sha256sum] = "33ad357a6e9a2f7f33f9a0aefe8368f64999e90e4e1490c7b4a1a3386dbe8382"

RDEPENDS:rust-libz-rs-sys+c-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+c-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+custom-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+default-devel = " \
 cargo \
 rust-libz-rs-sys+rust-allocator-devel \
 rust-libz-rs-sys+std-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+export-symbols-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+rust-allocator-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+rust-allocator-devel \
 "
RDEPENDS:rust-libz-rs-sys+semver-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys+std-devel = " \
 cargo \
 rust-libz-rs-sys-devel \
 rust-zlib-rs+std-devel \
 "
RDEPENDS:rust-libz-rs-sys+testing-prefix-devel = " \
 cargo \
 rust-libz-rs-sys+export-symbols-devel \
 rust-libz-rs-sys-devel \
 "
RDEPENDS:rust-libz-rs-sys-devel = " \
 cargo \
 rust \
 rust-zlib-rs-devel \
 "
