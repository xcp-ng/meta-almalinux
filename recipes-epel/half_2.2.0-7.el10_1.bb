# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "half"
PV = "2.2.0"
PR = "7.el10_1"
PACKAGES = " \
 half-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/half-2.2.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cfc59338f9fcd59e0f6aab1dc81082cda84729240589b2df47217942bfaa7a2"

URI_x86_64_v2_half-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/half-devel-2.2.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_half-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_half-devel}"
SRC_URI[x86_64_v2_half-devel.sha256sum] = "7c6ab754c88dcef18783034dbfc209c68c1a86d0e5ef9a75da67937dde12c471"

URI_aarch64_half-devel = "${EPEL_MIRROR}/aarch64/Packages/h/half-devel-2.2.0-7.el10_1.noarch.rpm;name=aarch64_half-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_half-devel}"
SRC_URI[aarch64_half-devel.sha256sum] = "2a10a0771d242c057123656363be14f7f93d62cc629ba063de0397d85b057a21"

RDEPENDS:half-devel = " \
 "
