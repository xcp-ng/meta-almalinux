# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk3"
PV = "3.24.43"
PR = "3.el10"
PACKAGES = " \
 gtk-update-icon-cache \
 gtk3 \
 gtk3-devel \
 gtk3-devel-docs \
 gtk3-immodule-xim \
 gtk3-immodules \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gtk3-3.24.43-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbf2ae0f2988dde740784345ed15cdb3141970829ecdcba03741f526a20135e2"

URI_x86_64_v2_gtk-update-icon-cache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk-update-icon-cache-3.24.43-3.el10.x86_64_v2.rpm;name=x86_64_v2_gtk-update-icon-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk-update-icon-cache}"
SRC_URI[x86_64_v2_gtk-update-icon-cache.sha256sum] = "9698765cc3b60862890a6b830357380ab2c1999566dca6f038bb2c61fb0797e9"

URI_x86_64_v2_gtk3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk3-3.24.43-3.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3}"
SRC_URI[x86_64_v2_gtk3.sha256sum] = "87f219119a528cc41ac79a53e311366a370954035bf4e8f79b116ffcaa5bb127"

URI_x86_64_v2_gtk3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk3-devel-3.24.43-3.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3-devel}"
SRC_URI[x86_64_v2_gtk3-devel.sha256sum] = "d044907363eafa0c4a1e5dbe6ff092f57c371831320292f63d8e125ca136fbdf"

URI_x86_64_v2_gtk3-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk3-devel-docs-3.24.43-3.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3-devel-docs}"
SRC_URI[x86_64_v2_gtk3-devel-docs.sha256sum] = "45585ee37bc2929dd49e27d08cc7feb598010a3a94b3a9b56bd68d884ce15f3e"

URI_x86_64_v2_gtk3-immodule-xim = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk3-immodule-xim-3.24.43-3.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3-immodule-xim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3-immodule-xim}"
SRC_URI[x86_64_v2_gtk3-immodule-xim.sha256sum] = "e12efd74798057971d1350e9f3e52f93280b3f37d9e19a9795fcab4a29d53d1c"

URI_x86_64_v2_gtk3-immodules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk3-immodules-3.24.43-3.el10.x86_64_v2.rpm;name=x86_64_v2_gtk3-immodules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtk3-immodules}"
SRC_URI[x86_64_v2_gtk3-immodules.sha256sum] = "a65acca99770b4f022548c2994c225e95e5a4c1a85d775f040fe7a00ee6454bd"

URI_aarch64_gtk-update-icon-cache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk-update-icon-cache-3.24.43-3.el10.aarch64.rpm;name=aarch64_gtk-update-icon-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk-update-icon-cache}"
SRC_URI[aarch64_gtk-update-icon-cache.sha256sum] = "8cd7cb7510666a52af4c771f7a7c146b2120ced1778d7a4d879d34c3119a2969"

URI_aarch64_gtk3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk3-3.24.43-3.el10.aarch64.rpm;name=aarch64_gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3}"
SRC_URI[aarch64_gtk3.sha256sum] = "3a804ff36c58ce14c945bed884903604486bbb95aaa70aa9514a4d46232b5fe8"

URI_aarch64_gtk3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk3-devel-3.24.43-3.el10.aarch64.rpm;name=aarch64_gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3-devel}"
SRC_URI[aarch64_gtk3-devel.sha256sum] = "4fffabc43819ba5f429855a9516db655ef690937f6cf6308880f16ec1171f99d"

URI_aarch64_gtk3-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk3-devel-docs-3.24.43-3.el10.aarch64.rpm;name=aarch64_gtk3-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3-devel-docs}"
SRC_URI[aarch64_gtk3-devel-docs.sha256sum] = "d41481229a9acb227a04c8a5deee2caf60e2c98b619267d19fb8f722b4baf932"

URI_aarch64_gtk3-immodule-xim = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk3-immodule-xim-3.24.43-3.el10.aarch64.rpm;name=aarch64_gtk3-immodule-xim;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3-immodule-xim}"
SRC_URI[aarch64_gtk3-immodule-xim.sha256sum] = "9dffeaba3de9b2375a225006e31d24ab16486b1fe9ea495b89e2f0ff75a7e277"

URI_aarch64_gtk3-immodules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk3-immodules-3.24.43-3.el10.aarch64.rpm;name=aarch64_gtk3-immodules;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtk3-immodules}"
SRC_URI[aarch64_gtk3-immodules.sha256sum] = "b675cf7692a72daf33fadae2bd669ef4fa6ecfbcad716dea7957a2cf86276721"

RDEPENDS:gtk-update-icon-cache = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 "
RDEPENDS:gtk3 = " \
 adwaita-icon-theme \
 at-spi2-atk \
 atk \
 bash \
 cairo \
 cairo-gobject \
 colord-libs \
 cups-libs \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules \
 glib2 \
 glibc \
 gtk-update-icon-cache \
 harfbuzz \
 hicolor-icon-theme \
 libX11 \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libtracker-sparql \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 pango \
 "
RDEPENDS:gtk3-devel = " \
 at-spi2-atk-devel \
 atk \
 atk-devel \
 cairo \
 cairo-devel \
 cairo-gobject-devel \
 fontconfig-devel \
 fribidi-devel \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 glib2 \
 glib2-devel \
 glibc \
 gtk3 \
 gtk3-devel \
 harfbuzz \
 libX11-devel \
 libXcomposite-devel \
 libXcursor-devel \
 libXdamage-devel \
 libXext-devel \
 libXfixes-devel \
 libXi-devel \
 libXinerama-devel \
 libXrandr-devel \
 libepoxy \
 libepoxy-devel \
 libxkbcommon-devel \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 wayland-devel \
 "
RDEPENDS:gtk3-devel-docs = " \
 gtk3 \
 "
RDEPENDS:gtk3-immodule-xim = " \
 glib2 \
 glibc \
 gtk3 \
 libX11 \
 pango \
 "
RDEPENDS:gtk3-immodules = " \
 glib2 \
 glibc \
 gtk3 \
 pango \
 "
