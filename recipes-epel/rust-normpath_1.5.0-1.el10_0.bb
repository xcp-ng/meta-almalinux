# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-normpath"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-normpath+default-devel \
 rust-normpath+localization-devel \
 rust-normpath+serde-devel \
 rust-normpath-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-normpath-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d5c8c648fadc08e070216895eb1633305de392a04e022704906ee812dd651d7"

URI_x86_64_v2_rust-normpath+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+default-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath+default-devel}"
SRC_URI[x86_64_v2_rust-normpath+default-devel.sha256sum] = "c2ff261f93211e9393cebb53e2bbba6e4efef2fb68a7b5b356d358df442fe23f"

URI_x86_64_v2_rust-normpath+localization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+localization-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+localization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath+localization-devel}"
SRC_URI[x86_64_v2_rust-normpath+localization-devel.sha256sum] = "acfef940493d44763d984acc3276a2835bebdf3d8dc6f04d63188d3b352814ca"

URI_x86_64_v2_rust-normpath+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath+serde-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath+serde-devel}"
SRC_URI[x86_64_v2_rust-normpath+serde-devel.sha256sum] = "452c012a4ddaf547b565e71e46a6137bde34a6257889649285cb940c92aa59c8"

URI_x86_64_v2_rust-normpath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-normpath-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-normpath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-normpath-devel}"
SRC_URI[x86_64_v2_rust-normpath-devel.sha256sum] = "fd9475916e30f9f67cbc245f2f540d49f6b3f81d9ca5fa8b406c554007393acb"

URI_aarch64_rust-normpath+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+default-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-normpath+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath+default-devel}"
SRC_URI[aarch64_rust-normpath+default-devel.sha256sum] = "156feff4f1a27a52cb1edb69eca5c0dc7a193f825a0f45473eb8aab935e4d23a"

URI_aarch64_rust-normpath+localization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+localization-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-normpath+localization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath+localization-devel}"
SRC_URI[aarch64_rust-normpath+localization-devel.sha256sum] = "ddbfef916055f83a0c09f42b378dc13534a78615379379351861e67bc66963b6"

URI_aarch64_rust-normpath+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath+serde-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-normpath+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath+serde-devel}"
SRC_URI[aarch64_rust-normpath+serde-devel.sha256sum] = "4a140e160957a5a60017698cc9289d407fb7a927db88ac2ec50491b54b069242"

URI_aarch64_rust-normpath-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-normpath-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-normpath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-normpath-devel}"
SRC_URI[aarch64_rust-normpath-devel.sha256sum] = "84a1a544970ec1ecfd2a35b47285fc62c016f4cbf547ae6d95c69db3cc6202ba"

RDEPENDS:rust-normpath+default-devel = " \
 cargo \
 rust-normpath-devel \
 "
RDEPENDS:rust-normpath+localization-devel = " \
 cargo \
 rust-normpath-devel \
 "
RDEPENDS:rust-normpath+serde-devel = " \
 cargo \
 rust-normpath-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-normpath-devel = " \
 cargo \
 rust \
 "
