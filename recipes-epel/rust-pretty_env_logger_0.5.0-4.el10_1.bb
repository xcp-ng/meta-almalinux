# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pretty_env_logger"
PV = "0.5.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-pretty_env_logger+default-devel \
 rust-pretty_env_logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pretty_env_logger-0.5.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e807970ae0dd9da2db08aa07cec9f2b0153bd4ade9569f2e258a5e8c24a6961"

URI_x86_64_v2_rust-pretty_env_logger+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty_env_logger+default-devel-0.5.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty_env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty_env_logger+default-devel}"
SRC_URI[x86_64_v2_rust-pretty_env_logger+default-devel.sha256sum] = "646ab855f83bd13773d01d65fec085f3446dc6e66d4c03ef4016265d80436260"

URI_x86_64_v2_rust-pretty_env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty_env_logger-devel-0.5.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty_env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty_env_logger-devel}"
SRC_URI[x86_64_v2_rust-pretty_env_logger-devel.sha256sum] = "cd4172996c88bd97acad74fa230465f4f64dfb0a858ef12671ef6c22650970cd"

URI_aarch64_rust-pretty_env_logger+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty_env_logger+default-devel-0.5.0-4.el10_1.noarch.rpm;name=aarch64_rust-pretty_env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty_env_logger+default-devel}"
SRC_URI[aarch64_rust-pretty_env_logger+default-devel.sha256sum] = "bc29bc120545166af257af2e4a07e2d34c012d170c3c8c153c7ff6d2b95d5795"

URI_aarch64_rust-pretty_env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty_env_logger-devel-0.5.0-4.el10_1.noarch.rpm;name=aarch64_rust-pretty_env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty_env_logger-devel}"
SRC_URI[aarch64_rust-pretty_env_logger-devel.sha256sum] = "8a6d5951b317190eeec542ce89a216994c67be01d4aee4b144430342a212e812"

RDEPENDS:rust-pretty_env_logger+default-devel = " \
 cargo \
 rust-pretty_env_logger-devel \
 "
RDEPENDS:rust-pretty_env_logger-devel = " \
 cargo \
 rust-env_logger0.10+default-devel \
 rust-log+default-devel \
 "
