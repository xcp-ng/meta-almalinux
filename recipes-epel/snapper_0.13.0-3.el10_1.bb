# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapper"
PV = "0.13.0"
PR = "3.el10_1"
PACKAGES = " \
 pam_snapper \
 snapper \
 snapper-backup \
 snapper-devel \
 snapper-libs \
 snapper-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapper-0.13.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad546eccdb8aeb455162fdc36c4c24bfc9ccd1c42270fc4747e8ead4153175cd"

URI_x86_64_v2_pam_snapper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pam_snapper-0.13.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pam_snapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_snapper}"
SRC_URI[x86_64_v2_pam_snapper.sha256sum] = "77e7dc4d3c8a5c38d90feb1a7c31fee7a33e263d9ed22acf24a3b25f2ef3a536"

URI_x86_64_v2_snapper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-0.13.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper}"
SRC_URI[x86_64_v2_snapper.sha256sum] = "90c16603bbbb1f5619ae4ffb6f33a7ee2433420fb6c556bcada0194709c8019c"

URI_x86_64_v2_snapper-backup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-backup-0.13.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-backup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-backup}"
SRC_URI[x86_64_v2_snapper-backup.sha256sum] = "6776c9082066c556d6cf4209d230a4f30b4e9f9a2ccdea1f892c52cc032be1c8"

URI_x86_64_v2_snapper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-devel-0.13.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-devel}"
SRC_URI[x86_64_v2_snapper-devel.sha256sum] = "74c0d35b86e9457b68b5bb93d3d3f0ff5f2430b101b915fd238c7884677babdc"

URI_x86_64_v2_snapper-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-libs-0.13.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-libs}"
SRC_URI[x86_64_v2_snapper-libs.sha256sum] = "f90d7f72d1b05c6c885423fd124f61b81b76a2cd05bc744d5d4b809e9a2de0f2"

URI_x86_64_v2_snapper-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapper-tests-0.13.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapper-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapper-tests}"
SRC_URI[x86_64_v2_snapper-tests.sha256sum] = "833281ec833cb478d68cad642b460aa40e74ea46e6a1563c830cfedbf0ba81a0"

URI_aarch64_pam_snapper = "${EPEL_MIRROR}/aarch64/Packages/p/pam_snapper-0.13.0-3.el10_1.aarch64.rpm;name=aarch64_pam_snapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_snapper}"
SRC_URI[aarch64_pam_snapper.sha256sum] = "3fdcd6c5de2316ae2986e92246241f6f2bf89b3ec2c20b20d5bd1d2c1eb196ef"

URI_aarch64_snapper = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-0.13.0-3.el10_1.aarch64.rpm;name=aarch64_snapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper}"
SRC_URI[aarch64_snapper.sha256sum] = "717ad0714e0e8a8fd3130f9a00ca077427960dd95b9307c0d943ca1f6214595a"

URI_aarch64_snapper-backup = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-backup-0.13.0-3.el10_1.aarch64.rpm;name=aarch64_snapper-backup;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-backup}"
SRC_URI[aarch64_snapper-backup.sha256sum] = "5250935309686fe48f467cfc4c6ced7d72eb8b997be9b31dade2c6cdeb065687"

URI_aarch64_snapper-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-devel-0.13.0-3.el10_1.aarch64.rpm;name=aarch64_snapper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-devel}"
SRC_URI[aarch64_snapper-devel.sha256sum] = "d1dd3ba31279aaa33ceb29333a54bdd82e1eb1737513d9ac12d27349a202215c"

URI_aarch64_snapper-libs = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-libs-0.13.0-3.el10_1.aarch64.rpm;name=aarch64_snapper-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-libs}"
SRC_URI[aarch64_snapper-libs.sha256sum] = "129608b5915e2b49f7c773216c1f4a65a9baf37f0d2dad654758d9fa8878321b"

URI_aarch64_snapper-tests = "${EPEL_MIRROR}/aarch64/Packages/s/snapper-tests-0.13.0-3.el10_1.aarch64.rpm;name=aarch64_snapper-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapper-tests}"
SRC_URI[aarch64_snapper-tests.sha256sum] = "8bd5da624b36d980464e55d0152e14de86499b0f058ea253fe64df39fa9007fe"

RDEPENDS:pam_snapper = " \
 bash \
 dbus-libs \
 glibc \
 libbtrfs \
 libselinux \
 pam-libs \
 snapper \
 "
RDEPENDS:snapper = " \
 bash \
 boost-thread \
 dbus-libs \
 diffutils \
 glibc \
 json-c \
 libgcc \
 libmount \
 libstdc++ \
 libxml2 \
 ncurses-libs \
 snapper-libs \
 "
RDEPENDS:snapper-backup = " \
 dbus-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 ncurses-libs \
 snapper \
 snapper-libs \
 "
RDEPENDS:snapper-devel = " \
 boost-devel \
 btrfs-progs-devel \
 libacl-devel \
 libmount-devel \
 libstdc++-devel \
 libxml2-devel \
 snapper-libs \
 "
RDEPENDS:snapper-libs = " \
 bash \
 boost-system \
 boost-thread \
 btrfs-progs \
 glibc \
 libacl \
 libbtrfs \
 libbtrfsutil \
 libgcc \
 libmount \
 libselinux \
 libstdc++ \
 libxml2 \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:snapper-tests = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 snapper-libs \
 "
