# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lsd"
PV = "1.2.0"
PR = "8.el10_3"
PACKAGES = " \
 lsd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-lsd-1.2.0-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "20faf5b895d9e355d138d91a7157dba63454b3c47f1d21e3e699e66683b99575"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsd-1.2.0-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsd;unpack=0"
SRC_URI[x86_64_v2_lsd.sha256sum] = "122a8455fdb01abc95e9a1a7d1072166f75ce53f36a811e475a3ecf0403604f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lsd-1.2.0-8.el10_3.aarch64.rpm;name=aarch64_lsd;unpack=0"
SRC_URI[aarch64_lsd.sha256sum] = "72e27bca72fdb5488d2cf23c98e41fee68e8548ff63c971e12ef03dd75d58a99"

RDEPENDS:lsd = " \
 glibc \
 libgcc \
 libgit2_1.9 \
 "
