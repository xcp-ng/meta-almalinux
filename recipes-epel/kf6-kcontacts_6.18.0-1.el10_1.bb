# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcontacts"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kcontacts \
 kf6-kcontacts-devel \
 kf6-kcontacts-doc \
 kf6-kcontacts-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcontacts-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c801fce4c73defae9b04323658c8035a7405c121b5f41c7654256b38587217b6"

URI_x86_64_v2_kf6-kcontacts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts}"
SRC_URI[x86_64_v2_kf6-kcontacts.sha256sum] = "eb3b0761b0d6c269cc28372d072ab2f538eb6a26a731b745bc6018e549d70afd"

URI_x86_64_v2_kf6-kcontacts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-devel}"
SRC_URI[x86_64_v2_kf6-kcontacts-devel.sha256sum] = "c146efe51e817fa7547eb0177eac6d18537e0e302fd21e711a3dc2db7ebc87d1"

URI_x86_64_v2_kf6-kcontacts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcontacts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-doc}"
SRC_URI[x86_64_v2_kf6-kcontacts-doc.sha256sum] = "5cff799c270f448ea206201b3fcf4ef0c92d2195180cce08cf1a0b4a9560d172"

URI_x86_64_v2_kf6-kcontacts-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcontacts-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-html}"
SRC_URI[x86_64_v2_kf6-kcontacts-html.sha256sum] = "4693b16064599d6e13803a836aa6d04c1a2dbdff6df4b3d70d884158c7732120"

URI_aarch64_kf6-kcontacts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcontacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts}"
SRC_URI[aarch64_kf6-kcontacts.sha256sum] = "8844efa34faf5f960aa3b3b043b8ec26ef08235a7415c013831833cbb5270664"

URI_aarch64_kf6-kcontacts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcontacts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-devel}"
SRC_URI[aarch64_kf6-kcontacts-devel.sha256sum] = "0c8fb5494c0f082b9ca2c2eed3f58c23d70433d33c65dd692913c6292bcc6ad8"

URI_aarch64_kf6-kcontacts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcontacts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-doc}"
SRC_URI[aarch64_kf6-kcontacts-doc.sha256sum] = "32aa71bd64d694af13bb61ddfc285051db48cdf7fd06e3915b9a49f6a6304224"

URI_aarch64_kf6-kcontacts-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcontacts-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-html}"
SRC_URI[aarch64_kf6-kcontacts-html.sha256sum] = "c83273b076ca7408a90be60d58163cf6f2010b176cc93b82fdebae0c82696f7f"

RDEPENDS:kf6-kcontacts = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcodecs-devel \
 kf6-kcontacts \
 kf6-kcoreaddons-devel \
 kf6-ki18n-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-doc = " \
 "
RDEPENDS:kf6-kcontacts-html = " \
 "
