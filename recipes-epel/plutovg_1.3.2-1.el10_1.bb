# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plutovg"
PV = "1.3.2"
PR = "1.el10_1"
PACKAGES = " \
 plutovg \
 plutovg-devel \
 plutovg-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plutovg-1.3.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a6dd85a703fd05481714364e20acc1421b592b3aa0c93bd6927f096019c89ff"

URI_x86_64_v2_plutovg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-1.3.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg}"
SRC_URI[x86_64_v2_plutovg.sha256sum] = "2fd49c3d14afb83fc192cbd674a06fd7efed310b3fa817e34d9b8063a59f538b"

URI_x86_64_v2_plutovg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-devel-1.3.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg-devel}"
SRC_URI[x86_64_v2_plutovg-devel.sha256sum] = "65674db664e82a8ada5330ad03abc8ec680b37e16615bc7f327e6735ded7d82e"

URI_x86_64_v2_plutovg-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutovg-samples-1.3.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutovg-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutovg-samples}"
SRC_URI[x86_64_v2_plutovg-samples.sha256sum] = "76042ad608cfe0fb99f987de4279c0868bd9e49bade60c5670e09a5c721505b6"

URI_aarch64_plutovg = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-1.3.2-1.el10_1.aarch64.rpm;name=aarch64_plutovg;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg}"
SRC_URI[aarch64_plutovg.sha256sum] = "1febf491fc2b869b1c0eb048286a3fff083d07ec97fa8393884ff546d4c964c2"

URI_aarch64_plutovg-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-devel-1.3.2-1.el10_1.aarch64.rpm;name=aarch64_plutovg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg-devel}"
SRC_URI[aarch64_plutovg-devel.sha256sum] = "0e04c6af49e9d149a8af5e760a7042c2811e16ea3599a4aa7d51c090ef048127"

URI_aarch64_plutovg-samples = "${EPEL_MIRROR}/aarch64/Packages/p/plutovg-samples-1.3.2-1.el10_1.aarch64.rpm;name=aarch64_plutovg-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutovg-samples}"
SRC_URI[aarch64_plutovg-samples.sha256sum] = "f2f5b554aaa77d6cf722cfde577ea899b0b43aee5ef1e0021319e3a0ef613191"

RDEPENDS:plutovg = " \
 glibc \
 "
RDEPENDS:plutovg-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plutovg \
 "
RDEPENDS:plutovg-samples = " \
 glibc \
 plutovg \
 "
