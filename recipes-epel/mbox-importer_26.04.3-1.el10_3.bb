# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mbox-importer"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 mbox-importer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mbox-importer-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86ab040057f73f4d0a0500dc77b8f46cc415a72cfcff8c382e3bb289cbb7f217"

URI_x86_64_v2_mbox-importer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mbox-importer-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mbox-importer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mbox-importer}"
SRC_URI[x86_64_v2_mbox-importer.sha256sum] = "c25d0ad7ddfc714098f3c01287c47125bf49252ea9a22fecead5d1c3ee9a927e"

URI_aarch64_mbox-importer = "${EPEL_MIRROR}/aarch64/Packages/m/mbox-importer-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_mbox-importer;unpack=0"
SRC_URI:append = " ${URI_aarch64_mbox-importer}"
SRC_URI[aarch64_mbox-importer.sha256sum] = "cc967232ad35af6cc6bbae642d6b275ac1711b79f5602274fe9d095bc194ecab"

RDEPENDS:mbox-importer = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 libgcc \
 libstdc++ \
 mailcommon \
 mailimporter \
 mailimporter-akonadi \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
