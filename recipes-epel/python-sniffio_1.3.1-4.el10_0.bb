# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sniffio"
PV = "1.3.1"
PR = "4.el10_0"
PACKAGES = " \
 python3-sniffio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sniffio-1.3.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7e89b0e1cfe3a6d281d039c66dedce7a8322dc3e535a9423ffb3356e3de945a"

URI_x86_64_v2_python3-sniffio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sniffio-1.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sniffio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sniffio}"
SRC_URI[x86_64_v2_python3-sniffio.sha256sum] = "3a8cfd76f15ec179de280ffd5d11257dc7f3b1062beb2423894fd3ef598a6367"

URI_aarch64_python3-sniffio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sniffio-1.3.1-4.el10_0.noarch.rpm;name=aarch64_python3-sniffio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sniffio}"
SRC_URI[aarch64_python3-sniffio.sha256sum] = "d93f18e08cae45ea6177a8f2346349a87023fea9a7ddadf2a759e55eb3ba8aa7"

RDEPENDS:python3-sniffio = " \
 python3 \
 "
