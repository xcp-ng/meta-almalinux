# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xattr"
PV = "1.6.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-xattr+default-devel \
 rust-xattr+unsupported-devel \
 rust-xattr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-xattr-1.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9c6c783118e0780026d5f8685ee98f328b3a690458f1217e7bf22fad2dc11255"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xattr+default-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xattr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xattr+default-devel.sha256sum] = "26202439daaf7e63711093cb71028647c95b33ec0b297db1f9606cb4ad80e6f6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xattr+unsupported-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xattr+unsupported-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xattr+unsupported-devel.sha256sum] = "d6c652968ed1d3e484b690063df675015b686394e84291bd844ee2b41c63d591"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xattr-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xattr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xattr-devel.sha256sum] = "286a5358d82c447bb7d8f84b4bb991261ca3442674fc54068c078f456a2f032e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xattr+default-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-xattr+default-devel;unpack=0"
SRC_URI[aarch64_rust-xattr+default-devel.sha256sum] = "d37efd778ab00ab7faadd71d2500eb551f1fa148a4060be34850e1c767202b89"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xattr+unsupported-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-xattr+unsupported-devel;unpack=0"
SRC_URI[aarch64_rust-xattr+unsupported-devel.sha256sum] = "6c074db85af5179bf1262ae5180b7fff568aea50e0d07d747f36ef544c70b01a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xattr-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-xattr-devel;unpack=0"
SRC_URI[aarch64_rust-xattr-devel.sha256sum] = "fc939841891fc572a9773a7caf333e8ca806017d41b00344affa23b33487d786"

RDEPENDS:rust-xattr+default-devel = " \
 cargo \
 rust-xattr+unsupported-devel \
 rust-xattr-devel \
 "
RDEPENDS:rust-xattr+unsupported-devel = " \
 cargo \
 rust-xattr-devel \
 "
RDEPENDS:rust-xattr-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
