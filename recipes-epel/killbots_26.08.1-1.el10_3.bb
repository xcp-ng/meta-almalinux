# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "killbots"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 killbots \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/killbots-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91dbc2909d7b52822899e215d03a0f3f34738d1410ab5e6689fefa3177999ef3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/killbots-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_killbots;unpack=0"
SRC_URI[x86_64_v2_killbots.sha256sum] = "080121cc18142b3b34c74357fb47db3a06bc2303576f097c53c12a8bf62f77b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/killbots-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_killbots;unpack=0"
SRC_URI[aarch64_killbots.sha256sum] = "dfc1e3a579f5124fc919322d16e50cc6c0dcc54bf28dd531fdcd2839cc203b62"

RDEPENDS:killbots = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
