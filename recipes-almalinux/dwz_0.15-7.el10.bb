# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dwz"
PV = "0.15"
PR = "7.el10"
PACKAGES = " \
 dwz \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dwz-0.15-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5124c66fd927d79302678948480508f79c94e1cd5fa6bdfd85fa8b30df38cc97"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dwz-0.15-7.el10.x86_64_v2.rpm;name=x86_64_v2_dwz;unpack=0"
SRC_URI[x86_64_v2_dwz.sha256sum] = "3093deaf594a3d7ffa39c637483a230793d504601f3b24d52b9218d57f6fb494"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dwz-0.15-7.el10.aarch64.rpm;name=aarch64_dwz;unpack=0"
SRC_URI[aarch64_dwz.sha256sum] = "f26940b9561e89ab518a05672929d54f7563694be97af5e2f4489d2d6f3bf969"

RDEPENDS:dwz = " \
 elfutils-libelf \
 glibc \
 "
