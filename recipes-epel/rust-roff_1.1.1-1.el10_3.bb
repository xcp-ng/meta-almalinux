# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-roff"
PV = "1.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-roff+default-devel \
 rust-roff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-roff-1.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dab90fdd252dab81fe96900ba13a9a008ce5d4575a252446765f554160f139d"

URI_x86_64_v2_rust-roff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roff+default-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roff+default-devel}"
SRC_URI[x86_64_v2_rust-roff+default-devel.sha256sum] = "bebf1598ccf29d04b2634e077d8fc29885243f3318b7b6ccfb0c6aa0009c9396"

URI_x86_64_v2_rust-roff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-roff-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-roff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-roff-devel}"
SRC_URI[x86_64_v2_rust-roff-devel.sha256sum] = "a44eb51e46ba21afd298dd242ee14c9c69aa90f8556aa975cc31c826a60560b9"

URI_aarch64_rust-roff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roff+default-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-roff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roff+default-devel}"
SRC_URI[aarch64_rust-roff+default-devel.sha256sum] = "e5a8c5d864824e8826339a2cfc05886271d8875f8e1582b64dbef7028f01d782"

URI_aarch64_rust-roff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-roff-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-roff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-roff-devel}"
SRC_URI[aarch64_rust-roff-devel.sha256sum] = "0133ce2904bd7c71be74be028ffdb493fc9b2a97aaaa31fc162e883725417234"

RDEPENDS:rust-roff+default-devel = " \
 cargo \
 rust-roff-devel \
 "
RDEPENDS:rust-roff-devel = " \
 cargo \
 rust \
 "
