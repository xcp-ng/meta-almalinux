# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vdo"
PV = "8.3.0.72"
PR = "1.el10"
PACKAGES = " \
 vdo \
 vdo-support \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/vdo-8.3.0.72-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81edaf9950b5832b56a6c92104a62532303a6116e46f98a216f054af5372800a"

URI_x86_64_v2_vdo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vdo-8.3.0.72-1.el10.x86_64_v2.rpm;name=x86_64_v2_vdo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vdo}"
SRC_URI[x86_64_v2_vdo.sha256sum] = "95972d8bfcf3a143480b1eb4d73b095bc7618d9f029e6eb1a00957b68d9bcb76"

URI_x86_64_v2_vdo-support = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/vdo-support-8.3.0.72-1.el10.x86_64_v2.rpm;name=x86_64_v2_vdo-support;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vdo-support}"
SRC_URI[x86_64_v2_vdo-support.sha256sum] = "c72901ace42dd59c9d4a6881af721a72a87c3b5afc7a0a495cdcc8df41a922cd"

URI_aarch64_vdo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vdo-8.3.0.72-1.el10.aarch64.rpm;name=aarch64_vdo;unpack=0"
SRC_URI:append = " ${URI_aarch64_vdo}"
SRC_URI[aarch64_vdo.sha256sum] = "7416091fc3736afef5d7844435ea42e4fa004801fe4c7c5dca3b2e21ea1a56cf"

URI_aarch64_vdo-support = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/vdo-support-8.3.0.72-1.el10.aarch64.rpm;name=aarch64_vdo-support;unpack=0"
SRC_URI:append = " ${URI_aarch64_vdo-support}"
SRC_URI[aarch64_vdo-support.sha256sum] = "11759fc88958dbc4c494ac49f7e70b4a96723876904b3ba96e23b1075bbea1bc"

RDEPENDS:vdo = " \
 glibc \
 libblkid \
 libuuid \
 zlib-ng-compat \
 "
RDEPENDS:vdo-support = " \
 bash \
 glibc \
 libuuid \
 zlib-ng-compat \
 "
