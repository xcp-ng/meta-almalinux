# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_chmod"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_chmod+default-devel \
 rust-uu_chmod-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_chmod-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28234c39080840f2046a1a76678e5e42c18e0663740b4482ad436956cd9a4ecf"

URI_x86_64_v2_rust-uu_chmod+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chmod+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chmod+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chmod+default-devel}"
SRC_URI[x86_64_v2_rust-uu_chmod+default-devel.sha256sum] = "1d8217ba7f125750061e760ee307e65eb9979d1f154b5ba2bc36382c034a6c7b"

URI_x86_64_v2_rust-uu_chmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chmod-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chmod-devel}"
SRC_URI[x86_64_v2_rust-uu_chmod-devel.sha256sum] = "166a51be66ada391cddba831415acc23a087b5fab27b687d3df182b56523ad01"

URI_aarch64_rust-uu_chmod+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chmod+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chmod+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chmod+default-devel}"
SRC_URI[aarch64_rust-uu_chmod+default-devel.sha256sum] = "516e65e8647b5fd1fe8030e8c5a2625b9f38c51b2ca8b10460430bd70d472c76"

URI_aarch64_rust-uu_chmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chmod-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chmod-devel}"
SRC_URI[aarch64_rust-uu_chmod-devel.sha256sum] = "088ab38fe4fad0db4016f76650dabc2c9e3c80f5f8a322663e5f8dea3ac6c60a"

RDEPENDS:rust-uu_chmod+default-devel = " \
 cargo \
 rust-uu_chmod-devel \
 "
RDEPENDS:rust-uu_chmod-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+mode-devel \
 rust-uucore+perms-devel \
 rust-uucore+safe-traversal-devel \
 "
