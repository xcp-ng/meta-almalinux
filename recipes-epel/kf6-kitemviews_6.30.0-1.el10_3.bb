# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemviews"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kitemviews \
 kf6-kitemviews-devel \
 kf6-kitemviews-doc \
 kf6-kitemviews-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemviews-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "060b503ec9d1eee938fa4118900abf7fbd3ccc313bf79a7ef8feb5c6d0bd2103"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews;unpack=0"
SRC_URI[x86_64_v2_kf6-kitemviews.sha256sum] = "6c2800526beeb6c8b30fcb3ff78566750dad51ba2be20ed26ad508a7919c9c2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kitemviews-devel.sha256sum] = "90b4f6e0076c3f5262312e825753a0d93ac5c0e7fecdae12cfdcb8ed701e4685"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemviews-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kitemviews-doc.sha256sum] = "36fb5d8f30ae7c00d7b5ac6f5fa3b840ff4824e0c92024891cf193a86669542f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemviews-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kitemviews-html.sha256sum] = "b9c9e98f3ef8a8d3e2c0829c4ee456d423b2a4ad011297695c95c09b67263663"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kitemviews;unpack=0"
SRC_URI[aarch64_kf6-kitemviews.sha256sum] = "e9fe9741a59a5c24d8ee4da3762a1c0241082afe82b4a0dfb88e0e3f21f9c43d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kitemviews-devel;unpack=0"
SRC_URI[aarch64_kf6-kitemviews-devel.sha256sum] = "a2f658ceb9f3c5a9df15c537a42ae00a07c7a66ea6a6d88286aa8eef9eef8291"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kitemviews-doc;unpack=0"
SRC_URI[aarch64_kf6-kitemviews-doc.sha256sum] = "03f3e221fbf95c0230760a4d5af10ed05db582496e22589a07fbbc8f0e36d994"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kitemviews-html;unpack=0"
SRC_URI[aarch64_kf6-kitemviews-html.sha256sum] = "ef0c1065051983d68e21f05b0bbdc56519176c41e7d3f3257a716e0b37a56518"

RDEPENDS:kf6-kitemviews = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kitemviews \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-doc = " \
 "
RDEPENDS:kf6-kitemviews-html = " \
 "
