# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvirt"
PV = "11.10.0"
PR = "12.9.el10_2.alma.1"
PACKAGES = " \
 libvirt \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-common \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 libvirt-daemon-kvm \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-plugin-sanlock \
 libvirt-daemon-proxy \
 libvirt-devel \
 libvirt-docs \
 libvirt-libs \
 libvirt-nss \
 libvirt-ssh-proxy \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvirt-11.10.0-12.9.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "43fb8f868234867d71ecf5f9fec7d9fbc1faf3b2cf1f4b3ff00a1b37cda2d70e"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - libvirt-daemon-plugin-sanlock: augeas

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - libvirt-daemon-plugin-sanlock: augeas

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt;unpack=0"
SRC_URI[x86_64_v2_libvirt.sha256sum] = "383a895120907c1eb69c7a7aece24245f805e04b890dde776f19837d98ab9326"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client;unpack=0"
SRC_URI[x86_64_v2_libvirt-client.sha256sum] = "14fb047bd7ec9488bf8603a48eeab858ec9c09234a55ed02477dcd253f8761e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-client-qemu-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-client-qemu;unpack=0"
SRC_URI[x86_64_v2_libvirt-client-qemu.sha256sum] = "64c5f9ceac88d4cad39530773b56bba9e131f089b333b0d776ec4f649be9ebb4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon.sha256sum] = "4a56f3e53994663704e4956c84f23d1f59e2b5fe62c1db678692684e413158a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-common-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-common;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-common.sha256sum] = "c6285d1ec2380d146c6b08d64dea1c1fa036dd77fdb0989e32e5fb7ad8ebc55f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-network-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-network;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-config-network.sha256sum] = "b468edfb67336c362248b09d17cf683d543d5b08c38b1ca7abb1f7e60a568cb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-config-nwfilter-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-config-nwfilter.sha256sum] = "ff1a6a823f65b3b827bea6aa418d4554ef57545c17f58d15a5dc556b05713e60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-interface-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-interface;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-interface.sha256sum] = "14cd957bc24eba0bc8852724d229523a1b9484365054cdf53c0d3355d60a35a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-network-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-network;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-network.sha256sum] = "c86c5af7a3962649ab9532ae35b56056d9568734772f67b47340f31f5e16faf4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nodedev-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nodedev.sha256sum] = "e413dedc7cc07dfd08acdb94ffb6594cb50433a048856eade94e15701a0de9ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-nwfilter-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-nwfilter.sha256sum] = "2a359920e3d1263ea4158c95ee1cbd8491f4d575de91171abb84d11474161287"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-qemu-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-qemu.sha256sum] = "17873c449e2b5b64c2f016846130d0d1778b9e169d4391e887bec928b2b72b49"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-secret-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-secret;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-secret.sha256sum] = "b898126db42ad17de2d61777cbb66beb96c03887900ad0763b379bcdfccc013f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage.sha256sum] = "3d2ab5e6e2d2a016d8f05bf2fe020f442a7863f8eac73cbff1cd36259084ff65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-core-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-core.sha256sum] = "d12eed06a19951a6b21271ef2d7929de39b4ffd268d4c5f746dfcd3faf58cfea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-disk-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-disk.sha256sum] = "4685872b1e243812c347db8f82b1424ae25af18fb481f3ae1991da815f8fb0fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-iscsi-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-iscsi.sha256sum] = "c250a3f6f76ee83d436da2edb2e66605de5a9a1f5416cf3a3c0854edbb82fb5f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-logical-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-logical.sha256sum] = "710c2ec99178c994aa1454f24e5fccd4ebff00c6af08991c3f49189dd9a14748"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-mpath-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-mpath.sha256sum] = "f2c9d3bbbe996e0a40a582f9e0b90e03c1e1949a26ce6c8b703711b491364473"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-rbd-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-rbd.sha256sum] = "c6d79545ca2fa603f1f4477302dd5f428e29923e27411b185fbaf6c157773377"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-driver-storage-scsi-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-driver-storage-scsi.sha256sum] = "1eb710ff6eab45dd7121c5c6fc34a7b356ce803cadcb05665f94e92a15e75ed8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-kvm-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-kvm;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-kvm.sha256sum] = "787f9c7424e6a5d02e297ad3df3b0e4a8b6ed5e3250aad357ffa071335195d82"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-lock-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-lock;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-lock.sha256sum] = "2f4a41dfc713dfc5a704304d5e2ccc007d11c41e1c47cd68d3510614b06ca7a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-log-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-log;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-log.sha256sum] = "629ea5dc27e208688122c041745e0e672fda3fbaa2d2e773463ec324ecc97966"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-plugin-lockd-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-lockd.sha256sum] = "a45cc0ed0192615c9ad3444777ed66d4d4344b44f6ac28de3b495df566020445"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-daemon-plugin-sanlock-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-plugin-sanlock.sha256sum] = "4ab403158e1a522751cdd8a8e0f77e7326986f92f03ee7e4358b6306b114c3fd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-daemon-proxy-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-daemon-proxy;unpack=0"
SRC_URI[x86_64_v2_libvirt-daemon-proxy.sha256sum] = "dd66f8f0cf9971df9d9665595ea7f19e3faf588ec8bc568187474f4e914eb3d7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-devel-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-devel;unpack=0"
SRC_URI[x86_64_v2_libvirt-devel.sha256sum] = "e15cabb9337dd9c91c99d3a87ce67ea76ccd858df66375bea0f1f8f796f2debc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvirt-docs-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-docs;unpack=0"
SRC_URI[x86_64_v2_libvirt-docs.sha256sum] = "a817b5eb9968668735d367a536c7937c573890047ed308190b14596f5e74c3f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-libs-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-libs;unpack=0"
SRC_URI[x86_64_v2_libvirt-libs.sha256sum] = "ac141b2cad47ee928697070d35d6e117c11bb7a538b24b60369a1a9c313f13b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-nss-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-nss;unpack=0"
SRC_URI[x86_64_v2_libvirt-nss.sha256sum] = "fe1696ce2ac386441c734d0c902ef6335f58af191ae274ca41f07cf04cb807d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvirt-ssh-proxy-11.10.0-12.9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libvirt-ssh-proxy;unpack=0"
SRC_URI[x86_64_v2_libvirt-ssh-proxy.sha256sum] = "7b0a4e72bf0ff34b083f9f6f8dc55af9ac249e225b50f40d41ff194801947092"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt;unpack=0"
SRC_URI[aarch64_libvirt.sha256sum] = "b14b57970483b66b97c0c78df64a7dd231944b3be47c3a6f36ecfa0e17cb9597"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-client;unpack=0"
SRC_URI[aarch64_libvirt-client.sha256sum] = "68ab4859c9fb189f994653366871568daaec3b6ac73dc099cc2e07fb7839a810"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-client-qemu-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-client-qemu;unpack=0"
SRC_URI[aarch64_libvirt-client-qemu.sha256sum] = "e978a4b1c03502443da062398ab9e5ca1a2642b1f52641f6005c41a2e347da16"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon;unpack=0"
SRC_URI[aarch64_libvirt-daemon.sha256sum] = "15ba0d159a6a7b106d6c0ea27077baa84e125078fcec1f71a9cdc870ca74ed45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-common-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-common;unpack=0"
SRC_URI[aarch64_libvirt-daemon-common.sha256sum] = "52932370a34b2cf1046cb2835fd721020800044442ee512ae4c92f47a5e628e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-network-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-network;unpack=0"
SRC_URI[aarch64_libvirt-daemon-config-network.sha256sum] = "7e8af7fce93b39a6c39290f336f6c7d824aed9219abd54e8ade3d0420fe1e0b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-config-nwfilter-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-config-nwfilter;unpack=0"
SRC_URI[aarch64_libvirt-daemon-config-nwfilter.sha256sum] = "12ab6552c2665ad778b6ab217668c79c14286586cb600d4214a7635023a75e1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-interface-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-interface;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-interface.sha256sum] = "823ef403f3e349e9e415be31fb559b83f222fc847c1e45df62eb55853ac41a7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-network-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-network;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-network.sha256sum] = "c323ff511518243fc97517a40c713eb97e331db91c19b1d3b0851a2cd8920008"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nodedev-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nodedev;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-nodedev.sha256sum] = "f86a8e10304749d670891f585ecc9a59a5c6398ba8ea79c7af4f0f1f0ab935df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-nwfilter-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-nwfilter;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-nwfilter.sha256sum] = "0045e1eedd9dc6a0ba3d8b8af0ad3048fd91908321960ec75d6ea19627eae291"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-qemu-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-qemu;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-qemu.sha256sum] = "df346ce4cd3d5d9b3c78800b3c1f1badccd81b6808625aa490c702f01340dad7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-secret-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-secret;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-secret.sha256sum] = "030d42b289fd280982d1dfd080855691447a2287a7039e9a6368fa85c63ada1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage.sha256sum] = "c6126ac9ebc6cea1feb9cc879518fae1aa4da50f5c7e0db3700e535f87b5dcf7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-core-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-core;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-core.sha256sum] = "99771adac3402c5429e00d9e6f0999079e7bd5007ed6807205a0f046c88cf8e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-disk-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-disk;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-disk.sha256sum] = "bd230a435e9a33397ba3adbe5411bc2e8c91272706511bec4785e17bcb9c007d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-iscsi-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-iscsi;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-iscsi.sha256sum] = "9f18bae5badc2a9e8ac1dcda17aae04fdab87e355526ee9738d6b8e36ba70180"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-logical-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-logical;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-logical.sha256sum] = "f3aff17c063c56cba4f6ec9564b06701bcd4847f5b4fa1a138c95fb2bab70fd0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-mpath-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-mpath;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-mpath.sha256sum] = "8397469fa8486ad03be26c679f065ef2959f649f9f3468ac1414d8243663d79a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-rbd-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-rbd;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-rbd.sha256sum] = "e8cf3f598bba5ca60329d389a170cb70e94ae6b5540343ac33d37501cf2599b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-driver-storage-scsi-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-driver-storage-scsi;unpack=0"
SRC_URI[aarch64_libvirt-daemon-driver-storage-scsi.sha256sum] = "56e8367045cb9591d6df4ef58fa367c3f6708b5ba49584036f2deac911be41c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-kvm-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-kvm;unpack=0"
SRC_URI[aarch64_libvirt-daemon-kvm.sha256sum] = "c8f395ae97a487109acd2bad6584e4e3a98068258646c2252fe2e3e99dcd0755"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-lock-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-lock;unpack=0"
SRC_URI[aarch64_libvirt-daemon-lock.sha256sum] = "d21830bce8fdd35884c2021553be4a4180dcf18484fa6a0b0d214415b804dfdf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-log-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-log;unpack=0"
SRC_URI[aarch64_libvirt-daemon-log.sha256sum] = "919781cf29d7aaea2ea9614f654d8d08c92efb8fded3e8eede5e9e4cc3c7e225"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-plugin-lockd-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-lockd;unpack=0"
SRC_URI[aarch64_libvirt-daemon-plugin-lockd.sha256sum] = "9c8f957b87e384bd077d4ff66d2bae3f5fc433b984bdda337db0fea4e41eb2c8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-daemon-plugin-sanlock-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-plugin-sanlock;unpack=0"
SRC_URI[aarch64_libvirt-daemon-plugin-sanlock.sha256sum] = "bcc56e8b5219b283ce04ddee59d3f9a6a84c0dcce856d5d51f3ab18ebec51065"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-daemon-proxy-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-daemon-proxy;unpack=0"
SRC_URI[aarch64_libvirt-daemon-proxy.sha256sum] = "841050780eba3a59fa806a19aad9ef8321b7a91a5f7f83a90606d35ef7afb10c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-devel-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-devel;unpack=0"
SRC_URI[aarch64_libvirt-devel.sha256sum] = "2aaf6a659fd1bba6e17ba377e695735c0695fdb56dd6ac4ac6fb40a94e33c44e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvirt-docs-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-docs;unpack=0"
SRC_URI[aarch64_libvirt-docs.sha256sum] = "336b44919e0e5137d2e15c97507f19ad2837da0b78585b26f25ce11f7d71e721"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-libs-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-libs;unpack=0"
SRC_URI[aarch64_libvirt-libs.sha256sum] = "229a9ebd86d34dde7ebde8f8877fbbbc5e1ea87d1d079375c1833d685f2b5f55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-nss-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-nss;unpack=0"
SRC_URI[aarch64_libvirt-nss.sha256sum] = "09204336fee684373110911d277360035808448b148857077e388d05150cac50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvirt-ssh-proxy-11.10.0-12.9.el10_2.alma.1.aarch64.rpm;name=aarch64_libvirt-ssh-proxy;unpack=0"
SRC_URI[aarch64_libvirt-ssh-proxy.sha256sum] = "31802947ae833c4adb7ca24ec236a2d8434fa750340f146325b1e256400d2148"

RDEPENDS:libvirt = " \
 libvirt-client \
 libvirt-client-qemu \
 libvirt-daemon \
 libvirt-daemon-config-network \
 libvirt-daemon-config-nwfilter \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-libs \
 "
RDEPENDS:libvirt-client = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libvirt-libs \
 libxml2 \
 readline \
 "
RDEPENDS:libvirt-client-qemu = " \
 libvirt-libs \
 python3 \
 python3-cryptography \
 python3-libvirt \
 python3-lxml \
 "
RDEPENDS:libvirt-daemon = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-common = " \
 bash \
 dbus \
 dmidecode \
 gettext \
 glib2 \
 glibc \
 iproute \
 iproute-tc \
 kmod \
 libacl \
 libgcc \
 libvirt-libs \
 polkit \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:libvirt-daemon-config-network = " \
 bash \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-daemon-config-nwfilter = " \
 bash \
 libvirt-daemon-driver-nwfilter \
 "
RDEPENDS:libvirt-daemon-driver-interface = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-network = " \
 bash \
 dnsmasq \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 nftables \
 "
RDEPENDS:libvirt-daemon-driver-nodedev = " \
 bash \
 glib2 \
 glibc \
 kmod \
 libgcc \
 libpciaccess \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 mdevctl \
 systemd \
 systemd-libs \
 "
RDEPENDS:libvirt-daemon-driver-nwfilter = " \
 bash \
 glib2 \
 glibc \
 iptables-nft \
 libgcc \
 libpcap \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-qemu = " \
 bash \
 bzip2 \
 glib2 \
 glibc \
 gnutls \
 gzip \
 libgcc \
 libnbd \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-log \
 libvirt-libs \
 libxml2 \
 lzop \
 numad \
 qemu-img \
 swtpm-tools \
 systemd-container \
 xz \
 zstd \
 "
RDEPENDS:libvirt-daemon-driver-secret = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage = " \
 libvirt-daemon-driver-storage-core \
 libvirt-daemon-driver-storage-disk \
 libvirt-daemon-driver-storage-iscsi \
 libvirt-daemon-driver-storage-logical \
 libvirt-daemon-driver-storage-mpath \
 libvirt-daemon-driver-storage-rbd \
 libvirt-daemon-driver-storage-scsi \
 "
RDEPENDS:libvirt-daemon-driver-storage-core = " \
 bash \
 glib2 \
 glibc \
 libblkid \
 libgcc \
 libselinux \
 libtirpc \
 libvirt-daemon-common \
 libvirt-libs \
 libxml2 \
 parted \
 qemu-img \
 scrub \
 util-linux \
 "
RDEPENDS:libvirt-daemon-driver-storage-disk = " \
 device-mapper \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 parted \
 "
RDEPENDS:libvirt-daemon-driver-storage-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-logical = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 lvm2 \
 "
RDEPENDS:libvirt-daemon-driver-storage-mpath = " \
 device-mapper \
 device-mapper-libs \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-rbd = " \
 glib2 \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-driver-storage-scsi = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-kvm = " \
 libvirt-daemon-common \
 libvirt-daemon-driver-interface \
 libvirt-daemon-driver-network \
 libvirt-daemon-driver-nodedev \
 libvirt-daemon-driver-nwfilter \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage \
 libvirt-daemon-lock \
 libvirt-daemon-log \
 libvirt-daemon-plugin-lockd \
 libvirt-daemon-proxy \
 libvirt-ssh-proxy \
 qemu-kvm \
 "
RDEPENDS:libvirt-daemon-lock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-log = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-lockd = " \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-daemon-common \
 libvirt-daemon-lock \
 libvirt-libs \
 "
RDEPENDS:libvirt-daemon-plugin-sanlock = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libvirt-daemon-common \
 libvirt-libs \
 sanlock \
 sanlock-lib \
 "
RDEPENDS:libvirt-daemon-proxy = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libtirpc \
 libvirt-libs \
 "
RDEPENDS:libvirt-devel = " \
 libvirt-devel \
 libvirt-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libvirt-docs = " \
 "
RDEPENDS:libvirt-libs = " \
 audit-libs \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 glib2 \
 glibc \
 gnutls \
 json-c \
 libacl \
 libcap-ng \
 libgcc \
 libnl3 \
 libselinux \
 libssh \
 libtirpc \
 libxml2 \
 numactl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libvirt-nss = " \
 glibc \
 json-c \
 libgcc \
 libvirt-daemon-driver-network \
 "
RDEPENDS:libvirt-ssh-proxy = " \
 glib2 \
 glibc \
 libgcc \
 libvirt-libs \
 libxml2 \
 "
