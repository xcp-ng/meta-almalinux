# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Date-Manip"
PV = "6.94"
PR = "5.el10"
PACKAGES = " \
 perl-Date-Manip \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Date-Manip-6.94-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aa87b0a53ababf0626c0a79e50d5d2cd5a1c401c0b394493396208e65f1bde4"

URI_x86_64_v2_perl-Date-Manip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Date-Manip-6.94-5.el10.noarch.rpm;name=x86_64_v2_perl-Date-Manip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Date-Manip}"
SRC_URI[x86_64_v2_perl-Date-Manip.sha256sum] = "90eb168f405bb144bd0b37c099c0d7c29c76b202454fa63440c83d4a32bec942"

URI_aarch64_perl-Date-Manip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Date-Manip-6.94-5.el10.noarch.rpm;name=aarch64_perl-Date-Manip;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Date-Manip}"
SRC_URI[aarch64_perl-Date-Manip.sha256sum] = "90eb168f405bb144bd0b37c099c0d7c29c76b202454fa63440c83d4a32bec942"

RDEPENDS:perl-Date-Manip = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Date-Manip \
 perl-Encode \
 perl-Exporter \
 perl-File-Find \
 perl-IO \
 perl-PathTools \
 perl-Storable \
 perl-interpreter \
 perl-libs \
 "
