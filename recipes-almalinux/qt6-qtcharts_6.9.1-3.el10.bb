# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtcharts"
PV = "6.9.1"
PR = "3.el10"
PACKAGES = " \
 qt6-qtcharts \
 qt6-qtcharts-devel \
 qt6-qtcharts-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtcharts-6.9.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90cfa8294ee9047421baacaadf174e4d23016504923d20a117c5aa343109d231"

URI_x86_64_v2_qt6-qtcharts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtcharts-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcharts}"
SRC_URI[x86_64_v2_qt6-qtcharts.sha256sum] = "ae08a4b62d5432ec6efc7891c921950f49520ac15983ff195997b3735d2e90be"

URI_x86_64_v2_qt6-qtcharts-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtcharts-devel-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcharts-devel}"
SRC_URI[x86_64_v2_qt6-qtcharts-devel.sha256sum] = "60ef3f59b35b6cf7bfeed6fd71f74f6fff688814857c0432bf5be1f99464db6b"

URI_x86_64_v2_qt6-qtcharts-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtcharts-examples-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcharts-examples}"
SRC_URI[x86_64_v2_qt6-qtcharts-examples.sha256sum] = "dc340e2ce391ed4bff8210d89d6591db3bfab5f72980f7e633c9fe4e19ff1d7c"

URI_aarch64_qt6-qtcharts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtcharts-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcharts}"
SRC_URI[aarch64_qt6-qtcharts.sha256sum] = "0dfa997082421c1653517d418c7cba8717991dc7761b69118216d53336f95d63"

URI_aarch64_qt6-qtcharts-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtcharts-devel-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcharts-devel}"
SRC_URI[aarch64_qt6-qtcharts-devel.sha256sum] = "3611bc71504d5bb222405c2633da42309e0cf847bcb405a6cdbb26a154fdbb8c"

URI_aarch64_qt6-qtcharts-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtcharts-examples-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcharts-examples}"
SRC_URI[aarch64_qt6-qtcharts-examples.sha256sum] = "77a2a793065755997e93a1cb2d447bca8d053e3e39a34d4774b36e0fa93902e1"

RDEPENDS:qt6-qtcharts = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtcharts-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtcharts \
 qt6-qtcharts-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qtcharts-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 "
