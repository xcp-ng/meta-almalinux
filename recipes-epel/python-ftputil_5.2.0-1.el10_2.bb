# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ftputil"
PV = "5.2.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-ftputil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ftputil-5.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a335818330b270c0f00fbc32cb1b6c81e24a404a52dc55bd51cfc4ab5f6d9759"

URI_x86_64_v2_python3-ftputil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ftputil-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ftputil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ftputil}"
SRC_URI[x86_64_v2_python3-ftputil.sha256sum] = "f750eeea9aa80188cdd36f615b81938dc1a692fde1f5402b937a808162df8ea2"

URI_aarch64_python3-ftputil = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ftputil-5.2.0-1.el10_2.noarch.rpm;name=aarch64_python3-ftputil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ftputil}"
SRC_URI[aarch64_python3-ftputil.sha256sum] = "e120ccb034d9e67d47904f1840e7d7f179bcefa2263df634b17c8626df8d973e"

RDEPENDS:python3-ftputil = " \
 ftp \
 python3 \
 "
