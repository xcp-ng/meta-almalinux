# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wnaf"
PV = "0.14.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-wnaf+alloc-devel \
 rust-wnaf+default-devel \
 rust-wnaf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wnaf-0.14.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abf29589549df06628c5af2fb6bc4de0e1cf93df8a6d95b5108e1a940f00c9dc"

URI_aarch64_rust-wnaf+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wnaf+alloc-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-wnaf+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wnaf+alloc-devel}"
SRC_URI[aarch64_rust-wnaf+alloc-devel.sha256sum] = "89332af1047463a230feab3428ed5da6485fd8b3933b6baea6f7832ebfc20a16"

URI_aarch64_rust-wnaf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wnaf+default-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-wnaf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wnaf+default-devel}"
SRC_URI[aarch64_rust-wnaf+default-devel.sha256sum] = "b83c65b649b520af906141ad1a7e78a469944764283516fd4ed4f77c897891cd"

URI_aarch64_rust-wnaf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wnaf-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-wnaf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wnaf-devel}"
SRC_URI[aarch64_rust-wnaf-devel.sha256sum] = "f447a1772442a081672f30025d687c7c69a01ef716a713bd1c06d4ac58e8efe0"

RDEPENDS:rust-wnaf+alloc-devel = " \
 cargo \
 rust-ff+alloc-devel \
 rust-group+alloc-devel \
 rust-hybrid-array+alloc-devel \
 rust-wnaf-devel \
 "
RDEPENDS:rust-wnaf+default-devel = " \
 cargo \
 rust-wnaf+alloc-devel \
 rust-wnaf-devel \
 "
RDEPENDS:rust-wnaf-devel = " \
 cargo \
 rust \
 rust-ff-devel \
 rust-group-devel \
 rust-hybrid-array+default-devel \
 "
