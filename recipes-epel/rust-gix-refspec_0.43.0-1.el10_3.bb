# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-refspec"
PV = "0.43.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-refspec+default-devel \
 rust-gix-refspec+sha1-devel \
 rust-gix-refspec+sha256-devel \
 rust-gix-refspec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-refspec-0.43.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c65d36e890843726b7004fa202f7334c77fd8edb2b251da6e52c7536a2a14f7"

URI_x86_64_v2_rust-gix-refspec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec+default-devel-0.43.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec+default-devel.sha256sum] = "0e3eba190279bdf17f8b434d8bcceb532a0b1c221520374be6c92c10ccbf4c78"

URI_x86_64_v2_rust-gix-refspec+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec+sha1-devel-0.43.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec+sha1-devel.sha256sum] = "b401c8fa3b383c1d210b25ab2e5cd52f675dc0b081d8636d079b7cbf1d46eb73"

URI_x86_64_v2_rust-gix-refspec+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec+sha256-devel-0.43.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec+sha256-devel.sha256sum] = "346a70ed3c1cad2492fbf096310082ca1b6fea004b43c2152a98abbd34c6e647"

URI_x86_64_v2_rust-gix-refspec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec-devel-0.43.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec-devel.sha256sum] = "25fe9fbe84b2593dce5eb1ae9bb3d7ee182302030c542e06368eea4cc2d3a461"

URI_aarch64_rust-gix-refspec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec+default-devel-0.43.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-refspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec+default-devel}"
SRC_URI[aarch64_rust-gix-refspec+default-devel.sha256sum] = "0f2c640620f8a1e7e142d76ab28447e054f3c337a2e591a2ab31e495413e001a"

URI_aarch64_rust-gix-refspec+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec+sha1-devel-0.43.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-refspec+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec+sha1-devel}"
SRC_URI[aarch64_rust-gix-refspec+sha1-devel.sha256sum] = "f4157f53db97ccbbf6e723ece6cf0d8fd894cecf9fb18907b26a36060754a9df"

URI_aarch64_rust-gix-refspec+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec+sha256-devel-0.43.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-refspec+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec+sha256-devel}"
SRC_URI[aarch64_rust-gix-refspec+sha256-devel.sha256sum] = "672625ebea85f525350f1888b248d84e98768ba5e64ca5d26e4ceae9a8f94597"

URI_aarch64_rust-gix-refspec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec-devel-0.43.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-refspec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec-devel}"
SRC_URI[aarch64_rust-gix-refspec-devel.sha256sum] = "a5975ae9d2ab7db1ea4308bbe43d579ceef84764d536ca9e345f5a0bcaf7b370"

RDEPENDS:rust-gix-refspec+default-devel = " \
 cargo \
 rust-gix-refspec-devel \
 "
RDEPENDS:rust-gix-refspec+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-refspec-devel \
 "
RDEPENDS:rust-gix-refspec+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-refspec-devel \
 "
RDEPENDS:rust-gix-refspec-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-error+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-revision-devel \
 rust-gix-validate+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
