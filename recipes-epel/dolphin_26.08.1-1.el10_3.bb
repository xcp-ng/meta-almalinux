# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dolphin"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 dolphin \
 dolphin-devel \
 dolphin-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dolphin-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0fb318191a1456034fa1353cc0164fd27508009561a6566e2a4c473d677a6c15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin;unpack=0"
SRC_URI[x86_64_v2_dolphin.sha256sum] = "485bb8ba53d1740a3c4515cc4a0e019e4589c048e85a724dbae74869ee960012"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-devel;unpack=0"
SRC_URI[x86_64_v2_dolphin-devel.sha256sum] = "986a64ceb81d6bfe256f3454a7508a410bbcc9a464ae57b9728b2cf37e3a5ac7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-libs;unpack=0"
SRC_URI[x86_64_v2_dolphin-libs.sha256sum] = "6e05691560d064a97660138db3dea437d2bd47aaf9648f277d6b08546c8efe54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dolphin-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_dolphin;unpack=0"
SRC_URI[aarch64_dolphin.sha256sum] = "12b63fa9cc0477929cad963b2486793606d6a82d4dfeb173ae4d591dbf944ddd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dolphin-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_dolphin-devel;unpack=0"
SRC_URI[aarch64_dolphin-devel.sha256sum] = "84ebe650973c1a2d753c536d8d7e60ee37502db90796f759dec2e9d942984120"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dolphin-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_dolphin-libs;unpack=0"
SRC_URI[aarch64_dolphin-libs.sha256sum] = "98c08ba3c7a58d1f977c500ffd0feda1429a86decb19c9d3deac3520dc629c32"

RDEPENDS:dolphin = " \
 PackageKit-Qt6 \
 baloo-widgets \
 dolphin-libs \
 glibc \
 kf6-baloo-libs \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kparts \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
RDEPENDS:dolphin-devel = " \
 cmake-filesystem \
 dolphin-libs \
 kf6-kio-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:dolphin-libs = " \
 baloo-widgets \
 glibc \
 kf6-baloo-libs \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
