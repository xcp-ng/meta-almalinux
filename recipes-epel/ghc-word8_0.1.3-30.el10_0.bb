# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-word8"
PV = "0.1.3"
PR = "30.el10_0"
PACKAGES = " \
 ghc-word8 \
 ghc-word8-devel \
 ghc-word8-doc \
 ghc-word8-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-word8-0.1.3-30.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caf250650ae074dbe98ec9d1fcc76ead5a0b2dba0bb593e15ee1bc89f783210c"

URI_x86_64_v2_ghc-word8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-word8-0.1.3-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-word8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-word8}"
SRC_URI[x86_64_v2_ghc-word8.sha256sum] = "7d91e072ba22a7d0e89012088d0645436147f5f2fa0e801aa40b05a155f41cf8"

URI_x86_64_v2_ghc-word8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-word8-devel-0.1.3-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-word8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-word8-devel}"
SRC_URI[x86_64_v2_ghc-word8-devel.sha256sum] = "4a5522933f941203f9f0d9f04d73654915b4ff11834122d41a017f9de7a3ddb3"

URI_x86_64_v2_ghc-word8-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-word8-doc-0.1.3-30.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-word8-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-word8-doc}"
SRC_URI[x86_64_v2_ghc-word8-doc.sha256sum] = "3e88a56a6f3cfb6bc43da9d971e7fbe7101c05e9376a45168e71000117024f60"

URI_x86_64_v2_ghc-word8-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-word8-prof-0.1.3-30.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-word8-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-word8-prof}"
SRC_URI[x86_64_v2_ghc-word8-prof.sha256sum] = "30b1fe40b914aded46d8f959b43243aed70e2bca0117e196ee434315956d1382"

URI_aarch64_ghc-word8 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-word8-0.1.3-30.el10_0.aarch64.rpm;name=aarch64_ghc-word8;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-word8}"
SRC_URI[aarch64_ghc-word8.sha256sum] = "9265875bd52c2d74222e9a7662b8834544c94c6a563c80e32bb9d50586f25536"

URI_aarch64_ghc-word8-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-word8-devel-0.1.3-30.el10_0.aarch64.rpm;name=aarch64_ghc-word8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-word8-devel}"
SRC_URI[aarch64_ghc-word8-devel.sha256sum] = "846d104de5061392f362a6340f87aacbdd7f0e52ffc1d1f9dbf4a8acf5dc650a"

URI_aarch64_ghc-word8-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-word8-doc-0.1.3-30.el10_0.noarch.rpm;name=aarch64_ghc-word8-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-word8-doc}"
SRC_URI[aarch64_ghc-word8-doc.sha256sum] = "2e68b02184b0b13b8a279a41f42ee145eeb0c26d0bd74d70d268969f96e4d9f9"

URI_aarch64_ghc-word8-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-word8-prof-0.1.3-30.el10_0.aarch64.rpm;name=aarch64_ghc-word8-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-word8-prof}"
SRC_URI[aarch64_ghc-word8-prof.sha256sum] = "b94a241479a4b87b982865e6a98b11beb8ec08e0912bc1c148e886759ca2395e"

RDEPENDS:ghc-word8 = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-word8-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-word8 \
 "
RDEPENDS:ghc-word8-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-word8-prof = " \
 ghc-base-prof \
 ghc-word8-devel \
 "
