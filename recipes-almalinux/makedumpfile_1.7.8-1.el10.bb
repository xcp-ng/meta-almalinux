# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "makedumpfile"
PV = "1.7.8"
PR = "1.el10"
PACKAGES = " \
 makedumpfile \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/makedumpfile-1.7.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ae8c301dc5f6c23eecc4feb65d20f1bf1c1b6444d1d46ee51ce17e289207ba2"

URI_x86_64_v2_makedumpfile = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/makedumpfile-1.7.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_makedumpfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_makedumpfile}"
SRC_URI[x86_64_v2_makedumpfile.sha256sum] = "b2df715db8dbaf21f18a4221986c7b6afa403544392435512a665437d8385ece"

URI_aarch64_makedumpfile = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/makedumpfile-1.7.8-1.el10.aarch64.rpm;name=aarch64_makedumpfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_makedumpfile}"
SRC_URI[aarch64_makedumpfile.sha256sum] = "429069ffe77f78c07f54bde48319c061375d68b7590252659979e89886be0a6b"

RDEPENDS:makedumpfile = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libgcc \
 libzstd \
 lzo \
 ncurses-libs \
 snappy \
 zlib-ng-compat \
 "
