# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-Info"
PV = "1.44"
PR = "4.el10_0"
PACKAGES = " \
 perl-Image-Info \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Image-Info-1.44-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1a0ec6782f42e42ba2391ed2080fd50a6208b87dbe8efd48d086dcdd6ad20847"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-Info-1.44-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-Info;unpack=0"
SRC_URI[x86_64_v2_perl-Image-Info.sha256sum] = "c25b2d2d173ac5d55c0c0fa3b8c77017f865ce6d6af97576d60856d31cf01bb4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-Info-1.44-4.el10_0.noarch.rpm;name=aarch64_perl-Image-Info;unpack=0"
SRC_URI[aarch64_perl-Image-Info.sha256sum] = "f7b198850487d36bbfea6b53876fbe7bafc82b662fd31d1ab46af8351a22b858"

RDEPENDS:perl-Image-Info = " \
 perl-Carp \
 perl-Exporter \
 perl-IO-Compress \
 perl-IO-stringy \
 perl-Image-Info \
 perl-Image-Xbm \
 perl-Image-Xpm \
 perl-XML-LibXML \
 perl-XML-Simple \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-vars \
 rgb \
 "
