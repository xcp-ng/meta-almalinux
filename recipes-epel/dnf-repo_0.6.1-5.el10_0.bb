# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-repo"
PV = "0.6.1"
PR = "5.el10_0"
PACKAGES = " \
 dnf-repo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnf-repo-0.6.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbce289abfd0b5361e80af463e6a31b4c2c8469cafd23128729ada8462b0c10e"

URI_x86_64_v2_dnf-repo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnf-repo-0.6.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnf-repo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-repo}"
SRC_URI[x86_64_v2_dnf-repo.sha256sum] = "a6856c55439eaa27f71886b1e535f66954cd9e8b780639bcc40d5506d490c41d"

URI_aarch64_dnf-repo = "${EPEL_MIRROR}/aarch64/Packages/d/dnf-repo-0.6.1-5.el10_0.aarch64.rpm;name=aarch64_dnf-repo;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-repo}"
SRC_URI[aarch64_dnf-repo.sha256sum] = "ebc4cde7b4ec8946503859d037f09699eac22fdbe341453aa036161d82031ecd"

RDEPENDS:dnf-repo = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
