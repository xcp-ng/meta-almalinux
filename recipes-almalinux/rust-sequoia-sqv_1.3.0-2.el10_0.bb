# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-sqv"
PV = "1.3.0"
PR = "2.el10_0"
PACKAGES = " \
 sequoia-sqv \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-sequoia-sqv-1.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac2f2ee3f4410b14ae7eb9ccf7ae11ef429420286c7c6f396be1313829e6942d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sequoia-sqv-1.3.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_sequoia-sqv;unpack=0"
SRC_URI[x86_64_v2_sequoia-sqv.sha256sum] = "58307e8bec4c0dfc621fafa0c45549b4f7c689a1158f358dbe98d271f5a4baba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sequoia-sqv-1.3.0-2.el10_0.aarch64.rpm;name=aarch64_sequoia-sqv;unpack=0"
SRC_URI[aarch64_sequoia-sqv.sha256sum] = "5dbd5500b4efd97b85aae61f59c8500a3e1cef4bd115796315afc334443bbf60"

RDEPENDS:sequoia-sqv = " \
 glibc \
 libgcc \
 openssl-libs \
 "
