# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktextaddons"
PV = "1.8.0"
PR = "1.el10_2"
PACKAGES = " \
 ktextaddons-common \
 ktextaddons-qt6 \
 ktextaddons-qt6-devel \
 ktextaddons-qt6-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktextaddons-1.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac025ab7231b54a7e2487d40a4a9e0475128ff1b498c34c919e59ed446c3f9f3"

URI_x86_64_v2_ktextaddons-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-common-1.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-common}"
SRC_URI[x86_64_v2_ktextaddons-common.sha256sum] = "abc92eb4a2065b5a4f441dc5fe2043fe05dbb439cd05abec559c61c9c3a48d44"

URI_x86_64_v2_ktextaddons-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-1.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6}"
SRC_URI[x86_64_v2_ktextaddons-qt6.sha256sum] = "193e9173d6bbf9422f9969d560783d079f3e39da2cd3fdd757ee48685c0ef3e5"

URI_x86_64_v2_ktextaddons-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-devel-1.8.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6-devel}"
SRC_URI[x86_64_v2_ktextaddons-qt6-devel.sha256sum] = "e9c6a3d09e3f434159adfbe1908497ecde6fd9a101f78a84ad35728ae955b0d2"

URI_x86_64_v2_ktextaddons-qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-doc-1.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6-doc}"
SRC_URI[x86_64_v2_ktextaddons-qt6-doc.sha256sum] = "02d60ee5be23d702241f8efbf180ef5f6e3f7cb31469e71fd780316cf9ddf9e4"

URI_aarch64_ktextaddons-common = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-common-1.8.0-1.el10_2.noarch.rpm;name=aarch64_ktextaddons-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-common}"
SRC_URI[aarch64_ktextaddons-common.sha256sum] = "5a46d2b20f967a80c87e6e7c116054726cec75aac2aacf1f73de02881680daff"

URI_aarch64_ktextaddons-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-1.8.0-1.el10_2.aarch64.rpm;name=aarch64_ktextaddons-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6}"
SRC_URI[aarch64_ktextaddons-qt6.sha256sum] = "df5f948dcaa149ba4fa62adec4df97b231d690dc86deaf18366c088008ee3d07"

URI_aarch64_ktextaddons-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-devel-1.8.0-1.el10_2.aarch64.rpm;name=aarch64_ktextaddons-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6-devel}"
SRC_URI[aarch64_ktextaddons-qt6-devel.sha256sum] = "2b1a2b7588f7917fe9a84383189c1d7008b49c737f294f6637337c31c82a831f"

URI_aarch64_ktextaddons-qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-doc-1.8.0-1.el10_2.noarch.rpm;name=aarch64_ktextaddons-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6-doc}"
SRC_URI[aarch64_ktextaddons-qt6-doc.sha256sum] = "bb63e50def1392284524b52668b2c2d2635755953031dbe6388df841b3a4defd"

RDEPENDS:ktextaddons-common = " \
 "
RDEPENDS:ktextaddons-qt6 = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-common \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 qtkeychain-qt6 \
 "
RDEPENDS:ktextaddons-qt6-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kconfig \
 kf6-ki18n \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:ktextaddons-qt6-doc = " \
 "
