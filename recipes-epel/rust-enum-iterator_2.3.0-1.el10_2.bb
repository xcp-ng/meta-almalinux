# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-iterator"
PV = "2.3.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-enum-iterator+default-devel \
 rust-enum-iterator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-iterator-2.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5f07a03b7187299aeca40d3b793bfc9ba1b19ce2f2e9dc79fdaa417aede28fd"

URI_x86_64_v2_rust-enum-iterator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator+default-devel-2.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator+default-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator+default-devel.sha256sum] = "18452ecb6b333584738847cb34655bddfa9ff22e2b0bb6d42a07db0ec1359591"

URI_x86_64_v2_rust-enum-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator-devel-2.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator-devel.sha256sum] = "e72acdcd3e309d847f1d15f1c2fdd792abdeff947938011569a6f7380579c434"

URI_aarch64_rust-enum-iterator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator+default-devel-2.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-enum-iterator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator+default-devel}"
SRC_URI[aarch64_rust-enum-iterator+default-devel.sha256sum] = "6bd2434b8cfcf87fa4836cf408542f24c247628d239d5a494c358065fec2a62b"

URI_aarch64_rust-enum-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator-devel-2.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-enum-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator-devel}"
SRC_URI[aarch64_rust-enum-iterator-devel.sha256sum] = "7c8bdda6ed05c5add1bbec6e4d0706a37cc9ea3e18bf5b01dc48935b201d8563"

RDEPENDS:rust-enum-iterator+default-devel = " \
 cargo \
 rust-enum-iterator-devel \
 "
RDEPENDS:rust-enum-iterator-devel = " \
 cargo \
 rust-enum-iterator-derive+default-devel \
 "
