# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsemanage"
PV = "3.9"
PR = "1.el10"
PACKAGES = " \
 libsemanage \
 libsemanage-devel \
 python3-libsemanage \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsemanage-3.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cfffe33e8c2fd4167cbeb641ab36f4699ceb90e5363b137a442a4f3ec71b637"

URI_x86_64_v2_libsemanage = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsemanage-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsemanage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsemanage}"
SRC_URI[x86_64_v2_libsemanage.sha256sum] = "5f7ce862cd44348a0e9d689df15d4b7681c9b38e505efb915af591a1a19f5b65"

URI_x86_64_v2_libsemanage-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsemanage-devel-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsemanage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsemanage-devel}"
SRC_URI[x86_64_v2_libsemanage-devel.sha256sum] = "7121a7e03ee0738d7f2947819cad4cb6c940dad102c668cf720449ff2732a22c"

URI_x86_64_v2_python3-libsemanage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libsemanage-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libsemanage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libsemanage}"
SRC_URI[x86_64_v2_python3-libsemanage.sha256sum] = "4fc6fd4caa7118b67a763ae0c01a9db873e85a2ae5ef9f9cbf43bf00d2d54345"

URI_aarch64_libsemanage = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsemanage-3.9-1.el10.aarch64.rpm;name=aarch64_libsemanage;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsemanage}"
SRC_URI[aarch64_libsemanage.sha256sum] = "9a697d02776c87c66331ad5faac997c913e5011218524b3fb4c52b95274f6113"

URI_aarch64_libsemanage-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsemanage-devel-3.9-1.el10.aarch64.rpm;name=aarch64_libsemanage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsemanage-devel}"
SRC_URI[aarch64_libsemanage-devel.sha256sum] = "085464df591b21888f7d0730c1b4179cd618b9ef41c1137b20db825ba7aefed4"

URI_aarch64_python3-libsemanage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libsemanage-3.9-1.el10.aarch64.rpm;name=aarch64_python3-libsemanage;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libsemanage}"
SRC_URI[aarch64_python3-libsemanage.sha256sum] = "f6cb31be76f144d223cfee8dae4e63627a56a93a7625c1ac659c10911020b0f9"

RDEPENDS:libsemanage = " \
 audit-libs \
 bzip2-libs \
 glibc \
 libselinux \
 libsepol \
 "
RDEPENDS:libsemanage-devel = " \
 libselinux-devel \
 libsemanage \
 libsepol-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libsemanage = " \
 glibc \
 libsemanage \
 python3 \
 python3-libselinux \
 "
