# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-server"
PV = "0.31.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-wayland-server+default-devel \
 rust-wayland-server+log-devel \
 rust-wayland-server-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-server-0.31.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c0991ba7432b543b8e2fba360ebba48b4df0962207f42ed9b136a73d21c7c4c"

URI_x86_64_v2_rust-wayland-server+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+default-devel-0.31.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+default-devel.sha256sum] = "b154f97a1ecfe6197431beb6d42554e8c9cc673046fa87d4e62fa2031151edce"

URI_x86_64_v2_rust-wayland-server+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server+log-devel-0.31.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-server+log-devel.sha256sum] = "265269132d130b679125eb43ed45a00ee06710d718984674d54511a0e0d37325"

URI_x86_64_v2_rust-wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-server-devel-0.31.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-server-devel.sha256sum] = "69e4697d70f0ae5fc090b7199a852417c3adc017fd1188df9f046f8d5eaad80a"

URI_aarch64_rust-wayland-server+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+default-devel-0.31.11-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+default-devel}"
SRC_URI[aarch64_rust-wayland-server+default-devel.sha256sum] = "403a0be5e391da2a0020ca9b359201d62765712af03ddc8c6b1bf53eaed85dd0"

URI_aarch64_rust-wayland-server+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server+log-devel-0.31.11-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-server+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server+log-devel}"
SRC_URI[aarch64_rust-wayland-server+log-devel.sha256sum] = "2bd1f9adade106e8d04514fd92555216a8799c184c910ecf0133c5eb5db16fdd"

URI_aarch64_rust-wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-server-devel-0.31.11-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-server-devel.sha256sum] = "5c2fa3b45809fb108e64e29fa755e9da40cd0353555f50f96932243d9fa3fea3"

RDEPENDS:rust-wayland-server+default-devel = " \
 cargo \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-server-devel \
 "
RDEPENDS:rust-wayland-server-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-downcast-rs+default-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
