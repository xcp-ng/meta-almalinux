# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spdx"
PV = "0.10.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-spdx+default-devel \
 rust-spdx+text-devel \
 rust-spdx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spdx-0.10.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67c888ba069d726af7895a23aa8ba6b4e9dabef6dfa02b93de778cd694fcdff2"

URI_x86_64_v2_rust-spdx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+default-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+default-devel}"
SRC_URI[x86_64_v2_rust-spdx+default-devel.sha256sum] = "d13b66d17af1ca5fd03a08c83936c61f1e9883242f2c871b5e67681da1a9b044"

URI_x86_64_v2_rust-spdx+text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+text-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+text-devel}"
SRC_URI[x86_64_v2_rust-spdx+text-devel.sha256sum] = "2827ee0925eff6ded158fbbc6b4e52ffd78f592c029379c5a7bbd438d5d67fdc"

URI_x86_64_v2_rust-spdx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx-devel-0.10.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx-devel}"
SRC_URI[x86_64_v2_rust-spdx-devel.sha256sum] = "1c0c6f131a79b793f7cbfdd549c5f8eaa3330673634891d03c032586f8e15d32"

URI_aarch64_rust-spdx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+default-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-spdx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+default-devel}"
SRC_URI[aarch64_rust-spdx+default-devel.sha256sum] = "6cb27e22f0d5c15559f7a9a63a6a051884e28cd141a022aa797facb5125bba45"

URI_aarch64_rust-spdx+text-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+text-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-spdx+text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+text-devel}"
SRC_URI[aarch64_rust-spdx+text-devel.sha256sum] = "2589f1d2d257e695c26cc062835dc36697b6e3d4539166e71d0f5ac245b9b93f"

URI_aarch64_rust-spdx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx-devel-0.10.9-1.el10_1.noarch.rpm;name=aarch64_rust-spdx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx-devel}"
SRC_URI[aarch64_rust-spdx-devel.sha256sum] = "a8b5e9405852759c9d1ba85f6a9cf247a82c9209fb3f48f40a5aa17c57eeeb49"

RDEPENDS:rust-spdx+default-devel = " \
 cargo \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+text-devel = " \
 cargo \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "
