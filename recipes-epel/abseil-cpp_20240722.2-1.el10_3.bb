# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "abseil-cpp"
PV = "20240722.2"
PR = "1.el10_3"
PACKAGES = " \
 abseil-cpp \
 abseil-cpp-devel \
 abseil-cpp-testing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/abseil-cpp-20240722.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "019e3274b6b456f755a43d8c082bfd47dd803a6aaca4ad4c7344f9881cdd16d1"

URI_x86_64_v2_abseil-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/abseil-cpp-20240722.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_abseil-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_abseil-cpp}"
SRC_URI[x86_64_v2_abseil-cpp.sha256sum] = "40ac6a241e074cb2b7c679f60abbb2b901b92ca2c24a4f0d73d4a53c6a50d940"

URI_x86_64_v2_abseil-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/abseil-cpp-devel-20240722.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_abseil-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_abseil-cpp-devel}"
SRC_URI[x86_64_v2_abseil-cpp-devel.sha256sum] = "656f50fb8aa360a01bc72b5df352aafb843e1fb1a181f5762194fee1dc768517"

URI_x86_64_v2_abseil-cpp-testing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/abseil-cpp-testing-20240722.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_abseil-cpp-testing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_abseil-cpp-testing}"
SRC_URI[x86_64_v2_abseil-cpp-testing.sha256sum] = "d52ef4a1028e3b20ac7204982520ecf9523e33ca613fe8cdd6c718a666676b21"

URI_aarch64_abseil-cpp = "${EPEL_MIRROR}/aarch64/Packages/a/abseil-cpp-20240722.2-1.el10_3.aarch64.rpm;name=aarch64_abseil-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_abseil-cpp}"
SRC_URI[aarch64_abseil-cpp.sha256sum] = "3f9c5fe448a2f4c5487b88ea6462457f86f29edf2a1fc6fb2ba866139fcfb8ee"

URI_aarch64_abseil-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/a/abseil-cpp-devel-20240722.2-1.el10_3.aarch64.rpm;name=aarch64_abseil-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_abseil-cpp-devel}"
SRC_URI[aarch64_abseil-cpp-devel.sha256sum] = "d8ef9b86b8e0f313e06ab0302f4b230aa8af190f21c9ebccc5d679f3aaea7d1b"

URI_aarch64_abseil-cpp-testing = "${EPEL_MIRROR}/aarch64/Packages/a/abseil-cpp-testing-20240722.2-1.el10_3.aarch64.rpm;name=aarch64_abseil-cpp-testing;unpack=0"
SRC_URI:append = " ${URI_aarch64_abseil-cpp-testing}"
SRC_URI[aarch64_abseil-cpp-testing.sha256sum] = "c584124c5a224766c3f76c02b0eaad27dde85324aaae078ff8681004b6052241"

RDEPENDS:abseil-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:abseil-cpp-devel = " \
 abseil-cpp \
 abseil-cpp-testing \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:abseil-cpp-testing = " \
 abseil-cpp \
 glibc \
 gmock \
 gtest \
 libgcc \
 libstdc++ \
 "
