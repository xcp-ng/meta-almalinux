# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgamma"
PE = "1"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kgamma \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgamma-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a92d6d7cb6bc0c3ca0c4170dff2bf574f83e01131578ee5f96c5b50ecb0b8f9"

URI_x86_64_v2_kgamma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgamma-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgamma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgamma}"
SRC_URI[x86_64_v2_kgamma.sha256sum] = "bf8d4beb91bbc4c7ea22f3e0a0e438fc6fa8c8dbc41a480817819614816f2388"

URI_aarch64_kgamma = "${EPEL_MIRROR}/aarch64/Packages/k/kgamma-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kgamma;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgamma}"
SRC_URI[aarch64_kgamma.sha256sum] = "4ee4706cf8943115ab2fe4bc3711399e625063339fde4578e336e317e9cc47af"

RDEPENDS:kgamma = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libX11 \
 libXxf86vm \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
