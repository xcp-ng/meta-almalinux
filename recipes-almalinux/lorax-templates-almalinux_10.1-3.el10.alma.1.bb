# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax-templates-almalinux"
PV = "10.1"
PR = "3.el10.alma.1"
PACKAGES = " \
 lorax-templates-almalinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-templates-almalinux-10.1-3.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52428e9225aa08837d1be9c65a4944b6a3d5eac4bdd82cbdff5a92b356b9e10e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-almalinux-10.1-3.el10.alma.1.noarch.rpm;name=x86_64_v2_lorax-templates-almalinux;unpack=0"
SRC_URI[x86_64_v2_lorax-templates-almalinux.sha256sum] = "59bd1291fc21e8c7dcbe57eabfbd792bdf8891d0188f436911b70b38ebb6ab84"
RPROVIDES:lorax-templates-almalinux:append:x86_64_v2 = " virtual/lorax-templates"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-almalinux-10.1-3.el10.alma.1.noarch.rpm;name=aarch64_lorax-templates-almalinux;unpack=0"
SRC_URI[aarch64_lorax-templates-almalinux.sha256sum] = "59bd1291fc21e8c7dcbe57eabfbd792bdf8891d0188f436911b70b38ebb6ab84"
RPROVIDES:lorax-templates-almalinux:append:aarch64 = " virtual/lorax-templates"

RDEPENDS:lorax-templates-almalinux = " \
 lorax \
 "
