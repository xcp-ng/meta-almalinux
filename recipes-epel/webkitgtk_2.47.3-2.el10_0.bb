# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "webkitgtk"
PV = "2.47.3"
PR = "2.el10_0"
PACKAGES = " \
 javascriptcoregtk4.1 \
 javascriptcoregtk4.1-devel \
 javascriptcoregtk6.0 \
 javascriptcoregtk6.0-devel \
 webkit2gtk4.1 \
 webkit2gtk4.1-devel \
 webkit2gtk4.1-doc \
 webkitgtk6.0 \
 webkitgtk6.0-devel \
 webkitgtk6.0-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/webkitgtk-2.47.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8bc9e56f20aa9157acddad4c4db6066c26f150c94a30acea131005479ac00fb"

URI_x86_64_v2_javascriptcoregtk4.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk4.1-2.47.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk4.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk4.1}"
SRC_URI[x86_64_v2_javascriptcoregtk4.1.sha256sum] = "b5e8dc6ab70de635114d05c9f02d462892528b6de2055a7891e7ebb47bf321eb"

URI_x86_64_v2_javascriptcoregtk4.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk4.1-devel-2.47.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk4.1-devel}"
SRC_URI[x86_64_v2_javascriptcoregtk4.1-devel.sha256sum] = "1c94d8d2f272ca2c69aec8d520aa105749d416ee7c7a80005c15d5d5a6f87491"

URI_x86_64_v2_javascriptcoregtk6.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk6.0-2.47.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk6.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk6.0}"
SRC_URI[x86_64_v2_javascriptcoregtk6.0.sha256sum] = "38d37b9cf7664bab6611af3bc4e2cdfa3aa2f3b0d2b824f2c9e92bf74175c238"

URI_x86_64_v2_javascriptcoregtk6.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk6.0-devel-2.47.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk6.0-devel}"
SRC_URI[x86_64_v2_javascriptcoregtk6.0-devel.sha256sum] = "aff5eecb4d8c29db5dfec366f4444a7976ce2a774550394397e0c3c0f97ee22f"

URI_x86_64_v2_webkit2gtk4.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-2.47.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkit2gtk4.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1}"
SRC_URI[x86_64_v2_webkit2gtk4.1.sha256sum] = "68a24f73c1d5db59af2d07496533fa4ea7d97265fe3f3913f90cb7d98d4d9e33"

URI_x86_64_v2_webkit2gtk4.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-devel-2.47.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkit2gtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1-devel}"
SRC_URI[x86_64_v2_webkit2gtk4.1-devel.sha256sum] = "492d15d534907ff5479ba4093b6757deeb616a775cc3961a9b8bde9d4937fc54"

URI_x86_64_v2_webkit2gtk4.1-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-doc-2.47.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_webkit2gtk4.1-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1-doc}"
SRC_URI[x86_64_v2_webkit2gtk4.1-doc.sha256sum] = "2cd832fa1e96db817227e6f729d027cab471eb7d24055bb53bb9315fa3aa018a"

URI_x86_64_v2_webkitgtk6.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-2.47.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkitgtk6.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0}"
SRC_URI[x86_64_v2_webkitgtk6.0.sha256sum] = "a4c6b06877aa9c61058a3f5d3e439b91811de6d9e1dcd228b61b24dd49b7a3a9"

URI_x86_64_v2_webkitgtk6.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-devel-2.47.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkitgtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0-devel}"
SRC_URI[x86_64_v2_webkitgtk6.0-devel.sha256sum] = "e3b0f3326b5c164889482adb2eeda0189172cc7d41770f8bea69aca24bd8a1fa"

URI_x86_64_v2_webkitgtk6.0-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-doc-2.47.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_webkitgtk6.0-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0-doc}"
SRC_URI[x86_64_v2_webkitgtk6.0-doc.sha256sum] = "eb9879a5eaa5120b2d978b46c182e5abbeb58295d7bc9cb96cd57a68f4d9e2b9"

URI_aarch64_javascriptcoregtk4.1 = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk4.1-2.47.3-2.el10_0.aarch64.rpm;name=aarch64_javascriptcoregtk4.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk4.1}"
SRC_URI[aarch64_javascriptcoregtk4.1.sha256sum] = "6fb8d285fd3f5bc75032c92d053436c037e7c1411dd50d930f2ef09c21131bd3"

URI_aarch64_javascriptcoregtk4.1-devel = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk4.1-devel-2.47.3-2.el10_0.aarch64.rpm;name=aarch64_javascriptcoregtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk4.1-devel}"
SRC_URI[aarch64_javascriptcoregtk4.1-devel.sha256sum] = "6998b624bec4d50f6b7b87b29ae498195aed596c41c1915d53330853874b90c3"

URI_aarch64_javascriptcoregtk6.0 = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk6.0-2.47.3-2.el10_0.aarch64.rpm;name=aarch64_javascriptcoregtk6.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk6.0}"
SRC_URI[aarch64_javascriptcoregtk6.0.sha256sum] = "9bd30bb83ec8d522dbff513a58e5d4d76d033e769b6dbc34f5b24724181183b8"

URI_aarch64_javascriptcoregtk6.0-devel = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk6.0-devel-2.47.3-2.el10_0.aarch64.rpm;name=aarch64_javascriptcoregtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk6.0-devel}"
SRC_URI[aarch64_javascriptcoregtk6.0-devel.sha256sum] = "634cfeacdef0015ef39074860d209262b6176e5b50032ac0a3ed2ade555e2319"

URI_aarch64_webkit2gtk4.1 = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-2.47.3-2.el10_0.aarch64.rpm;name=aarch64_webkit2gtk4.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1}"
SRC_URI[aarch64_webkit2gtk4.1.sha256sum] = "c72ee84bddb45cb960314ccae1521a74e7250a51bd58ba22fe81771480f0c55b"

URI_aarch64_webkit2gtk4.1-devel = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-devel-2.47.3-2.el10_0.aarch64.rpm;name=aarch64_webkit2gtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1-devel}"
SRC_URI[aarch64_webkit2gtk4.1-devel.sha256sum] = "f654e847533a32362b5eaf7a1e7f87ec0d48f843736c9875628397073e606910"

URI_aarch64_webkit2gtk4.1-doc = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-doc-2.47.3-2.el10_0.noarch.rpm;name=aarch64_webkit2gtk4.1-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1-doc}"
SRC_URI[aarch64_webkit2gtk4.1-doc.sha256sum] = "291e2a14773e6fc3a1ec692d22a5273114157a56441fc8bb7e05f7f1341c020d"

URI_aarch64_webkitgtk6.0 = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-2.47.3-2.el10_0.aarch64.rpm;name=aarch64_webkitgtk6.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0}"
SRC_URI[aarch64_webkitgtk6.0.sha256sum] = "61a839f8bf6842bbe96ba2d47c215e6368e03e7f48f053d4fe749c23a4a6fb92"

URI_aarch64_webkitgtk6.0-devel = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-devel-2.47.3-2.el10_0.aarch64.rpm;name=aarch64_webkitgtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0-devel}"
SRC_URI[aarch64_webkitgtk6.0-devel.sha256sum] = "0d2f2e12ac4e24600089cade84e5b1cece397bb038c0293292e1338ba2749f75"

URI_aarch64_webkitgtk6.0-doc = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-doc-2.47.3-2.el10_0.noarch.rpm;name=aarch64_webkitgtk6.0-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0-doc}"
SRC_URI[aarch64_webkitgtk6.0-doc.sha256sum] = "45088b7d32bad068a4aa6e966c58731cd5313b056c7486bdf31cc107875dc48b"

RDEPENDS:javascriptcoregtk4.1 = " \
 glib2 \
 glibc \
 libatomic \
 libgcc \
 libicu \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:javascriptcoregtk4.1-devel = " \
 glib2-devel \
 glibc \
 javascriptcoregtk4.1 \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:javascriptcoregtk6.0 = " \
 glib2 \
 glibc \
 libatomic \
 libgcc \
 libicu \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:javascriptcoregtk6.0-devel = " \
 glib2-devel \
 glibc \
 javascriptcoregtk6.0 \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:webkit2gtk4.1 = " \
 atk \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk3 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk4.1 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcc \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
 "
RDEPENDS:webkit2gtk4.1-devel = " \
 cairo \
 glib2 \
 glib2-devel \
 glibc \
 gstreamer1 \
 gtk3 \
 gtk3-devel \
 javascriptcoregtk4.1 \
 javascriptcoregtk4.1-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 webkit2gtk4.1 \
 "
RDEPENDS:webkit2gtk4.1-doc = " \
 webkit2gtk4.1 \
 "
RDEPENDS:webkitgtk6.0 = " \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk4 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk6.0 \
 lcms2 \
 libX11 \
 libatomic \
 libavif \
 libdrm \
 libepoxy \
 libgcc \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
 "
RDEPENDS:webkitgtk6.0-devel = " \
 glib2 \
 glib2-devel \
 glibc \
 gstreamer1 \
 gtk4 \
 gtk4-devel \
 javascriptcoregtk6.0 \
 javascriptcoregtk6.0-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 webkitgtk6.0 \
 "
RDEPENDS:webkitgtk6.0-doc = " \
 webkitgtk6.0 \
 "
