# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-diff"
PV = "0.1.13"
PR = "7.el10_0"
PACKAGES = " \
 rust-diff+default-devel \
 rust-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-diff-0.1.13-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e798b1d87c8b143b55d4467cc62a76455db5d365c65f3467b83dc063f4ba8c0e"

URI_x86_64_v2_rust-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-diff+default-devel-0.1.13-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-diff+default-devel}"
SRC_URI[x86_64_v2_rust-diff+default-devel.sha256sum] = "cb051b9035a9fea882299418bc3e9117a73cce4cda939800efc7dcc21c6d80fa"

URI_x86_64_v2_rust-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-diff-devel-0.1.13-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-diff-devel}"
SRC_URI[x86_64_v2_rust-diff-devel.sha256sum] = "8155f692cfbc58a996fe0c4bcb64755ab66532dae1fbb53eca167a9456d0e729"

URI_aarch64_rust-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-diff+default-devel-0.1.13-7.el10_0.noarch.rpm;name=aarch64_rust-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-diff+default-devel}"
SRC_URI[aarch64_rust-diff+default-devel.sha256sum] = "2d8947a75ba8dc3de947e112ac1db314888e32a6b4eddf5120ea9b84056704cb"

URI_aarch64_rust-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-diff-devel-0.1.13-7.el10_0.noarch.rpm;name=aarch64_rust-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-diff-devel}"
SRC_URI[aarch64_rust-diff-devel.sha256sum] = "a5239dfb5e485db9661089ce000994382047f7ea0c138c9c63e2f665e4be7dee"

RDEPENDS:rust-diff+default-devel = " \
 cargo \
 rust-diff-devel \
 "
RDEPENDS:rust-diff-devel = " \
 cargo \
 "
