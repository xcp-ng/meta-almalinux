# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mojo-parent"
PV = "78"
PR = "4.el10"
PACKAGES = " \
 mojo-parent \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mojo-parent-78-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f319441f514d363f70a5ddef4d3ac4ba5adf75bffc785524b2787ad9a0f0ec83"

URI_x86_64_v2_mojo-parent = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mojo-parent-78-4.el10.noarch.rpm;name=x86_64_v2_mojo-parent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mojo-parent}"
SRC_URI[x86_64_v2_mojo-parent.sha256sum] = "ec1c3291df78c7025aefe22a01fdf3ec29fea03c662e836fbefc44376e086857"

URI_aarch64_mojo-parent = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mojo-parent-78-4.el10.noarch.rpm;name=aarch64_mojo-parent;unpack=0"
SRC_URI:append = " ${URI_aarch64_mojo-parent}"
SRC_URI[aarch64_mojo-parent.sha256sum] = "ec1c3291df78c7025aefe22a01fdf3ec29fea03c662e836fbefc44376e086857"

RDEPENDS:mojo-parent = " \
 javapackages-filesystem \
 maven-assembly-plugin \
 "
