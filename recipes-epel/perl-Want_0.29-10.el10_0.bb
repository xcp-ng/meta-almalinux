# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Want"
PV = "0.29"
PR = "10.el10_0"
PACKAGES = " \
 perl-Want \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Want-0.29-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7650ca082ebdf968a23350001c77084cf27640035c6d73a6fba09806ab8b90a1"

URI_x86_64_v2_perl-Want = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Want-0.29-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Want;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Want}"
SRC_URI[x86_64_v2_perl-Want.sha256sum] = "dd8cac4ece561c8f48abe7c02379f1e5b06f378d9581b2a0eada0d9b95f2f5a7"

URI_aarch64_perl-Want = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Want-0.29-10.el10_0.aarch64.rpm;name=aarch64_perl-Want;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Want}"
SRC_URI[aarch64_perl-Want.sha256sum] = "9056787ccc448d4474fd568b3e13017e36091257ff31bfbcbd0f826a8e13b799"

RDEPENDS:perl-Want = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
