# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimetreeparser"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 mimetreeparser \
 mimetreeparser-devel \
 mimetreeparser-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/mimetreeparser-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6f4227c502e3f67bda1a63c544695666436bd801d595bff739581809041c70c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser;unpack=0"
SRC_URI[x86_64_v2_mimetreeparser.sha256sum] = "95f994f59d9fe525a140a5b9fb7f4cf0079663d43004453d08c55f372b16dbfa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimetreeparser-devel;unpack=0"
SRC_URI[x86_64_v2_mimetreeparser-devel.sha256sum] = "6eb8b792d5586ba5055c81c03694a77a0df38391b10483cedda8f09d0770ea61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimetreeparser-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mimetreeparser-doc;unpack=0"
SRC_URI[x86_64_v2_mimetreeparser-doc.sha256sum] = "af613a2a0e03a8f45d11c3d8b0e6565e206420dad5719bc5a2e9c427c29b0521"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_mimetreeparser;unpack=0"
SRC_URI[aarch64_mimetreeparser.sha256sum] = "67f0bbd5583c27034901651faff372c119d6c67dd2c251a6f0748c9d8e44cd54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_mimetreeparser-devel;unpack=0"
SRC_URI[aarch64_mimetreeparser-devel.sha256sum] = "e7ef819335fa2c5bcd40e624e9748ebe01728dfef73bef14d512719456c4febd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mimetreeparser-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_mimetreeparser-doc;unpack=0"
SRC_URI[aarch64_mimetreeparser-doc.sha256sum] = "c48755ddbaf863f057db70eb528ebf1dde084f384782812fb669c4db2c9186ab"

RDEPENDS:mimetreeparser = " \
 glibc \
 gpgme2pp \
 kf6-kcalendarcore \
 kf6-kcolorscheme \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kmime \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kmbox \
 libkleo \
 libstdc++ \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:mimetreeparser-devel = " \
 cmake-filesystem \
 mimetreeparser \
 "
RDEPENDS:mimetreeparser-doc = " \
 "
