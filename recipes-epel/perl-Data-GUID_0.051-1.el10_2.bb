# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-GUID"
PV = "0.051"
PR = "1.el10_2"
PACKAGES = " \
 perl-Data-GUID \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-GUID-0.051-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81d3c03a927ebbf8aa4f122a4fa9cb0a222efa763404b1eae593925ea382673a"

URI_x86_64_v2_perl-Data-GUID = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-GUID-0.051-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-GUID;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-GUID}"
SRC_URI[x86_64_v2_perl-Data-GUID.sha256sum] = "6fc96d3ac048fb200d2bef84e2855d7e88b49b2327bd152dfcb5052ab93cbf02"

URI_aarch64_perl-Data-GUID = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-GUID-0.051-1.el10_2.noarch.rpm;name=aarch64_perl-Data-GUID;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-GUID}"
SRC_URI[aarch64_perl-Data-GUID.sha256sum] = "fc9c592f342946b338d99184216e88133ae84f776b959ec4d71b07aa90e7e833"

RDEPENDS:perl-Data-GUID = " \
 perl-Carp \
 perl-Data-UUID \
 perl-Sub-Exporter \
 perl-Sub-Install \
 perl-libs \
 perl-overload \
 "
