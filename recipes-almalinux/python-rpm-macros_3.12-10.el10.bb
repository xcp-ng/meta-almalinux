# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rpm-macros"
PV = "3.12"
PR = "10.el10"
PACKAGES = " \
 python-rpm-macros \
 python-srpm-macros \
 python3-rpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-rpm-macros-3.12-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d035b1323c167c8d37f7b8187bb40042be9f0f7bac24ee3993ea32fc8bd4f88"

URI_x86_64_v2_python-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-rpm-macros-3.12-10.el10.noarch.rpm;name=x86_64_v2_python-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-rpm-macros}"
SRC_URI[x86_64_v2_python-rpm-macros.sha256sum] = "cee4a09710a1d27861c8a92fc02d6cd6240f412065055f469ca31ec6386f3f2b"

URI_x86_64_v2_python-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-srpm-macros-3.12-10.el10.noarch.rpm;name=x86_64_v2_python-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-srpm-macros}"
SRC_URI[x86_64_v2_python-srpm-macros.sha256sum] = "0e8c47a13f6e07665b1821a53549e7a4d2e36d554f80ec2521cfba23976396c2"

URI_x86_64_v2_python3-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-rpm-macros-3.12-10.el10.noarch.rpm;name=x86_64_v2_python3-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpm-macros}"
SRC_URI[x86_64_v2_python3-rpm-macros.sha256sum] = "d3927ebf18d73d42d1abc3fe7db4a0a65803838849fe537fbe3a073945d1f042"

URI_aarch64_python-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-rpm-macros-3.12-10.el10.noarch.rpm;name=aarch64_python-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-rpm-macros}"
SRC_URI[aarch64_python-rpm-macros.sha256sum] = "cee4a09710a1d27861c8a92fc02d6cd6240f412065055f469ca31ec6386f3f2b"

URI_aarch64_python-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-srpm-macros-3.12-10.el10.noarch.rpm;name=aarch64_python-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-srpm-macros}"
SRC_URI[aarch64_python-srpm-macros.sha256sum] = "0e8c47a13f6e07665b1821a53549e7a4d2e36d554f80ec2521cfba23976396c2"

URI_aarch64_python3-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-rpm-macros-3.12-10.el10.noarch.rpm;name=aarch64_python3-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpm-macros}"
SRC_URI[aarch64_python3-rpm-macros.sha256sum] = "d3927ebf18d73d42d1abc3fe7db4a0a65803838849fe537fbe3a073945d1f042"

RDEPENDS:python-rpm-macros = " \
 python-srpm-macros \
 "
RDEPENDS:python-srpm-macros = " \
 bash \
 redhat-rpm-config \
 "
RDEPENDS:python3-rpm-macros = " \
 python-rpm-macros \
 python-srpm-macros \
 "
