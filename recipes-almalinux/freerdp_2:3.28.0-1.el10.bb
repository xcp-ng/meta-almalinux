# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freerdp"
PE = "2"
PV = "3.28.0"
PR = "1.el10"
PACKAGES = " \
 freerdp \
 freerdp-devel \
 freerdp-libs \
 freerdp-server \
 libwinpr \
 libwinpr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/freerdp-3.28.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "678169d947c6825579eb476cd28f8191cac0321759a0fc3dfc95852e0df0e6db"

URI_x86_64_v2_freerdp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-3.28.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_freerdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp}"
SRC_URI[x86_64_v2_freerdp.sha256sum] = "1772b820aa16c0ed2d0a43200eafc86fc56addce27a4cb81260a3ee9db9fabd5"

URI_x86_64_v2_freerdp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-devel-3.28.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_freerdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-devel}"
SRC_URI[x86_64_v2_freerdp-devel.sha256sum] = "408a851e2dd67eb6c6d3212a6b72c7d0774362449fee10158fff8a26da6ab69a"

URI_x86_64_v2_freerdp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freerdp-libs-3.28.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_freerdp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-libs}"
SRC_URI[x86_64_v2_freerdp-libs.sha256sum] = "eb61456a9bc5fcc3b07bc3873f922205af48e2baca0ab3e6244e02ede8c21a4b"

URI_x86_64_v2_freerdp-server = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freerdp-server-3.28.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_freerdp-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp-server}"
SRC_URI[x86_64_v2_freerdp-server.sha256sum] = "ca885599d05439ef976c38b1c8db001fc2b6d00f24d7237976969dcc23561819"

URI_x86_64_v2_libwinpr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwinpr-3.28.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwinpr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr}"
SRC_URI[x86_64_v2_libwinpr.sha256sum] = "26b80ab0534684a7ebd96340475557051dbef169141eb3ceb4218aa136e9cf34"

URI_x86_64_v2_libwinpr-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwinpr-devel-3.28.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwinpr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr-devel}"
SRC_URI[x86_64_v2_libwinpr-devel.sha256sum] = "7991b8aa7a8c9d89c85989ebcfb1899eba713b601623331338556412e849512a"

URI_aarch64_freerdp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-3.28.0-1.el10.aarch64.rpm;name=aarch64_freerdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp}"
SRC_URI[aarch64_freerdp.sha256sum] = "0fac5a0e3d62518b7a9ad194e50668e11e3907a67557bca64618ca5b390046a3"

URI_aarch64_freerdp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-devel-3.28.0-1.el10.aarch64.rpm;name=aarch64_freerdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-devel}"
SRC_URI[aarch64_freerdp-devel.sha256sum] = "66b8a0f6eec7b718b5468459ac51510146947f8a6c0e197dd06176f96553959e"

URI_aarch64_freerdp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freerdp-libs-3.28.0-1.el10.aarch64.rpm;name=aarch64_freerdp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-libs}"
SRC_URI[aarch64_freerdp-libs.sha256sum] = "b27bf1c183cef483126a74dcd3a6861e0383552e86f76b91686636b23e4ae67a"

URI_aarch64_freerdp-server = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freerdp-server-3.28.0-1.el10.aarch64.rpm;name=aarch64_freerdp-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp-server}"
SRC_URI[aarch64_freerdp-server.sha256sum] = "25f30ccfa1b343ffa7ef2beb0405dae6302302aa65852e6bea458a9e5b038027"

URI_aarch64_libwinpr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwinpr-3.28.0-1.el10.aarch64.rpm;name=aarch64_libwinpr;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr}"
SRC_URI[aarch64_libwinpr.sha256sum] = "c2763c2ab6b49093d07d347a51ed303b849ac66e0be5ef1cd9af8e21d428418a"

URI_aarch64_libwinpr-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwinpr-devel-3.28.0-1.el10.aarch64.rpm;name=aarch64_libwinpr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr-devel}"
SRC_URI[aarch64_libwinpr-devel.sha256sum] = "e812271522661ed7343ffb1511dfd8f09e4c25993cb1b5c3d243c051a681d38e"

RDEPENDS:freerdp = " \
 freerdp-libs \
 glibc \
 libX11 \
 libXcursor \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXrender \
 libwayland-client \
 libwayland-cursor \
 libwinpr \
 libxkbcommon \
 "
RDEPENDS:freerdp-devel = " \
 cmake \
 cmake-filesystem \
 freerdp-devel \
 freerdp-libs \
 libwinpr-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:freerdp-libs = " \
 alsa-lib \
 cairo \
 cups-libs \
 fdk-aac-free \
 fuse3-libs \
 glibc \
 gsm \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXinerama \
 libXtst \
 libcbor \
 libfido2 \
 libgcc \
 libstdc++ \
 libusb1 \
 libwinpr \
 libxkbfile \
 openssl-libs \
 opus \
 pam-libs \
 pulseaudio-libs \
 zlib-ng-compat \
 "
RDEPENDS:freerdp-server = " \
 freerdp-libs \
 glibc \
 libwinpr \
 "
RDEPENDS:libwinpr = " \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libjpeg-turbo \
 libpng \
 libwebp \
 openssl-libs \
 "
RDEPENDS:libwinpr-devel = " \
 cmake \
 cmake-filesystem \
 libwinpr \
 libwinpr-devel \
 pkgconf-pkg-config \
 "
