# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libss7"
PV = "2.0.1"
PR = "14.el10_0"
PACKAGES = " \
 libss7 \
 libss7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libss7-2.0.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ed0fe413a79dc524d3bafd43e2ea1219284da038b0f0df60c1cc4ccee55bbe9"

URI_x86_64_v2_libss7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libss7-2.0.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libss7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libss7}"
SRC_URI[x86_64_v2_libss7.sha256sum] = "d4f9c3ccf04b82d3b27f3200b8319fe67a90c35a01691179da5e7b5c22b1a3d8"

URI_x86_64_v2_libss7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libss7-devel-2.0.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libss7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libss7-devel}"
SRC_URI[x86_64_v2_libss7-devel.sha256sum] = "a872e46aaf97b0c1562296da770712fd5c6baaf36d15cb672fcec64b3083bdf2"

URI_aarch64_libss7 = "${EPEL_MIRROR}/aarch64/Packages/l/libss7-2.0.1-14.el10_0.aarch64.rpm;name=aarch64_libss7;unpack=0"
SRC_URI:append = " ${URI_aarch64_libss7}"
SRC_URI[aarch64_libss7.sha256sum] = "22f58648355db25cbb26f4586a1ae80ffe5e77907f7665667bdf972934d03273"

URI_aarch64_libss7-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libss7-devel-2.0.1-14.el10_0.aarch64.rpm;name=aarch64_libss7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libss7-devel}"
SRC_URI[aarch64_libss7-devel.sha256sum] = "30f004fb1d354d335662f0ae7a857caf642353f6d4dd774a4bead884cc1b7140"

RDEPENDS:libss7 = " \
 glibc \
 "
RDEPENDS:libss7-devel = " \
 libss7 \
 "
