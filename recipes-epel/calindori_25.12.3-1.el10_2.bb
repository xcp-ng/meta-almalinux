# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calindori"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 calindori \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/calindori-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d477ae3987de493423d77f6ede4357804a699d5fab96fa57fbe7754116fa298f"

URI_x86_64_v2_calindori = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calindori-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calindori;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calindori}"
SRC_URI[x86_64_v2_calindori.sha256sum] = "ad22699761eeff22ce4620d9ac3010308059f9aab328aea584e217d31b08b42b"

URI_aarch64_calindori = "${EPEL_MIRROR}/aarch64/Packages/c/calindori-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_calindori;unpack=0"
SRC_URI:append = " ${URI_aarch64_calindori}"
SRC_URI[aarch64_calindori.sha256sum] = "f09a936743dfc093b726c2ce264eab7ad2ca4fa9e7caf662e3be890d06ae1516"

RDEPENDS:calindori = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpeople \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
