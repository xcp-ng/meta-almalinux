# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fish"
PV = "4.0.2"
PR = "1.el10_0"
PACKAGES = " \
 fish \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fish-4.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74f0d6372c54cc656e36b70526dfaacc8ecbaa5186973d0e356e0c9fee9b7dd8"

URI_x86_64_v2_fish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fish-4.0.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fish}"
SRC_URI[x86_64_v2_fish.sha256sum] = "f570f6581adae43639cbf670002c56b25c9b30babcf54c06da55c7258b2ae70d"

URI_aarch64_fish = "${EPEL_MIRROR}/aarch64/Packages/f/fish-4.0.2-1.el10_0.aarch64.rpm;name=aarch64_fish;unpack=0"
SRC_URI:append = " ${URI_aarch64_fish}"
SRC_URI[aarch64_fish.sha256sum] = "ef197c421d4c74d30c178250cd07e56ad90b10f225c2442dbc65d7252eeaf432"

RDEPENDS:fish = " \
 bash \
 glibc \
 libgcc \
 ncurses-term \
 pcre2 \
 pcre2-utf32 \
 pkgconf-pkg-config \
 python3 \
 "
