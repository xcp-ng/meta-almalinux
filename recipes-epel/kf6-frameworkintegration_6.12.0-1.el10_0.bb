# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-frameworkintegration"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-frameworkintegration \
 kf6-frameworkintegration-devel \
 kf6-frameworkintegration-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-frameworkintegration-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f428279ee4927fd2ff9e7bba98c94ba83ad8881c6f57601f99f02f5326393b38"

URI_x86_64_v2_kf6-frameworkintegration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration}"
SRC_URI[x86_64_v2_kf6-frameworkintegration.sha256sum] = "d9c777ac76f04f4c81f244eb44089c4a41dc5c2512158d4560c7864a28996793"

URI_x86_64_v2_kf6-frameworkintegration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-devel}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-devel.sha256sum] = "38cb7207c340e12007c33e8c16191b068ffccfe360926e24094112c1e8203081"

URI_x86_64_v2_kf6-frameworkintegration-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-libs-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-libs}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-libs.sha256sum] = "2d8647c94b9a4a6154d2e49a8112f821d7a69b8ea1f14a2ba02deb9d58b4b8b2"

URI_aarch64_kf6-frameworkintegration = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-frameworkintegration;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration}"
SRC_URI[aarch64_kf6-frameworkintegration.sha256sum] = "fd4b8dd722cc56dfbb7f520be0fef58d67e23da54d67b42a59fda6cf8e7c8b85"

URI_aarch64_kf6-frameworkintegration-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-frameworkintegration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-devel}"
SRC_URI[aarch64_kf6-frameworkintegration-devel.sha256sum] = "c54d2841129849dac001d94316c973bb9fb39bd76427650073d946c8c7f3b949"

URI_aarch64_kf6-frameworkintegration-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-libs-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-frameworkintegration-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-libs}"
SRC_URI[aarch64_kf6-frameworkintegration-libs.sha256sum] = "3aeb38364112bd660c732efb1cff4645cbf1f9fc6b7f4634f610af28ce0af8b9"

RDEPENDS:kf6-frameworkintegration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-frameworkintegration-devel = " \
 cmake-filesystem \
 kf6-frameworkintegration-libs \
 kf6-kconfigwidgets-devel \
 kf6-kiconthemes-devel \
 "
RDEPENDS:kf6-frameworkintegration-libs = " \
 PackageKit-Qt6 \
 appstream-qt \
 glibc \
 kf6-frameworkintegration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
