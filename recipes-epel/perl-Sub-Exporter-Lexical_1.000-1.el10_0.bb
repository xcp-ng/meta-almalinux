# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sub-Exporter-Lexical"
PV = "1.000"
PR = "1.el10_0"
PACKAGES = " \
 perl-Sub-Exporter-Lexical \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sub-Exporter-Lexical-1.000-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e49853150f12b01635aff730e21218d6b712b1207b0730a790696592dd4578c"

URI_x86_64_v2_perl-Sub-Exporter-Lexical = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sub-Exporter-Lexical-1.000-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sub-Exporter-Lexical;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sub-Exporter-Lexical}"
SRC_URI[x86_64_v2_perl-Sub-Exporter-Lexical.sha256sum] = "a89915014b258fa51540b934d3929293cf63e5858a70c4746c0b97d251219b90"

URI_aarch64_perl-Sub-Exporter-Lexical = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sub-Exporter-Lexical-1.000-1.el10_0.noarch.rpm;name=aarch64_perl-Sub-Exporter-Lexical;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sub-Exporter-Lexical}"
SRC_URI[aarch64_perl-Sub-Exporter-Lexical.sha256sum] = "dc0a96a6e26fe25d73be357e78e3a00c83bf20c60a4bb89c2757ee3a2267d109"

RDEPENDS:perl-Sub-Exporter-Lexical = " \
 perl-Sub-Exporter \
 perl-libs \
 "
