# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Bencode"
PV = "1.502"
PR = "7.el10_0"
PACKAGES = " \
 perl-Bencode \
 perl-Bencode-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Bencode-1.502-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ee382465349df8f53a521705b452e0f73f66d0da8347ca8028a25660bc30a16"

URI_x86_64_v2_perl-Bencode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Bencode-1.502-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Bencode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Bencode}"
SRC_URI[x86_64_v2_perl-Bencode.sha256sum] = "b6913480b3a34cb8f4a573bd54f5d0fec0cb48515ae9e6e089a3f1c02a21f0b1"

URI_x86_64_v2_perl-Bencode-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Bencode-tests-1.502-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Bencode-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Bencode-tests}"
SRC_URI[x86_64_v2_perl-Bencode-tests.sha256sum] = "c9c4d0001b1b2fc7d6c2facbc52697ca0e58ef06035c084cadd150cbfe184b2d"

URI_aarch64_perl-Bencode = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Bencode-1.502-7.el10_0.noarch.rpm;name=aarch64_perl-Bencode;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Bencode}"
SRC_URI[aarch64_perl-Bencode.sha256sum] = "717859b3c0f627a8656738945f43b12720399f1c829860075d8b6b64b2f80a12"

URI_aarch64_perl-Bencode-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Bencode-tests-1.502-7.el10_0.noarch.rpm;name=aarch64_perl-Bencode-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Bencode-tests}"
SRC_URI[aarch64_perl-Bencode-tests.sha256sum] = "e5d55535a5fc80ac14c4407362ffc93927772ed1aa0da8916db9f25d14d717b5"

RDEPENDS:perl-Bencode = " \
 perl-Exporter-Tidy \
 perl-libs \
 "
RDEPENDS:perl-Bencode-tests = " \
 bash \
 perl-Bencode \
 perl-Test-Differences \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
