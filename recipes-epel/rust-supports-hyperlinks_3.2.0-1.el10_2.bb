# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-supports-hyperlinks"
PV = "3.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-supports-hyperlinks+default-devel \
 rust-supports-hyperlinks-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-supports-hyperlinks-3.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3988b4238127334c39d7bed39d126151e6c222e0ebb900143f2673bca565f6e"

URI_x86_64_v2_rust-supports-hyperlinks+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-supports-hyperlinks+default-devel-3.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-supports-hyperlinks+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-supports-hyperlinks+default-devel}"
SRC_URI[x86_64_v2_rust-supports-hyperlinks+default-devel.sha256sum] = "b300fbe61903a438fb0312b52aadac3208b8ecef1c3aaf7d86a93f573696de88"

URI_x86_64_v2_rust-supports-hyperlinks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-supports-hyperlinks-devel-3.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-supports-hyperlinks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-supports-hyperlinks-devel}"
SRC_URI[x86_64_v2_rust-supports-hyperlinks-devel.sha256sum] = "478c53d239ec66c6b154ad0bfa11c6c82049b736e2d66b284d31b786d55d0319"

URI_aarch64_rust-supports-hyperlinks+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-supports-hyperlinks+default-devel-3.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-supports-hyperlinks+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-supports-hyperlinks+default-devel}"
SRC_URI[aarch64_rust-supports-hyperlinks+default-devel.sha256sum] = "faf841954f1dfa698b6b9b7980f2343685cf3bb2a51cbcb5bfbf271bca16b9ee"

URI_aarch64_rust-supports-hyperlinks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-supports-hyperlinks-devel-3.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-supports-hyperlinks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-supports-hyperlinks-devel}"
SRC_URI[aarch64_rust-supports-hyperlinks-devel.sha256sum] = "08a9b3216ebbd5c04ef85e7d69899e10cc7ac10d7d4e4c2a717cd06f945ae90a"

RDEPENDS:rust-supports-hyperlinks+default-devel = " \
 cargo \
 rust-supports-hyperlinks-devel \
 "
RDEPENDS:rust-supports-hyperlinks-devel = " \
 cargo \
 rust \
 "
