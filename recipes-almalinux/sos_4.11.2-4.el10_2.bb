# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sos"
PV = "4.11.2"
PR = "4.el10_2"
PACKAGES = " \
 sos \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sos-4.11.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c87a6f951d43d2cf4bf4933de6a6288129086f0e0d60eb5daaf43daf37d41bb0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sos-4.11.2-4.el10_2.noarch.rpm;name=x86_64_v2_sos;unpack=0"
SRC_URI[x86_64_v2_sos.sha256sum] = "d4c12494d880b33e97924b75f5dad3bf8f907d2015b7977d8bdce24ed2093622"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sos-4.11.2-4.el10_2.noarch.rpm;name=aarch64_sos;unpack=0"
SRC_URI[aarch64_sos.sha256sum] = "d4c12494d880b33e97924b75f5dad3bf8f907d2015b7977d8bdce24ed2093622"

RDEPENDS:sos = " \
 python3 \
 python3-packaging \
 python3-pexpect \
 python3-pyyaml \
 python3-requests \
 python3-setuptools \
 "
