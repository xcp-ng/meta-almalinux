# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-15-gcc"
PV = "15.2.1"
PR = "7.el10.alma.2"
PACKAGES:x86_64_v2 = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-gcc-c++ \
 gcc-toolset-15-gcc-gfortran \
 gcc-toolset-15-gcc-plugin-annobin \
 gcc-toolset-15-gcc-plugin-devel \
 gcc-toolset-15-libasan-devel \
 gcc-toolset-15-libatomic-devel \
 gcc-toolset-15-libgccjit \
 gcc-toolset-15-libgccjit-devel \
 gcc-toolset-15-libitm-devel \
 gcc-toolset-15-liblsan-devel \
 gcc-toolset-15-libquadmath-devel \
 gcc-toolset-15-libstdc++-devel \
 gcc-toolset-15-libstdc++-docs \
 gcc-toolset-15-libtsan-devel \
 gcc-toolset-15-libubsan-devel \
 gcc-toolset-15-offload-nvptx \
"
PACKAGES:aarch64 = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-gcc-c++ \
 gcc-toolset-15-gcc-gfortran \
 gcc-toolset-15-gcc-plugin-annobin \
 gcc-toolset-15-gcc-plugin-devel \
 gcc-toolset-15-libasan-devel \
 gcc-toolset-15-libatomic-devel \
 gcc-toolset-15-libgccjit \
 gcc-toolset-15-libgccjit-devel \
 gcc-toolset-15-libitm-devel \
 gcc-toolset-15-liblsan-devel \
 gcc-toolset-15-libstdc++-devel \
 gcc-toolset-15-libstdc++-docs \
 gcc-toolset-15-libtsan-devel \
 gcc-toolset-15-libubsan-devel \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-15-gcc-15.2.1-7.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab8ed656336fa301aaa8a944636901a8ef39a9cee9247fb43fe8f16a4445c233"

URI_x86_64_v2_gcc-toolset-15-gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc.sha256sum] = "54394d0cce59ca958827bfcd933bc72294d1a47ae9248b8e5c3dde3af3634bdd"

URI_x86_64_v2_gcc-toolset-15-gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-c++-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc-c++}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-c++.sha256sum] = "a5cebadc2a37fe6fd0ee8ab9cd2f4a838b461c4c6e98205e1719e1cec514429a"

URI_x86_64_v2_gcc-toolset-15-gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-gfortran-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc-gfortran}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-gfortran.sha256sum] = "aa175a6bad7a215ebbe6d85aa6f06e53d962c6fd1e9c731f3e47ebdd5fa25eb9"

URI_x86_64_v2_gcc-toolset-15-gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-plugin-annobin-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc-plugin-annobin}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-plugin-annobin.sha256sum] = "0214b44127bec874c90fcd26a4060b3cb49789d07bbc364679cd8887e85b7037"

URI_x86_64_v2_gcc-toolset-15-gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-gcc-plugin-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-gcc-plugin-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-gcc-plugin-devel.sha256sum] = "08f0e6cb7c42f1520534fbc0355363b8f6701c6162f9a96b7470f9bf8bbda134"

URI_x86_64_v2_gcc-toolset-15-libasan-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libasan-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libasan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libasan-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libasan-devel.sha256sum] = "27f42842ec59d335d0963e5ab0ffa1b3aad90923fd36a66341f671b56e69f3ca"

URI_x86_64_v2_gcc-toolset-15-libatomic-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libatomic-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libatomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libatomic-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libatomic-devel.sha256sum] = "afedbaab37160beaef565c561a9899e315417f45b8c6fd66e90bcd4fd482fd92"

URI_x86_64_v2_gcc-toolset-15-libgccjit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libgccjit-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libgccjit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libgccjit}"
SRC_URI[x86_64_v2_gcc-toolset-15-libgccjit.sha256sum] = "6da8c33d5a572ede03af2b7d122b1d0840b26ff8b616f00ec16dc24ef36a4913"
RPROVIDES:gcc-toolset-15-libgccjit:x86_64_v2 = "virtual/libgccjit.so.0___64bit_"

URI_x86_64_v2_gcc-toolset-15-libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libgccjit-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libgccjit-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libgccjit-devel.sha256sum] = "a48ff2de77771954927d7be3a8f210e8c01116595ad9af87aa39670acc484e56"

URI_x86_64_v2_gcc-toolset-15-libitm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libitm-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libitm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libitm-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libitm-devel.sha256sum] = "a2d44ea048942e27a8d233f942305bdb779c0f76379a65fce1726a0e20bc3a1d"

URI_x86_64_v2_gcc-toolset-15-liblsan-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-liblsan-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-liblsan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-liblsan-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-liblsan-devel.sha256sum] = "91827c9368159aee04cf1a8c0d293b4a468cc1d9e74af986ed41ba8af64c3aa7"

URI_x86_64_v2_gcc-toolset-15-libquadmath-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libquadmath-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libquadmath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libquadmath-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libquadmath-devel.sha256sum] = "817469db012b1ddf539fb2c317365072d426b510f43e2d44b38615ee7b8c28d3"

URI_x86_64_v2_gcc-toolset-15-libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libstdc++-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libstdc++-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libstdc++-devel.sha256sum] = "014cedcb46b44db5fa2f9828bc65e6235c2d6ffca100e93e411ed3aa29d9d1f7"

URI_x86_64_v2_gcc-toolset-15-libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libstdc++-docs-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libstdc++-docs}"
SRC_URI[x86_64_v2_gcc-toolset-15-libstdc++-docs.sha256sum] = "93844987056d78bfcf89466f3b3d9ca1fee1591dec5e7efed8850fcd700c4d5f"

URI_x86_64_v2_gcc-toolset-15-libtsan-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libtsan-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libtsan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libtsan-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libtsan-devel.sha256sum] = "8aa63c6a210cd0eb1f23f773394b4578ad4e40d87daa001a6265915e6b89a25b"

URI_x86_64_v2_gcc-toolset-15-libubsan-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-libubsan-devel-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-libubsan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-libubsan-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-libubsan-devel.sha256sum] = "d8bd9ec53196475fa1c647d482d51cf25a25ec86757b280e494537a9a1f65c28"

URI_x86_64_v2_gcc-toolset-15-offload-nvptx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-offload-nvptx-15.2.1-7.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-offload-nvptx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-offload-nvptx}"
SRC_URI[x86_64_v2_gcc-toolset-15-offload-nvptx.sha256sum] = "6cc6f531cc6120d6859149f50a358c2d40be869677c00e5db56ad236d61e1223"

URI_aarch64_gcc-toolset-15-gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc}"
SRC_URI[aarch64_gcc-toolset-15-gcc.sha256sum] = "bd9f1b5830d423f706b09ef2e4db530107aabcc9d3b8d95c9e475eb055897d3b"

URI_aarch64_gcc-toolset-15-gcc-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-c++-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc-c++}"
SRC_URI[aarch64_gcc-toolset-15-gcc-c++.sha256sum] = "8b36e75c55beb21fd5db26a62bb5e96910636dae48b843e87259e79be02a4e87"

URI_aarch64_gcc-toolset-15-gcc-gfortran = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-gfortran-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-gfortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc-gfortran}"
SRC_URI[aarch64_gcc-toolset-15-gcc-gfortran.sha256sum] = "d2561b67743c5d62b2966fd05c262091f3229d965afb562c5b7b3071e3274034"

URI_aarch64_gcc-toolset-15-gcc-plugin-annobin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-plugin-annobin-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-plugin-annobin;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc-plugin-annobin}"
SRC_URI[aarch64_gcc-toolset-15-gcc-plugin-annobin.sha256sum] = "4a29eea8c0539cba9235ada69da59f5d1fc70aaca1d628a9348a4892944d1783"

URI_aarch64_gcc-toolset-15-gcc-plugin-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-gcc-plugin-devel-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-gcc-plugin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-gcc-plugin-devel}"
SRC_URI[aarch64_gcc-toolset-15-gcc-plugin-devel.sha256sum] = "9108226da79f57c682118f8f92d1de1f9e3497e36117be034097893e670e146f"

URI_aarch64_gcc-toolset-15-libasan-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libasan-devel-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-libasan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libasan-devel}"
SRC_URI[aarch64_gcc-toolset-15-libasan-devel.sha256sum] = "8cd872e5cf8e076f1fd62d64bd52d2fd0d48d1bd720f901c9459f1de49879317"

URI_aarch64_gcc-toolset-15-libatomic-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libatomic-devel-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-libatomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libatomic-devel}"
SRC_URI[aarch64_gcc-toolset-15-libatomic-devel.sha256sum] = "b60b9988d968f7d440ae21006c4742130e368b3dd48eaa9d8ff8d3084f5f1859"

URI_aarch64_gcc-toolset-15-libgccjit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libgccjit-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-libgccjit;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libgccjit}"
SRC_URI[aarch64_gcc-toolset-15-libgccjit.sha256sum] = "e54c6d0d6654553e005862506891884617073367c4daf7ac05f0cd627e0ee7ca"
RPROVIDES:gcc-toolset-15-libgccjit:aarch64 = "virtual/libgccjit.so.0___64bit_"

URI_aarch64_gcc-toolset-15-libgccjit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libgccjit-devel-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-libgccjit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libgccjit-devel}"
SRC_URI[aarch64_gcc-toolset-15-libgccjit-devel.sha256sum] = "16c5f18809d8d31839711a1323fb8ee59d74729d15057f8e2d900ff29cc1de6c"

URI_aarch64_gcc-toolset-15-libitm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libitm-devel-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-libitm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libitm-devel}"
SRC_URI[aarch64_gcc-toolset-15-libitm-devel.sha256sum] = "c451fc8810bf84d2a7a31300a5a764dfe09f15bc4e967befd8c37ca49a230d5d"

URI_aarch64_gcc-toolset-15-liblsan-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-liblsan-devel-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-liblsan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-liblsan-devel}"
SRC_URI[aarch64_gcc-toolset-15-liblsan-devel.sha256sum] = "ab9ca388e8a0e0bb88a90c76d8acd2e823e17ca2ab43361a82df6a743d5528c0"

URI_aarch64_gcc-toolset-15-libstdc++-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libstdc++-devel-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libstdc++-devel}"
SRC_URI[aarch64_gcc-toolset-15-libstdc++-devel.sha256sum] = "08073edb32ce0b493f772df4377ea99b9a744e2cbacc4f37170ae16b19238621"

URI_aarch64_gcc-toolset-15-libstdc++-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libstdc++-docs-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-libstdc++-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libstdc++-docs}"
SRC_URI[aarch64_gcc-toolset-15-libstdc++-docs.sha256sum] = "da6e074fdac4b2f27bab4ba180cdf08313727918b96c71f64719516b0f38b789"

URI_aarch64_gcc-toolset-15-libtsan-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libtsan-devel-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-libtsan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libtsan-devel}"
SRC_URI[aarch64_gcc-toolset-15-libtsan-devel.sha256sum] = "6e21fabc5f1cc818883513a71fa6aba7272cea164ffe894bf6c31ef4d6631ba7"

URI_aarch64_gcc-toolset-15-libubsan-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-libubsan-devel-15.2.1-7.el10.alma.2.aarch64.rpm;name=aarch64_gcc-toolset-15-libubsan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-libubsan-devel}"
SRC_URI[aarch64_gcc-toolset-15-libubsan-devel.sha256sum] = "eb359d624e7dddc4b945ef0d1f0f96d6c1f089f1763e625c4502976b187e2a8f"

RDEPENDS:gcc-toolset-15-gcc:x86_64_v2 = " \
 bash \
 gcc-toolset-15-binutils \
 gcc-toolset-15-runtime \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc:aarch64 = " \
 gcc-toolset-15-binutils \
 gcc-toolset-15-runtime \
 glibc \
 glibc-devel \
 gmp \
 libgcc \
 libgomp \
 libmpc \
 libzstd \
 make \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-c++ = " \
 gcc-toolset-15-gcc \
 gcc-toolset-15-libstdc++-devel \
 glibc \
 gmp \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-gcc-gfortran:x86_64_v2 = " \
 bash \
 gcc-toolset-15-gcc \
 gcc-toolset-15-libquadmath-devel \
 glibc \
 gmp \
 info \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-gfortran:aarch64 = " \
 bash \
 gcc-toolset-15-gcc \
 glibc \
 gmp \
 info \
 libgfortran \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
"
RDEPENDS:gcc-toolset-15-gcc-plugin-annobin = " \
 gcc-toolset-15-gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gcc-toolset-15-gcc-plugin-devel = " \
 gcc-toolset-15-gcc \
 glibc \
 gmp-devel \
 libmpc-devel \
 mpfr-devel \
 "
RDEPENDS:gcc-toolset-15-libasan-devel = " \
 libasan \
 "
RDEPENDS:gcc-toolset-15-libatomic-devel = " \
 libatomic \
 "
RDEPENDS:gcc-toolset-15-libgccjit = " \
 gcc-toolset-15-gcc \
 glibc \
 gmp \
 libmpc \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-15-libgccjit-devel = " \
 gcc-toolset-15-libgccjit \
 "
RDEPENDS:gcc-toolset-15-libitm-devel = " \
 gcc-toolset-15-gcc \
 libitm \
 "
RDEPENDS:gcc-toolset-15-liblsan-devel = " \
 liblsan \
 "
RDEPENDS:gcc-toolset-15-libquadmath-devel = " \
 gcc-toolset-15-gcc \
 libquadmath \
 "
RDEPENDS:gcc-toolset-15-libstdc++-devel = " \
 libstdc++ \
 "
RDEPENDS:gcc-toolset-15-libstdc++-docs = " \
 "
RDEPENDS:gcc-toolset-15-libtsan-devel = " \
 libtsan \
 "
RDEPENDS:gcc-toolset-15-libubsan-devel = " \
 libubsan \
 "
RDEPENDS:gcc-toolset-15-offload-nvptx = " \
 gcc \
 glibc \
 gmp \
 libgcc \
 libgomp-offload-nvptx \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libgccjit.so.0___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libgccjit.so.0___64bit_"
