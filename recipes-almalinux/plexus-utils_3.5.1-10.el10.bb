# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-utils"
PV = "3.5.1"
PR = "10.el10"
PACKAGES = " \
 plexus-utils \
 plexus-utils-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plexus-utils-3.5.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "661e15052066b15f52abf2814441d77a3efc10159d9510cb61146d6475cb8b2c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plexus-utils-3.5.1-10.el10.noarch.rpm;name=x86_64_v2_plexus-utils;unpack=0"
SRC_URI[x86_64_v2_plexus-utils.sha256sum] = "3dc063d4c4deafa54aa322e9b9f44a426fc208cb43eb108c028d2b7fea42a9ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-utils-javadoc-3.5.1-10.el10.noarch.rpm;name=x86_64_v2_plexus-utils-javadoc;unpack=0"
SRC_URI[x86_64_v2_plexus-utils-javadoc.sha256sum] = "cbf43cafa8851fb50134b37fc88bef0f28fb8cacdcbcb67df3df9e6dc27e3fb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plexus-utils-3.5.1-10.el10.noarch.rpm;name=aarch64_plexus-utils;unpack=0"
SRC_URI[aarch64_plexus-utils.sha256sum] = "3dc063d4c4deafa54aa322e9b9f44a426fc208cb43eb108c028d2b7fea42a9ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-utils-javadoc-3.5.1-10.el10.noarch.rpm;name=aarch64_plexus-utils-javadoc;unpack=0"
SRC_URI[aarch64_plexus-utils-javadoc.sha256sum] = "cbf43cafa8851fb50134b37fc88bef0f28fb8cacdcbcb67df3df9e6dc27e3fb6"

RDEPENDS:plexus-utils = " \
 javapackages-filesystem \
 "
RDEPENDS:plexus-utils-javadoc = " \
 javapackages-filesystem \
 "
