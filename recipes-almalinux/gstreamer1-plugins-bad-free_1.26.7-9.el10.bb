# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-bad-free"
PV = "1.26.7"
PR = "9.el10"
PACKAGES = " \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-bad-free-1.26.7-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b8111d80ac9cf827c7b71d0f5189602a23856414eb79db3a7dab57cfad5be6e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-1.26.7-9.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free.sha256sum] = "cb2cedaf81ce2f739f9d547b60e60a869ebe1e1445aabfee2ca70dd3f2fc5e57"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-devel-1.26.7-9.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-devel.sha256sum] = "c50158c2f42addee1ee9692b374f3cbf4574ba5ef92dbafac0df9022799d0d95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-libs-1.26.7-9.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-libs.sha256sum] = "a2e6386008fa1db9c1330468c0c7659b1c4a563ac17a9b0e6b8cafcf5030f601"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-1.26.7-9.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-bad-free.sha256sum] = "63c12a7914cd5452bdd1c28625dd3fa4393d19a14fec4789cb4e393cb0b58331"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gstreamer1-plugins-bad-free-devel-1.26.7-9.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-devel.sha256sum] = "7e1c6b9a237116963dd328fc365644a6bc935b4f9858de79b06b72a1be1935fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-libs-1.26.7-9.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-libs.sha256sum] = "0d3606e8e7a795d348b33be204b149b6af46e2fe4ab79e7dbb2f1b2a5cfa5f44"

RDEPENDS:gstreamer1-plugins-bad-free = " \
 bzip2-libs \
 cairo \
 fdk-aac-free \
 glib2 \
 glibc \
 gsm \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk3 \
 json-glib \
 lcms2 \
 libdrm \
 libdvdnav \
 libdvdread \
 libgcc \
 libgudev \
 liblc3 \
 librsvg2 \
 libsndfile \
 libsrtp \
 libstdc++ \
 libusb1 \
 libva \
 libwayland-client \
 libwebp \
 libxml2 \
 openjpeg2 \
 openssl-libs \
 opus \
 orc \
 pango \
 soundtouch \
 vulkan-loader \
 webrtc-audio-processing \
 "
RDEPENDS:gstreamer1-plugins-bad-free-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base-devel \
 libdrm-devel \
 libva-devel \
 pkgconf-pkg-config \
 vulkan-loader-devel \
 wayland-devel \
 "
RDEPENDS:gstreamer1-plugins-bad-free-libs = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 libwayland-client \
 vulkan-loader \
 "
