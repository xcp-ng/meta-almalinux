# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpcbind"
PV = "1.2.7"
PR = "3.el10"
PACKAGES = " \
 rpcbind \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rpcbind-1.2.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ba30818cf49aa930175a845975a5b7d4dcda12234523db8b6f710c3aa918455"

URI_x86_64_v2_rpcbind = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpcbind-1.2.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_rpcbind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpcbind}"
SRC_URI[x86_64_v2_rpcbind.sha256sum] = "c18911716f741ff3c2dace229791088c7cfa39e8628668c491185804fcba717a"

URI_aarch64_rpcbind = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpcbind-1.2.7-3.el10.aarch64.rpm;name=aarch64_rpcbind;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpcbind}"
SRC_URI[aarch64_rpcbind.sha256sum] = "5202567a6bc0e9127bb84869ae52f30e581458ef3225bae3dfac7d9cb86206bf"

RDEPENDS:rpcbind = " \
 bash \
 glibc \
 glibc-common \
 libtirpc \
 setup \
 shadow-utils \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
