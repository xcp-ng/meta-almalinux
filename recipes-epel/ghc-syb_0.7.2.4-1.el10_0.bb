# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-syb"
PV = "0.7.2.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-syb \
 ghc-syb-devel \
 ghc-syb-doc \
 ghc-syb-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-syb-0.7.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8035c05ea594f03b3a09315a26b019534c9b420fc245f97a6b2f2f10e73da0a7"

URI_x86_64_v2_ghc-syb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-syb-0.7.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-syb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-syb}"
SRC_URI[x86_64_v2_ghc-syb.sha256sum] = "7193794643423006ea4a7ef4438deb48e71fa8ce15093e4a8a3ac2dea779976c"

URI_x86_64_v2_ghc-syb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-syb-devel-0.7.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-syb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-syb-devel}"
SRC_URI[x86_64_v2_ghc-syb-devel.sha256sum] = "b48df329eb1fe7aeaf9f20502bbfa01df0433e0866839ba8bcc79440401e54e2"

URI_x86_64_v2_ghc-syb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-syb-doc-0.7.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-syb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-syb-doc}"
SRC_URI[x86_64_v2_ghc-syb-doc.sha256sum] = "72a500a4d2d78c3e32aaa360e1c854ada8afad29462d936b8dfdcbe89bc88bfa"

URI_x86_64_v2_ghc-syb-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-syb-prof-0.7.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-syb-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-syb-prof}"
SRC_URI[x86_64_v2_ghc-syb-prof.sha256sum] = "49c9f3f2f054787160a4b758c99809c525dcd8148b553c75436755d9795c03ee"

URI_aarch64_ghc-syb = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-syb-0.7.2.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-syb;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-syb}"
SRC_URI[aarch64_ghc-syb.sha256sum] = "d607643f49e8515918a45f10a906e6c5d1c3b59a55b45ccb8a2a1934af8a7cd9"

URI_aarch64_ghc-syb-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-syb-devel-0.7.2.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-syb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-syb-devel}"
SRC_URI[aarch64_ghc-syb-devel.sha256sum] = "7d0a676005cce8971da21f8e49319509238c49c77fe949ed207c8abae2170651"

URI_aarch64_ghc-syb-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-syb-doc-0.7.2.4-1.el10_0.noarch.rpm;name=aarch64_ghc-syb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-syb-doc}"
SRC_URI[aarch64_ghc-syb-doc.sha256sum] = "0c34c35386eadbfabbd3d8bd519aa72c40a88c37e3fb17e254c1bd585c527565"

URI_aarch64_ghc-syb-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-syb-prof-0.7.2.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-syb-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-syb-prof}"
SRC_URI[aarch64_ghc-syb-prof.sha256sum] = "2e213e3e3dee887fa4615a7f195c98136ecc879d80af4092a01d217e11882700"

RDEPENDS:ghc-syb = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-syb-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-syb \
 "
RDEPENDS:ghc-syb-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-syb-prof = " \
 ghc-base-prof \
 ghc-syb-devel \
 "
