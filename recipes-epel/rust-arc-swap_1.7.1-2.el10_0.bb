# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arc-swap"
PV = "1.7.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-arc-swap+default-devel \
 rust-arc-swap+experimental-strategies-devel \
 rust-arc-swap+experimental-thread-local-devel \
 rust-arc-swap+internal-test-strategies-devel \
 rust-arc-swap+serde-devel \
 rust-arc-swap+weak-devel \
 rust-arc-swap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arc-swap-1.7.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecb48e0e2593f3e57236c76c5be106c13cf7a213e1fa9e58d532ff09583ec038"

URI_x86_64_v2_rust-arc-swap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+default-devel-1.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+default-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+default-devel.sha256sum] = "e2e4e03d647b3984dbcf764fdad4d7b7a19475b9822226bddf1ed0e3e3e5c05a"

URI_x86_64_v2_rust-arc-swap+experimental-strategies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+experimental-strategies-devel-1.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+experimental-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+experimental-strategies-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+experimental-strategies-devel.sha256sum] = "7334b058d34d2be10cbf20a6af5751a09b5925f5b6e12096f442790369c326a5"

URI_x86_64_v2_rust-arc-swap+experimental-thread-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+experimental-thread-local-devel-1.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+experimental-thread-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+experimental-thread-local-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+experimental-thread-local-devel.sha256sum] = "6d60bdf1d9fa513e4fc7b98a27293feb4c4f6a78f4e143ed461f9e44e5406c5c"

URI_x86_64_v2_rust-arc-swap+internal-test-strategies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+internal-test-strategies-devel-1.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+internal-test-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+internal-test-strategies-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+internal-test-strategies-devel.sha256sum] = "8c28ca6bd54690358eed34651656f92e0387619acac99ff16927b55ed748a833"

URI_x86_64_v2_rust-arc-swap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+serde-devel-1.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+serde-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+serde-devel.sha256sum] = "9f6ffe4013e44b9c6971b8a3fb5cb6e7d9d476ac176c13b5a7acb4d79c5cf448"

URI_x86_64_v2_rust-arc-swap+weak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap+weak-devel-1.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap+weak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap+weak-devel}"
SRC_URI[x86_64_v2_rust-arc-swap+weak-devel.sha256sum] = "7f0a2c2374abca5d29663ec5f465a71998ae21fe8cefe472d5c40cc39474f050"

URI_x86_64_v2_rust-arc-swap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arc-swap-devel-1.7.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arc-swap-devel}"
SRC_URI[x86_64_v2_rust-arc-swap-devel.sha256sum] = "1b9112eb067a4676cc89f825ce136ad874c121b44766838dc36666ad08bf132a"

URI_aarch64_rust-arc-swap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+default-devel-1.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-arc-swap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+default-devel}"
SRC_URI[aarch64_rust-arc-swap+default-devel.sha256sum] = "b662f386a2e29737f9e196907dc2ad576a657f803880e8d8d5b99f7ae7bed5a7"

URI_aarch64_rust-arc-swap+experimental-strategies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+experimental-strategies-devel-1.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-arc-swap+experimental-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+experimental-strategies-devel}"
SRC_URI[aarch64_rust-arc-swap+experimental-strategies-devel.sha256sum] = "9cc8dd05a0c4977e2a06e1c91a5fa1e30bce2c9adccc39be939ea959dc4599fd"

URI_aarch64_rust-arc-swap+experimental-thread-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+experimental-thread-local-devel-1.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-arc-swap+experimental-thread-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+experimental-thread-local-devel}"
SRC_URI[aarch64_rust-arc-swap+experimental-thread-local-devel.sha256sum] = "f3ab06b3caa6e538c206b1db48f1adcdf58210da1d49f35d28c7e1154831a151"

URI_aarch64_rust-arc-swap+internal-test-strategies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+internal-test-strategies-devel-1.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-arc-swap+internal-test-strategies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+internal-test-strategies-devel}"
SRC_URI[aarch64_rust-arc-swap+internal-test-strategies-devel.sha256sum] = "3b4a5ec472c796e5f4dc261bca80b027e65dd8f112f9f2f3da005363f83fe1fd"

URI_aarch64_rust-arc-swap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+serde-devel-1.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-arc-swap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+serde-devel}"
SRC_URI[aarch64_rust-arc-swap+serde-devel.sha256sum] = "b9faacca69e392030485f68c37f197039d76553e9ed67b31f327e638269e8f0f"

URI_aarch64_rust-arc-swap+weak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap+weak-devel-1.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-arc-swap+weak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap+weak-devel}"
SRC_URI[aarch64_rust-arc-swap+weak-devel.sha256sum] = "172e467069802ebab09f7791172c9dc8f7a38283355cfa7e99f570a1390efe28"

URI_aarch64_rust-arc-swap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arc-swap-devel-1.7.1-2.el10_0.noarch.rpm;name=aarch64_rust-arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arc-swap-devel}"
SRC_URI[aarch64_rust-arc-swap-devel.sha256sum] = "6fa85d44a28145674a56bcf3086c0c8403ca3b9f069d74e425740f6e14b45fac"

RDEPENDS:rust-arc-swap+default-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+experimental-strategies-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+experimental-thread-local-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+internal-test-strategies-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap+serde-devel = " \
 cargo \
 rust-arc-swap-devel \
 rust-serde+default-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-arc-swap+weak-devel = " \
 cargo \
 rust-arc-swap-devel \
 "
RDEPENDS:rust-arc-swap-devel = " \
 bash \
 cargo \
 "
