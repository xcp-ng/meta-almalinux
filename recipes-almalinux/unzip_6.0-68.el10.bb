# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unzip"
PV = "6.0"
PR = "68.el10"
PACKAGES = " \
 unzip \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/unzip-6.0-68.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "105b989e884c15523b13a95502103110dbc71fc5d8ff01f7730466215dcf09d2"

URI_x86_64_v2_unzip = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unzip-6.0-68.el10.x86_64_v2.rpm;name=x86_64_v2_unzip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unzip}"
SRC_URI[x86_64_v2_unzip.sha256sum] = "61fe741d79502002f0fa00d129635e43ab528cac2f8133a5c566edb032714f72"

URI_aarch64_unzip = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unzip-6.0-68.el10.aarch64.rpm;name=aarch64_unzip;unpack=0"
SRC_URI:append = " ${URI_aarch64_unzip}"
SRC_URI[aarch64_unzip.sha256sum] = "a09f861ae0614880729e3c303865a25825bcc38d885aaa57dfcb56f7a3f3f343"

RDEPENDS:unzip = " \
 bash \
 bzip2-libs \
 glibc \
 "
