# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-postcard"
PV = "1.1.3"
PR = "4.el10_1"
PACKAGES = " \
 rust-postcard+alloc-devel \
 rust-postcard+core-num-saturating-devel \
 rust-postcard+crc-devel \
 rust-postcard+default-devel \
 rust-postcard+experimental-derive-devel \
 rust-postcard+heapless-cas-devel \
 rust-postcard+heapless-devel \
 rust-postcard+nalgebra-v0_33-devel \
 rust-postcard+nalgebra_v0_33-devel \
 rust-postcard+paste-devel \
 rust-postcard+postcard-derive-devel \
 rust-postcard+use-crc-devel \
 rust-postcard+use-std-devel \
 rust-postcard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-postcard-1.1.3-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7906fa5a906dd520dd51f2416902cc3e19e7be7be919a43f035198f71e1106a"

URI_x86_64_v2_rust-postcard+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+alloc-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+alloc-devel}"
SRC_URI[x86_64_v2_rust-postcard+alloc-devel.sha256sum] = "58bd59b4db9933e7a3be56eda68988c495bb7060439b419b7e89f6037bf0aeae"

URI_x86_64_v2_rust-postcard+core-num-saturating-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+core-num-saturating-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+core-num-saturating-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+core-num-saturating-devel}"
SRC_URI[x86_64_v2_rust-postcard+core-num-saturating-devel.sha256sum] = "5b5d3223ebbe4b7cb0896df1b1de4d7cc6a70414ad32c876458ba9ebe605e341"

URI_x86_64_v2_rust-postcard+crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+crc-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+crc-devel}"
SRC_URI[x86_64_v2_rust-postcard+crc-devel.sha256sum] = "46af183d4453fa2b35ad186640c97e06f9cd0afb721694e41b740a776445cef7"

URI_x86_64_v2_rust-postcard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+default-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+default-devel}"
SRC_URI[x86_64_v2_rust-postcard+default-devel.sha256sum] = "9aaef75b7ad085decda709400c186ec0246ae8aedd09b4aaf5c860a666679d0c"

URI_x86_64_v2_rust-postcard+experimental-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+experimental-derive-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+experimental-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+experimental-derive-devel}"
SRC_URI[x86_64_v2_rust-postcard+experimental-derive-devel.sha256sum] = "3ee23bec34611e98dad375534499143923c46ca38528ed7edf7ce13a1628e41e"

URI_x86_64_v2_rust-postcard+heapless-cas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+heapless-cas-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+heapless-cas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+heapless-cas-devel}"
SRC_URI[x86_64_v2_rust-postcard+heapless-cas-devel.sha256sum] = "8ad82c5e227a0e11e4569e301a1a7e4087f863a91de637e0d5ff3809cb25da66"

URI_x86_64_v2_rust-postcard+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+heapless-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+heapless-devel}"
SRC_URI[x86_64_v2_rust-postcard+heapless-devel.sha256sum] = "4e466da4777649224d74bb855ea6ceeb6d20915340a9d20a97898a5c88593c7a"

URI_x86_64_v2_rust-postcard+nalgebra-v0_33-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+nalgebra-v0_33-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+nalgebra-v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+nalgebra-v0_33-devel}"
SRC_URI[x86_64_v2_rust-postcard+nalgebra-v0_33-devel.sha256sum] = "d4ed37e902b24b0a4833246c4f694d4f7449365177c9ce2de7080a6a9bf89f3a"

URI_x86_64_v2_rust-postcard+nalgebra_v0_33-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+nalgebra_v0_33-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+nalgebra_v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+nalgebra_v0_33-devel}"
SRC_URI[x86_64_v2_rust-postcard+nalgebra_v0_33-devel.sha256sum] = "a26216c90304e1b8fb1f4f2654b5fb34244f253b343bdf2b0c4abd0c492332d1"

URI_x86_64_v2_rust-postcard+paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+paste-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+paste-devel}"
SRC_URI[x86_64_v2_rust-postcard+paste-devel.sha256sum] = "54d9acebac058efe6183db903e6b3c00b714e62dad8e486f0dc91696e10a565d"

URI_x86_64_v2_rust-postcard+postcard-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+postcard-derive-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+postcard-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+postcard-derive-devel}"
SRC_URI[x86_64_v2_rust-postcard+postcard-derive-devel.sha256sum] = "0bf3ae61632f19a516bfbaba7532ce331ffc2fc4763f106919d714c710260723"

URI_x86_64_v2_rust-postcard+use-crc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+use-crc-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+use-crc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+use-crc-devel}"
SRC_URI[x86_64_v2_rust-postcard+use-crc-devel.sha256sum] = "5fec9695b85da81c9b5a29b6e33400e5b6de69750b31b39d81992556e6465516"

URI_x86_64_v2_rust-postcard+use-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard+use-std-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard+use-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard+use-std-devel}"
SRC_URI[x86_64_v2_rust-postcard+use-std-devel.sha256sum] = "ec6efd75605826149034d36df5e9c3366f035849f8ae52825723fe5fa56a2e81"

URI_x86_64_v2_rust-postcard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-postcard-devel-1.1.3-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-postcard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-postcard-devel}"
SRC_URI[x86_64_v2_rust-postcard-devel.sha256sum] = "11ce9b9db272573ad5f33913a4b84ceea7ad4350da96c33e53bb6a23a286002e"

URI_aarch64_rust-postcard+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+alloc-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+alloc-devel}"
SRC_URI[aarch64_rust-postcard+alloc-devel.sha256sum] = "53c67b11118ea3a5995213dae30f98d908dace3d3f235a778f52014b3f36888e"

URI_aarch64_rust-postcard+core-num-saturating-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+core-num-saturating-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+core-num-saturating-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+core-num-saturating-devel}"
SRC_URI[aarch64_rust-postcard+core-num-saturating-devel.sha256sum] = "d4e46260b96c5783ee0620b198c5affcf7ce716fbfed964a85064751bf25056a"

URI_aarch64_rust-postcard+crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+crc-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+crc-devel}"
SRC_URI[aarch64_rust-postcard+crc-devel.sha256sum] = "805c31b806425979a60a55e50d67fae6587f43dc7f263b1e3c61368b317880ee"

URI_aarch64_rust-postcard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+default-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+default-devel}"
SRC_URI[aarch64_rust-postcard+default-devel.sha256sum] = "5a4a5e1b5e15b617ccfbdcecb82f699b540c19facb08d02b64223973b41c06c8"

URI_aarch64_rust-postcard+experimental-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+experimental-derive-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+experimental-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+experimental-derive-devel}"
SRC_URI[aarch64_rust-postcard+experimental-derive-devel.sha256sum] = "cb37bbf26b496d3b7fe05aaf37084f877584a77145457e04743e6f5f3695a869"

URI_aarch64_rust-postcard+heapless-cas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+heapless-cas-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+heapless-cas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+heapless-cas-devel}"
SRC_URI[aarch64_rust-postcard+heapless-cas-devel.sha256sum] = "0a1c49074d9debaf75012f7c6bf8583c7f2fe7de1e9e85d47a1621189f547d32"

URI_aarch64_rust-postcard+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+heapless-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+heapless-devel}"
SRC_URI[aarch64_rust-postcard+heapless-devel.sha256sum] = "db407f55b42b57b6dbe79a839780b804a3c9646b6d7c3721672ab6730f7ad421"

URI_aarch64_rust-postcard+nalgebra-v0_33-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+nalgebra-v0_33-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+nalgebra-v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+nalgebra-v0_33-devel}"
SRC_URI[aarch64_rust-postcard+nalgebra-v0_33-devel.sha256sum] = "b5a8383e4b15a4fe517dbe0bbb04f3053873503f97dbaa5eb097a1f9088e4fe3"

URI_aarch64_rust-postcard+nalgebra_v0_33-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+nalgebra_v0_33-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+nalgebra_v0_33-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+nalgebra_v0_33-devel}"
SRC_URI[aarch64_rust-postcard+nalgebra_v0_33-devel.sha256sum] = "c568153430b3edee193fd725483bfa387fb19c805578c2e127fffb70d06d0712"

URI_aarch64_rust-postcard+paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+paste-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+paste-devel}"
SRC_URI[aarch64_rust-postcard+paste-devel.sha256sum] = "1ddacef2dfbadf61825f476933775b2c871d7c538b8cd7af83ed3c51f3d0e615"

URI_aarch64_rust-postcard+postcard-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+postcard-derive-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+postcard-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+postcard-derive-devel}"
SRC_URI[aarch64_rust-postcard+postcard-derive-devel.sha256sum] = "b7690897f986e368ac9461b80062589b423e732136b2f66c9ec0791bce8c4f06"

URI_aarch64_rust-postcard+use-crc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+use-crc-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+use-crc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+use-crc-devel}"
SRC_URI[aarch64_rust-postcard+use-crc-devel.sha256sum] = "d210227e60695ce15a4754992b9eaa9d849c069929eb0420cb130864fbb3e527"

URI_aarch64_rust-postcard+use-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard+use-std-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard+use-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard+use-std-devel}"
SRC_URI[aarch64_rust-postcard+use-std-devel.sha256sum] = "28e2973d0a5822b542c44e4c32a0a3ae6d2b69ef6f9ee5b52efba615a9622e20"

URI_aarch64_rust-postcard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-postcard-devel-1.1.3-4.el10_1.noarch.rpm;name=aarch64_rust-postcard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-postcard-devel}"
SRC_URI[aarch64_rust-postcard-devel.sha256sum] = "56f89757ccb1ef1647bfd98faa4f355a184a5b635b3f4ab129083a2309e1004e"

RDEPENDS:rust-postcard+alloc-devel = " \
 cargo \
 rust-postcard-devel \
 rust-serde+alloc-devel \
 "
RDEPENDS:rust-postcard+core-num-saturating-devel = " \
 cargo \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+crc-devel = " \
 cargo \
 rust-crc+default-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+default-devel = " \
 cargo \
 rust-postcard+heapless-cas-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+experimental-derive-devel = " \
 cargo \
 rust-postcard+postcard-derive-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+heapless-cas-devel = " \
 cargo \
 rust-heapless0.7+cas-devel \
 rust-heapless0.7+serde-devel \
 rust-heapless0.7-devel \
 rust-postcard+heapless-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+heapless-devel = " \
 cargo \
 rust-heapless0.7+serde-devel \
 rust-heapless0.7-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+nalgebra-v0_33-devel = " \
 cargo \
 rust-postcard+nalgebra_v0_33-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+nalgebra_v0_33-devel = " \
 cargo \
 rust-nalgebra-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+paste-devel = " \
 cargo \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+postcard-derive-devel = " \
 cargo \
 rust-postcard-derive+default-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+use-crc-devel = " \
 cargo \
 rust-postcard+crc-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-postcard+use-std-devel = " \
 cargo \
 rust-postcard+alloc-devel \
 rust-postcard-devel \
 rust-serde+std-devel \
 "
RDEPENDS:rust-postcard-devel = " \
 cargo \
 rust-cobs-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
