# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-beanutils"
PV = "1.9.4"
PR = "21.el10_0"
PACKAGES = " \
 apache-commons-beanutils \
 apache-commons-beanutils-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/apache-commons-beanutils-1.9.4-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83da17e8a2d57e6fae25752a8e6e975153fad9cd9f7af9d5436d4002a8229c67"

URI_x86_64_v2_apache-commons-beanutils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-beanutils-1.9.4-21.el10_0.noarch.rpm;name=x86_64_v2_apache-commons-beanutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-beanutils}"
SRC_URI[x86_64_v2_apache-commons-beanutils.sha256sum] = "4059e83bd50b918c71843552d88feb350b7b2efd37d4d1f85f281258f57bdba1"

URI_x86_64_v2_apache-commons-beanutils-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-beanutils-javadoc-1.9.4-21.el10_0.noarch.rpm;name=x86_64_v2_apache-commons-beanutils-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-beanutils-javadoc}"
SRC_URI[x86_64_v2_apache-commons-beanutils-javadoc.sha256sum] = "b87046c6aefd71b034500295acb0a9bf964dcd44c15debd74be8fabf18b2b32b"

URI_aarch64_apache-commons-beanutils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-beanutils-1.9.4-21.el10_0.noarch.rpm;name=aarch64_apache-commons-beanutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-beanutils}"
SRC_URI[aarch64_apache-commons-beanutils.sha256sum] = "4059e83bd50b918c71843552d88feb350b7b2efd37d4d1f85f281258f57bdba1"

URI_aarch64_apache-commons-beanutils-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-beanutils-javadoc-1.9.4-21.el10_0.noarch.rpm;name=aarch64_apache-commons-beanutils-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-beanutils-javadoc}"
SRC_URI[aarch64_apache-commons-beanutils-javadoc.sha256sum] = "b87046c6aefd71b034500295acb0a9bf964dcd44c15debd74be8fabf18b2b32b"

RDEPENDS:apache-commons-beanutils = " \
 apache-commons-collections \
 apache-commons-logging \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-beanutils-javadoc = " \
 javapackages-filesystem \
 "
