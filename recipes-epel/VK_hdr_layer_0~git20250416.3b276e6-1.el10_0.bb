# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "VK_hdr_layer"
PV = "0~git20250416.3b276e6"
PR = "1.el10_0"
PACKAGES = " \
 VK_hdr_layer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/VK_hdr_layer-0~git20250416.3b276e6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0c4a4938544a3fa7c46d44cbc167cc7e2d332c030d17d2dfb7f5538a1132e16"

URI_x86_64_v2_VK_hdr_layer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/VK_hdr_layer-0~git20250416.3b276e6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_VK_hdr_layer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_VK_hdr_layer}"
SRC_URI[x86_64_v2_VK_hdr_layer.sha256sum] = "393955c85c897852be8a005ff179db5c0bcedd32bb0adcb7ea909840e50a6426"

URI_aarch64_VK_hdr_layer = "${EPEL_MIRROR}/aarch64/Packages/v/VK_hdr_layer-0~git20250416.3b276e6-1.el10_0.aarch64.rpm;name=aarch64_VK_hdr_layer;unpack=0"
SRC_URI:append = " ${URI_aarch64_VK_hdr_layer}"
SRC_URI[aarch64_VK_hdr_layer.sha256sum] = "eae9322ab1d63cf48fadb27fac910337fe357603c1121955e8be811149caf76b"

RDEPENDS:VK_hdr_layer = " \
 glibc \
 libgcc \
 libstdc++ \
 libwayland-client \
 "
