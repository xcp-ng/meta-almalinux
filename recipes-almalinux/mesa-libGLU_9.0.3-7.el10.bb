# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa-libGLU"
PV = "9.0.3"
PR = "7.el10"
PACKAGES = " \
 mesa-libGLU \
 mesa-libGLU-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-libGLU-9.0.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9359b902de2431cc9a9690976b2393a198a4b5bcdad8f7cb1b6e2a77a9f232fb"

URI_x86_64_v2_mesa-libGLU = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGLU-9.0.3-7.el10.x86_64_v2.rpm;name=x86_64_v2_mesa-libGLU;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGLU}"
SRC_URI[x86_64_v2_mesa-libGLU.sha256sum] = "4c6354a534a50aab3e939227021dcc7023ac031683aa26ca34168214a0b40b97"

URI_x86_64_v2_mesa-libGLU-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGLU-devel-9.0.3-7.el10.x86_64_v2.rpm;name=x86_64_v2_mesa-libGLU-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGLU-devel}"
SRC_URI[x86_64_v2_mesa-libGLU-devel.sha256sum] = "6b199fa6d4a19f013098e67d1a0bfcefb45dbffd3fe4dd483b70ad4cd9edafa1"

URI_aarch64_mesa-libGLU = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGLU-9.0.3-7.el10.aarch64.rpm;name=aarch64_mesa-libGLU;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGLU}"
SRC_URI[aarch64_mesa-libGLU.sha256sum] = "bb6cf41eb1bc8445caeec6c3f14478e210061e05dea7a4ecf91cb275ab3c1d1b"

URI_aarch64_mesa-libGLU-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGLU-devel-9.0.3-7.el10.aarch64.rpm;name=aarch64_mesa-libGLU-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGLU-devel}"
SRC_URI[aarch64_mesa-libGLU-devel.sha256sum] = "618ee344e9e40af72ca2b2d574c857ecaf955b1b9538962f4d903506a424f861"

RDEPENDS:mesa-libGLU = " \
 glibc \
 libgcc \
 libglvnd-opengl \
 libstdc++ \
 "
RDEPENDS:mesa-libGLU-devel = " \
 libglvnd-devel \
 mesa-libGLU \
 pkgconf-pkg-config \
 "
