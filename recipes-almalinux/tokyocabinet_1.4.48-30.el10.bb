# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tokyocabinet"
PV = "1.4.48"
PR = "30.el10"
PACKAGES = " \
 tokyocabinet \
 tokyocabinet-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tokyocabinet-1.4.48-30.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8996f478abf5cc081ef25c1b1464e12b2b97765d40391d9a7e48c296f3d33d60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tokyocabinet-1.4.48-30.el10.x86_64_v2.rpm;name=x86_64_v2_tokyocabinet;unpack=0"
SRC_URI[x86_64_v2_tokyocabinet.sha256sum] = "f7e889f1e6b46a0acf67e804b18efd529b69c553de0fa6942f74109ae12fdafa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tokyocabinet-devel-1.4.48-30.el10.x86_64_v2.rpm;name=x86_64_v2_tokyocabinet-devel;unpack=0"
SRC_URI[x86_64_v2_tokyocabinet-devel.sha256sum] = "282726b50d52195b6ad0030670d4255f590dc3141f1f06f14b0e849c00d92d15"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tokyocabinet-1.4.48-30.el10.aarch64.rpm;name=aarch64_tokyocabinet;unpack=0"
SRC_URI[aarch64_tokyocabinet.sha256sum] = "16102a4ab780a20134832337161bfc77a69c37f8d1bec1288dca8085ed45fbbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tokyocabinet-devel-1.4.48-30.el10.aarch64.rpm;name=aarch64_tokyocabinet-devel;unpack=0"
SRC_URI[aarch64_tokyocabinet-devel.sha256sum] = "90319cdbea98cedfcd668cc82bcdfe4cd7ff83ff5de323d76e9a4e6dd02b7fa3"

RDEPENDS:tokyocabinet = " \
 bzip2-libs \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:tokyocabinet-devel = " \
 pkgconf-pkg-config \
 tokyocabinet \
 "
