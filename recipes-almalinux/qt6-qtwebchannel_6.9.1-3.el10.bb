# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebchannel"
PV = "6.9.1"
PR = "3.el10"
PACKAGES = " \
 qt6-qtwebchannel \
 qt6-qtwebchannel-devel \
 qt6-qtwebchannel-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtwebchannel-6.9.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7a0e45a3536c30aca18b85c45a1a9755c5f30244c06df548f203f3391bdfaad"

URI_x86_64_v2_qt6-qtwebchannel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebchannel-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebchannel}"
SRC_URI[x86_64_v2_qt6-qtwebchannel.sha256sum] = "62d8853e64c88f773fa11e7c949f9b58e02b53c9181201303eb2dcd626a335a1"

URI_x86_64_v2_qt6-qtwebchannel-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebchannel-devel-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebchannel-devel}"
SRC_URI[x86_64_v2_qt6-qtwebchannel-devel.sha256sum] = "bf0f947743268fd4c37453816f57af4ee185dcee3f18618a334f9b57d73ac599"

URI_x86_64_v2_qt6-qtwebchannel-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtwebchannel-examples-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebchannel-examples}"
SRC_URI[x86_64_v2_qt6-qtwebchannel-examples.sha256sum] = "3f4087c453e19936e0223e70d46b22866b740deca8f93997f57a2d0c32b45650"

URI_aarch64_qt6-qtwebchannel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebchannel-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtwebchannel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebchannel}"
SRC_URI[aarch64_qt6-qtwebchannel.sha256sum] = "c7dc81ae8cdbc3690cdef640ac95447da1879fafc999f534b7ac0e65a18dbd34"

URI_aarch64_qt6-qtwebchannel-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebchannel-devel-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtwebchannel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebchannel-devel}"
SRC_URI[aarch64_qt6-qtwebchannel-devel.sha256sum] = "7549dee142096a89980e7c46ab68b93ce2d9aad2820ebd3af9d1cd3c67af65be"

URI_aarch64_qt6-qtwebchannel-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtwebchannel-examples-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtwebchannel-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebchannel-examples}"
SRC_URI[aarch64_qt6-qtwebchannel-examples.sha256sum] = "b80a995878d5605441456a429624af1d8c644ae72bd6c3d8c1abe498310d3e6b"

RDEPENDS:qt6-qtwebchannel = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtwebchannel-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtwebchannel \
 "
RDEPENDS:qt6-qtwebchannel-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtwebchannel \
 qt6-qtwebsockets \
 "
