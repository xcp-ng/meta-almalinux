# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "emacs"
PE = "1"
PV = "29.4"
PR = "13.el10_2"
PACKAGES = " \
 emacs \
 emacs-common \
 emacs-filesystem \
 emacs-lucid \
 emacs-nw \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/emacs-29.4-13.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85d8701490d9962b7eb815ba0c0213eb7f3e751879d3cbc9903f543e54099741"

URI_x86_64_v2_emacs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-29.4-13.el10_2.x86_64_v2.rpm;name=x86_64_v2_emacs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs}"
SRC_URI[x86_64_v2_emacs.sha256sum] = "e3c9e3b05bb4374fb87d5e0d830e11553189215384f31ca891aa0562fe49e304"
RPROVIDES:emacs:x86_64_v2 = "virtual/emacs_bin__ge_29.4"

URI_x86_64_v2_emacs-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-common-29.4-13.el10_2.x86_64_v2.rpm;name=x86_64_v2_emacs-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-common}"
SRC_URI[x86_64_v2_emacs-common.sha256sum] = "ca9d4cbe704e3452ae04e1cb577fb530800b76c0a9c22fc8721302e0027e720c"

URI_x86_64_v2_emacs-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/emacs-filesystem-29.4-13.el10_2.noarch.rpm;name=x86_64_v2_emacs-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-filesystem}"
SRC_URI[x86_64_v2_emacs-filesystem.sha256sum] = "a095d2062cdbe41da409d71e5554a5f43cf9b613a9c1a8b8944080fc1e79407a"

URI_x86_64_v2_emacs-lucid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-lucid-29.4-13.el10_2.x86_64_v2.rpm;name=x86_64_v2_emacs-lucid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-lucid}"
SRC_URI[x86_64_v2_emacs-lucid.sha256sum] = "ec29269d2ef876fc7368f507b43699efc7c86b8b222b5e3a7c4e887a1c50f5ce"
RPROVIDES:emacs-lucid:x86_64_v2 = "virtual/emacs_bin__ge_29.4"

URI_x86_64_v2_emacs-nw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/emacs-nw-29.4-13.el10_2.x86_64_v2.rpm;name=x86_64_v2_emacs-nw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_emacs-nw}"
SRC_URI[x86_64_v2_emacs-nw.sha256sum] = "a84bf02b319721900fbf77f119802a00c6a0f939fdc5e0eb0f1ee9d29ebb34bd"
RPROVIDES:emacs-nw:x86_64_v2 = "virtual/emacs_bin__ge_29.4"

URI_aarch64_emacs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-29.4-13.el10_2.aarch64.rpm;name=aarch64_emacs;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs}"
SRC_URI[aarch64_emacs.sha256sum] = "ed693da59922a6f8e02c5509222edcc5bd61ab3f627bb663b7653663cac1132b"
RPROVIDES:emacs:aarch64 = "virtual/emacs_bin__ge_29.4"

URI_aarch64_emacs-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-common-29.4-13.el10_2.aarch64.rpm;name=aarch64_emacs-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-common}"
SRC_URI[aarch64_emacs-common.sha256sum] = "a8287950ca683c4b89ae873b5a28d1761437d853e0bc140e28c38d1e16a6e56f"

URI_aarch64_emacs-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/emacs-filesystem-29.4-13.el10_2.noarch.rpm;name=aarch64_emacs-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-filesystem}"
SRC_URI[aarch64_emacs-filesystem.sha256sum] = "a095d2062cdbe41da409d71e5554a5f43cf9b613a9c1a8b8944080fc1e79407a"

URI_aarch64_emacs-lucid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-lucid-29.4-13.el10_2.aarch64.rpm;name=aarch64_emacs-lucid;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-lucid}"
SRC_URI[aarch64_emacs-lucid.sha256sum] = "8fe8446ea4269636714e8eb0505a8fbba4c17a3c44cabcb5d8890be785f91657"
RPROVIDES:emacs-lucid:aarch64 = "virtual/emacs_bin__ge_29.4"

URI_aarch64_emacs-nw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/emacs-nw-29.4-13.el10_2.aarch64.rpm;name=aarch64_emacs-nw;unpack=0"
SRC_URI:append = " ${URI_aarch64_emacs-nw}"
SRC_URI[aarch64_emacs-nw.sha256sum] = "d6bf8418731a0d74e0c2088b974e2b4c79e070e69f3c6806c0461d45d844e300"
RPROVIDES:emacs-nw:aarch64 = "virtual/emacs_bin__ge_29.4"

RDEPENDS:emacs = " \
 alsa-lib \
 alternatives \
 bash \
 cairo \
 dbus-libs \
 emacs-common \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 giflib \
 glib2 \
 glibc \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 gtk3 \
 harfbuzz \
 jansson \
 libacl \
 libgcc \
 libjpeg-turbo \
 libotf \
 libpng \
 librsvg2 \
 libselinux \
 libtiff \
 libtree-sitter \
 libwebp \
 libxml2 \
 ncurses-libs \
 pango \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:emacs-common = " \
 alternatives \
 bash \
 emacs-filesystem \
 glibc \
 libgccjit \
 libtree-sitter \
 pkgconf-pkg-config \
 "
RDEPENDS:emacs-filesystem = " \
 "
RDEPENDS:emacs-lucid = " \
 Xaw3d \
 alsa-lib \
 alternatives \
 bash \
 cairo \
 dbus-libs \
 emacs-common \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 giflib \
 glib2 \
 glibc \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 harfbuzz \
 jansson \
 libICE \
 libSM \
 libX11 \
 libXcomposite \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXmu \
 libXpm \
 libXrandr \
 libXrender \
 libXt \
 libacl \
 libgcc \
 libjpeg-turbo \
 libotf \
 libpng \
 librsvg2 \
 libselinux \
 libtiff \
 libtree-sitter \
 libwebp \
 libxml2 \
 m17n-lib \
 ncurses-libs \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:emacs-nw = " \
 alsa-lib \
 alternatives \
 bash \
 dbus-libs \
 emacs-common \
 glibc \
 gnutls \
 jansson \
 libacl \
 libgcc \
 libselinux \
 libtree-sitter \
 libxml2 \
 ncurses-libs \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/emacs_bin__ge_29.4"

PROVIDES:append:aarch64 = " rpm/virtual/emacs_bin__ge_29.4"
