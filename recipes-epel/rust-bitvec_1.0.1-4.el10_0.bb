# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitvec"
PV = "1.0.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-bitvec+alloc-devel \
 rust-bitvec+atomic-devel \
 rust-bitvec+default-devel \
 rust-bitvec+serde-devel \
 rust-bitvec+std-devel \
 rust-bitvec+testing-devel \
 rust-bitvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitvec-1.0.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19dcb50cae18dd613f8b150a6fcbf0f67b47d19250685b8cea41437b1736b2a2"

URI_x86_64_v2_rust-bitvec+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec+alloc-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec+alloc-devel}"
SRC_URI[x86_64_v2_rust-bitvec+alloc-devel.sha256sum] = "58539675acacda8d3dfff6fe52102c0ebe6e75b99a85584b926ea76ed6132255"

URI_x86_64_v2_rust-bitvec+atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec+atomic-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec+atomic-devel}"
SRC_URI[x86_64_v2_rust-bitvec+atomic-devel.sha256sum] = "1c1d8bdbf988ee7ee078d50eb4c48d97a4a434eb599d14c7ed848cf3fb35a5fa"

URI_x86_64_v2_rust-bitvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec+default-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec+default-devel}"
SRC_URI[x86_64_v2_rust-bitvec+default-devel.sha256sum] = "ea4fa92d3946f4b1d845b318782d469cd4ec436dccea51790532a4794cfe9b7a"

URI_x86_64_v2_rust-bitvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec+serde-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec+serde-devel}"
SRC_URI[x86_64_v2_rust-bitvec+serde-devel.sha256sum] = "e21d9a66807bd64fa06c214c4e111cf96a5ee4bb72e2fd57ff65ea6ce723d215"

URI_x86_64_v2_rust-bitvec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec+std-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec+std-devel}"
SRC_URI[x86_64_v2_rust-bitvec+std-devel.sha256sum] = "d11886caa54ae58e48f394292c7bb0fb4613e523928d2734b580305f15405a5b"

URI_x86_64_v2_rust-bitvec+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec+testing-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec+testing-devel}"
SRC_URI[x86_64_v2_rust-bitvec+testing-devel.sha256sum] = "1df520b5f5c797a64518eb12a51383236e78f9fa8ced0fada05f0a3b1f344cdc"

URI_x86_64_v2_rust-bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec-devel}"
SRC_URI[x86_64_v2_rust-bitvec-devel.sha256sum] = "b45f161e7ea0be7c2373bc392009cc1e4b97cddac2ccadb7245ee40f8fcb87ff"

URI_aarch64_rust-bitvec+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec+alloc-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-bitvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec+alloc-devel}"
SRC_URI[aarch64_rust-bitvec+alloc-devel.sha256sum] = "fa8c7027cf3fb7c8d0c21bbc1f67e92cdec3906222f5c3314943683a2afe8838"

URI_aarch64_rust-bitvec+atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec+atomic-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-bitvec+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec+atomic-devel}"
SRC_URI[aarch64_rust-bitvec+atomic-devel.sha256sum] = "78a8d38696028616beb96d444cc9b57f31fdaba18c14f6a80246ce03c2a301d0"

URI_aarch64_rust-bitvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec+default-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-bitvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec+default-devel}"
SRC_URI[aarch64_rust-bitvec+default-devel.sha256sum] = "88ab94e88ace58ee5a6001df2808be4e76b266f390f581879ac5ea249b0c94fe"

URI_aarch64_rust-bitvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec+serde-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-bitvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec+serde-devel}"
SRC_URI[aarch64_rust-bitvec+serde-devel.sha256sum] = "debf43ac30d1d80a18bd9585f0e956aa8204cb943ba8c117d2b8a8462450d495"

URI_aarch64_rust-bitvec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec+std-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-bitvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec+std-devel}"
SRC_URI[aarch64_rust-bitvec+std-devel.sha256sum] = "3173eccaec5899dd1301a9fcec39cee369fb248143ab7cde7319908ec44ae39f"

URI_aarch64_rust-bitvec+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec+testing-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-bitvec+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec+testing-devel}"
SRC_URI[aarch64_rust-bitvec+testing-devel.sha256sum] = "5a6706a6ac8667846c11992fd278be942b131203837f606e7d9a613025ac303a"

URI_aarch64_rust-bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec-devel}"
SRC_URI[aarch64_rust-bitvec-devel.sha256sum] = "e37c905cce5894326f70d6f3e618ba12a21f13bb1f2ce67586cc76394097318e"

RDEPENDS:rust-bitvec+alloc-devel = " \
 cargo \
 rust-bitvec-devel \
 "
RDEPENDS:rust-bitvec+atomic-devel = " \
 cargo \
 rust-bitvec-devel \
 "
RDEPENDS:rust-bitvec+default-devel = " \
 cargo \
 rust-bitvec+atomic-devel \
 rust-bitvec+std-devel \
 rust-bitvec-devel \
 "
RDEPENDS:rust-bitvec+serde-devel = " \
 cargo \
 rust-bitvec-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bitvec+std-devel = " \
 cargo \
 rust-bitvec+alloc-devel \
 rust-bitvec-devel \
 "
RDEPENDS:rust-bitvec+testing-devel = " \
 cargo \
 rust-bitvec-devel \
 "
RDEPENDS:rust-bitvec-devel = " \
 cargo \
 rust \
 rust-funty-devel \
 rust-radium+default-devel \
 rust-tap+default-devel \
 rust-wyz-devel \
 "
