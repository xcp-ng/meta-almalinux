# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-smarty4"
PV = "4.5.6"
PR = "2.el10_0"
PACKAGES = " \
 php-smarty4 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-smarty4-4.5.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4d2c756cc663c01e32163583a900c18f055c754351f14660c23b4d35637a4f4e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-smarty4-4.5.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_php-smarty4;unpack=0"
SRC_URI[x86_64_v2_php-smarty4.sha256sum] = "715193494c1015d072a109524c1922326ed7eada3a6fca763d61b9144559835e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-smarty4-4.5.6-2.el10_0.noarch.rpm;name=aarch64_php-smarty4;unpack=0"
SRC_URI[aarch64_php-smarty4.sha256sum] = "816e90a002e4960065d067586aedd3c62bff2a2ab78e64d64b64d9c6338adcf6"

RDEPENDS:php-smarty4 = " \
 php-common \
 php-mbstring \
 php-opcache \
 php-pdo \
 "
