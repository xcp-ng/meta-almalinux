# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "riemann-c-client"
PV = "1.10.5"
PR = "11.el10_0"
PACKAGES = " \
 riemann-c-client \
 riemann-c-client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/riemann-c-client-1.10.5-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "996dd39013738befcecc6b242610f788d9af385bd915be81bb0fb91d7d6876de"

URI_x86_64_v2_riemann-c-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/riemann-c-client-1.10.5-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_riemann-c-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_riemann-c-client}"
SRC_URI[x86_64_v2_riemann-c-client.sha256sum] = "43d7e7d32becf9347cb13bb75442ef8e7b25941ea9433578582dc8f54abc31c1"

URI_x86_64_v2_riemann-c-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/riemann-c-client-devel-1.10.5-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_riemann-c-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_riemann-c-client-devel}"
SRC_URI[x86_64_v2_riemann-c-client-devel.sha256sum] = "7a238784947f88c011105a84925dafd61250a7844adabe35c9f49f9d1625aa0c"

URI_aarch64_riemann-c-client = "${EPEL_MIRROR}/aarch64/Packages/r/riemann-c-client-1.10.5-11.el10_0.aarch64.rpm;name=aarch64_riemann-c-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_riemann-c-client}"
SRC_URI[aarch64_riemann-c-client.sha256sum] = "e4928508b87aa7669e41fb68195bce40ad742bc0bca0f0fd4b0840cdd7b931e7"

URI_aarch64_riemann-c-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/riemann-c-client-devel-1.10.5-11.el10_0.aarch64.rpm;name=aarch64_riemann-c-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_riemann-c-client-devel}"
SRC_URI[aarch64_riemann-c-client-devel.sha256sum] = "dfc29ebc9a2b722df0714cedc3b442018293be894b864616b4c3e5e9bf8b5f56"

RDEPENDS:riemann-c-client = " \
 glibc \
 gnutls \
 json-c \
 protobuf-c \
 "
RDEPENDS:riemann-c-client-devel = " \
 json-c-devel \
 pkgconf-pkg-config \
 protobuf-c-devel \
 riemann-c-client \
 "
