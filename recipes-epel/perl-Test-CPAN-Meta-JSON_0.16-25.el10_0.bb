# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-CPAN-Meta-JSON"
PV = "0.16"
PR = "25.el10_0"
PACKAGES = " \
 perl-Test-CPAN-Meta-JSON \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-CPAN-Meta-JSON-0.16-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6421422f4e543e5b87d5d6eaaeaf64b87a85857aea41f90c73c02d8edef41ed0"

URI_x86_64_v2_perl-Test-CPAN-Meta-JSON = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-CPAN-Meta-JSON-0.16-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-CPAN-Meta-JSON;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-CPAN-Meta-JSON}"
SRC_URI[x86_64_v2_perl-Test-CPAN-Meta-JSON.sha256sum] = "7dff4253c60ddf8b89b98ab90e449e684bbcf6873653c3ae3b0024cb492fd1b3"

URI_aarch64_perl-Test-CPAN-Meta-JSON = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-CPAN-Meta-JSON-0.16-25.el10_0.noarch.rpm;name=aarch64_perl-Test-CPAN-Meta-JSON;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-CPAN-Meta-JSON}"
SRC_URI[aarch64_perl-Test-CPAN-Meta-JSON.sha256sum] = "5d74a8e2e9a89f0df680fd6bce54c93c59e0bf3645b8d36fc7f54d3973942171"

RDEPENDS:perl-Test-CPAN-Meta-JSON = " \
 perl-IO \
 perl-JSON \
 perl-Test-CPAN-Meta-JSON \
 perl-Test-Simple \
 perl-libs \
 perl-vars \
 "
