# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parley"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 parley \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/parley-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "410bf5b3339fa2b27a8fc9374ecda852ab63350541f018972261aec46fff7a2e"

URI_x86_64_v2_parley = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parley-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parley;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parley}"
SRC_URI[x86_64_v2_parley.sha256sum] = "d75fc9c539b145737a9817f0620e12bd960d21a3ddfb498234cd8412392c2303"

URI_aarch64_parley = "${EPEL_MIRROR}/aarch64/Packages/p/parley-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_parley;unpack=0"
SRC_URI:append = " ${URI_aarch64_parley}"
SRC_URI[aarch64_parley.sha256sum] = "bb02af10b8c4019a69d792144ad43b52c12f6b07d51fe2278228f1efc08cf645"

RDEPENDS:parley = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 qt6-qtwebengine \
 "
