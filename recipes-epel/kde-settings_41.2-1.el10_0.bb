# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-settings"
PV = "41.2"
PR = "1.el10_0"
PACKAGES = " \
 initial-setup-gui-wayland-plasma \
 kde-settings \
 kde-settings-plasma \
 kde-settings-pulseaudio \
 kde-settings-sddm \
 qt-settings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-settings-41.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a5869fdada34a1f9fc1f82d4f40ce3825890581db25aa0b27c929018e734b07"

URI_x86_64_v2_initial-setup-gui-wayland-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/initial-setup-gui-wayland-plasma-41.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_initial-setup-gui-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_initial-setup-gui-wayland-plasma}"
SRC_URI[x86_64_v2_initial-setup-gui-wayland-plasma.sha256sum] = "c69b12ccf4097f1a3ab3837cc87e115fda402d2a29a5db4d63fe76982d8ff11c"
RPROVIDES:initial-setup-gui-wayland-plasma:x86_64_v2 = "virtual/firstboot_gui-backend_"

URI_x86_64_v2_kde-settings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-41.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-settings}"
SRC_URI[x86_64_v2_kde-settings.sha256sum] = "c632d9879fcf63038fd0ce9ba9cab44cf73694f5055b83c26dab44a2911ae0e7"

URI_x86_64_v2_kde-settings-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-plasma-41.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-settings-plasma}"
SRC_URI[x86_64_v2_kde-settings-plasma.sha256sum] = "4a55532f8f6571cb93f3d856611aa5488769532ba39d7fb400ac4115d01a1537"

URI_x86_64_v2_kde-settings-pulseaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-pulseaudio-41.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-settings-pulseaudio}"
SRC_URI[x86_64_v2_kde-settings-pulseaudio.sha256sum] = "3d7f456650af0a6cc1eff7908759159c8968ea2bab35adf475d4013d86a18166"

URI_x86_64_v2_kde-settings-sddm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-settings-sddm-41.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kde-settings-sddm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-settings-sddm}"
SRC_URI[x86_64_v2_kde-settings-sddm.sha256sum] = "3f1333091abdf8a65a80dbe0f63901712990a3485dff4de68777328de726f2cd"

URI_x86_64_v2_qt-settings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-settings-41.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt-settings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-settings}"
SRC_URI[x86_64_v2_qt-settings.sha256sum] = "e06453740c81b067147e1ae8c412210bafb03e6ca405a3418b00e25eeadd4b0a"

URI_aarch64_initial-setup-gui-wayland-plasma = "${EPEL_MIRROR}/aarch64/Packages/i/initial-setup-gui-wayland-plasma-41.2-1.el10_0.noarch.rpm;name=aarch64_initial-setup-gui-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_initial-setup-gui-wayland-plasma}"
SRC_URI[aarch64_initial-setup-gui-wayland-plasma.sha256sum] = "1a1a63fef51d6ba39edf7e6b7e790d76ee409545939e10519fa82ffb3fd85103"
RPROVIDES:initial-setup-gui-wayland-plasma:aarch64 = "virtual/firstboot_gui-backend_"

URI_aarch64_kde-settings = "${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-41.2-1.el10_0.noarch.rpm;name=aarch64_kde-settings;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-settings}"
SRC_URI[aarch64_kde-settings.sha256sum] = "2abe56275aae6967b580445936293fa017a574d54de4020d778e611f72143aed"

URI_aarch64_kde-settings-plasma = "${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-plasma-41.2-1.el10_0.noarch.rpm;name=aarch64_kde-settings-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-settings-plasma}"
SRC_URI[aarch64_kde-settings-plasma.sha256sum] = "e424df2776c538a1f7bdadde36be90fb989b3c138597aa0657f3f433767149e3"

URI_aarch64_kde-settings-pulseaudio = "${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-pulseaudio-41.2-1.el10_0.noarch.rpm;name=aarch64_kde-settings-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-settings-pulseaudio}"
SRC_URI[aarch64_kde-settings-pulseaudio.sha256sum] = "8861747e8337614404a2451e992a9156b4dd104cc127c8cdce2117115516b5bd"

URI_aarch64_kde-settings-sddm = "${EPEL_MIRROR}/aarch64/Packages/k/kde-settings-sddm-41.2-1.el10_0.noarch.rpm;name=aarch64_kde-settings-sddm;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-settings-sddm}"
SRC_URI[aarch64_kde-settings-sddm.sha256sum] = "76683a8fa7e780c06fad30acb820fbb9eadbc17b355aa89dd3791ea6c30b1936"

URI_aarch64_qt-settings = "${EPEL_MIRROR}/aarch64/Packages/q/qt-settings-41.2-1.el10_0.noarch.rpm;name=aarch64_qt-settings;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-settings}"
SRC_URI[aarch64_qt-settings.sha256sum] = "60178ae9d0bd555fa991a53ba4ab07b2e4bb9ad15374b6b4d9906c6733ce3034"

RDEPENDS:initial-setup-gui-wayland-plasma = " \
 bash \
 initial-setup-gui \
 kwin-wayland \
 maliit-keyboard \
 xorg-x11-server-Xwayland \
 "
RDEPENDS:kde-settings = " \
 bash \
 breeze-icon-theme \
 kde-filesystem \
 pam \
 shared-mime-info \
 xdg-user-dirs \
 "
RDEPENDS:kde-settings-plasma = " \
 almalinux-logos \
 f41-backgrounds-kde \
 google-noto-sans-fonts \
 google-noto-sans-mono-fonts \
 kde-settings \
 "
RDEPENDS:kde-settings-pulseaudio = " \
 alsa-plugins-pulseaudio \
 kde-settings \
 pipewire-alsa \
 pipewire-pulseaudio \
 "
RDEPENDS:kde-settings-sddm = " \
 breeze-cursor-theme \
 sddm \
 "
RDEPENDS:qt-settings = " \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/firstboot_gui-backend_"

PROVIDES:append:aarch64 = " rpm/virtual/firstboot_gui-backend_"
