# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dogpile-cache"
PV = "1.5.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-dogpile-cache \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dogpile-cache-1.5.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f810fa26e4a5b871b863dfaa05a96ac527aeeec2e9d86d556b31b02f6fcdd53d"

URI_x86_64_v2_python3-dogpile-cache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dogpile-cache-1.5.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dogpile-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dogpile-cache}"
SRC_URI[x86_64_v2_python3-dogpile-cache.sha256sum] = "de33da771902037e64e2ae9b43b0068064e64d0b561e708c61a25e4c4a3515d1"

URI_aarch64_python3-dogpile-cache = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dogpile-cache-1.5.0-2.el10_2.noarch.rpm;name=aarch64_python3-dogpile-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dogpile-cache}"
SRC_URI[aarch64_python3-dogpile-cache.sha256sum] = "1cae0e808fb817d496ead9a01754bf19bfa08ccf2fc6a92caa834d6dbd407bc9"

RDEPENDS:python3-dogpile-cache = " \
 python3 \
 python3-decorator \
 python3-mako \
 python3-stevedore \
 "
