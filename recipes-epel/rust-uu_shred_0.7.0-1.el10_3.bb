# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_shred"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_shred+default-devel \
 rust-uu_shred-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_shred-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ebb3e6e0e86ba836c53116ed86ad061bd93c87c8c29835419f2808c07d53f11"

URI_x86_64_v2_rust-uu_shred+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_shred+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_shred+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_shred+default-devel}"
SRC_URI[x86_64_v2_rust-uu_shred+default-devel.sha256sum] = "2a5fc40d94e1961f939a1bbe854832c23b86db3a9ac27a529d78f1a8e19df04e"

URI_x86_64_v2_rust-uu_shred-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_shred-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_shred-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_shred-devel}"
SRC_URI[x86_64_v2_rust-uu_shred-devel.sha256sum] = "6adae96191dda0374db0c0750e164ed2ad7a19d53df268ba015fd2f129cd397b"

URI_aarch64_rust-uu_shred+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_shred+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_shred+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_shred+default-devel}"
SRC_URI[aarch64_rust-uu_shred+default-devel.sha256sum] = "4db65727630b551d418ea8cc5f957369529f8e777a270752df0bc65abf8536f6"

URI_aarch64_rust-uu_shred-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_shred-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_shred-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_shred-devel}"
SRC_URI[aarch64_rust-uu_shred-devel.sha256sum] = "d47e12071b239653e32f5ab882f8d6d302d3202dd832237b7adffab12cd52371"

RDEPENDS:rust-uu_shred+default-devel = " \
 cargo \
 rust-uu_shred-devel \
 "
RDEPENDS:rust-uu_shred-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-rand0.9+default-devel \
 rust-rand0.9+small_rng-devel \
 rust-uucore+default-devel \
 rust-uucore+parser-size-devel \
 "
