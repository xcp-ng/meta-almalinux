# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libssh2"
PV = "1.11.1"
PR = "1.el10_0"
PACKAGES = " \
 libssh2 \
 libssh2-devel \
 libssh2-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libssh2-1.11.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "673af6e6d2fbb54867a5ee3565411db237990ff474fc14e4d2aaa16d1d4f168d"

URI_x86_64_v2_libssh2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-1.11.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libssh2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2}"
SRC_URI[x86_64_v2_libssh2.sha256sum] = "a68b3b4d1fc6fd77a03488c7b60e0591b7a99f243b9036c953c1d9ba3f7dbecf"

URI_x86_64_v2_libssh2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-devel-1.11.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libssh2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2-devel}"
SRC_URI[x86_64_v2_libssh2-devel.sha256sum] = "56efa8bf71b42b1b178c05dfeb6972afb2715c566ba8ef19ce882aab23110793"

URI_x86_64_v2_libssh2-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libssh2-docs-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libssh2-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libssh2-docs}"
SRC_URI[x86_64_v2_libssh2-docs.sha256sum] = "0cd07d03240f71f17a83bf56c56b5b5c2ab91c8feda57f1a52ae5cf07d1cd20f"

URI_aarch64_libssh2 = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-1.11.1-1.el10_0.aarch64.rpm;name=aarch64_libssh2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2}"
SRC_URI[aarch64_libssh2.sha256sum] = "87464c95b6c2c97862b1358ce95da8b254de4ee3b404942ccce078e0d9ec467b"

URI_aarch64_libssh2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-devel-1.11.1-1.el10_0.aarch64.rpm;name=aarch64_libssh2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2-devel}"
SRC_URI[aarch64_libssh2-devel.sha256sum] = "dfb6d888bb69ccc3a8cdbacb90b8dc29cca355e835812fb9d8ae74a354008dea"

URI_aarch64_libssh2-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libssh2-docs-1.11.1-1.el10_0.noarch.rpm;name=aarch64_libssh2-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libssh2-docs}"
SRC_URI[aarch64_libssh2-docs.sha256sum] = "304869ece08f200fa80c9d75addcca94605e899192544aa39661b5b99cd10de3"

RDEPENDS:libssh2 = " \
 glibc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libssh2-devel = " \
 libssh2 \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:libssh2-docs = " \
 libssh2 \
 "
