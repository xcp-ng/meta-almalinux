# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-top"
PV = "1.1.2"
PR = "1.el10.alma.1"
PACKAGES = " \
 virt-top \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-top-1.1.2-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfb33149e1f3babb5c5bd8e36c78bcdd48e155bed6429d5f005fbddd61da2c68"

URI_x86_64_v2_virt-top = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-top-1.1.2-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_virt-top;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-top}"
SRC_URI[x86_64_v2_virt-top.sha256sum] = "fa3014b8ed766124c7f5aef7d70a29123dbe476f11e6815c9d89cef84099a1cc"

URI_aarch64_virt-top = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-top-1.1.2-1.el10.alma.1.aarch64.rpm;name=aarch64_virt-top;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-top}"
SRC_URI[aarch64_virt-top.sha256sum] = "3b68b3a2369fd7a741ee29f49244bd2d801472ed353ceba9975d38fa18de704c"

RDEPENDS:virt-top = " \
 glibc \
 libvirt-libs \
 libxml2 \
 ncurses-libs \
 python3 \
 "
