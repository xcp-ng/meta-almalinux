# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Package-Variant"
PV = "1.003002"
PR = "29.el10_3"
PACKAGES = " \
 perl-Package-Variant \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Package-Variant-1.003002-29.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f844e4dc03fbcce09726a11d636b386a0790919bc424e5643edad1c784d7117f"

URI_x86_64_v2_perl-Package-Variant = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Package-Variant-1.003002-29.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Package-Variant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Package-Variant}"
SRC_URI[x86_64_v2_perl-Package-Variant.sha256sum] = "ec85266d1cbac88033caeef27bbc79be43af0f64ec502e997f6a39bb93382e43"

URI_aarch64_perl-Package-Variant = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Package-Variant-1.003002-29.el10_3.noarch.rpm;name=aarch64_perl-Package-Variant;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Package-Variant}"
SRC_URI[aarch64_perl-Package-Variant.sha256sum] = "6b6f55400348a7070fff50b39d64a9d5d31372762baf09a43d3c242acd8eda72"

RDEPENDS:perl-Package-Variant = " \
 perl-Carp \
 perl-Import-Into \
 perl-Module-Runtime \
 perl-libs \
 perl-strictures \
 "
