# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-No-Worries"
PV = "1.7"
PR = "14.el10_1"
PACKAGES = " \
 perl-No-Worries \
 perl-No-Worries-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-No-Worries-1.7-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e91bddeb201ab124d22ac1380a8429c588ccfc4012b59ded8543225c5f6d065"

URI_x86_64_v2_perl-No-Worries = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-No-Worries-1.7-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-No-Worries;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-No-Worries}"
SRC_URI[x86_64_v2_perl-No-Worries.sha256sum] = "932addd69e6b0f9556060d7330f51b996e16dcd2419a2f2cf9ada12b402774fe"

URI_x86_64_v2_perl-No-Worries-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-No-Worries-tests-1.7-14.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-No-Worries-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-No-Worries-tests}"
SRC_URI[x86_64_v2_perl-No-Worries-tests.sha256sum] = "4e4aabfd81583bebfbb5655179ac04431a77aa78e9f1427426d86645783fa46a"

URI_aarch64_perl-No-Worries = "${EPEL_MIRROR}/aarch64/Packages/p/perl-No-Worries-1.7-14.el10_1.noarch.rpm;name=aarch64_perl-No-Worries;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-No-Worries}"
SRC_URI[aarch64_perl-No-Worries.sha256sum] = "d0c113bb2212f13a68556c94bca979d11725c6af0214d46e9b954d874bb97d29"

URI_aarch64_perl-No-Worries-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-No-Worries-tests-1.7-14.el10_1.noarch.rpm;name=aarch64_perl-No-Worries-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-No-Worries-tests}"
SRC_URI[aarch64_perl-No-Worries-tests.sha256sum] = "d296252b76dc3bd10eb5e03b1a429194433bda8629a285c1003f4bdb003baa3a"

RDEPENDS:perl-No-Worries = " \
 perl-Carp \
 perl-Encode \
 perl-Fcntl \
 perl-HTTP-Date \
 perl-IO \
 perl-No-Worries \
 perl-POSIX \
 perl-Params-Validate \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-URI \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-No-Worries-tests = " \
 bash \
 perl-Encode \
 perl-File-Temp \
 perl-No-Worries \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-constant \
 perl-libs \
 "
