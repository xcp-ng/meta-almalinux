# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zvbi"
PV = "0.2.42"
PR = "1.el10_0"
PACKAGES = " \
 zvbi \
 zvbi-devel \
 zvbi-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zvbi-0.2.42-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cb8b9a20718040cb6f0e4dc946905a1ab7eff6f70668c9dfbfc4b1b4b16ec5f"

URI_x86_64_v2_zvbi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zvbi-0.2.42-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zvbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zvbi}"
SRC_URI[x86_64_v2_zvbi.sha256sum] = "1410e229923fab9bf22ed701a1a68467f028354909822f34824804a41a87c864"

URI_x86_64_v2_zvbi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zvbi-devel-0.2.42-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zvbi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zvbi-devel}"
SRC_URI[x86_64_v2_zvbi-devel.sha256sum] = "f87fd9217af1803b89d77df14c1257457d71480d473ed8f5aa01513482e79e1c"

URI_x86_64_v2_zvbi-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zvbi-fonts-0.2.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zvbi-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zvbi-fonts}"
SRC_URI[x86_64_v2_zvbi-fonts.sha256sum] = "aefd1069337710c8815dab1a173ed4411f14441e4d961c51b5412863e48c1134"

URI_aarch64_zvbi = "${EPEL_MIRROR}/aarch64/Packages/z/zvbi-0.2.42-1.el10_0.aarch64.rpm;name=aarch64_zvbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_zvbi}"
SRC_URI[aarch64_zvbi.sha256sum] = "ff8bcedb12b68faf1a06a7a92fd776fdfce61522d88c9fbb805b29bb56d23520"

URI_aarch64_zvbi-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zvbi-devel-0.2.42-1.el10_0.aarch64.rpm;name=aarch64_zvbi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zvbi-devel}"
SRC_URI[aarch64_zvbi-devel.sha256sum] = "86b80dadc93144a29103073532fb7562cfd12f311e2f3dc62c232a7d47acbbc2"

URI_aarch64_zvbi-fonts = "${EPEL_MIRROR}/aarch64/Packages/z/zvbi-fonts-0.2.42-1.el10_0.noarch.rpm;name=aarch64_zvbi-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_zvbi-fonts}"
SRC_URI[aarch64_zvbi-fonts.sha256sum] = "4c6c4b52a0e7592d0e3bb9faddedb8e9d7e7534f981c8af104e37ca1c27576ee"

RDEPENDS:zvbi = " \
 bash \
 glibc \
 libgcc \
 libpng \
 zlib-ng-compat \
 "
RDEPENDS:zvbi-devel = " \
 pkgconf-pkg-config \
 zvbi \
 "
RDEPENDS:zvbi-fonts = " \
 "
