# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmodmap"
PV = "1.0.11"
PR = "5.el10_0"
PACKAGES = " \
 xmodmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xmodmap-1.0.11-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71dbd52dc7d722c3f1f7cb389ddfb278e2f033d0ba928e19f608bbcff5810296"

URI_x86_64_v2_xmodmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xmodmap-1.0.11-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xmodmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmodmap}"
SRC_URI[x86_64_v2_xmodmap.sha256sum] = "9716663f439fdeec3c8caa2e2206db1c39678f9345c14e3f798a842b5c56f236"

URI_aarch64_xmodmap = "${EPEL_MIRROR}/aarch64/Packages/x/xmodmap-1.0.11-5.el10_0.aarch64.rpm;name=aarch64_xmodmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmodmap}"
SRC_URI[aarch64_xmodmap.sha256sum] = "d61f4719a5f150a942a18b5af8acc19f9992fda5468fe6dd50c09842cecffb74"

RDEPENDS:xmodmap = " \
 glibc \
 libX11 \
 "
