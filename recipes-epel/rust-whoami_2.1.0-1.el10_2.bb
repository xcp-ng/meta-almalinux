# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-whoami"
PV = "2.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-whoami+default-devel \
 rust-whoami+force-stub-devel \
 rust-whoami+std-devel \
 rust-whoami-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-whoami-2.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ecc813b29d9632f80061ca5cd1c80c4e76bf912a1bf3124381aef65a166ca02"

URI_x86_64_v2_rust-whoami+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-whoami+default-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-whoami+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-whoami+default-devel}"
SRC_URI[x86_64_v2_rust-whoami+default-devel.sha256sum] = "fc2c9cc171cd34ec05923a2279d5f515eaf4f29b96e4ed9bdf0d8ac67ff90e70"

URI_x86_64_v2_rust-whoami+force-stub-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-whoami+force-stub-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-whoami+force-stub-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-whoami+force-stub-devel}"
SRC_URI[x86_64_v2_rust-whoami+force-stub-devel.sha256sum] = "6122f03757637e829934cca3b84dcb7057c469cc233d04c51ad0469468a6c7f9"

URI_x86_64_v2_rust-whoami+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-whoami+std-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-whoami+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-whoami+std-devel}"
SRC_URI[x86_64_v2_rust-whoami+std-devel.sha256sum] = "266f5ee335ba9daf6cfd25ac33f3b1fccfdf63213ac0bd57faff44e339efc49a"

URI_x86_64_v2_rust-whoami-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-whoami-devel-2.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-whoami-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-whoami-devel}"
SRC_URI[x86_64_v2_rust-whoami-devel.sha256sum] = "b1990ea806908d87ffeac9d25c1965aa7e8b9dda50c7eed73cb3b66e17708d6a"

URI_aarch64_rust-whoami+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-whoami+default-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-whoami+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-whoami+default-devel}"
SRC_URI[aarch64_rust-whoami+default-devel.sha256sum] = "bd5c9991270f4ca46463ebc93922ef5ce343850484624970bd6acb0cdee4627a"

URI_aarch64_rust-whoami+force-stub-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-whoami+force-stub-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-whoami+force-stub-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-whoami+force-stub-devel}"
SRC_URI[aarch64_rust-whoami+force-stub-devel.sha256sum] = "aea8cc24bc8aee3795c51c26a9a2ce7fbe5e49a7ba450a34174a200f41314b34"

URI_aarch64_rust-whoami+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-whoami+std-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-whoami+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-whoami+std-devel}"
SRC_URI[aarch64_rust-whoami+std-devel.sha256sum] = "308601b0ca82d66d19f6a485a09848ea4697cda725a2c297f171cef6651cd8cc"

URI_aarch64_rust-whoami-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-whoami-devel-2.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-whoami-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-whoami-devel}"
SRC_URI[aarch64_rust-whoami-devel.sha256sum] = "13ba4a8114283016239e5cf301abca662a4785275029c1ca5f5569265ce576b8"

RDEPENDS:rust-whoami+default-devel = " \
 cargo \
 rust-whoami+std-devel \
 rust-whoami-devel \
 "
RDEPENDS:rust-whoami+force-stub-devel = " \
 cargo \
 rust-whoami-devel \
 "
RDEPENDS:rust-whoami+std-devel = " \
 cargo \
 rust-whoami-devel \
 "
RDEPENDS:rust-whoami-devel = " \
 cargo \
 rust \
 "
