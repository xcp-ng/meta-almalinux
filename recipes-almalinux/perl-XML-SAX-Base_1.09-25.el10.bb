# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-SAX-Base"
PV = "1.09"
PR = "25.el10"
PACKAGES = " \
 perl-XML-SAX-Base \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-XML-SAX-Base-1.09-25.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57aef9faa59a8f49c8ce8b6a3885129e506dc2d3e4d4fc2fde0661d72f04af53"

URI_x86_64_v2_perl-XML-SAX-Base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-XML-SAX-Base-1.09-25.el10.noarch.rpm;name=x86_64_v2_perl-XML-SAX-Base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-SAX-Base}"
SRC_URI[x86_64_v2_perl-XML-SAX-Base.sha256sum] = "c7bf3c5bfca62c463e95b67e81cf1d29cc7a1c9d88bb8835c129eabaefb58c89"

URI_aarch64_perl-XML-SAX-Base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-XML-SAX-Base-1.09-25.el10.noarch.rpm;name=aarch64_perl-XML-SAX-Base;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-SAX-Base}"
SRC_URI[aarch64_perl-XML-SAX-Base.sha256sum] = "c7bf3c5bfca62c463e95b67e81cf1d29cc7a1c9d88bb8835c129eabaefb58c89"

RDEPENDS:perl-XML-SAX-Base = " \
 perl-Carp \
 perl-XML-SAX-Base \
 perl-libs \
 perl-overload \
 perl-vars \
 "
