# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dbl"
PV = "0.3.2"
PR = "6.el10_2"
PACKAGES = " \
 rust-dbl+default-devel \
 rust-dbl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dbl-0.3.2-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec263fd5e3245b1d4bd09ae3978b3ba9405aa6275059add1ca7cc612c79bdcdd"

URI_x86_64_v2_rust-dbl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dbl+default-devel-0.3.2-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dbl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dbl+default-devel}"
SRC_URI[x86_64_v2_rust-dbl+default-devel.sha256sum] = "54e1086400201645f550fe8a5f784c17ff5448d9c98f9fa17d0860981e457e69"

URI_x86_64_v2_rust-dbl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dbl-devel-0.3.2-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dbl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dbl-devel}"
SRC_URI[x86_64_v2_rust-dbl-devel.sha256sum] = "6a620a2bd237eea224acf0841852ba8d3f5d699abe29c98e28b7864f46c4f6bb"

URI_aarch64_rust-dbl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dbl+default-devel-0.3.2-6.el10_2.noarch.rpm;name=aarch64_rust-dbl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dbl+default-devel}"
SRC_URI[aarch64_rust-dbl+default-devel.sha256sum] = "69a56df9ed93c7bb5940adc59871bbf5782f40389cd2c7880493ef54115ba579"

URI_aarch64_rust-dbl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dbl-devel-0.3.2-6.el10_2.noarch.rpm;name=aarch64_rust-dbl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dbl-devel}"
SRC_URI[aarch64_rust-dbl-devel.sha256sum] = "f5db74ca4a70457370e59caa064368905410e44bcfe027e8094fb70eb0098ce6"

RDEPENDS:rust-dbl+default-devel = " \
 cargo \
 rust-dbl-devel \
 "
RDEPENDS:rust-dbl-devel = " \
 cargo \
 rust-generic-array+default-devel \
 "
