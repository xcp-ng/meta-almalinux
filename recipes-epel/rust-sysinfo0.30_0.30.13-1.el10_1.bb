# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sysinfo0.30"
PV = "0.30.13"
PR = "1.el10_1"
PACKAGES = " \
 rust-sysinfo0.30+c-interface-devel \
 rust-sysinfo0.30+debug-devel \
 rust-sysinfo0.30+default-devel \
 rust-sysinfo0.30+linux-netdevs-devel \
 rust-sysinfo0.30+linux-tmpfs-devel \
 rust-sysinfo0.30+multithread-devel \
 rust-sysinfo0.30+rayon-devel \
 rust-sysinfo0.30+serde-devel \
 rust-sysinfo0.30-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sysinfo0.30-0.30.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ae0a5185d696210216f4d1ed9bd2d6c6b5d2ec23beb566c9b97e6d0a1eb2ca9"

URI_x86_64_v2_rust-sysinfo0.30+c-interface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+c-interface-devel-0.30.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+c-interface-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+c-interface-devel.sha256sum] = "c0bed89e88d1205ec2eebae44d458e3574911622a208187657ca65d813f13d31"

URI_x86_64_v2_rust-sysinfo0.30+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+debug-devel-0.30.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+debug-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+debug-devel.sha256sum] = "0caa94325a6563e01dd900c55662502ddc87fcd92f450886b1be1dc9c60455cb"

URI_x86_64_v2_rust-sysinfo0.30+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+default-devel-0.30.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+default-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+default-devel.sha256sum] = "3fb531653547ef5116fba7b98aeca4ce1aa44a5017d03d50aa6a8edbd244cfcd"

URI_x86_64_v2_rust-sysinfo0.30+linux-netdevs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+linux-netdevs-devel-0.30.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+linux-netdevs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+linux-netdevs-devel.sha256sum] = "1efbbad6b726930c72deb3b73a89d7ea9cf19dd473a20df52a17d4abbcd6ea72"

URI_x86_64_v2_rust-sysinfo0.30+linux-tmpfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+linux-tmpfs-devel-0.30.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+linux-tmpfs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+linux-tmpfs-devel.sha256sum] = "e737299d232c97200977eba82790862f14f12e6a05ea1075365695cd1cab705c"

URI_x86_64_v2_rust-sysinfo0.30+multithread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+multithread-devel-0.30.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+multithread-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+multithread-devel.sha256sum] = "1a4a79da9a50801254acad75996eb381dd45c095468f3805b1b42d7d0c51c414"

URI_x86_64_v2_rust-sysinfo0.30+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+rayon-devel-0.30.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+rayon-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+rayon-devel.sha256sum] = "35bcdb44d49dc4b49e9a7410414eda21cf6647a11f976f719cee57711a9f2c43"

URI_x86_64_v2_rust-sysinfo0.30+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+serde-devel-0.30.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+serde-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+serde-devel.sha256sum] = "e3dd5a5781ca3f6821427c69f443b20480aecaa3e9e589cc73ecf6c307f052a4"

URI_x86_64_v2_rust-sysinfo0.30-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30-devel-0.30.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30-devel.sha256sum] = "144c015c35be90acf9a97219c36fab22743bb4894bfbd8d35a74c4ef99a07c63"

URI_aarch64_rust-sysinfo0.30+c-interface-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+c-interface-devel-0.30.13-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo0.30+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+c-interface-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+c-interface-devel.sha256sum] = "1556521765523ea1f0555c8d26c08e2d1ce413696b3738dcd3c9f964157014f5"

URI_aarch64_rust-sysinfo0.30+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+debug-devel-0.30.13-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo0.30+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+debug-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+debug-devel.sha256sum] = "1fe33d1338cb09142b44c0fe96bcff2cdde432c15f16439618173255324a1e43"

URI_aarch64_rust-sysinfo0.30+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+default-devel-0.30.13-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo0.30+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+default-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+default-devel.sha256sum] = "1f128f4f0d6ac1a7754d44bbad15a9fd814e1e68f1b00d2ce556e7bbb708218c"

URI_aarch64_rust-sysinfo0.30+linux-netdevs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+linux-netdevs-devel-0.30.13-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo0.30+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+linux-netdevs-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+linux-netdevs-devel.sha256sum] = "2f0ba82a2a2e8c1c0ed49a6acd2d831ff5647149af0aac1832c5c509d72037be"

URI_aarch64_rust-sysinfo0.30+linux-tmpfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+linux-tmpfs-devel-0.30.13-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo0.30+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+linux-tmpfs-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+linux-tmpfs-devel.sha256sum] = "012061f4152c26a7a9f4af4a15335eb24c961b455a7e00879aeb9e12882a32f5"

URI_aarch64_rust-sysinfo0.30+multithread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+multithread-devel-0.30.13-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo0.30+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+multithread-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+multithread-devel.sha256sum] = "bddfe7f4b880dca14122359bc89e9e1962539e8510489a6a5d80b8ff96ef00a6"

URI_aarch64_rust-sysinfo0.30+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+rayon-devel-0.30.13-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo0.30+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+rayon-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+rayon-devel.sha256sum] = "93b5918b04e00e495f9f623da0fdc00ae92c6f1461ba9ab8898dc63b2bf83852"

URI_aarch64_rust-sysinfo0.30+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+serde-devel-0.30.13-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo0.30+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+serde-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+serde-devel.sha256sum] = "20981b1a0acaf43e4cfa30af0cc6ba8b5c4f7f6038a8947f15c130e271baa9eb"

URI_aarch64_rust-sysinfo0.30-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30-devel-0.30.13-1.el10_1.noarch.rpm;name=aarch64_rust-sysinfo0.30-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30-devel}"
SRC_URI[aarch64_rust-sysinfo0.30-devel.sha256sum] = "1472b49105e7622c5c8e2f692391a16202c536e1a096a7a129114aab51d12c89"

RDEPENDS:rust-sysinfo0.30+c-interface-devel = " \
 cargo \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+debug-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+default-devel = " \
 cargo \
 rust-sysinfo0.30+multithread-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+linux-netdevs-devel = " \
 cargo \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+linux-tmpfs-devel = " \
 cargo \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+multithread-devel = " \
 cargo \
 rust-sysinfo0.30+rayon-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+rayon-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 "
