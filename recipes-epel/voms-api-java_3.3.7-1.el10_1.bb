# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms-api-java"
PV = "3.3.7"
PR = "1.el10_1"
PACKAGES = " \
 voms-api-java \
 voms-api-java-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/voms-api-java-3.3.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77ffe6d32e924933d4c549565cccdf5d472dd8259bb1f8e698bb4cb696448cd1"

URI_x86_64_v2_voms-api-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-api-java-3.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_voms-api-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-api-java}"
SRC_URI[x86_64_v2_voms-api-java.sha256sum] = "a9bccf7c54fc4d9eed03d5dfb019076baafb3022e93ab478f9da10c59d131493"

URI_x86_64_v2_voms-api-java-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-api-java-javadoc-3.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_voms-api-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-api-java-javadoc}"
SRC_URI[x86_64_v2_voms-api-java-javadoc.sha256sum] = "44ba5b9da9663911a898437ee8433b0b07e75cb17921d063e8cf09ac91bd6886"

URI_aarch64_voms-api-java = "${EPEL_MIRROR}/aarch64/Packages/v/voms-api-java-3.3.7-1.el10_1.noarch.rpm;name=aarch64_voms-api-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-api-java}"
SRC_URI[aarch64_voms-api-java.sha256sum] = "6b2ade83a6d625ba0af8b8f6fae4cd9179b9cbc45a236fa66dac9b02cc72cf48"

URI_aarch64_voms-api-java-javadoc = "${EPEL_MIRROR}/aarch64/Packages/v/voms-api-java-javadoc-3.3.7-1.el10_1.noarch.rpm;name=aarch64_voms-api-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-api-java-javadoc}"
SRC_URI[aarch64_voms-api-java-javadoc.sha256sum] = "34c1c0249b6857cf80f6058885fc569c169aeb324b0bc058f7dbf6c7f808e77f"

RDEPENDS:voms-api-java = " \
 bouncycastle \
 bouncycastle-pkix \
 canl-java \
 javapackages-filesystem \
 "
RDEPENDS:voms-api-java-javadoc = " \
 javapackages-filesystem \
 "
