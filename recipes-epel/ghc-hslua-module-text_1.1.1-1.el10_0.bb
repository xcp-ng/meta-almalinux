# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hslua-module-text"
PV = "1.1.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-hslua-module-text \
 ghc-hslua-module-text-devel \
 ghc-hslua-module-text-doc \
 ghc-hslua-module-text-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hslua-module-text-1.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4be396b5b63034e3331d19666e8aecf193349b92d71da2bde72cf851541d870"

URI_x86_64_v2_ghc-hslua-module-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-text-1.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-text}"
SRC_URI[x86_64_v2_ghc-hslua-module-text.sha256sum] = "b94022db488c47060dc2618910bdfca7c2969fb4f1ebfe800f756553fabe7681"

URI_x86_64_v2_ghc-hslua-module-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-text-devel-1.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-text-devel}"
SRC_URI[x86_64_v2_ghc-hslua-module-text-devel.sha256sum] = "ffa3ae4050770e924f411731b489bf49858a800d18e079843ab0c7d52bf45d9f"

URI_x86_64_v2_ghc-hslua-module-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-text-doc-1.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hslua-module-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-text-doc}"
SRC_URI[x86_64_v2_ghc-hslua-module-text-doc.sha256sum] = "2aae36b0370fe28d5344dee6c78a89b844652fe7c47492d9792df425cabe3714"

URI_x86_64_v2_ghc-hslua-module-text-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hslua-module-text-prof-1.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hslua-module-text-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hslua-module-text-prof}"
SRC_URI[x86_64_v2_ghc-hslua-module-text-prof.sha256sum] = "217b4432c017a849600468aec784fc23acc19d6b9aac42c43cac1450bd623f54"

URI_aarch64_ghc-hslua-module-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-text-1.1.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-text}"
SRC_URI[aarch64_ghc-hslua-module-text.sha256sum] = "f22b72f073c8107d395c6b1defbfd60936bc7998f6f4fb460e2dd46f25ae7707"

URI_aarch64_ghc-hslua-module-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-text-devel-1.1.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-text-devel}"
SRC_URI[aarch64_ghc-hslua-module-text-devel.sha256sum] = "c165d382b5833065271dde8f75fa0fa8a006868c89e46b3c750ab25ae8607b65"

URI_aarch64_ghc-hslua-module-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-text-doc-1.1.1-1.el10_0.noarch.rpm;name=aarch64_ghc-hslua-module-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-text-doc}"
SRC_URI[aarch64_ghc-hslua-module-text-doc.sha256sum] = "ba6713b477227e888f40506bd517be5e1194d6e5bd0ee39fdd3990009e9fa15f"

URI_aarch64_ghc-hslua-module-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hslua-module-text-prof-1.1.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-hslua-module-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hslua-module-text-prof}"
SRC_URI[aarch64_ghc-hslua-module-text-prof.sha256sum] = "4536a4c7f63bdb3d7c3466c51c0d60d364acd6299be98bbc4ecdb2f2fc00a1b1"

RDEPENDS:ghc-hslua-module-text = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hslua-core \
 ghc-hslua-marshalling \
 ghc-hslua-objectorientation \
 ghc-hslua-packaging \
 ghc-hslua-typing \
 ghc-lua \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hslua-module-text-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-hslua-core-devel \
 ghc-hslua-marshalling-devel \
 ghc-hslua-module-text \
 ghc-hslua-packaging-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hslua-module-text-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hslua-module-text-prof = " \
 ghc-base-prof \
 ghc-hslua-core-prof \
 ghc-hslua-marshalling-prof \
 ghc-hslua-module-text-devel \
 ghc-hslua-packaging-prof \
 ghc-text-prof \
 "
