# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dialog"
PV = "1.3"
PR = "52.20240101.el10"
PACKAGES = " \
 dialog \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dialog-1.3-52.20240101.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5189e27db2d730e78bc346428e6c3aae9f23705c5b1ba080b863552c1e36f072"

URI_x86_64_v2_dialog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dialog-1.3-52.20240101.el10.x86_64_v2.rpm;name=x86_64_v2_dialog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dialog}"
SRC_URI[x86_64_v2_dialog.sha256sum] = "1ae590648d7490deb80003a7da3d8b4cec23591970fac305685bfc67807fbf61"

URI_aarch64_dialog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dialog-1.3-52.20240101.el10.aarch64.rpm;name=aarch64_dialog;unpack=0"
SRC_URI:append = " ${URI_aarch64_dialog}"
SRC_URI[aarch64_dialog.sha256sum] = "7957e00f0f5b20de4dd8b5ea2277e2b7b7357e2d960c8b66b6a41342fcc90894"

RDEPENDS:dialog = " \
 glibc \
 ncurses-libs \
 "
