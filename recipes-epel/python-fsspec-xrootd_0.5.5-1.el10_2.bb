# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fsspec-xrootd"
PV = "0.5.5"
PR = "1.el10_2"
PACKAGES = " \
 python3-fsspec-xrootd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-fsspec-xrootd-0.5.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6563e702b0c15e3153d125c612fa23886412152d28f65e17c0a04cd97ec87209"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec-xrootd-0.5.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec-xrootd;unpack=0"
SRC_URI[x86_64_v2_python3-fsspec-xrootd.sha256sum] = "99f771a7de5561966c9bbdf90122846066a162da0a2cfbc73bafff5546aefde9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec-xrootd-0.5.5-1.el10_2.noarch.rpm;name=aarch64_python3-fsspec-xrootd;unpack=0"
SRC_URI[aarch64_python3-fsspec-xrootd.sha256sum] = "4c3300d35542e87b6f22eadafa8c03eeda774c211a7c05e381d542e812bf3532"

RDEPENDS:python3-fsspec-xrootd = " \
 python3 \
 python3-fsspec \
 python3-xrootd \
 "
