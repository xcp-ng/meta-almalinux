# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indoc1"
PV = "1.0.9"
PR = "4.el10_0"
PACKAGES = " \
 rust-indoc1+default-devel \
 rust-indoc1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indoc1-1.0.9-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1ee096021cde6eaf8f21c60bcc7e33e1e6f7dbfb662429efe8bc06f30b82999"

URI_x86_64_v2_rust-indoc1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indoc1+default-devel-1.0.9-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indoc1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indoc1+default-devel}"
SRC_URI[x86_64_v2_rust-indoc1+default-devel.sha256sum] = "d03f16c98afea4707811476851c45b38f828e579eee98efb01692d1109f64d55"

URI_x86_64_v2_rust-indoc1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indoc1-devel-1.0.9-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indoc1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indoc1-devel}"
SRC_URI[x86_64_v2_rust-indoc1-devel.sha256sum] = "7171eb159ab4f17bdb47218868d8741be344bdc3ecca5705489d678d0c82bc95"

URI_aarch64_rust-indoc1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indoc1+default-devel-1.0.9-4.el10_0.noarch.rpm;name=aarch64_rust-indoc1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indoc1+default-devel}"
SRC_URI[aarch64_rust-indoc1+default-devel.sha256sum] = "306a5e15b995efb781033a721cc8fd8ab229be28197f53fd6bd95a4c4c88f920"

URI_aarch64_rust-indoc1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indoc1-devel-1.0.9-4.el10_0.noarch.rpm;name=aarch64_rust-indoc1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indoc1-devel}"
SRC_URI[aarch64_rust-indoc1-devel.sha256sum] = "1ee4c6b0384b8aed0f37d5e1346bab3e074494733f36328074fd1938096aea35"

RDEPENDS:rust-indoc1+default-devel = " \
 cargo \
 rust-indoc1-devel \
 "
RDEPENDS:rust-indoc1-devel = " \
 cargo \
 rust \
 "
