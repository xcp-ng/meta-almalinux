# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Device-SerialPort"
PV = "1.04"
PR = "52.el10_0"
PACKAGES = " \
 perl-Device-SerialPort \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Device-SerialPort-1.04-52.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e5c06d0334c8c2f5584a0b94862a8dfd6a626437e0ed8569f2a5f35513b5c6e"

URI_x86_64_v2_perl-Device-SerialPort = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Device-SerialPort-1.04-52.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Device-SerialPort;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Device-SerialPort}"
SRC_URI[x86_64_v2_perl-Device-SerialPort.sha256sum] = "5ee219d9bd1eec414e1f55d36a1fca6ab8c828538c4ca8aca0774c5f4f1dd603"

URI_aarch64_perl-Device-SerialPort = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Device-SerialPort-1.04-52.el10_0.aarch64.rpm;name=aarch64_perl-Device-SerialPort;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Device-SerialPort}"
SRC_URI[aarch64_perl-Device-SerialPort.sha256sum] = "e625ed2af9f86de16822814b0a6184f1e0624ed1b5fe4e1cc571d430999a7937"

RDEPENDS:perl-Device-SerialPort = " \
 glibc \
 perl-Carp \
 perl-Device-SerialPort \
 perl-Exporter \
 perl-IO \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
