# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-vhacdx"
PV = "0.0.5"
PR = "1.el10_0"
PACKAGES = " \
 python3-vhacdx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-vhacdx-0.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "247168f35097b35e310ee5c4eacdbc22f712955f7a8f72f3207bdd2755b7b163"

URI_x86_64_v2_python3-vhacdx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vhacdx-0.0.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-vhacdx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vhacdx}"
SRC_URI[x86_64_v2_python3-vhacdx.sha256sum] = "cf6e3126a809188e63178badfec548b7d375ad465285d6bed1557606158f855e"

URI_aarch64_python3-vhacdx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vhacdx-0.0.5-1.el10_0.aarch64.rpm;name=aarch64_python3-vhacdx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vhacdx}"
SRC_URI[aarch64_python3-vhacdx.sha256sum] = "601a991d63fc39b4a16af19fc048ddbc38d0cb706f1ac7430ce485ea480a35da"

RDEPENDS:python3-vhacdx = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "
