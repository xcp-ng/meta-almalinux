# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cinderclient"
PV = "9.9.0"
PR = "2.el10_2"
PACKAGES = " \
 python-cinderclient-doc \
 python3-cinderclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cinderclient-9.9.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d62db40b9584bdd265c547cd8e0f30a091ee402786ce20fdc251ddb65138c3a7"

URI_x86_64_v2_python-cinderclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-cinderclient-doc-9.9.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-cinderclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-cinderclient-doc}"
SRC_URI[x86_64_v2_python-cinderclient-doc.sha256sum] = "57b678656a4733c9722da361ccb05b92f7dedb6425d363c51482ae6b774fbf8c"

URI_x86_64_v2_python3-cinderclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cinderclient-9.9.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cinderclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cinderclient}"
SRC_URI[x86_64_v2_python3-cinderclient.sha256sum] = "136905429b39923d58b339bd3973141bb5996e6ae297c8f492e851ba15db467b"

URI_aarch64_python-cinderclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-cinderclient-doc-9.9.0-2.el10_2.noarch.rpm;name=aarch64_python-cinderclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-cinderclient-doc}"
SRC_URI[aarch64_python-cinderclient-doc.sha256sum] = "cde862e142e604bb5a54c87cb726342c59e551e62a445f1ce0f49ba813433f60"

URI_aarch64_python3-cinderclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cinderclient-9.9.0-2.el10_2.noarch.rpm;name=aarch64_python3-cinderclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cinderclient}"
SRC_URI[aarch64_python3-cinderclient.sha256sum] = "20dfb8cc27e30b71afd42680a478739a53e6b735d988f57dfa178029207d54ca"

RDEPENDS:python-cinderclient-doc = " \
 "
RDEPENDS:python3-cinderclient = " \
 python3 \
 python3-keystoneauth1 \
 python3-oslo-i18n \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-requests \
 python3-stevedore \
 "
