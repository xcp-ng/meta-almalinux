# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-features"
PV = "0.44.1"
PR = "3.el10_2"
PACKAGES = " \
 rust-gix-features+cache-efficiency-debug-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+document-features-devel \
 rust-gix-features+fs-read-dir-devel \
 rust-gix-features+io-pipe-devel \
 rust-gix-features+once_cell-devel \
 rust-gix-features+parallel-devel \
 rust-gix-features+prodash-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+progress-unit-bytes-devel \
 rust-gix-features+progress-unit-human-numbers-devel \
 rust-gix-features+tracing-detail-devel \
 rust-gix-features+tracing-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-features+zlib-devel \
 rust-gix-features-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-features-0.44.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c50de0c02168a5616c3db15647c81724398ce78aea6b9c81cb6d2531090dd22"

URI_x86_64_v2_rust-gix-features+cache-efficiency-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+cache-efficiency-debug-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+cache-efficiency-debug-devel}"
SRC_URI[x86_64_v2_rust-gix-features+cache-efficiency-debug-devel.sha256sum] = "1e3361bd439f7c5824ffbc4e4d13fc420be0814c78413991e8be04568d49aad3"

URI_x86_64_v2_rust-gix-features+crc32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+crc32-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+crc32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+crc32-devel}"
SRC_URI[x86_64_v2_rust-gix-features+crc32-devel.sha256sum] = "88404b21f46d9a37aa61482c6513144a216301c80841788d39b6af0f299366b8"

URI_x86_64_v2_rust-gix-features+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+default-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+default-devel}"
SRC_URI[x86_64_v2_rust-gix-features+default-devel.sha256sum] = "4b8b7542c0486ca01dab8a6c8aa197e38751822b3402b3ec189c23da2fa22acd"

URI_x86_64_v2_rust-gix-features+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+document-features-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-features+document-features-devel.sha256sum] = "4707ee37badbec78e872a3b3553f9f1f57b70e87454759999463f288bca6db9c"

URI_x86_64_v2_rust-gix-features+fs-read-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+fs-read-dir-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+fs-read-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+fs-read-dir-devel}"
SRC_URI[x86_64_v2_rust-gix-features+fs-read-dir-devel.sha256sum] = "55a84c6db45fc3ab837705ff9f0f8d87f3e10bc49b270c972aae1a0e92cec8de"

URI_x86_64_v2_rust-gix-features+io-pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+io-pipe-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+io-pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+io-pipe-devel}"
SRC_URI[x86_64_v2_rust-gix-features+io-pipe-devel.sha256sum] = "a99c8eb9a6bb6c36375c3a032004c88682926da2d7cc17dd3203c72eba01d643"

URI_x86_64_v2_rust-gix-features+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+once_cell-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+once_cell-devel}"
SRC_URI[x86_64_v2_rust-gix-features+once_cell-devel.sha256sum] = "4ab729be8acc44d87ffdd2404bdcc8898becaa8c45f26218af43dfb47debad2d"

URI_x86_64_v2_rust-gix-features+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+parallel-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-features+parallel-devel.sha256sum] = "9fd237e20aae1e2586462c31381d19f6003b0375f2d83c3ae94aa9af8a8633ff"

URI_x86_64_v2_rust-gix-features+prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+prodash-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+prodash-devel}"
SRC_URI[x86_64_v2_rust-gix-features+prodash-devel.sha256sum] = "4b3b85eea7dcfa804c7a9b18e0ec176bf82861c3a523f742561da600236ed3bf"

URI_x86_64_v2_rust-gix-features+progress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-devel.sha256sum] = "118ff2aaf14e2a73f55e856323cce019ef9348d86dba041eda3f000b5812dcfe"

URI_x86_64_v2_rust-gix-features+progress-unit-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-unit-bytes-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-unit-bytes-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-unit-bytes-devel.sha256sum] = "8c1a2b3be705bbe77bbb920ba490f8a76aabb6a965b498f97cb4577dbc732348"

URI_x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-unit-human-numbers-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel.sha256sum] = "e77d2f24bca5c410bb3d66ec34c6df5651b2efe628ec789d409a4fd045fd3773"

URI_x86_64_v2_rust-gix-features+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+tracing-detail-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix-features+tracing-detail-devel.sha256sum] = "c82f037cb2357333b5d277ef03e2972f22b2415f12e277cbcc1bcd3b9365a912"

URI_x86_64_v2_rust-gix-features+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+tracing-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix-features+tracing-devel.sha256sum] = "dab8711456cdad145d868c8b9293743cfc3bf83458f7813431d0d8ef03a41da0"

URI_x86_64_v2_rust-gix-features+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+walkdir-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+walkdir-devel}"
SRC_URI[x86_64_v2_rust-gix-features+walkdir-devel.sha256sum] = "7a4e703c78ec7ebfeb49d520936c5eb7d380c6bf120bee80578955883bb53f8f"

URI_x86_64_v2_rust-gix-features+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-devel.sha256sum] = "2f816fd6ade3a33adc2428d53abb511b9242a26ae6277f0b828db23869628918"

URI_x86_64_v2_rust-gix-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features-devel-0.44.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features-devel}"
SRC_URI[x86_64_v2_rust-gix-features-devel.sha256sum] = "20b75a1d8b25ad78beba0f16e591ba5e877443a3c8ff287dfadc86c4a63ac126"

URI_aarch64_rust-gix-features+cache-efficiency-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+cache-efficiency-debug-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+cache-efficiency-debug-devel}"
SRC_URI[aarch64_rust-gix-features+cache-efficiency-debug-devel.sha256sum] = "0386b0d7f0ffacaba853dbc19644fd66170d4cc5e3cdb6e0d830409024879a95"

URI_aarch64_rust-gix-features+crc32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+crc32-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+crc32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+crc32-devel}"
SRC_URI[aarch64_rust-gix-features+crc32-devel.sha256sum] = "c19ef2219cc4a1501bdf99c25f08c65c619e6b07dd43a5d0728a3118178704d4"

URI_aarch64_rust-gix-features+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+default-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+default-devel}"
SRC_URI[aarch64_rust-gix-features+default-devel.sha256sum] = "256edf5866109e4068bb4dde5f582daaa876700968b60df85f27e4c716f62ec5"

URI_aarch64_rust-gix-features+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+document-features-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+document-features-devel}"
SRC_URI[aarch64_rust-gix-features+document-features-devel.sha256sum] = "2da2f77151f509cca45342dee352b62b07d4bc0518a1bc27e910d53d0f26b275"

URI_aarch64_rust-gix-features+fs-read-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+fs-read-dir-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+fs-read-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+fs-read-dir-devel}"
SRC_URI[aarch64_rust-gix-features+fs-read-dir-devel.sha256sum] = "16cfa330bb6ed76cf2b118c7a6b941da67bd3b5a4f5b52203587035314d0e802"

URI_aarch64_rust-gix-features+io-pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+io-pipe-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+io-pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+io-pipe-devel}"
SRC_URI[aarch64_rust-gix-features+io-pipe-devel.sha256sum] = "d4c294b4e6321ab3e6d6ca968abd7cd6d0f655de93e831cb4b97623e4ba4af99"

URI_aarch64_rust-gix-features+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+once_cell-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+once_cell-devel}"
SRC_URI[aarch64_rust-gix-features+once_cell-devel.sha256sum] = "9175455ed29ca6646e30a63dd4cfb9628aca49ff3745a3a79df196f38c373a8d"

URI_aarch64_rust-gix-features+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+parallel-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+parallel-devel}"
SRC_URI[aarch64_rust-gix-features+parallel-devel.sha256sum] = "6c318128ca67712220a920d9a92a9b3d8b0db2c0db554ca61163bfa1bc83e044"

URI_aarch64_rust-gix-features+prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+prodash-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+prodash-devel}"
SRC_URI[aarch64_rust-gix-features+prodash-devel.sha256sum] = "ff9b6a63e4bacdabe08201f5a69e9ae0b50deeaf319f6fb755aded74bc5f4ea6"

URI_aarch64_rust-gix-features+progress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+progress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-devel}"
SRC_URI[aarch64_rust-gix-features+progress-devel.sha256sum] = "b8de4d18dcf15b4055845d83a010094d3bfd50843cfc45b4d2a1112664270a5f"

URI_aarch64_rust-gix-features+progress-unit-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-unit-bytes-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+progress-unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-unit-bytes-devel}"
SRC_URI[aarch64_rust-gix-features+progress-unit-bytes-devel.sha256sum] = "5b2fcc6cba27a66919b85750d5fd682075187165701692228c0d4ff542dca9b6"

URI_aarch64_rust-gix-features+progress-unit-human-numbers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-unit-human-numbers-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+progress-unit-human-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-unit-human-numbers-devel}"
SRC_URI[aarch64_rust-gix-features+progress-unit-human-numbers-devel.sha256sum] = "87caa4b5089566799fc5da748700b8d9be87e7102e2851f10fadd0aa67cb8c75"

URI_aarch64_rust-gix-features+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+tracing-detail-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix-features+tracing-detail-devel.sha256sum] = "60cd6b1b954c925b4349eafa9d16bf66f79fce466ad41d3d942855731591c58c"

URI_aarch64_rust-gix-features+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+tracing-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+tracing-devel}"
SRC_URI[aarch64_rust-gix-features+tracing-devel.sha256sum] = "e9b0dbb33210d834ca2f61817f13e61867e38c53c90c9fdc78f2aa895b531047"

URI_aarch64_rust-gix-features+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+walkdir-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+walkdir-devel}"
SRC_URI[aarch64_rust-gix-features+walkdir-devel.sha256sum] = "99627ca6192d10fc233b70e6d82aa9eb3be8f9cea54e73beffe52e3feb6a3fa7"

URI_aarch64_rust-gix-features+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-devel.sha256sum] = "95f79cdeff443d3b3042267f669b07496401157c6c53405ac1385faef49f5642"

URI_aarch64_rust-gix-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features-devel-0.44.1-3.el10_2.noarch.rpm;name=aarch64_rust-gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features-devel}"
SRC_URI[aarch64_rust-gix-features-devel.sha256sum] = "1c11078b449244532ae8702cf7fab2480cb30a40ac96f34d5b22e85697e2823c"

RDEPENDS:rust-gix-features+cache-efficiency-debug-devel = " \
 cargo \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+crc32-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+default-devel = " \
 cargo \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+fs-read-dir-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-utils+default-devel \
 "
RDEPENDS:rust-gix-features+io-pipe-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+once_cell-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-gix-features+parallel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-gix-features-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-features+prodash-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 "
RDEPENDS:rust-gix-features+progress-devel = " \
 cargo \
 rust-gix-features+prodash-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+progress-unit-bytes-devel = " \
 cargo \
 rust-bytesize+default-devel \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 rust-prodash+unit-bytes-devel \
 "
RDEPENDS:rust-gix-features+progress-unit-human-numbers-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 rust-prodash+unit-human-devel \
 "
RDEPENDS:rust-gix-features+tracing-detail-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-trace+tracing-detail-devel \
 "
RDEPENDS:rust-gix-features+tracing-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-trace+tracing-devel \
 "
RDEPENDS:rust-gix-features+walkdir-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-path+default-devel \
 rust-gix-utils+default-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-gix-features+zlib-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-libz-rs-sys+default-devel \
 rust-thiserror+default-devel \
 "
RDEPENDS:rust-gix-features-devel = " \
 cargo \
 rust \
 rust-gix-trace+default-devel \
 rust-libc+default-devel \
 "
