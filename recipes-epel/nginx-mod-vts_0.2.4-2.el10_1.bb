# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-vts"
PV = "0.2.4"
PR = "2.el10_1"
PACKAGES = " \
 nginx-mod-vts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-vts-0.2.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d22bb6ba12e49d61264192902e890fd0ed7bd683424e6b613b6b1bbb94947328"

URI_x86_64_v2_nginx-mod-vts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-vts-0.2.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-vts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-vts}"
SRC_URI[x86_64_v2_nginx-mod-vts.sha256sum] = "7254487478eb8c2b4b8690705c4b883d76349fed0dc7c7e028c9bf841a795413"

URI_aarch64_nginx-mod-vts = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-vts-0.2.4-2.el10_1.aarch64.rpm;name=aarch64_nginx-mod-vts;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-vts}"
SRC_URI[aarch64_nginx-mod-vts.sha256sum] = "2fa0f1955dcec192cc5d3801bc79c8d29d0a3482d41c431a00bcc0d613fceb88"

RDEPENDS:nginx-mod-vts = " \
 glibc \
 nginx \
 "
