# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-psutil"
PV = "5.9.8"
PR = "5.el10"
PACKAGES = " \
 python3-psutil \
 python3-psutil-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-psutil-5.9.8-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d32b3d152577315098405151350102333231caeb04713cc89cdd136aa69c89f"

URI_x86_64_v2_python3-psutil = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-psutil-5.9.8-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-psutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-psutil}"
SRC_URI[x86_64_v2_python3-psutil.sha256sum] = "ebc708ebd1f00dadf2d234c29bf566882418006847152e9d7a6e1b7d547923ac"

URI_x86_64_v2_python3-psutil-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-psutil-tests-5.9.8-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-psutil-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-psutil-tests}"
SRC_URI[x86_64_v2_python3-psutil-tests.sha256sum] = "d75ceaf7037e36a793115efdd8ec02f50544e7ced0aff82fc8ddcfb283552fd2"

URI_aarch64_python3-psutil = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-psutil-5.9.8-5.el10.aarch64.rpm;name=aarch64_python3-psutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-psutil}"
SRC_URI[aarch64_python3-psutil.sha256sum] = "3538c3b1ed3104493fc0be3a65a3b56f5f22a15a89f814de27397f7023a0b42c"

URI_aarch64_python3-psutil-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-psutil-tests-5.9.8-5.el10.aarch64.rpm;name=aarch64_python3-psutil-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-psutil-tests}"
SRC_URI[aarch64_python3-psutil-tests.sha256sum] = "c936f4013c6bf6f1196c852a54538ac07b63ffbb73671d4a77fc9376a8add4aa"

RDEPENDS:python3-psutil = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-psutil-tests = " \
 python3 \
 python3-psutil \
 "
