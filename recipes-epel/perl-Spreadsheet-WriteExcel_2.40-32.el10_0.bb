# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Spreadsheet-WriteExcel"
PV = "2.40"
PR = "32.el10_0"
PACKAGES = " \
 perl-Spreadsheet-WriteExcel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Spreadsheet-WriteExcel-2.40-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01faf5a127840dbaa9cb5f053dc861be03567d7cbd4f574e85f861a5d3dfe509"

URI_x86_64_v2_perl-Spreadsheet-WriteExcel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Spreadsheet-WriteExcel-2.40-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Spreadsheet-WriteExcel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Spreadsheet-WriteExcel}"
SRC_URI[x86_64_v2_perl-Spreadsheet-WriteExcel.sha256sum] = "5833b701984f4811a637a049e874cd3e392b65a6f7ff99f49474ee408ea390cd"

URI_aarch64_perl-Spreadsheet-WriteExcel = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Spreadsheet-WriteExcel-2.40-32.el10_0.noarch.rpm;name=aarch64_perl-Spreadsheet-WriteExcel;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Spreadsheet-WriteExcel}"
SRC_URI[aarch64_perl-Spreadsheet-WriteExcel.sha256sum] = "f5023063a1aa42bd5aa24763ceec24c0b22fbf3b46a012f33bbe7ad9c69a0ce6"

RDEPENDS:perl-Spreadsheet-WriteExcel = " \
 perl-Carp \
 perl-Date-Calc \
 perl-Date-Manip \
 perl-Digest-MD4 \
 perl-Encode \
 perl-Exporter \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-OLE-Storage_Lite \
 perl-POSIX \
 perl-Parse-RecDescent \
 perl-Pod-Usage \
 perl-Spreadsheet-WriteExcel \
 perl-Time-Local \
 perl-autouse \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
