# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zix"
PV = "0.8.0"
PR = "2.el10_3"
PACKAGES = " \
 zix \
 zix-devel \
 zix-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/z/zix-0.8.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a32601e37904d876388dc71b497331f0bd25f8cdabeea5ae879959e4c63faf82"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zix-0.8.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zix;unpack=0"
SRC_URI[x86_64_v2_zix.sha256sum] = "0eed43dd184d7f6959498798914a4d52ebc759739a8e144bcfa2867c5cd87886"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zix-devel-0.8.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zix-devel;unpack=0"
SRC_URI[x86_64_v2_zix-devel.sha256sum] = "5e16db4a9455cc3c3a1771bcb35729e11feae81c5643fe36e5cec3835013c8bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zix-doc-0.8.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zix-doc;unpack=0"
SRC_URI[x86_64_v2_zix-doc.sha256sum] = "6d72d437ae15e58793c0fba7345ffcac9a2c2fe284f832db2aa36ccd0adc8ae2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zix-0.8.0-2.el10_3.aarch64.rpm;name=aarch64_zix;unpack=0"
SRC_URI[aarch64_zix.sha256sum] = "05f6e37fb2cf59aad31f2cf88b7a3890b18868204b681c2a67c9dfcd828c0458"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zix-devel-0.8.0-2.el10_3.aarch64.rpm;name=aarch64_zix-devel;unpack=0"
SRC_URI[aarch64_zix-devel.sha256sum] = "31ba052b123ada20c6844ed3cb57b657c4275f477f53de2f64440b65cdf03339"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zix-doc-0.8.0-2.el10_3.noarch.rpm;name=aarch64_zix-doc;unpack=0"
SRC_URI[aarch64_zix-doc.sha256sum] = "9f3880526098abd769a06d57bb822505b0d75ad25ebdec75de57dc121967bc4d"

RDEPENDS:zix = " \
 glibc \
 "
RDEPENDS:zix-devel = " \
 pkgconf-pkg-config \
 zix \
 "
RDEPENDS:zix-doc = " \
 "
