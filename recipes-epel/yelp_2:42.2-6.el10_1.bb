# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yelp"
PE = "2"
PV = "42.2"
PR = "6.el10_1"
PACKAGES = " \
 yelp \
 yelp-devel \
 yelp-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yelp-42.2-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6c0293324273de73862bfecb70db10228b4af02fba62a0537034cf011f5cd8d"

URI_x86_64_v2_yelp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yelp-42.2-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yelp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yelp}"
SRC_URI[x86_64_v2_yelp.sha256sum] = "8485f815b9a64c583c4623ecbf800991383ce15f50f06153a1f6cdd2013606aa"

URI_x86_64_v2_yelp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yelp-devel-42.2-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yelp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yelp-devel}"
SRC_URI[x86_64_v2_yelp-devel.sha256sum] = "3a2fbe0e590f01e91c937020aa1e9b479c1d2b71ae50fa7f718d77118d2e57b4"

URI_x86_64_v2_yelp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yelp-libs-42.2-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yelp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yelp-libs}"
SRC_URI[x86_64_v2_yelp-libs.sha256sum] = "527f364410a2b320481bd9643751c5b80a2c25973f4f546b4d6eabe6d131cf1e"

URI_aarch64_yelp = "${EPEL_MIRROR}/aarch64/Packages/y/yelp-42.2-6.el10_1.aarch64.rpm;name=aarch64_yelp;unpack=0"
SRC_URI:append = " ${URI_aarch64_yelp}"
SRC_URI[aarch64_yelp.sha256sum] = "29116042908782899903898f1996079e0f5ac4f0f040fa2bd6c0819e35f3d728"

URI_aarch64_yelp-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yelp-devel-42.2-6.el10_1.aarch64.rpm;name=aarch64_yelp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yelp-devel}"
SRC_URI[aarch64_yelp-devel.sha256sum] = "bf4b83110eef30870878a8d7db7afc66e60b5647041dc01e05f2781c7edb16b5"

URI_aarch64_yelp-libs = "${EPEL_MIRROR}/aarch64/Packages/y/yelp-libs-42.2-6.el10_1.aarch64.rpm;name=aarch64_yelp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_yelp-libs}"
SRC_URI[aarch64_yelp-libs.sha256sum] = "fe8a862088ea94ea716e75e3545fed200cebaf5968978499bbed78743832ac8b"

RDEPENDS:yelp = " \
 glib2 \
 glibc \
 gtk3 \
 libhandy \
 webkit2gtk4.1 \
 yelp-libs \
 yelp-xsl \
 "
RDEPENDS:yelp-devel = " \
 yelp-libs \
 "
RDEPENDS:yelp-libs = " \
 atk \
 bzip2-libs \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 javascriptcoregtk4.1 \
 libhandy \
 libsoup3 \
 libxml2 \
 libxslt \
 pango \
 sqlite-libs \
 webkit2gtk4.1 \
 xz-libs \
 "
