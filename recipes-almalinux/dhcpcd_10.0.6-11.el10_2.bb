# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcpcd"
PV = "10.0.6"
PR = "11.el10_2"
PACKAGES = " \
 dhcpcd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dhcpcd-10.0.6-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab9b24c1728d0389095ad52a0c5883889a2db3d8d41ccbd220942279ad4dee90"

URI_x86_64_v2_dhcpcd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dhcpcd-10.0.6-11.el10_2.x86_64_v2.rpm;name=x86_64_v2_dhcpcd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhcpcd}"
SRC_URI[x86_64_v2_dhcpcd.sha256sum] = "42840908bc607174037e599bdae561887ec58fe83ccb8cd77d03ebf17975e328"

URI_aarch64_dhcpcd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dhcpcd-10.0.6-11.el10_2.aarch64.rpm;name=aarch64_dhcpcd;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhcpcd}"
SRC_URI[aarch64_dhcpcd.sha256sum] = "1d8a6ff0b0c2e33a6ce7caefdafe5cb85683dcbea700e02b55e30c66871ea617"

RDEPENDS:dhcpcd = " \
 bash \
 glibc \
 shadow-utils \
 systemd \
 systemd-libs \
 "
