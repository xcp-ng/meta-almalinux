# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sensible-utils"
PV = "0.0.24"
PR = "3.el10_1"
PACKAGES = " \
 sensible-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sensible-utils-0.0.24-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "303d0f44d6714a0a7efe2c24b9331e213c5ea8829852b7ea637b5be30eb345a1"

URI_x86_64_v2_sensible-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sensible-utils-0.0.24-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sensible-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sensible-utils}"
SRC_URI[x86_64_v2_sensible-utils.sha256sum] = "ecae3882a6c5665b01f02a380b1dce8007fb6e2020a1426f5ac7a86f9fa9bf17"

URI_aarch64_sensible-utils = "${EPEL_MIRROR}/aarch64/Packages/s/sensible-utils-0.0.24-3.el10_1.noarch.rpm;name=aarch64_sensible-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_sensible-utils}"
SRC_URI[aarch64_sensible-utils.sha256sum] = "c3bbc7c9f31a816c4da9172f0235e8a0aa58d9f9e9762d8ea99cf0edf187d3f8"

RDEPENDS:sensible-utils = " \
 bash \
 gettext-runtime \
 virtual//usr/bin/realpath \
 "
