# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mkdocs-material"
PV = "9.5.48"
PR = "4.el10_1"
PACKAGES = " \
 mkdocs-material \
 mkdocs-material+imaging \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mkdocs-material-9.5.48-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00eef3a98aded2c3e816684b40082fc7653f65c1e31d5d69212d6255c2ec0469"

URI_x86_64_v2_mkdocs-material = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mkdocs-material-9.5.48-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mkdocs-material;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mkdocs-material}"
SRC_URI[x86_64_v2_mkdocs-material.sha256sum] = "ece6a1c73f622a8c655b49b533987680953cfa18155549194d9e51fb47eb60e8"

URI_x86_64_v2_mkdocs-material+imaging = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mkdocs-material+imaging-9.5.48-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mkdocs-material+imaging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mkdocs-material+imaging}"
SRC_URI[x86_64_v2_mkdocs-material+imaging.sha256sum] = "8a22a7ee5c9c46012310b2c6b818270d878dc36ed1ba9bc45a28d9d0e48198fb"

URI_aarch64_mkdocs-material = "${EPEL_MIRROR}/aarch64/Packages/m/mkdocs-material-9.5.48-4.el10_1.noarch.rpm;name=aarch64_mkdocs-material;unpack=0"
SRC_URI:append = " ${URI_aarch64_mkdocs-material}"
SRC_URI[aarch64_mkdocs-material.sha256sum] = "b8f292d08ab4a2e240bdbfc91cd20c18c809d4e58f42cf15ad99dbd86d143cca"

URI_aarch64_mkdocs-material+imaging = "${EPEL_MIRROR}/aarch64/Packages/m/mkdocs-material+imaging-9.5.48-4.el10_1.noarch.rpm;name=aarch64_mkdocs-material+imaging;unpack=0"
SRC_URI:append = " ${URI_aarch64_mkdocs-material+imaging}"
SRC_URI[aarch64_mkdocs-material+imaging.sha256sum] = "bbfad9458a09af8f16a63984b4772292e2d13a55de5db74ac1d55af016872441"

RDEPENDS:mkdocs-material = " \
 mkdocs \
 python3 \
 python3-babel \
 python3-colorama \
 python3-jinja2 \
 python3-markdown \
 python3-paginate \
 python3-pygments \
 python3-pymdown-extensions \
 python3-regex \
 python3-requests \
 "
RDEPENDS:mkdocs-material+imaging = " \
 mkdocs-material \
 python3 \
 python3-cairosvg \
 python3-pillow \
 "
