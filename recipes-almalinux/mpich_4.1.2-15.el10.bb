# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mpich"
PV = "4.1.2"
PR = "15.el10"
PACKAGES = " \
 mpich \
 mpich-autoload \
 mpich-devel \
 mpich-doc \
 python3-mpich \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mpich-4.1.2-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efb199e5e931718f7eebeb5d098e7b3c2eb8adaf970042f68f8f3b9943246c28"

URI_x86_64_v2_mpich = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mpich-4.1.2-15.el10.x86_64_v2.rpm;name=x86_64_v2_mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpich}"
SRC_URI[x86_64_v2_mpich.sha256sum] = "392f104152172e7a2a45ced28729f23f90e56d5aa638508a5fc6c3797f7e0d41"

URI_x86_64_v2_mpich-autoload = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mpich-autoload-4.1.2-15.el10.x86_64_v2.rpm;name=x86_64_v2_mpich-autoload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpich-autoload}"
SRC_URI[x86_64_v2_mpich-autoload.sha256sum] = "eda4074c119c3d8be5acc1a9f4684d54b4dba6d17df4850e2d0b12623a7f80f4"

URI_x86_64_v2_mpich-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mpich-devel-4.1.2-15.el10.x86_64_v2.rpm;name=x86_64_v2_mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpich-devel}"
SRC_URI[x86_64_v2_mpich-devel.sha256sum] = "d546cd5835c20799d905e28dc923c7bedbed8cbd3285c7b0ae30eb673f13eea7"

URI_x86_64_v2_mpich-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mpich-doc-4.1.2-15.el10.noarch.rpm;name=x86_64_v2_mpich-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpich-doc}"
SRC_URI[x86_64_v2_mpich-doc.sha256sum] = "f6afababdf38703258401ae5974b290d19fe8378ef9b7c300f06268bd0cae190"

URI_x86_64_v2_python3-mpich = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-mpich-4.1.2-15.el10.x86_64_v2.rpm;name=x86_64_v2_python3-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mpich}"
SRC_URI[x86_64_v2_python3-mpich.sha256sum] = "981e0b6cecf33a81bfa3e2278c78a862faf7b4a2394d4ae5093e5f913016590f"

URI_aarch64_mpich = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mpich-4.1.2-15.el10.aarch64.rpm;name=aarch64_mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpich}"
SRC_URI[aarch64_mpich.sha256sum] = "4492ea6ed4349f3fcf91bd280bf8278db9309c9770f440ebcbc3eff8c7979efc"

URI_aarch64_mpich-autoload = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mpich-autoload-4.1.2-15.el10.aarch64.rpm;name=aarch64_mpich-autoload;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpich-autoload}"
SRC_URI[aarch64_mpich-autoload.sha256sum] = "d6418bad0aa79e0ce361ab8d615069c324d910327b39551f20d0827c9ce78828"

URI_aarch64_mpich-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mpich-devel-4.1.2-15.el10.aarch64.rpm;name=aarch64_mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpich-devel}"
SRC_URI[aarch64_mpich-devel.sha256sum] = "9d6120ae5e5b268e3bcaa951c9d66129add3b6c563b572c2dcb1e1f65d90b32e"

URI_aarch64_mpich-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mpich-doc-4.1.2-15.el10.noarch.rpm;name=aarch64_mpich-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpich-doc}"
SRC_URI[aarch64_mpich-doc.sha256sum] = "f6afababdf38703258401ae5974b290d19fe8378ef9b7c300f06268bd0cae190"

URI_aarch64_python3-mpich = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-mpich-4.1.2-15.el10.aarch64.rpm;name=aarch64_python3-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mpich}"
SRC_URI[aarch64_python3-mpich.sha256sum] = "6d8ca0492836b48bb707e39a3bcf28a5a345a1fa3fb81e7df86dc3ace03f55b0"

RDEPENDS:mpich:x86_64_v2 = " \
 glibc \
 hwloc-libs \
 libfabric \
 libgcc \
 libgfortran \
 libstdc++ \
 perl-interpreter \
 python3 \
 virtual/environment_modules_ \
"
RDEPENDS:mpich:aarch64 = " \
 glibc \
 hwloc-libs \
 libfabric \
 libgfortran \
 libstdc++ \
 perl-interpreter \
 python3 \
 virtual/environment_modules_ \
"
RDEPENDS:mpich-autoload = " \
 mpich \
 "
RDEPENDS:mpich-devel = " \
 bash \
 gcc-gfortran \
 mpich \
 pkgconf-pkg-config \
 redhat-rpm-config \
 rpm-mpi-hooks \
 "
RDEPENDS:mpich-doc = " \
 mpich-devel \
 "
RDEPENDS:python3-mpich = " \
 mpich \
 python3 \
 "
