# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-YAML"
PV = "1.31"
PR = "7.el10"
PACKAGES = " \
 perl-YAML \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-YAML-1.31-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b9ec266effe3fe792088d720bc95cb46d08640760339bf85766ea0160d6776a"

URI_x86_64_v2_perl-YAML = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-YAML-1.31-7.el10.noarch.rpm;name=x86_64_v2_perl-YAML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-YAML}"
SRC_URI[x86_64_v2_perl-YAML.sha256sum] = "653e94b68098c2c8b07ff4b6cac1c8f3f7aaad76deeb20fccd626f1522b78b5f"

URI_aarch64_perl-YAML = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-YAML-1.31-7.el10.noarch.rpm;name=aarch64_perl-YAML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-YAML}"
SRC_URI[aarch64_perl-YAML.sha256sum] = "653e94b68098c2c8b07ff4b6cac1c8f3f7aaad76deeb20fccd626f1522b78b5f"

RDEPENDS:perl-YAML = " \
 perl-B \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 perl-overload \
 "
