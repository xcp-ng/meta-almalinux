# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base64"
PV = "0.22.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-base64+alloc-devel \
 rust-base64+default-devel \
 rust-base64+std-devel \
 rust-base64-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base64-0.22.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b904b3753c6ff04c18039a9a5fa8615aa2c801faa7a44c1ec1536ac522ab64a5"

URI_x86_64_v2_rust-base64+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64+alloc-devel-0.22.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64+alloc-devel}"
SRC_URI[x86_64_v2_rust-base64+alloc-devel.sha256sum] = "0b2a548da1ed2143c4b26a7d288db2783e70819261c562f0ff62f7a14cd9f386"

URI_x86_64_v2_rust-base64+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64+default-devel-0.22.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64+default-devel}"
SRC_URI[x86_64_v2_rust-base64+default-devel.sha256sum] = "780972eea7c8bd4fb42569e42aa3c0d6f77f408d4f96e36d0741fa8a7671b391"

URI_x86_64_v2_rust-base64+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64+std-devel-0.22.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64+std-devel}"
SRC_URI[x86_64_v2_rust-base64+std-devel.sha256sum] = "5809bce17991c8caa2ba22f070ad0d45a75a8ddd6c9facd77ad2f939c0837be6"

URI_x86_64_v2_rust-base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64-devel-0.22.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64-devel}"
SRC_URI[x86_64_v2_rust-base64-devel.sha256sum] = "85eb02010aed98041e1d33cefd7cdf30db6e45796240b247466d2c48c93fe3e0"

URI_aarch64_rust-base64+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64+alloc-devel-0.22.1-2.el10_0.noarch.rpm;name=aarch64_rust-base64+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64+alloc-devel}"
SRC_URI[aarch64_rust-base64+alloc-devel.sha256sum] = "e0b0ad9c9be4538b29ce7ae7e05953a5faa3a4c5cc6ac230040968bd5d57c282"

URI_aarch64_rust-base64+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64+default-devel-0.22.1-2.el10_0.noarch.rpm;name=aarch64_rust-base64+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64+default-devel}"
SRC_URI[aarch64_rust-base64+default-devel.sha256sum] = "a5a76a147f36d418542d6517ad8870684a070dda2736639bd92c0b956c89ba81"

URI_aarch64_rust-base64+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64+std-devel-0.22.1-2.el10_0.noarch.rpm;name=aarch64_rust-base64+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64+std-devel}"
SRC_URI[aarch64_rust-base64+std-devel.sha256sum] = "1345cea6e14ea910174824def932e8da20a159c69e01075845cb980516dea4cb"

URI_aarch64_rust-base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64-devel-0.22.1-2.el10_0.noarch.rpm;name=aarch64_rust-base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64-devel}"
SRC_URI[aarch64_rust-base64-devel.sha256sum] = "b7ec1d9d52586dc5b96c953af3e7ec8386e2f6ffb4ed45535b85e926cda4bf13"

RDEPENDS:rust-base64+alloc-devel = " \
 cargo \
 rust-base64-devel \
 "
RDEPENDS:rust-base64+default-devel = " \
 cargo \
 rust-base64+std-devel \
 rust-base64-devel \
 "
RDEPENDS:rust-base64+std-devel = " \
 cargo \
 rust-base64+alloc-devel \
 rust-base64-devel \
 "
RDEPENDS:rust-base64-devel = " \
 cargo \
 rust \
 "
