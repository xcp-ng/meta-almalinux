# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-philhofer-fwd"
PV = "1.1.2"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-philhofer-fwd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-philhofer-fwd-1.1.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64187efcd45c73ec79bdcc11b00ff38ebf1ab467cdf6c0c4d10e95cae708c0ec"

URI_x86_64_v2_golang-github-philhofer-fwd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-philhofer-fwd-devel-1.1.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-philhofer-fwd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-philhofer-fwd-devel}"
SRC_URI[x86_64_v2_golang-github-philhofer-fwd-devel.sha256sum] = "6c0c2befe608a786c6674cd184a6ed949b2e20aa30d1b075936fb22fdd174aa1"

URI_aarch64_golang-github-philhofer-fwd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-philhofer-fwd-devel-1.1.2-4.el10_0.noarch.rpm;name=aarch64_golang-github-philhofer-fwd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-philhofer-fwd-devel}"
SRC_URI[aarch64_golang-github-philhofer-fwd-devel.sha256sum] = "e077f4d426b0d43a06383ad270680e9309c4121b84283339c4ba7b57f95fff56"

RDEPENDS:golang-github-philhofer-fwd-devel = " \
 go-filesystem \
 "
