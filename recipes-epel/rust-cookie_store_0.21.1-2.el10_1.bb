# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cookie_store"
PV = "0.21.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-cookie_store+default-devel \
 rust-cookie_store+log_secure_cookie_values-devel \
 rust-cookie_store+preserve_order-devel \
 rust-cookie_store+public_suffix-devel \
 rust-cookie_store+serde-devel \
 rust-cookie_store+serde_json-devel \
 rust-cookie_store-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cookie_store-0.21.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0395f47a487755844bdf175f1eeb9f62f537aff57f493c185df98fc6a5cc689e"

URI_x86_64_v2_rust-cookie_store+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+default-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+default-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+default-devel.sha256sum] = "b03bedab043559b866151d8ab5ff29922273b212d1c9d8db484556e17a1d6d55"

URI_x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+log_secure_cookie_values-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+log_secure_cookie_values-devel.sha256sum] = "d91a0b344d1e30b78fa995a1d896e685d042413ab7c2b4c4e26a7b505ba8b2aa"

URI_x86_64_v2_rust-cookie_store+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+preserve_order-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+preserve_order-devel.sha256sum] = "3972d198a9af7f4dd65abc28abf6a920b4b75a942be4b750a512d8d7da5e19fc"

URI_x86_64_v2_rust-cookie_store+public_suffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+public_suffix-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+public_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+public_suffix-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+public_suffix-devel.sha256sum] = "30baf71891f6664548a52b5eb22adb8bd9ea5df94102f8bb88504382e9fa18b1"

URI_x86_64_v2_rust-cookie_store+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+serde-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+serde-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+serde-devel.sha256sum] = "a7a42187b9e88a6a95bd86f2fa0a43059de146af0705bfea2d1f0550dcb158d1"

URI_x86_64_v2_rust-cookie_store+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store+serde_json-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store+serde_json-devel}"
SRC_URI[x86_64_v2_rust-cookie_store+serde_json-devel.sha256sum] = "01ccc826d374305e7542be80d3be7da886095bf324107d960b2498b70afec034"

URI_x86_64_v2_rust-cookie_store-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie_store-devel-0.21.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie_store-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie_store-devel}"
SRC_URI[x86_64_v2_rust-cookie_store-devel.sha256sum] = "04e33274cb22068d6969b897984ba2b4a2ebb02398152e2b1523233885d62b64"

URI_aarch64_rust-cookie_store+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+default-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cookie_store+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+default-devel}"
SRC_URI[aarch64_rust-cookie_store+default-devel.sha256sum] = "6036cae2341564b0659b8364244e9af419f0c5e61561ee720f7a50c3d68f7582"

URI_aarch64_rust-cookie_store+log_secure_cookie_values-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+log_secure_cookie_values-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cookie_store+log_secure_cookie_values-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+log_secure_cookie_values-devel}"
SRC_URI[aarch64_rust-cookie_store+log_secure_cookie_values-devel.sha256sum] = "acb5f665bcfa4e8d8066760351981af8936dc5489a5ca56ff5da29a7dd1c9f2f"

URI_aarch64_rust-cookie_store+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+preserve_order-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cookie_store+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+preserve_order-devel}"
SRC_URI[aarch64_rust-cookie_store+preserve_order-devel.sha256sum] = "5b8100cc0cb3483ac8d5ba2771d65069da60e60a305490e5dc63efb2577cfb93"

URI_aarch64_rust-cookie_store+public_suffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+public_suffix-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cookie_store+public_suffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+public_suffix-devel}"
SRC_URI[aarch64_rust-cookie_store+public_suffix-devel.sha256sum] = "69cc33ec0cbf30c67a9cef24cca73b65d10b82fca65c3886e04be481b447bf79"

URI_aarch64_rust-cookie_store+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+serde-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cookie_store+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+serde-devel}"
SRC_URI[aarch64_rust-cookie_store+serde-devel.sha256sum] = "ff06287623d50a284888cdce02371ef25cc2905c5d3a25e1259a33dcbd4199da"

URI_aarch64_rust-cookie_store+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store+serde_json-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cookie_store+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store+serde_json-devel}"
SRC_URI[aarch64_rust-cookie_store+serde_json-devel.sha256sum] = "8b56754e2afda2119f6ea3e4f2be0944812f4d9d74fc818ab1c72cd627c0d6ec"

URI_aarch64_rust-cookie_store-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie_store-devel-0.21.1-2.el10_1.noarch.rpm;name=aarch64_rust-cookie_store-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie_store-devel}"
SRC_URI[aarch64_rust-cookie_store-devel.sha256sum] = "31bfd58a75a718b4c200fb6cc35d028b0a13217db7f02bf33dbd8981d081e267"

RDEPENDS:rust-cookie_store+default-devel = " \
 cargo \
 rust-cookie_store+public_suffix-devel \
 rust-cookie_store+serde_json-devel \
 rust-cookie_store-devel \
 "
RDEPENDS:rust-cookie_store+log_secure_cookie_values-devel = " \
 cargo \
 rust-cookie_store-devel \
 "
RDEPENDS:rust-cookie_store+preserve_order-devel = " \
 cargo \
 rust-cookie_store-devel \
 rust-indexmap+default-devel \
 "
RDEPENDS:rust-cookie_store+public_suffix-devel = " \
 cargo \
 rust-cookie_store-devel \
 rust-publicsuffix+default-devel \
 "
RDEPENDS:rust-cookie_store+serde-devel = " \
 cargo \
 rust-cookie_store-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-cookie_store+serde_json-devel = " \
 cargo \
 rust-cookie_store+serde-devel \
 rust-cookie_store-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-cookie_store-devel = " \
 bash \
 cargo \
 rust \
 rust-cookie+default-devel \
 rust-cookie+percent-encode-devel \
 rust-document-features+default-devel \
 rust-idna+default-devel \
 rust-log+default-devel \
 rust-time+default-devel \
 rust-url+default-devel \
 "
