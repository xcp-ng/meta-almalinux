# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bit_field"
PV = "0.10.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-bit_field+default-devel \
 rust-bit_field-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bit_field-0.10.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dc6559cbbaf6239f22f27a3d9246aa6545f88539b07ab7930a182a943d0b2a0"

URI_x86_64_v2_rust-bit_field+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit_field+default-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit_field+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit_field+default-devel}"
SRC_URI[x86_64_v2_rust-bit_field+default-devel.sha256sum] = "fffd7c38aeeafee2d214b3aa50c19a6c1cdbd2492d0411dc6942ae540903d65f"

URI_x86_64_v2_rust-bit_field-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit_field-devel-0.10.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit_field-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit_field-devel}"
SRC_URI[x86_64_v2_rust-bit_field-devel.sha256sum] = "218ff7cb56e0adeeb41be4941020b3b318cfd0c6982c6c3b3894fedefd98afe0"

URI_aarch64_rust-bit_field+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit_field+default-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit_field+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit_field+default-devel}"
SRC_URI[aarch64_rust-bit_field+default-devel.sha256sum] = "91b3e7a7929c2c82310281bd129f7cbffce2bb1a06ea6979ba1aa0c3e83aef40"

URI_aarch64_rust-bit_field-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit_field-devel-0.10.3-1.el10_0.noarch.rpm;name=aarch64_rust-bit_field-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit_field-devel}"
SRC_URI[aarch64_rust-bit_field-devel.sha256sum] = "687746004f9e1d0f65eb3dcc1b4b11432ccd27d008a7d3ea0ec80b48aa19bd41"

RDEPENDS:rust-bit_field+default-devel = " \
 cargo \
 rust-bit_field-devel \
 "
RDEPENDS:rust-bit_field-devel = " \
 cargo \
 "
