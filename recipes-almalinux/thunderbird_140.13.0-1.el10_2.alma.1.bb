# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thunderbird"
PV = "140.13.0"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 thunderbird \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/thunderbird-140.13.0-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88e1796692beb673dc3c6184b4f8036165b6e8d1ed0c75083ebb2ffc3d522419"

URI_x86_64_v2_thunderbird = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/thunderbird-140.13.0-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_thunderbird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thunderbird}"
SRC_URI[x86_64_v2_thunderbird.sha256sum] = "dbde50784b4ef033b3099da23ec43be532ecdee887982a7397e348e1b6d655cf"

URI_aarch64_thunderbird = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/thunderbird-140.13.0-1.el10_2.alma.1.aarch64.rpm;name=aarch64_thunderbird;unpack=0"
SRC_URI:append = " ${URI_aarch64_thunderbird}"
SRC_URI[aarch64_thunderbird.sha256sum] = "c3a5190baf6e19bd412014a2b39569f670f875bf12c217a5a24d720aca044fb9"

RDEPENDS:thunderbird = " \
 alsa-lib \
 atk \
 bash \
 bzip2-libs \
 cairo \
 cairo-gobject \
 dbus-libs \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libX11 \
 libX11-xcb \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXrandr \
 libXrender \
 libffi \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libxcb \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 p11-kit-trust \
 pango \
 pciutils-libs \
 zlib-ng-compat \
 "
