# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lskat"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 lskat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lskat-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c18dbe498e2a9203f08091919f0c55a01fb91373a6bd6220f0fde04ea9f3820"

URI_x86_64_v2_lskat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lskat-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lskat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lskat}"
SRC_URI[x86_64_v2_lskat.sha256sum] = "e49bf60574c35018040dd3c4de9cec55b26aed9452bd33611f107017cbeef948"

URI_aarch64_lskat = "${EPEL_MIRROR}/aarch64/Packages/l/lskat-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_lskat;unpack=0"
SRC_URI:append = " ${URI_aarch64_lskat}"
SRC_URI[aarch64_lskat.sha256sum] = "55eb558a64c6ef6d22bc185f9d4cf54b858f3757e16a3ec947ff25930cc30e2d"

RDEPENDS:lskat = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
