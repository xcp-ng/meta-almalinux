# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-ansi-wl-pprint"
PV = "1.0.2"
PR = "2.el10_0"
PACKAGES = " \
 ghc-ansi-wl-pprint \
 ghc-ansi-wl-pprint-devel \
 ghc-ansi-wl-pprint-doc \
 ghc-ansi-wl-pprint-prof \
 ghc-prettyprinter-compat-ansi-wl-pprint \
 ghc-prettyprinter-compat-ansi-wl-pprint-devel \
 ghc-prettyprinter-compat-ansi-wl-pprint-doc \
 ghc-prettyprinter-compat-ansi-wl-pprint-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-ansi-wl-pprint-1.0.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "017a81cad221539d52b6147f4a13bdd83efbeeb26ae78e57c7b0dfbbab1595f5"

URI_x86_64_v2_ghc-ansi-wl-pprint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-wl-pprint-1.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ansi-wl-pprint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-wl-pprint}"
SRC_URI[x86_64_v2_ghc-ansi-wl-pprint.sha256sum] = "f7f27a423afb2b9568aa04fa8f7be0f596b28e3ad8dff494fbbe3cda4e38ba8a"

URI_x86_64_v2_ghc-ansi-wl-pprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-wl-pprint-devel-1.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ansi-wl-pprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-wl-pprint-devel}"
SRC_URI[x86_64_v2_ghc-ansi-wl-pprint-devel.sha256sum] = "d3a6952bc1042b475e41cd57839d4686bd5417318fdee1996f2d666f30f03d6d"

URI_x86_64_v2_ghc-ansi-wl-pprint-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-wl-pprint-doc-1.0.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ansi-wl-pprint-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-wl-pprint-doc}"
SRC_URI[x86_64_v2_ghc-ansi-wl-pprint-doc.sha256sum] = "a4b2f086e441f6b0345935681e19282ab9046e7703afacbd706630e6ee204144"

URI_x86_64_v2_ghc-ansi-wl-pprint-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ansi-wl-pprint-prof-1.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ansi-wl-pprint-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ansi-wl-pprint-prof}"
SRC_URI[x86_64_v2_ghc-ansi-wl-pprint-prof.sha256sum] = "e3a80f8ec9389004db90b0c5d1a78525d0886bbb366a1b3083f53757df958ece"

URI_x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-prettyprinter-compat-ansi-wl-pprint-1.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint}"
SRC_URI[x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint.sha256sum] = "767b0e3f35c945022a7989d8df5d76a6cec342d5943e7b08007ebb8d852e1b7a"

URI_x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-prettyprinter-compat-ansi-wl-pprint-devel-1.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-devel}"
SRC_URI[x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-devel.sha256sum] = "07e3d930965725d458d92cf9261ece2da72b05d775515cb6e697cace359f5d55"

URI_x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-prettyprinter-compat-ansi-wl-pprint-doc-1.0.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-doc}"
SRC_URI[x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-doc.sha256sum] = "260d640c7bc9be514493ff46c0af69599951ea7a249ae151333dc57d89ecf3ab"

URI_x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-prettyprinter-compat-ansi-wl-pprint-prof-1.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-prof}"
SRC_URI[x86_64_v2_ghc-prettyprinter-compat-ansi-wl-pprint-prof.sha256sum] = "02ff95009d07631408f4ab30d53a46069b00c3af395357e3ad62b8e77f3c2d13"

URI_aarch64_ghc-ansi-wl-pprint = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-wl-pprint-1.0.2-2.el10_0.aarch64.rpm;name=aarch64_ghc-ansi-wl-pprint;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-wl-pprint}"
SRC_URI[aarch64_ghc-ansi-wl-pprint.sha256sum] = "a8bbd1c5540d65b1a688c2889eb4f4d24d652294bea970ff47843fcbb92ce69a"

URI_aarch64_ghc-ansi-wl-pprint-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-wl-pprint-devel-1.0.2-2.el10_0.aarch64.rpm;name=aarch64_ghc-ansi-wl-pprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-wl-pprint-devel}"
SRC_URI[aarch64_ghc-ansi-wl-pprint-devel.sha256sum] = "50a63180fe33c3d7e765e2a0e3ad8c70e969a80f41df3168468ecb014ab46487"

URI_aarch64_ghc-ansi-wl-pprint-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-wl-pprint-doc-1.0.2-2.el10_0.noarch.rpm;name=aarch64_ghc-ansi-wl-pprint-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-wl-pprint-doc}"
SRC_URI[aarch64_ghc-ansi-wl-pprint-doc.sha256sum] = "4264481dfc96699df18e8a3505313f572d3dc74957f7642ed90c6c7551b4d09f"

URI_aarch64_ghc-ansi-wl-pprint-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ansi-wl-pprint-prof-1.0.2-2.el10_0.aarch64.rpm;name=aarch64_ghc-ansi-wl-pprint-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ansi-wl-pprint-prof}"
SRC_URI[aarch64_ghc-ansi-wl-pprint-prof.sha256sum] = "ff1be0f76f9ee809987b82624701d3ff552f2454ab6962ac248db38d22d985ab"

URI_aarch64_ghc-prettyprinter-compat-ansi-wl-pprint = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-prettyprinter-compat-ansi-wl-pprint-1.0.2-2.el10_0.aarch64.rpm;name=aarch64_ghc-prettyprinter-compat-ansi-wl-pprint;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-prettyprinter-compat-ansi-wl-pprint}"
SRC_URI[aarch64_ghc-prettyprinter-compat-ansi-wl-pprint.sha256sum] = "a663ed0b775eb634310859e0765ded408da4f22a3e17af39c37b5cb6e781ea82"

URI_aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-prettyprinter-compat-ansi-wl-pprint-devel-1.0.2-2.el10_0.aarch64.rpm;name=aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-devel}"
SRC_URI[aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-devel.sha256sum] = "3a709daf5eaa1787baea3d7bded0ce3ec86493c66fb7932084ba41a899099e65"

URI_aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-prettyprinter-compat-ansi-wl-pprint-doc-1.0.2-2.el10_0.noarch.rpm;name=aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-doc}"
SRC_URI[aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-doc.sha256sum] = "c73f029b475976c5b7b2bcba6c24c74b94c5532ce30a0825f5205e19aaa0ddda"

URI_aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-prettyprinter-compat-ansi-wl-pprint-prof-1.0.2-2.el10_0.aarch64.rpm;name=aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-prof}"
SRC_URI[aarch64_ghc-prettyprinter-compat-ansi-wl-pprint-prof.sha256sum] = "402049caf97cfa83754eb9866d6e87a2a462a9fcfb58f36f4cfd69350dfb9fd2"

RDEPENDS:ghc-ansi-wl-pprint = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-prettyprinter-compat-ansi-wl-pprint \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ansi-wl-pprint-devel = " \
 ghc-ansi-wl-pprint \
 ghc-base-devel \
 ghc-compiler \
 ghc-prettyprinter-compat-ansi-wl-pprint-devel \
 "
RDEPENDS:ghc-ansi-wl-pprint-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ansi-wl-pprint-prof = " \
 ghc-ansi-wl-pprint-devel \
 ghc-base-prof \
 ghc-prettyprinter-compat-ansi-wl-pprint-prof \
 "
RDEPENDS:ghc-prettyprinter-compat-ansi-wl-pprint = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-prettyprinter-compat-ansi-wl-pprint-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-prettyprinter-ansi-terminal-devel \
 ghc-prettyprinter-compat-ansi-wl-pprint \
 ghc-prettyprinter-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-prettyprinter-compat-ansi-wl-pprint-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-prettyprinter-compat-ansi-wl-pprint-prof = " \
 ghc-base-prof \
 ghc-prettyprinter-ansi-terminal-prof \
 ghc-prettyprinter-compat-ansi-wl-pprint-devel \
 ghc-prettyprinter-prof \
 ghc-text-prof \
 "
