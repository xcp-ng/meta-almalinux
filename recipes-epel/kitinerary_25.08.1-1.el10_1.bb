# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kitinerary"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kitinerary \
 kitinerary-devel \
 kitinerary-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kitinerary-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c94152541cc55666885149b25b98add493c20fe49e1738eee721bd60d579c275"

URI_x86_64_v2_kitinerary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary}"
SRC_URI[x86_64_v2_kitinerary.sha256sum] = "f2e8139ad1afcfbd4ab1aa611e77981ca708333a63c89f88bd25204100edfb84"

URI_x86_64_v2_kitinerary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary-devel}"
SRC_URI[x86_64_v2_kitinerary-devel.sha256sum] = "bdcd88c06fc87be57c6100d3651476219947ae1de91589fd9cd0fe1b5de57272"

URI_x86_64_v2_kitinerary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kitinerary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary-doc}"
SRC_URI[x86_64_v2_kitinerary-doc.sha256sum] = "c3054371b2b51ea4b199900f4587f254beaa8a7cc2fb49b732e3501426575faa"

URI_aarch64_kitinerary = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kitinerary;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary}"
SRC_URI[aarch64_kitinerary.sha256sum] = "683be765901b82a2d6ab4d8da1088184f94d51eef6e54b32de37ddfa7e173919"

URI_aarch64_kitinerary-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kitinerary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary-devel}"
SRC_URI[aarch64_kitinerary-devel.sha256sum] = "59a04ff00f6704f3ec1c28179e6697dcaf158fe8b615ccebfc3e9d70998a1213"

URI_aarch64_kitinerary-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kitinerary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary-doc}"
SRC_URI[aarch64_kitinerary-doc.sha256sum] = "2929c75471edbe12ada4d34489eb4f081ff733bcd7148bf7ffb343b177b9326d"

RDEPENDS:kitinerary = " \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcontacts \
 kf6-ki18n \
 kmime \
 kpkpass \
 libgcc \
 libstdc++ \
 libxml2 \
 openssl-libs \
 poppler \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 zxing-cpp \
 "
RDEPENDS:kitinerary-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kitinerary \
 kmime-devel \
 kpkpass-devel \
 "
RDEPENDS:kitinerary-doc = " \
 "
