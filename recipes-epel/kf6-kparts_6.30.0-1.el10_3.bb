# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kparts"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kparts \
 kf6-kparts-devel \
 kf6-kparts-doc \
 kf6-kparts-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kparts-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8e92154b98bd310051b1ba15efde9f9737c8c4f7fdf954a08f92af44f43f3e75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts;unpack=0"
SRC_URI[x86_64_v2_kf6-kparts.sha256sum] = "f659f97f926d38a1ff161c4b7aeb7abcb9fe1807bfa07e63ec84c6ec5a3b011e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kparts-devel.sha256sum] = "4419a76175f759baf1fa07621c1eb9fc4532624cb6444143c036e528023f5ab8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kparts-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kparts-doc.sha256sum] = "8ebc23c2961aeeba01c8bce275904c5edac1a5abbabda54d798d220f8d0e1099"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kparts-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kparts-html.sha256sum] = "9e5c78fd1da6740112be41850e3f7fa9e5fbe37c32a12f704232ef50db1a9247"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kparts;unpack=0"
SRC_URI[aarch64_kf6-kparts.sha256sum] = "54d88d75d1d1c232c565a805c76c82d2b308d5c2f7f3feb9d9b367a7ad60fe0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kparts-devel;unpack=0"
SRC_URI[aarch64_kf6-kparts-devel.sha256sum] = "61250445423aa1ca8e15c15aa3c75389627ea843e3e96a9d10929263897a9acc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kparts-doc;unpack=0"
SRC_URI[aarch64_kf6-kparts-doc.sha256sum] = "8c5dfe65b3338e836f42a55a6f9847b24efe0189f82696a805127d3ae6e72d86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kparts-html;unpack=0"
SRC_URI[aarch64_kf6-kparts-html.sha256sum] = "19b1d6b32a105cdac9345332ae90c71b65c93f0b3b2911b674b9d6bf4c6f11bb"

RDEPENDS:kf6-kparts = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kparts-devel = " \
 cmake-filesystem \
 kf6-kio-devel \
 kf6-kparts \
 kf6-ktextwidgets-devel \
 kf6-kxmlgui-devel \
 "
RDEPENDS:kf6-kparts-doc = " \
 "
RDEPENDS:kf6-kparts-html = " \
 "
