# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdwarf"
PE = "1"
PV = "2.1.0"
PR = "2.el10_1"
PACKAGES = " \
 libdwarf \
 libdwarf-devel \
 libdwarf-static \
 libdwarf-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdwarf-2.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7283376d61e00b504757853f982ed8f711845d5973b3c8c2023abf62ecb67fc9"

URI_x86_64_v2_libdwarf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-2.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdwarf}"
SRC_URI[x86_64_v2_libdwarf.sha256sum] = "3e000b83ab06a7a95346a0e995b6d7eeb2d4fda4c90c8c3d37da8fa01d3759bb"

URI_x86_64_v2_libdwarf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-devel-2.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdwarf-devel}"
SRC_URI[x86_64_v2_libdwarf-devel.sha256sum] = "604b91f36c3e0696a528ddf38bd1cc9e36a10d49d388656ff92928672665820e"

URI_x86_64_v2_libdwarf-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-static-2.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdwarf-static}"
SRC_URI[x86_64_v2_libdwarf-static.sha256sum] = "16d90c448535023cbfb2cba74c5d38c7826138aa03a36c557df878f71a84cf09"

URI_x86_64_v2_libdwarf-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdwarf-tools-2.1.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdwarf-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdwarf-tools}"
SRC_URI[x86_64_v2_libdwarf-tools.sha256sum] = "80376bbc8f6e0b0aeef57175e6b379c48412a6cb0ff8b3e37539d98802cfba30"

URI_aarch64_libdwarf = "${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-2.1.0-2.el10_1.aarch64.rpm;name=aarch64_libdwarf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdwarf}"
SRC_URI[aarch64_libdwarf.sha256sum] = "378cfd9c989222532313e1b1dc3d02455c9e75a15a9db685db681ecdb5a6a105"

URI_aarch64_libdwarf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-devel-2.1.0-2.el10_1.aarch64.rpm;name=aarch64_libdwarf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdwarf-devel}"
SRC_URI[aarch64_libdwarf-devel.sha256sum] = "c5539868e0bfd36f15b6155415b5c38973f4b457766d68801d6795b4ae9797fd"

URI_aarch64_libdwarf-static = "${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-static-2.1.0-2.el10_1.aarch64.rpm;name=aarch64_libdwarf-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdwarf-static}"
SRC_URI[aarch64_libdwarf-static.sha256sum] = "93502407bb8a084f28968066c8293c56e2394a86c39318c52370272d947e188e"

URI_aarch64_libdwarf-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libdwarf-tools-2.1.0-2.el10_1.aarch64.rpm;name=aarch64_libdwarf-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdwarf-tools}"
SRC_URI[aarch64_libdwarf-tools.sha256sum] = "62b9181d16f05580b0810dde72137db127c1a064507781a9dbf42b1c41658cde"

RDEPENDS:libdwarf = " \
 glibc \
 "
RDEPENDS:libdwarf-devel = " \
 libdwarf \
 libzstd-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libdwarf-static = " \
 libdwarf-devel \
 "
RDEPENDS:libdwarf-tools = " \
 glibc \
 libdwarf \
 libgcc \
 libstdc++ \
 "
