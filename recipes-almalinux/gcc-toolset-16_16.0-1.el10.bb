# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-16"
PV = "16.0"
PR = "1.el10"
PACKAGES = " \
 gcc-toolset-16 \
 gcc-toolset-16-devel \
 gcc-toolset-16-runtime \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-16-16.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7d54e7f85853d8b2beecc9c1d3342052ff8f7aff763bb3bdd9ecaadb90c03f3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-16.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16.sha256sum] = "ff68d1a93ef47ca8c81bf93456f978df1287946e8f20e034808641e68ba9f11f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-devel-16.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-devel.sha256sum] = "c900db9edd768e262331652a47fdbf01a1214864038976fa385dbdb4654b78f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-runtime-16.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-runtime;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-runtime.sha256sum] = "5b684dd858015956c550e81b8520077e003837643e40d67453c4e7fbaadbf8a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-16.0-1.el10.aarch64.rpm;name=aarch64_gcc-toolset-16;unpack=0"
SRC_URI[aarch64_gcc-toolset-16.sha256sum] = "0c362d1e5bdb733b22d520fe7b03e293e11c4a97540d36c722bbd26d3aedb4b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-devel-16.0-1.el10.aarch64.rpm;name=aarch64_gcc-toolset-16-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-devel.sha256sum] = "8c03e20ec020a83bf0587a12a0bfa982c6eb1c82358b31550e4c7260dcf388fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-runtime-16.0-1.el10.aarch64.rpm;name=aarch64_gcc-toolset-16-runtime;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-runtime.sha256sum] = "6e51c4ea9769781ff5d2c6610ee2297ac6db3cffc3009a0d17716276b918120d"

RDEPENDS:gcc-toolset-16 = " \
 gcc-toolset-16-binutils \
 gcc-toolset-16-gcc \
 gcc-toolset-16-gcc-c++ \
 gcc-toolset-16-gcc-gfortran \
 gcc-toolset-16-runtime \
 "
RDEPENDS:gcc-toolset-16-devel = " \
 "
RDEPENDS:gcc-toolset-16-runtime = " \
 bash \
 "
