# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaddressbook"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kaddressbook \
 kaddressbook-devel \
 kaddressbook-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaddressbook-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8570d0fb3f0ca53f090297e849a0df51e4c02fa1b60ea108c4982d8021c11a8f"

URI_x86_64_v2_kaddressbook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook}"
SRC_URI[x86_64_v2_kaddressbook.sha256sum] = "cf96982b8751c56aff4fd208f2a27f93acbc38b80e2333ef07979bad92581841"

URI_x86_64_v2_kaddressbook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook-devel}"
SRC_URI[x86_64_v2_kaddressbook-devel.sha256sum] = "eb3b43f77cf6def30a099c6d21ece35052fb0c8b265278bde6500e952be07fc4"

URI_x86_64_v2_kaddressbook-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook-libs}"
SRC_URI[x86_64_v2_kaddressbook-libs.sha256sum] = "abe5c13beff831941c265301b0ee4f0af142060c8bb0797cdcb8396f39684777"

URI_aarch64_kaddressbook = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kaddressbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook}"
SRC_URI[aarch64_kaddressbook.sha256sum] = "8e8da6e1af1d317f9e077cbaaa321c35a7b7b452e7605fad6775e90126b27df2"

URI_aarch64_kaddressbook-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kaddressbook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook-devel}"
SRC_URI[aarch64_kaddressbook-devel.sha256sum] = "334b9d543ae5ac2b5e9060ea8272b7661b9bcd4f69846dac05d59532438084e6"

URI_aarch64_kaddressbook-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kaddressbook-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook-libs}"
SRC_URI[aarch64_kaddressbook-libs.sha256sum] = "46cbb4fa389fda954866af4d09f0fb27d9f853f9d6391758167e7259e214cb95"

RDEPENDS:kaddressbook = " \
 glibc \
 kaddressbook-libs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 libgcc \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kaddressbook-devel = " \
 cmake-filesystem \
 kaddressbook \
 kaddressbook-libs \
 "
RDEPENDS:kaddressbook-libs = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 grantleetheme \
 kaddressbook \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
