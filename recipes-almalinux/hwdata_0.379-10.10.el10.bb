# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hwdata"
PV = "0.379"
PR = "10.10.el10"
PACKAGES = " \
 hwdata \
 hwdata-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/hwdata-0.379-10.10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "00abae266917616c585c31f0fb47a24e08696d928f010a69d5f62daab94dfe5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/hwdata-0.379-10.10.el10.noarch.rpm;name=x86_64_v2_hwdata;unpack=0"
SRC_URI[x86_64_v2_hwdata.sha256sum] = "8bd5f0ce2871c1ef4fffe74dc5eee5e92fa5742feeab5092029267cccc4a2bb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/hwdata-devel-0.379-10.10.el10.noarch.rpm;name=x86_64_v2_hwdata-devel;unpack=0"
SRC_URI[x86_64_v2_hwdata-devel.sha256sum] = "2406fb5de45bc976938f322805d70f07b07b6437479ab909c117536ffeebc7a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/hwdata-0.379-10.10.el10.noarch.rpm;name=aarch64_hwdata;unpack=0"
SRC_URI[aarch64_hwdata.sha256sum] = "8bd5f0ce2871c1ef4fffe74dc5eee5e92fa5742feeab5092029267cccc4a2bb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/hwdata-devel-0.379-10.10.el10.noarch.rpm;name=aarch64_hwdata-devel;unpack=0"
SRC_URI[aarch64_hwdata-devel.sha256sum] = "2406fb5de45bc976938f322805d70f07b07b6437479ab909c117536ffeebc7a4"

RDEPENDS:hwdata = " \
 "
RDEPENDS:hwdata-devel = " \
 hwdata \
 pkgconf-pkg-config \
 "
