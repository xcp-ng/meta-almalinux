# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gzip"
PV = "1.13"
PR = "3.el10"
PACKAGES = " \
 gzip \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gzip-1.13-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04823d5405544406fae47cb6baa5f42cfb44b94767c6ab706df36d77725de7f1"

URI_x86_64_v2_gzip = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/gzip-1.13-3.el10.x86_64_v2.rpm;name=x86_64_v2_gzip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gzip}"
SRC_URI[x86_64_v2_gzip.sha256sum] = "08586d4af627dbb3fc8aaad15e192be3f8a9eb677c3cb7f51a56a204f4822e07"

URI_aarch64_gzip = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/gzip-1.13-3.el10.aarch64.rpm;name=aarch64_gzip;unpack=0"
SRC_URI:append = " ${URI_aarch64_gzip}"
SRC_URI[aarch64_gzip.sha256sum] = "cd13cad8eaee4f78f2b2527b5a32f9663843276a1db0a15b17252e9ac68d7c6d"

RDEPENDS:gzip = " \
 bash \
 glibc \
 virtual/coreutils \
 "
