# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-CIDR"
PV = "0.27"
PR = "1.el10_1"
PACKAGES = " \
 perl-Net-CIDR \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-CIDR-0.27-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0cb5b0834b3c2f9fdd47bf32edebe8b800252d663d9c7b891d2f5fc47ba61ae"

URI_x86_64_v2_perl-Net-CIDR = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-CIDR-0.27-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-CIDR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-CIDR}"
SRC_URI[x86_64_v2_perl-Net-CIDR.sha256sum] = "2d6e701fbdfb038144ab870a0a9b68ad9fdadf2d4661a39164d98d8c067dd098"

URI_aarch64_perl-Net-CIDR = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-CIDR-0.27-1.el10_1.noarch.rpm;name=aarch64_perl-Net-CIDR;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-CIDR}"
SRC_URI[aarch64_perl-Net-CIDR.sha256sum] = "6885035b468ee7b814f1839638c6a6cae5a5077cdca556277aff60886422ea70"

RDEPENDS:perl-Net-CIDR = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
