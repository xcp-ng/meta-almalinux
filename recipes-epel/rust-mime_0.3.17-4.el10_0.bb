# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mime"
PV = "0.3.17"
PR = "4.el10_0"
PACKAGES = " \
 rust-mime+default-devel \
 rust-mime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mime-0.3.17-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55b5abe48c154e8d444defb569f3a520551ddbb1fbc1eaa6ab9e0bc13a041b85"

URI_x86_64_v2_rust-mime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mime+default-devel-0.3.17-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mime+default-devel}"
SRC_URI[x86_64_v2_rust-mime+default-devel.sha256sum] = "a955a0585251ca7b3892fc12ef9ce68206cc0c0e9e97bd8115a6297fe53709e6"

URI_x86_64_v2_rust-mime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mime-devel-0.3.17-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mime-devel}"
SRC_URI[x86_64_v2_rust-mime-devel.sha256sum] = "f8d7bd2fb0178b7e68ebdbf4e164c71509f17e96b3e3dba65891ca059a49f9a1"

URI_aarch64_rust-mime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mime+default-devel-0.3.17-4.el10_0.noarch.rpm;name=aarch64_rust-mime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mime+default-devel}"
SRC_URI[aarch64_rust-mime+default-devel.sha256sum] = "3d52dff466f15717033130573032adcc2e3c5d22d3d58940a124f1fae147cb83"

URI_aarch64_rust-mime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mime-devel-0.3.17-4.el10_0.noarch.rpm;name=aarch64_rust-mime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mime-devel}"
SRC_URI[aarch64_rust-mime-devel.sha256sum] = "34c31f2e956d72ea22a5ddacf634c9800bf11e3dc89bb9a9c103cced1da03143"

RDEPENDS:rust-mime+default-devel = " \
 cargo \
 rust-mime-devel \
 "
RDEPENDS:rust-mime-devel = " \
 cargo \
 "
