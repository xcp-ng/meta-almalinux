# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-core"
PV = "3.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-core+default-devel \
 rust-reqsign-core+jwt-devel \
 rust-reqsign-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-core-3.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f252659f2c295eaddf49febb264eb5129d8b747c0e7d5fecbe9bd1303491b945"

URI_x86_64_v2_rust-reqsign-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core+default-devel-3.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-core+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-core+default-devel.sha256sum] = "d294e3f1a5c1bab5eb8bfd87f55672ec8dec1ff834046b65a4c516865a6e37e2"

URI_x86_64_v2_rust-reqsign-core+jwt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core+jwt-devel-3.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core+jwt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-core+jwt-devel}"
SRC_URI[x86_64_v2_rust-reqsign-core+jwt-devel.sha256sum] = "47ebfdc6fb717b520d7943945766605eb7519874256af979f12244fe5f2ce788"

URI_x86_64_v2_rust-reqsign-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-core-devel-3.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-core-devel}"
SRC_URI[x86_64_v2_rust-reqsign-core-devel.sha256sum] = "45cfb666956b67f7ea1f42426d2d2e9c205cb57967787b9e93c9d568cde3443e"

URI_aarch64_rust-reqsign-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core+default-devel-3.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-core+default-devel}"
SRC_URI[aarch64_rust-reqsign-core+default-devel.sha256sum] = "3ce40a82a9d9d2fa40451466b40aa711bc63ed57e22e867918d7222a817e617e"

URI_aarch64_rust-reqsign-core+jwt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core+jwt-devel-3.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-core+jwt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-core+jwt-devel}"
SRC_URI[aarch64_rust-reqsign-core+jwt-devel.sha256sum] = "a10316118b4d4fcae48560a66284b7f37eac3cad43565c259f759fae36f5cbbc"

URI_aarch64_rust-reqsign-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-core-devel-3.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-core-devel}"
SRC_URI[aarch64_rust-reqsign-core-devel.sha256sum] = "01760a296557ec312bb7de0b67bad8eac1c30c0c3c1f63d7607ddeb1d797be86"

RDEPENDS:rust-reqsign-core+default-devel = " \
 cargo \
 rust-reqsign-core-devel \
 "
RDEPENDS:rust-reqsign-core+jwt-devel = " \
 cargo \
 rust-reqsign-core-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-reqsign-core-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-base64_0.22+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-futures+default-devel \
 rust-hex+default-devel \
 rust-hmac+default-devel \
 rust-http+default-devel \
 rust-jiff+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-sha1+default-devel \
 rust-sha2+default-devel \
 rust-sha2+oid-devel \
 "
