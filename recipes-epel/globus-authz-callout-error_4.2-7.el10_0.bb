# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-authz-callout-error"
PV = "4.2"
PR = "7.el10_0"
PACKAGES = " \
 globus-authz-callout-error \
 globus-authz-callout-error-devel \
 globus-authz-callout-error-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-authz-callout-error-4.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e49a4f78da4c4a15c00c47300a3459d681b961b839461de22051fce1d4caf8bb"

URI_x86_64_v2_globus-authz-callout-error = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-authz-callout-error-4.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-authz-callout-error;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-authz-callout-error}"
SRC_URI[x86_64_v2_globus-authz-callout-error.sha256sum] = "f6939f789da4ecbfc861f450cb11335c218b55d12b747b28e80865f190fa69ab"

URI_x86_64_v2_globus-authz-callout-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-authz-callout-error-devel-4.2-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-authz-callout-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-authz-callout-error-devel}"
SRC_URI[x86_64_v2_globus-authz-callout-error-devel.sha256sum] = "080af621e881900ee3af11771ff9c4d0004a861e6e6110f4afe9e88bef3a4096"

URI_x86_64_v2_globus-authz-callout-error-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-authz-callout-error-doc-4.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-authz-callout-error-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-authz-callout-error-doc}"
SRC_URI[x86_64_v2_globus-authz-callout-error-doc.sha256sum] = "b615938b6d1bee09d5ee796107d95ec0de08dd1a405e49bbf29c2d5329241d9f"

URI_aarch64_globus-authz-callout-error = "${EPEL_MIRROR}/aarch64/Packages/g/globus-authz-callout-error-4.2-7.el10_0.aarch64.rpm;name=aarch64_globus-authz-callout-error;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-authz-callout-error}"
SRC_URI[aarch64_globus-authz-callout-error.sha256sum] = "7c18dd73634a22828c7bd4d15acdb182ccbd0505d1e189b2cfa6339c22941b7b"

URI_aarch64_globus-authz-callout-error-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-authz-callout-error-devel-4.2-7.el10_0.aarch64.rpm;name=aarch64_globus-authz-callout-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-authz-callout-error-devel}"
SRC_URI[aarch64_globus-authz-callout-error-devel.sha256sum] = "02f8f3e635ab731c80a9a37f2f276c6c2ee73b1378ba352cc15ecdeccdf436b8"

URI_aarch64_globus-authz-callout-error-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-authz-callout-error-doc-4.2-7.el10_0.noarch.rpm;name=aarch64_globus-authz-callout-error-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-authz-callout-error-doc}"
SRC_URI[aarch64_globus-authz-callout-error-doc.sha256sum] = "666318c5d105c08ce30a4f4127a4f1ee7b8d2f5d98f13b84847e81a2b727ea8d"

RDEPENDS:globus-authz-callout-error = " \
 glibc \
 "
RDEPENDS:globus-authz-callout-error-devel = " \
 globus-authz-callout-error \
 globus-common-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-authz-callout-error-doc = " \
 "
