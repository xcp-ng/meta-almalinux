# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "holland"
PV = "1.3.1"
PR = "2.el10_3"
PACKAGES = " \
 holland \
 holland-command \
 holland-common \
 holland-commvault \
 holland-lvm \
 holland-mariabackup \
 holland-mariadb-dump \
 holland-mongodump \
 holland-mysql \
 holland-mysqldump \
 holland-mysqllvm \
 holland-mysqlsh \
 holland-pg_basebackup \
 holland-pgdump \
 holland-xtrabackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/holland-1.3.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2973ee3a42759dc058f8c0034691a030fd8163f7ccbdca6bd5ac713e61665b45"

URI_x86_64_v2_holland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland}"
SRC_URI[x86_64_v2_holland.sha256sum] = "803b837bf1ad9f558ce6e8375528c67dc236c731b53e194c321257e08fd45833"

URI_x86_64_v2_holland-command = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-command-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-command}"
SRC_URI[x86_64_v2_holland-command.sha256sum] = "189bedc42c3b8670ddbad92d8a6930e8ddd2527d66a0280de21896168608bc7d"

URI_x86_64_v2_holland-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-common-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-common}"
SRC_URI[x86_64_v2_holland-common.sha256sum] = "21436d4196fb22b39416c04d857a1f4c4ab01038faa8d71514f116ca4dd0bb57"

URI_x86_64_v2_holland-commvault = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-commvault-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-commvault;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-commvault}"
SRC_URI[x86_64_v2_holland-commvault.sha256sum] = "c254fa9ec4b7dcd94667c1e0fcd31df852ccd14eedcb2005c123c0a65b9de5ca"

URI_x86_64_v2_holland-lvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-lvm-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-lvm}"
SRC_URI[x86_64_v2_holland-lvm.sha256sum] = "661657c1b6bd346eb2ffb540a51902d887a4a3647dae0e548b37256534ca9c26"

URI_x86_64_v2_holland-mariabackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mariabackup-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mariabackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mariabackup}"
SRC_URI[x86_64_v2_holland-mariabackup.sha256sum] = "c434c18b3bf61afbb91e7bb6771864131ca7a647bb18cd2804221114017fb353"

URI_x86_64_v2_holland-mariadb-dump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mariadb-dump-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mariadb-dump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mariadb-dump}"
SRC_URI[x86_64_v2_holland-mariadb-dump.sha256sum] = "c536b62dbf51d83f239a08b5ef3113ab179d4c048f54c6a7a94ce57837b1c7a6"

URI_x86_64_v2_holland-mongodump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mongodump-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mongodump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mongodump}"
SRC_URI[x86_64_v2_holland-mongodump.sha256sum] = "7789845150e87f8e86e3d64d6ed441d09bf708a546fd2a58cb90ce2efe8b8196"

URI_x86_64_v2_holland-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysql-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysql}"
SRC_URI[x86_64_v2_holland-mysql.sha256sum] = "e33d52d10bb74c8d20187ae77fb58bbe7e22bbf409ca8ee09f7ddc4f01544ec3"

URI_x86_64_v2_holland-mysqldump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysqldump-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysqldump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysqldump}"
SRC_URI[x86_64_v2_holland-mysqldump.sha256sum] = "11d3e383d13649d5400c2aecc3d130afbdb7459208523c75753b546340ce0728"

URI_x86_64_v2_holland-mysqllvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysqllvm-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysqllvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysqllvm}"
SRC_URI[x86_64_v2_holland-mysqllvm.sha256sum] = "60d38f5eee5768d7771aa89dcdac2e7650fddfdbc79daaa651a6021342b8ec2a"

URI_x86_64_v2_holland-mysqlsh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-mysqlsh-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-mysqlsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-mysqlsh}"
SRC_URI[x86_64_v2_holland-mysqlsh.sha256sum] = "ca68c2a6469303ded6bfa11cea1572baf5fe06758b1e5557007e95b8dd0fe84e"

URI_x86_64_v2_holland-pg_basebackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-pg_basebackup-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-pg_basebackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-pg_basebackup}"
SRC_URI[x86_64_v2_holland-pg_basebackup.sha256sum] = "13f7a2a5e17e11b0285d3bee4e3d41d5929eb907a82a72401727824f14155c22"

URI_x86_64_v2_holland-pgdump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-pgdump-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-pgdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-pgdump}"
SRC_URI[x86_64_v2_holland-pgdump.sha256sum] = "164deadd6c4ef7e8cfe1a5ff0a20c2e5ddbbce85844be9f2cb99160e359da84e"

URI_x86_64_v2_holland-xtrabackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/holland-xtrabackup-1.3.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_holland-xtrabackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_holland-xtrabackup}"
SRC_URI[x86_64_v2_holland-xtrabackup.sha256sum] = "09e462b180f47fbf8a4d6463787b90865852cef46a1832d273e1614ae562ba18"

URI_aarch64_holland = "${EPEL_MIRROR}/aarch64/Packages/h/holland-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland}"
SRC_URI[aarch64_holland.sha256sum] = "6f7c1be70342a3e49a386c0d5ccc0ed151925f7f87a35c65e4ac35fcaed39b33"

URI_aarch64_holland-command = "${EPEL_MIRROR}/aarch64/Packages/h/holland-command-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-command}"
SRC_URI[aarch64_holland-command.sha256sum] = "5e28bd607c36bfcee3b0dd134448d5fab9ba064c9753bfe3682508e26e015cd8"

URI_aarch64_holland-common = "${EPEL_MIRROR}/aarch64/Packages/h/holland-common-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-common}"
SRC_URI[aarch64_holland-common.sha256sum] = "f71546866315bd2b24134b4fd338148fea1a0af355de4f327fbcef89587a26d4"

URI_aarch64_holland-commvault = "${EPEL_MIRROR}/aarch64/Packages/h/holland-commvault-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-commvault;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-commvault}"
SRC_URI[aarch64_holland-commvault.sha256sum] = "e58c5fc75005865236bf4d922d2dcd0daedd30fbe11611fd4683fc3111b4c6de"

URI_aarch64_holland-lvm = "${EPEL_MIRROR}/aarch64/Packages/h/holland-lvm-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-lvm}"
SRC_URI[aarch64_holland-lvm.sha256sum] = "100b8aeb678757d594228b54d8330767466c2f2d62f1b2d7e21ed0beee789ce3"

URI_aarch64_holland-mariabackup = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mariabackup-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-mariabackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mariabackup}"
SRC_URI[aarch64_holland-mariabackup.sha256sum] = "b686dc31997acc885877dccf238772c5043c0e61d6f2bcc44e1d211b20510edc"

URI_aarch64_holland-mariadb-dump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mariadb-dump-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-mariadb-dump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mariadb-dump}"
SRC_URI[aarch64_holland-mariadb-dump.sha256sum] = "ca011ed844089147691bbc8d1fe557aca95b25d9fb502ad250990ec02ea91904"

URI_aarch64_holland-mongodump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mongodump-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-mongodump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mongodump}"
SRC_URI[aarch64_holland-mongodump.sha256sum] = "e21cde955966211d15a92ad4fecb052b60a966e9a355bf4bd5814390ad348554"

URI_aarch64_holland-mysql = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysql-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysql}"
SRC_URI[aarch64_holland-mysql.sha256sum] = "f54570f564e90253a6cd8bc45a6809380e2d50ffc50e3fc820afcc6e9d5788a1"

URI_aarch64_holland-mysqldump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysqldump-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-mysqldump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysqldump}"
SRC_URI[aarch64_holland-mysqldump.sha256sum] = "ece67635a7711a5f9a1e18924e245222a5a98a002f9e0af88be8d033c362fc8b"

URI_aarch64_holland-mysqllvm = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysqllvm-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-mysqllvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysqllvm}"
SRC_URI[aarch64_holland-mysqllvm.sha256sum] = "84eb6f5b52b3c906f70f783c27b036393ac6ee1e81c7d81ad2b7099e4f09a8dd"

URI_aarch64_holland-mysqlsh = "${EPEL_MIRROR}/aarch64/Packages/h/holland-mysqlsh-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-mysqlsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-mysqlsh}"
SRC_URI[aarch64_holland-mysqlsh.sha256sum] = "d1cf2b51777dc1a80cf7c7238df0d3e6fbe5ceb5d20130019d5f7b56f4b71a02"

URI_aarch64_holland-pg_basebackup = "${EPEL_MIRROR}/aarch64/Packages/h/holland-pg_basebackup-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-pg_basebackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-pg_basebackup}"
SRC_URI[aarch64_holland-pg_basebackup.sha256sum] = "ed34517ac86a7f428b59cfa64aa766725b75d4625f51af9e8ce27564157d7769"

URI_aarch64_holland-pgdump = "${EPEL_MIRROR}/aarch64/Packages/h/holland-pgdump-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-pgdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-pgdump}"
SRC_URI[aarch64_holland-pgdump.sha256sum] = "e6c029d89f4995ec159ba0e1dcf293aedc115b13b5ccd17f508a55ae17532222"

URI_aarch64_holland-xtrabackup = "${EPEL_MIRROR}/aarch64/Packages/h/holland-xtrabackup-1.3.1-2.el10_3.noarch.rpm;name=aarch64_holland-xtrabackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_holland-xtrabackup}"
SRC_URI[aarch64_holland-xtrabackup.sha256sum] = "49f91924417bca12a731425e30131fc993a8c0e46bcbf5ad1e83115573a1bc95"

RDEPENDS:holland = " \
 logrotate \
 python3 \
 python3-configobj \
 python3-setuptools \
 python3-six \
 "
RDEPENDS:holland-command = " \
 holland-common \
 python3 \
 "
RDEPENDS:holland-common = " \
 holland \
 python3 \
 "
RDEPENDS:holland-commvault = " \
 holland \
 python3 \
 python3-pid \
 tar \
 "
RDEPENDS:holland-lvm = " \
 holland \
 python3 \
 "
RDEPENDS:holland-mariabackup = " \
 holland-common \
 holland-mysql \
 python3 \
 virtual//usr/bin/mariabackup \
 "
RDEPENDS:holland-mariadb-dump = " \
 holland-common \
 holland-mysql \
 python3 \
 virtual//usr/bin/mariadb-dump \
 "
RDEPENDS:holland-mongodump = " \
 holland-common \
 python3 \
 python3-pymongo \
 "
RDEPENDS:holland-mysql = " \
 holland-common \
 python3 \
 python3-PyMySQL \
 python3-mysqlclient \
 "
RDEPENDS:holland-mysqldump = " \
 holland-mysql \
 python3 \
 virtual//usr/bin/mysqldump \
 "
RDEPENDS:holland-mysqllvm = " \
 holland-lvm \
 holland-mysql \
 lvm2 \
 python3 \
 tar \
 "
RDEPENDS:holland-mysqlsh = " \
 holland-common \
 holland-mysql \
 python3 \
 "
RDEPENDS:holland-pg_basebackup = " \
 holland-common \
 python3 \
 python3-psycopg2 \
 "
RDEPENDS:holland-pgdump = " \
 holland-common \
 python3 \
 python3-psycopg2 \
 "
RDEPENDS:holland-xtrabackup = " \
 holland-common \
 holland-mysql \
 python3 \
 python3-mysqlclient \
 "
