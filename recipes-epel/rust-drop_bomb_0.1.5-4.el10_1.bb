# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-drop_bomb"
PV = "0.1.5"
PR = "4.el10_1"
PACKAGES = " \
 rust-drop_bomb+default-devel \
 rust-drop_bomb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-drop_bomb-0.1.5-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4891bdd441d517ac765e607ba65ab71a1f5772d3d08c45312ac92fee0ad3e903"

URI_x86_64_v2_rust-drop_bomb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-drop_bomb+default-devel-0.1.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-drop_bomb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-drop_bomb+default-devel}"
SRC_URI[x86_64_v2_rust-drop_bomb+default-devel.sha256sum] = "3ca1134c4491b0860581fc47373c4c47450441a3196e7e66d5419018ae647e07"

URI_x86_64_v2_rust-drop_bomb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-drop_bomb-devel-0.1.5-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-drop_bomb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-drop_bomb-devel}"
SRC_URI[x86_64_v2_rust-drop_bomb-devel.sha256sum] = "6f9ef8d5b5a5e2659c105ce61853e96615672dfdd52472785dd793822cb41b9e"

URI_aarch64_rust-drop_bomb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-drop_bomb+default-devel-0.1.5-4.el10_1.noarch.rpm;name=aarch64_rust-drop_bomb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-drop_bomb+default-devel}"
SRC_URI[aarch64_rust-drop_bomb+default-devel.sha256sum] = "d30db823188d9edb16713c0fbe1191970979758ef5ecfa643f916836ee4d94d5"

URI_aarch64_rust-drop_bomb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-drop_bomb-devel-0.1.5-4.el10_1.noarch.rpm;name=aarch64_rust-drop_bomb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-drop_bomb-devel}"
SRC_URI[aarch64_rust-drop_bomb-devel.sha256sum] = "2fabc64f445bb24934032a7af149cda32138e17f1bf8ec5900d5e236a8d553d6"

RDEPENDS:rust-drop_bomb+default-devel = " \
 cargo \
 rust-drop_bomb-devel \
 "
RDEPENDS:rust-drop_bomb-devel = " \
 cargo \
 "
