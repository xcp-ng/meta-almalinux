# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb-connector-c"
PV = "3.4.4"
PR = "1.el10"
PACKAGES = " \
 mariadb-connector-c \
 mariadb-connector-c-config \
 mariadb-connector-c-devel \
 mariadb-connector-c-doc \
 mariadb-connector-c-test \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mariadb-connector-c-3.4.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b74eba88d87ff33e390c880f5951cd36f22163dd549be5d43615f629ba9ace7"

URI_x86_64_v2_mariadb-connector-c = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mariadb-connector-c-3.4.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-connector-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c}"
SRC_URI[x86_64_v2_mariadb-connector-c.sha256sum] = "50472133f59b9a2915847cc6d4af286b0c37d708c7b0c8c2a02f222b73ad194f"

URI_x86_64_v2_mariadb-connector-c-config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mariadb-connector-c-config-3.4.4-1.el10.noarch.rpm;name=x86_64_v2_mariadb-connector-c-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c-config}"
SRC_URI[x86_64_v2_mariadb-connector-c-config.sha256sum] = "6449d19b2ed47f90c7a6c56ddb11a7c35e9a5c0c6da7cb0d890ce22435bacd28"

URI_x86_64_v2_mariadb-connector-c-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-connector-c-devel-3.4.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-connector-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c-devel}"
SRC_URI[x86_64_v2_mariadb-connector-c-devel.sha256sum] = "9c2e3999f9863ae91ef70e03c5a37de96d70175b5aa26ddfeabfabd9ce8bb81f"

URI_x86_64_v2_mariadb-connector-c-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mariadb-connector-c-doc-3.4.4-1.el10.noarch.rpm;name=x86_64_v2_mariadb-connector-c-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c-doc}"
SRC_URI[x86_64_v2_mariadb-connector-c-doc.sha256sum] = "1689cf99d693357a37b52cbefed7864b41c35337cb4e0ac412235371274a6915"

URI_x86_64_v2_mariadb-connector-c-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mariadb-connector-c-test-3.4.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-connector-c-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-c-test}"
SRC_URI[x86_64_v2_mariadb-connector-c-test.sha256sum] = "1145d794bc6c74f2835db1b609c047d3e2ab4f7cea91a36f9a202c53457f63ad"

URI_aarch64_mariadb-connector-c = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mariadb-connector-c-3.4.4-1.el10.aarch64.rpm;name=aarch64_mariadb-connector-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c}"
SRC_URI[aarch64_mariadb-connector-c.sha256sum] = "df359598655fc5c29c16a8507d2cc730d91830820b2eac08c4f41c4d1a275d2c"

URI_aarch64_mariadb-connector-c-config = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mariadb-connector-c-config-3.4.4-1.el10.noarch.rpm;name=aarch64_mariadb-connector-c-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c-config}"
SRC_URI[aarch64_mariadb-connector-c-config.sha256sum] = "6449d19b2ed47f90c7a6c56ddb11a7c35e9a5c0c6da7cb0d890ce22435bacd28"

URI_aarch64_mariadb-connector-c-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-connector-c-devel-3.4.4-1.el10.aarch64.rpm;name=aarch64_mariadb-connector-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c-devel}"
SRC_URI[aarch64_mariadb-connector-c-devel.sha256sum] = "c3d54f76d5b48ce6dcd0804bbdc8fc145ea503629a440a6c6eeb6837843b8880"

URI_aarch64_mariadb-connector-c-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mariadb-connector-c-doc-3.4.4-1.el10.noarch.rpm;name=aarch64_mariadb-connector-c-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c-doc}"
SRC_URI[aarch64_mariadb-connector-c-doc.sha256sum] = "1689cf99d693357a37b52cbefed7864b41c35337cb4e0ac412235371274a6915"

URI_aarch64_mariadb-connector-c-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mariadb-connector-c-test-3.4.4-1.el10.aarch64.rpm;name=aarch64_mariadb-connector-c-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-c-test}"
SRC_URI[aarch64_mariadb-connector-c-test.sha256sum] = "e087eea7f0149c32ba72ddc522fb78a69edb6c2b2b41708db61e9756ab8f0984"

RDEPENDS:mariadb-connector-c = " \
 glibc \
 krb5-libs \
 libzstd \
 mariadb-connector-c-config \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-connector-c-config = " \
 "
RDEPENDS:mariadb-connector-c-devel = " \
 glibc \
 mariadb-connector-c \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:mariadb-connector-c-doc = " \
 mariadb-connector-c \
 "
RDEPENDS:mariadb-connector-c-test = " \
 cmake \
 glibc \
 mariadb-connector-c \
 openssl-libs \
 zlib-ng-compat \
 "
