# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcg-cpp"
PV = "0.98.1^20220408git428802d"
PR = "16.el10_0"
PACKAGES = " \
 pcg-cpp-devel \
 pcg-cpp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pcg-cpp-0.98.1^20220408git428802d-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e049379146dea4727fbcaf6ba3a0843c5194a156161f3396a1879181fff3345b"

URI_x86_64_v2_pcg-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcg-cpp-devel-0.98.1^20220408git428802d-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pcg-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcg-cpp-devel}"
SRC_URI[x86_64_v2_pcg-cpp-devel.sha256sum] = "d3d8af7bce7869933d31278683e6dd486c7a1177b33d3bd8dbd70d45abbb9e84"

URI_x86_64_v2_pcg-cpp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pcg-cpp-doc-0.98.1^20220408git428802d-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pcg-cpp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcg-cpp-doc}"
SRC_URI[x86_64_v2_pcg-cpp-doc.sha256sum] = "7a9b2b508916fb1f5cec0de9ea4bd47eee23c95b9732264583c320829cdb9b51"

URI_aarch64_pcg-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pcg-cpp-devel-0.98.1^20220408git428802d-16.el10_0.noarch.rpm;name=aarch64_pcg-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcg-cpp-devel}"
SRC_URI[aarch64_pcg-cpp-devel.sha256sum] = "0f535daa6cc3ddceffffa0cd30e2e4a7f92b56d973e67be10f909236fba1a3a8"

URI_aarch64_pcg-cpp-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pcg-cpp-doc-0.98.1^20220408git428802d-16.el10_0.noarch.rpm;name=aarch64_pcg-cpp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcg-cpp-doc}"
SRC_URI[aarch64_pcg-cpp-doc.sha256sum] = "c83b189fcb90908b7020662bf92bc232f402ab76f8a6f970a049dd386dd2f8cc"

RDEPENDS:pcg-cpp-devel = " \
 "
RDEPENDS:pcg-cpp-doc = " \
 "
