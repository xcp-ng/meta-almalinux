# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wprof"
PV = "0.5"
PR = "3.el10_3"
PACKAGES = " \
 wprof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wprof-0.5-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74206f5648de7a16b895467c1e0f8445568784a0a1c398dc97daf232409a139c"

URI_x86_64_v2_wprof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wprof-0.5-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wprof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wprof}"
SRC_URI[x86_64_v2_wprof.sha256sum] = "f4d0e6e4bff16b080fc74f56bcd0a53a760c5f526f6e33aee635723c4c022284"

URI_aarch64_wprof = "${EPEL_MIRROR}/aarch64/Packages/w/wprof-0.5-3.el10_3.aarch64.rpm;name=aarch64_wprof;unpack=0"
SRC_URI:append = " ${URI_aarch64_wprof}"
SRC_URI[aarch64_wprof.sha256sum] = "7db0bc89132c3f58b1b7ba44ee3c0bf3fba1eda13be819f95055f57d7c463d2e"

RDEPENDS:wprof = " \
 elfutils-libelf \
 glibc \
 libgcc \
 zlib-ng-compat \
 "
