# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kstatusnotifieritem"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kstatusnotifieritem \
 kf6-kstatusnotifieritem-devel \
 kf6-kstatusnotifieritem-doc \
 kf6-kstatusnotifieritem-html \
 python3-kf6-kstatusnotifieritem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kstatusnotifieritem-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1e15a81d6a9ee26fe1b2c4796fbbf64e2feeb2d61c81c8d6ca6cb0a6d170239"

URI_x86_64_v2_kf6-kstatusnotifieritem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem.sha256sum] = "4780e69460c4c9ac01622ad324ca41f2b6f203328bd152e3fbe4fa6b87f5ed75"

URI_x86_64_v2_kf6-kstatusnotifieritem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-devel}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-devel.sha256sum] = "afc21b92af31457a2a3e9b91e597ff17e650fb87ee421af103f503b4d91301e5"

URI_x86_64_v2_kf6-kstatusnotifieritem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-doc}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-doc.sha256sum] = "44cd833bafc0c2514260866eea6d9f121917f55ed9418f6336044928bdc17ed6"

URI_x86_64_v2_kf6-kstatusnotifieritem-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-html}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-html.sha256sum] = "0b680598ca3d9f5710b2e2d5100baf3b7b1973c59f286a6418b15dd1467f1c80"

URI_x86_64_v2_python3-kf6-kstatusnotifieritem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kstatusnotifieritem-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kstatusnotifieritem}"
SRC_URI[x86_64_v2_python3-kf6-kstatusnotifieritem.sha256sum] = "3b1f7b02325dbcedb2811f578593104130b72ec9f286006b7592bf134887de91"

URI_aarch64_kf6-kstatusnotifieritem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem}"
SRC_URI[aarch64_kf6-kstatusnotifieritem.sha256sum] = "5c8c1776d4cb4bab2bcbbf884184c1b0b3962207f0768a967f483288af09f4d3"

URI_aarch64_kf6-kstatusnotifieritem-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-devel}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-devel.sha256sum] = "68e96b7861a20cd75f7aec85836334f2df23eebcd8376bdc799878ccbdc9045c"

URI_aarch64_kf6-kstatusnotifieritem-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-doc}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-doc.sha256sum] = "b13f6acdc364c1e2087db363962562612ad685b5cbf2e8445e7c40436a765620"

URI_aarch64_kf6-kstatusnotifieritem-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kstatusnotifieritem-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-html}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-html.sha256sum] = "cb212e87165e36f8d1e8a84b76c9eaa379869267b66914cb7ad54810cd48ba5d"

URI_aarch64_python3-kf6-kstatusnotifieritem = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kstatusnotifieritem-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kstatusnotifieritem}"
SRC_URI[aarch64_python3-kf6-kstatusnotifieritem.sha256sum] = "badf2fef3b7f2f259513d105c0f6d422016846f0c1777768b9e7de99d438493d"

RDEPENDS:kf6-kstatusnotifieritem = " \
 glibc \
 kf6-filesystem \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kstatusnotifieritem-devel = " \
 cmake-filesystem \
 kf6-kstatusnotifieritem \
 "
RDEPENDS:kf6-kstatusnotifieritem-doc = " \
 "
RDEPENDS:kf6-kstatusnotifieritem-html = " \
 "
RDEPENDS:python3-kf6-kstatusnotifieritem = " \
 glibc \
 kf6-kstatusnotifieritem \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
