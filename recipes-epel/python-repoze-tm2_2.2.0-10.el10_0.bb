# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-repoze-tm2"
PV = "2.2.0"
PR = "10.el10_0"
PACKAGES = " \
 python3-repoze-tm2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-repoze-tm2-2.2.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eee012c71f65d1b4062935cdbcfa64c3332f730212e47e21ab911bad39d36f26"

URI_x86_64_v2_python3-repoze-tm2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-repoze-tm2-2.2.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-repoze-tm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-repoze-tm2}"
SRC_URI[x86_64_v2_python3-repoze-tm2.sha256sum] = "dd2105e684746a42adf9b67bd89bcbee53bd12bfa513324fc29dee47499f0ddc"

URI_aarch64_python3-repoze-tm2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-repoze-tm2-2.2.0-10.el10_0.noarch.rpm;name=aarch64_python3-repoze-tm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-repoze-tm2}"
SRC_URI[aarch64_python3-repoze-tm2.sha256sum] = "af39f7c095087acb464392df7f9b80be5a32f8b8667b346337a3c1bd3c4415e1"

RDEPENDS:python3-repoze-tm2 = " \
 python3 \
 python3-transaction \
 "
