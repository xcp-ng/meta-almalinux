# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openfortivpn"
PV = "1.23.1"
PR = "2.el10_1"
PACKAGES = " \
 openfortivpn \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openfortivpn-1.23.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a11affde4ed106644794577b55c0287171abf2c4239fa8669703413a61d5f183"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openfortivpn-1.23.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openfortivpn;unpack=0"
SRC_URI[x86_64_v2_openfortivpn.sha256sum] = "678ffa2587a5a54fcbb37b4044306e1057211b6b3e7fb12347f82f54e36c4462"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openfortivpn-1.23.1-2.el10_1.aarch64.rpm;name=aarch64_openfortivpn;unpack=0"
SRC_URI[aarch64_openfortivpn.sha256sum] = "880da617c7c636cd037ad32ae9aeeb7490a36cf048f39653cf560f66e8a38592"

RDEPENDS:openfortivpn = " \
 glibc \
 openssl-libs \
 ppp \
 systemd-libs \
 "
