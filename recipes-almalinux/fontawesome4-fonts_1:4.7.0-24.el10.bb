# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fontawesome4-fonts"
PE = "1"
PV = "4.7.0"
PR = "24.el10"
PACKAGES = " \
 fontawesome4-fonts \
 fontawesome4-fonts-web \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fontawesome4-fonts-4.7.0-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "173ea27e58ed8816f75db93119b24b86a2016bce6ff37739b9f4d44908113e7d"

URI_x86_64_v2_fontawesome4-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fontawesome4-fonts-4.7.0-24.el10.noarch.rpm;name=x86_64_v2_fontawesome4-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontawesome4-fonts}"
SRC_URI[x86_64_v2_fontawesome4-fonts.sha256sum] = "ce04ca3cfd5ff24a50366da4c7480c9aa3c99ef6f726643d215f984af106a013"

URI_x86_64_v2_fontawesome4-fonts-web = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fontawesome4-fonts-web-4.7.0-24.el10.noarch.rpm;name=x86_64_v2_fontawesome4-fonts-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontawesome4-fonts-web}"
SRC_URI[x86_64_v2_fontawesome4-fonts-web.sha256sum] = "0b7976ec98d8205cc9c1b21834900af23c3856e4a4abc533e61c28345867c472"

URI_aarch64_fontawesome4-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fontawesome4-fonts-4.7.0-24.el10.noarch.rpm;name=aarch64_fontawesome4-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontawesome4-fonts}"
SRC_URI[aarch64_fontawesome4-fonts.sha256sum] = "ce04ca3cfd5ff24a50366da4c7480c9aa3c99ef6f726643d215f984af106a013"

URI_aarch64_fontawesome4-fonts-web = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fontawesome4-fonts-web-4.7.0-24.el10.noarch.rpm;name=aarch64_fontawesome4-fonts-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontawesome4-fonts-web}"
SRC_URI[aarch64_fontawesome4-fonts-web.sha256sum] = "0b7976ec98d8205cc9c1b21834900af23c3856e4a4abc533e61c28345867c472"

RDEPENDS:fontawesome4-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:fontawesome4-fonts-web = " \
 fontawesome4-fonts \
 "
