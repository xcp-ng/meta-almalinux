# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sanlock"
PV = "5.1.0"
PR = "2.el10"
PACKAGES = " \
 sanlock \
 sanlock-devel \
 sanlock-lib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sanlock-5.1.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58b83f7e3a2e56ad2e7cef201636809af3c9ef08fae87428b80689e623502c91"

URI_x86_64_v2_sanlock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-5.1.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock}"
SRC_URI[x86_64_v2_sanlock.sha256sum] = "79e0638bcc99c8d769c63acdd9d7348a2004e1bc8a4f898f05348ac873a8dee7"

URI_x86_64_v2_sanlock-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sanlock-devel-5.1.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock-devel}"
SRC_URI[x86_64_v2_sanlock-devel.sha256sum] = "141cc7af64e6e2e2386383dce0a5f4fcea10c35834bf6d3b26ee7189c0af5b5c"

URI_x86_64_v2_sanlock-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sanlock-lib-5.1.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_sanlock-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sanlock-lib}"
SRC_URI[x86_64_v2_sanlock-lib.sha256sum] = "4303ff4c8e6911067ecf91c94c45ba19c60ddd295dfd09bc281c0cc9d31ab63f"

URI_aarch64_sanlock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-5.1.0-2.el10.aarch64.rpm;name=aarch64_sanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock}"
SRC_URI[aarch64_sanlock.sha256sum] = "443a7fb2baba47535ae85d65b6185c02d1b9bc88fddd598f4fd8c33349de4191"

URI_aarch64_sanlock-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sanlock-devel-5.1.0-2.el10.aarch64.rpm;name=aarch64_sanlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock-devel}"
SRC_URI[aarch64_sanlock-devel.sha256sum] = "a67bb33672d8e3ad76aaa6ed977a9fa546203c6ecb165f38c7096cda5a3e2748"

URI_aarch64_sanlock-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sanlock-lib-5.1.0-2.el10.aarch64.rpm;name=aarch64_sanlock-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_sanlock-lib}"
SRC_URI[aarch64_sanlock-lib.sha256sum] = "3f1951dbb7b678feab1d4379f90ce74e6d61b0e8d14fce9ebc95238231b27695"

RDEPENDS:sanlock = " \
 bash \
 device-mapper-libs \
 glibc \
 libaio \
 libblkid \
 libuuid \
 sanlock-lib \
 systemd \
 "
RDEPENDS:sanlock-devel = " \
 pkgconf-pkg-config \
 sanlock-lib \
 "
RDEPENDS:sanlock-lib = " \
 device-mapper-libs \
 glibc \
 libaio \
 libblkid \
 "
