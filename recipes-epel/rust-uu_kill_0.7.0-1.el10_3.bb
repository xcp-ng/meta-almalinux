# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_kill"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_kill+default-devel \
 rust-uu_kill-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_kill-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a215474b490451b1f2701708b3c87aaffc0af6c75a43b15c894c1c3301d3887"

URI_x86_64_v2_rust-uu_kill+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_kill+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_kill+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_kill+default-devel}"
SRC_URI[x86_64_v2_rust-uu_kill+default-devel.sha256sum] = "7d76c37494ddb21101ad6e2a35a9a52f626545042ed9a49b2ddd50383ac2c19a"

URI_x86_64_v2_rust-uu_kill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_kill-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_kill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_kill-devel}"
SRC_URI[x86_64_v2_rust-uu_kill-devel.sha256sum] = "2b0d834e4988ffb7bea9f55494dee60193a00ae2ca9a0a536894e91ee33fa73f"

URI_aarch64_rust-uu_kill+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_kill+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_kill+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_kill+default-devel}"
SRC_URI[aarch64_rust-uu_kill+default-devel.sha256sum] = "68f5a72c8988376a4f8649f6b5dab3e9b9b168ce9a3398e8423e073f6887118d"

URI_aarch64_rust-uu_kill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_kill-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_kill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_kill-devel}"
SRC_URI[aarch64_rust-uu_kill-devel.sha256sum] = "3edb35083d802ab74b37c9ec7b71cbaff1ff5f0a9a9aa4b1f4fe2054899218c3"

RDEPENDS:rust-uu_kill+default-devel = " \
 cargo \
 rust-uu_kill-devel \
 "
RDEPENDS:rust-uu_kill-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-nix0.30+signal-devel \
 rust-nix0.30-devel \
 rust-uucore+default-devel \
 rust-uucore+signals-devel \
 "
