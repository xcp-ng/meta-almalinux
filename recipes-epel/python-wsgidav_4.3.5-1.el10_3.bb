# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wsgidav"
PV = "4.3.5"
PR = "1.el10_3"
PACKAGES = " \
 python3-wsgidav \
 python3-wsgidav+pam \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-wsgidav-4.3.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62dd5edf481776e31173b29982e792ad9ed9dc5607e6a62d77dadf129430dffb"

URI_x86_64_v2_python3-wsgidav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wsgidav-4.3.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-wsgidav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wsgidav}"
SRC_URI[x86_64_v2_python3-wsgidav.sha256sum] = "c5b30b27a2d1f8a4a5a87a5d5a8acd4cd802f8ffb1a0c7d4f064ad0a1369f029"

URI_x86_64_v2_python3-wsgidav+pam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wsgidav+pam-4.3.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-wsgidav+pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wsgidav+pam}"
SRC_URI[x86_64_v2_python3-wsgidav+pam.sha256sum] = "06aa579fcdaf2f7de962416f738c7d116f5f089a29d613e78a19bacfa13ecdce"

URI_aarch64_python3-wsgidav = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wsgidav-4.3.5-1.el10_3.noarch.rpm;name=aarch64_python3-wsgidav;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wsgidav}"
SRC_URI[aarch64_python3-wsgidav.sha256sum] = "b7cf0d5218893522631e107855e35883e246f582d1f311fd8686767e4d14a92e"

URI_aarch64_python3-wsgidav+pam = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wsgidav+pam-4.3.5-1.el10_3.noarch.rpm;name=aarch64_python3-wsgidav+pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wsgidav+pam}"
SRC_URI[aarch64_python3-wsgidav+pam.sha256sum] = "8a710b33eac0308a0e80cb5d1891e7caadb2fbf08d04effe3452a6476e304fbb"

RDEPENDS:python3-wsgidav = " \
 python3 \
 python3-bcrypt \
 python3-defusedxml \
 python3-jinja2 \
 python3-json5 \
 python3-passlib \
 python3-pyyaml \
 "
RDEPENDS:python3-wsgidav+pam = " \
 python3 \
 python3-pam \
 python3-wsgidav \
 "
