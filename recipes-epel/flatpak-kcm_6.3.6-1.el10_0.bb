# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-kcm"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 flatpak-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flatpak-kcm-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a34eaf8c0f399f74182a9a90d210a9d5be596259a0a29bd48ed0664e995040f"

URI_x86_64_v2_flatpak-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatpak-kcm-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flatpak-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-kcm}"
SRC_URI[x86_64_v2_flatpak-kcm.sha256sum] = "d797cf544c9aa7fa755cdcd2a0edee2de7ac73d1081913a2f20b4a62651757c4"

URI_aarch64_flatpak-kcm = "${EPEL_MIRROR}/aarch64/Packages/f/flatpak-kcm-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_flatpak-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-kcm}"
SRC_URI[aarch64_flatpak-kcm.sha256sum] = "959270e2cd260b02699e5609ca1e7d9456a65afbfcb213f841b68fc7f5347a06"

RDEPENDS:flatpak-kcm = " \
 flatpak-libs \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
