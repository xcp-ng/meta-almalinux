# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kunifiedpush"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kunifiedpush \
 kunifiedpush-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kunifiedpush-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6af3d97c300eb5af398fa0f453b4069fc4613dd959d95d533702b8b8a97fe982"

URI_x86_64_v2_kunifiedpush = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kunifiedpush}"
SRC_URI[x86_64_v2_kunifiedpush.sha256sum] = "85abcae16a44c9742df3fea241d12766351cc2e29d528e2c29a9671ab4f6320e"

URI_x86_64_v2_kunifiedpush-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kunifiedpush-devel}"
SRC_URI[x86_64_v2_kunifiedpush-devel.sha256sum] = "b87a5512aecfe783c691250cd43c47c89af1aa61e0bcb4a47cbf6fee77bda461"

URI_aarch64_kunifiedpush = "${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kunifiedpush;unpack=0"
SRC_URI:append = " ${URI_aarch64_kunifiedpush}"
SRC_URI[aarch64_kunifiedpush.sha256sum] = "73e47e4376041fb1f7836f42c2c92d874355e89934c0214d4e3d949bc10cb3d0"

URI_aarch64_kunifiedpush-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kunifiedpush-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kunifiedpush-devel}"
SRC_URI[aarch64_kunifiedpush-devel.sha256sum] = "b87c7f0a4fccf45e48613d3b962d4532fc493dd736f34dc6e5123445c1b3f44d"

RDEPENDS:kunifiedpush = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kservice \
 kf6-solid \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:kunifiedpush-devel = " \
 cmake-filesystem \
 kunifiedpush \
 "
