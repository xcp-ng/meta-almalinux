# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opari2"
PV = "2.0.9"
PR = "1.el10_1"
PACKAGES = " \
 opari2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opari2-2.0.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "708e6c9e414ce23ef2ae536a02d395a14b0f44ae75a9cf1841874628d88030b3"

URI_x86_64_v2_opari2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opari2-2.0.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opari2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opari2}"
SRC_URI[x86_64_v2_opari2.sha256sum] = "55a1c1314495be2628be8998b4811b2bb377e26d08ca6b618de91e121f4353f6"

URI_aarch64_opari2 = "${EPEL_MIRROR}/aarch64/Packages/o/opari2-2.0.9-1.el10_1.aarch64.rpm;name=aarch64_opari2;unpack=0"
SRC_URI:append = " ${URI_aarch64_opari2}"
SRC_URI[aarch64_opari2.sha256sum] = "1c73ad9d77481e6d8ccae9c9b4ee12963f14b459874e58c690814be6485f9120"

RDEPENDS:opari2 = " \
 gawk \
 glibc \
 libgcc \
 libstdc++ \
 "
