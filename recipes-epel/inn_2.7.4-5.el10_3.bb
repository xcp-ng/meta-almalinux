# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "inn"
PV = "2.7.4"
PR = "5.el10_3"
PACKAGES = " \
 inews \
 inn \
 inn-devel \
 inn-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/inn-2.7.4-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fdf8d7ee27aeb467f233b6f8277acacd7eb6d0a0bb4a6907b4185371fd2ef63a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/inews-2.7.4-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_inews;unpack=0"
SRC_URI[x86_64_v2_inews.sha256sum] = "a18127cb6d5e550ed783cc059340023717e68b9b16c7ee5e220f75b98b9add73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/inn-2.7.4-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_inn;unpack=0"
SRC_URI[x86_64_v2_inn.sha256sum] = "24fbbc36b7674e535fbab537f2d6c4bb70b96fd88599250f4789c90952f49300"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/inn-devel-2.7.4-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_inn-devel;unpack=0"
SRC_URI[x86_64_v2_inn-devel.sha256sum] = "a1c2f321bebcdf810b65e7393968cade571477652f39aa7ce6df96c5ea016202"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/inn-libs-2.7.4-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_inn-libs;unpack=0"
SRC_URI[x86_64_v2_inn-libs.sha256sum] = "d8261bbdf5e4f1925d18fa95248864528e863d3b39610f81f8b6a9886d7bcd61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/inews-2.7.4-5.el10_3.aarch64.rpm;name=aarch64_inews;unpack=0"
SRC_URI[aarch64_inews.sha256sum] = "610d18abd8c64c334bea1d253b454d273312548f7f97f0a347587c3847c69bd1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/inn-2.7.4-5.el10_3.aarch64.rpm;name=aarch64_inn;unpack=0"
SRC_URI[aarch64_inn.sha256sum] = "ec7c045e88d1752a6a8b28218f78f97dbcdae557763c618c46f9be0d1fccce14"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/inn-devel-2.7.4-5.el10_3.aarch64.rpm;name=aarch64_inn-devel;unpack=0"
SRC_URI[aarch64_inn-devel.sha256sum] = "b150063c407feae14525f1660b5f89a48aba8bdfd7324944a7997ad9f6e689d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/inn-libs-2.7.4-5.el10_3.aarch64.rpm;name=aarch64_inn-libs;unpack=0"
SRC_URI[aarch64_inn-libs.sha256sum] = "a38f046a0b76534edf5d5ed58a638df06202ef33d7fc8c79cf83e71d463f755e"

RDEPENDS:inews = " \
 glibc \
 inn-libs \
 "
RDEPENDS:inn = " \
 bash \
 cyrus-sasl-lib \
 glibc \
 grep \
 inews \
 inn-libs \
 krb5-libs \
 libcanlock \
 libdb \
 libxcrypt \
 openssl-libs \
 pam-libs \
 perl-Carp \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-IO-Compress \
 perl-IPC-Open3 \
 perl-MIME-tools \
 perl-Math-BigInt \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-Time-Piece \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libnet \
 perl-libs \
 perl-subs \
 perl-vars \
 python3-libs \
 sed \
 sqlite-libs \
 virtual/coreutils \
 wget \
 zlib-ng-compat \
 "
RDEPENDS:inn-devel = " \
 inn \
 inn-libs \
 "
RDEPENDS:inn-libs = " \
 glibc \
 libdb \
 sqlite-libs \
 zlib-ng-compat \
 "
