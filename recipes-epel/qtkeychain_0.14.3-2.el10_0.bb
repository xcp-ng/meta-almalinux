# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qtkeychain"
PV = "0.14.3"
PR = "2.el10_0"
PACKAGES = " \
 qtkeychain-qt5 \
 qtkeychain-qt5-devel \
 qtkeychain-qt6 \
 qtkeychain-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qtkeychain-0.14.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "389338ee88a6c3a5f02df238801de318f3ce4dd2f2b1be1feee35ad05380e647"

URI_x86_64_v2_qtkeychain-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt5-0.14.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt5}"
SRC_URI[x86_64_v2_qtkeychain-qt5.sha256sum] = "15db21eb0c03a07e17f46d4ad753e53dd241c6b1b45f534b645e4713d7f3164b"

URI_x86_64_v2_qtkeychain-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt5-devel-0.14.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt5-devel}"
SRC_URI[x86_64_v2_qtkeychain-qt5-devel.sha256sum] = "b0cabc402a15caf1b2d0a486ff1bab2386afc50d46525482aa8ab6c8ef79508f"

URI_x86_64_v2_qtkeychain-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt6-0.14.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt6}"
SRC_URI[x86_64_v2_qtkeychain-qt6.sha256sum] = "07aafd0862d40df9695f17d3bf05e9b54f69e5a96eb5908faf64295bb86fcaab"

URI_x86_64_v2_qtkeychain-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qtkeychain-qt6-devel-0.14.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qtkeychain-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qtkeychain-qt6-devel}"
SRC_URI[x86_64_v2_qtkeychain-qt6-devel.sha256sum] = "3aa0371f83f786b554bcb5b655407d571a335387dfc7bb57ef793c4a8f5ce47b"

URI_aarch64_qtkeychain-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt5-0.14.3-2.el10_0.aarch64.rpm;name=aarch64_qtkeychain-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt5}"
SRC_URI[aarch64_qtkeychain-qt5.sha256sum] = "2c4d614273fcfaaeccf82ba52dcea394df7d2a18dbd044dfd1df047fc468ce6b"

URI_aarch64_qtkeychain-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt5-devel-0.14.3-2.el10_0.aarch64.rpm;name=aarch64_qtkeychain-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt5-devel}"
SRC_URI[aarch64_qtkeychain-qt5-devel.sha256sum] = "39fff48149ba21f75c3f6627255f225225202790a5e807a39270eaae98061321"

URI_aarch64_qtkeychain-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt6-0.14.3-2.el10_0.aarch64.rpm;name=aarch64_qtkeychain-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt6}"
SRC_URI[aarch64_qtkeychain-qt6.sha256sum] = "e48b73b00fe83f8591d9afbcd31a749c59b2a71cd5c25886980a61d2afda138e"

URI_aarch64_qtkeychain-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qtkeychain-qt6-devel-0.14.3-2.el10_0.aarch64.rpm;name=aarch64_qtkeychain-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qtkeychain-qt6-devel}"
SRC_URI[aarch64_qtkeychain-qt6-devel.sha256sum] = "844f157e2d0338e3cafa550c8a27173a620552c99278bfbbe7e6d64854b52d85"

RDEPENDS:qtkeychain-qt5 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qtkeychain-qt5-devel = " \
 cmake-filesystem \
 libsecret-devel \
 qt5-qtbase-devel \
 qtkeychain-qt5 \
 "
RDEPENDS:qtkeychain-qt6 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qtkeychain-qt6-devel = " \
 cmake-filesystem \
 libsecret-devel \
 qt6-qtbase-devel \
 qtkeychain-qt6 \
 "
