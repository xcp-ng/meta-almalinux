# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IPC-Run3"
PV = "0.049"
PR = "4.el10"
PACKAGES = " \
 perl-IPC-Run3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-IPC-Run3-0.049-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5439306576fa54a4a45c04e3da5e1ab62d3a6bd3cb5cb2d0f4d8469ec60c951"

URI_x86_64_v2_perl-IPC-Run3 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-IPC-Run3-0.049-4.el10.noarch.rpm;name=x86_64_v2_perl-IPC-Run3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IPC-Run3}"
SRC_URI[x86_64_v2_perl-IPC-Run3.sha256sum] = "389f41a26b69f40b08a7eb56ebb53e6b80e4543caa54fd9711b5c3188020d388"

URI_aarch64_perl-IPC-Run3 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-IPC-Run3-0.049-4.el10.noarch.rpm;name=aarch64_perl-IPC-Run3;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IPC-Run3}"
SRC_URI[aarch64_perl-IPC-Run3.sha256sum] = "389f41a26b69f40b08a7eb56ebb53e6b80e4543caa54fd9711b5c3188020d388"

RDEPENDS:perl-IPC-Run3 = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Temp \
 perl-IPC-Run3 \
 perl-POSIX \
 perl-constant \
 perl-libs \
 "
