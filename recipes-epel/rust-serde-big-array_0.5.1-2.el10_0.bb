# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde-big-array"
PV = "0.5.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-serde-big-array+default-devel \
 rust-serde-big-array-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-serde-big-array-0.5.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7642b90d1d73b4367b71a6c553d9a1fe4c3ab6144f5ddcd8914b590b65a66a30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-big-array+default-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-big-array+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde-big-array+default-devel.sha256sum] = "6911019621947864e9002c3b2039314d204fff172eccffcd2eb4dd6857ec1855"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-big-array-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-big-array-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde-big-array-devel.sha256sum] = "c45e0afc5b577dd1f1d489be61cba9874dd006f6e4b6823f42601617d9ea54ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-big-array+default-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-serde-big-array+default-devel;unpack=0"
SRC_URI[aarch64_rust-serde-big-array+default-devel.sha256sum] = "f7e39176c9ecbdfeb39ed6d7fe5d375af6ac05b7d6005b4bbeec7837fc55cc79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-big-array-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-serde-big-array-devel;unpack=0"
SRC_URI[aarch64_rust-serde-big-array-devel.sha256sum] = "495a749073ae763ae06d9cd7de4dffc3af838cb9871a82329158f6faf788893f"

RDEPENDS:rust-serde-big-array+default-devel = " \
 cargo \
 rust-serde-big-array-devel \
 "
RDEPENDS:rust-serde-big-array-devel = " \
 cargo \
 rust-serde-devel \
 "
