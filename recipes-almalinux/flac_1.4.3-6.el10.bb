# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flac"
PV = "1.4.3"
PR = "6.el10"
PACKAGES = " \
 flac \
 flac-devel \
 flac-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/flac-1.4.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "876a7acbce3a90a0307aac3053fc38a0aee3adecaccefbc69b2015f3c742ea3a"

URI_x86_64_v2_flac = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flac-1.4.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_flac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flac}"
SRC_URI[x86_64_v2_flac.sha256sum] = "db2cf1a4a147acb0924c7aef6fd4df148e988855cfd301f6506229ce93383fde"

URI_x86_64_v2_flac-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flac-devel-1.4.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_flac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flac-devel}"
SRC_URI[x86_64_v2_flac-devel.sha256sum] = "27241d0083aa8c05fe83c21bf921edb9237e06c35cb338a166c7a8c72d513ffb"

URI_x86_64_v2_flac-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/flac-libs-1.4.3-6.el10.x86_64_v2.rpm;name=x86_64_v2_flac-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flac-libs}"
SRC_URI[x86_64_v2_flac-libs.sha256sum] = "95d6c72d43327f99423011ca52b05021f2e19f5da35b876d2c7dc4d91814625f"

URI_aarch64_flac = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flac-1.4.3-6.el10.aarch64.rpm;name=aarch64_flac;unpack=0"
SRC_URI:append = " ${URI_aarch64_flac}"
SRC_URI[aarch64_flac.sha256sum] = "88ce73332fdb5f826976ac635f0e4cc99d00ecddbe5e050b0010c0d54875e496"

URI_aarch64_flac-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flac-devel-1.4.3-6.el10.aarch64.rpm;name=aarch64_flac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_flac-devel}"
SRC_URI[aarch64_flac-devel.sha256sum] = "a859157a2c507cc4bb3cab77b81efc73dceeec89c899b14bacb763ad5622ef5d"

URI_aarch64_flac-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/flac-libs-1.4.3-6.el10.aarch64.rpm;name=aarch64_flac-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_flac-libs}"
SRC_URI[aarch64_flac-libs.sha256sum] = "6d97b6b95f826ea0256d1b9f5d51dc7abae698a64fb2a7d9ef7585c0cc2fd67b"

RDEPENDS:flac = " \
 flac-libs \
 glibc \
 "
RDEPENDS:flac-devel = " \
 flac-devel \
 flac-libs \
 libogg-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:flac-libs = " \
 glibc \
 libgcc \
 libogg \
 libstdc++ \
 "
