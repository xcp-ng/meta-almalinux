# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libflate"
PV = "2.1.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-libflate+default-devel \
 rust-libflate+std-devel \
 rust-libflate-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libflate-2.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d82607f52c87a77729d2490ebd3ef7d048371aadddf7b1854a8f2892636a3e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libflate+default-devel-2.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libflate+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libflate+default-devel.sha256sum] = "f5fc496dae88ccac2a056c9fa42e0ba252fbf5d8de772135b864171e472287cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libflate+std-devel-2.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libflate+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libflate+std-devel.sha256sum] = "2ec53d3654fcb74d2133b005e6012e692935f41ef269e0c0d9e7fb723fab0e6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libflate-devel-2.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libflate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libflate-devel.sha256sum] = "ddbcc0cfc5eae100f107a79ecb3e954c0a562aa99edaae04f734c7c1d5e7feb3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libflate+default-devel-2.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-libflate+default-devel;unpack=0"
SRC_URI[aarch64_rust-libflate+default-devel.sha256sum] = "2eff1f69a01a33eff6c7d2049d4b646b706a5351622334f3e79fc0f26f275418"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libflate+std-devel-2.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-libflate+std-devel;unpack=0"
SRC_URI[aarch64_rust-libflate+std-devel.sha256sum] = "dd3e1f767d1510e55925831cd0912d349333516b74460fea0ad145f2313a1f7f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libflate-devel-2.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-libflate-devel;unpack=0"
SRC_URI[aarch64_rust-libflate-devel.sha256sum] = "3a4b316206cca02d224c1fdcee313237d9c6f079e311da0e9ae816dc837b64cf"

RDEPENDS:rust-libflate+default-devel = " \
 cargo \
 rust-libflate+std-devel \
 rust-libflate-devel \
 "
RDEPENDS:rust-libflate+std-devel = " \
 cargo \
 rust-core2+std-devel \
 rust-libflate-devel \
 rust-libflate_lz77+std-devel \
 "
RDEPENDS:rust-libflate-devel = " \
 cargo \
 rust-adler32-devel \
 rust-core2+alloc-devel \
 rust-core2-devel \
 rust-crc32fast-devel \
 rust-dary_heap+default-devel \
 rust-libflate_lz77-devel \
 "
