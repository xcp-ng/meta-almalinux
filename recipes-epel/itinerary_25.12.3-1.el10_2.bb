# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "itinerary"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 itinerary \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/itinerary-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "daf441c79b5d580b3915f397cbc542ebb7c005b05ab45e11edc229bfe31b88a8"

URI_x86_64_v2_itinerary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/itinerary-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_itinerary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_itinerary}"
SRC_URI[x86_64_v2_itinerary.sha256sum] = "ba1df0df3dfdc015815da53707822174b27907577337c5080e3c63356c4cc1ce"

URI_aarch64_itinerary = "${EPEL_MIRROR}/aarch64/Packages/i/itinerary-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_itinerary;unpack=0"
SRC_URI:append = " ${URI_aarch64_itinerary}"
SRC_URI[aarch64_itinerary.sha256sum] = "028f5d8415960083f9534dc75f196163b7267b8caa8b43402975a7633676da42"

RDEPENDS:itinerary = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kunitconversion \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-qqc2-desktop-style \
 khealthcertificate \
 kitinerary \
 kosmindoormap \
 kpkpass \
 kpublictransport \
 libquotient-qt6 \
 libstdc++ \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qtkeychain-qt6 \
 zlib-ng-compat \
 "
