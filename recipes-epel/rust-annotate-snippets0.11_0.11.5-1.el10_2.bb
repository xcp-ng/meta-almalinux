# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-annotate-snippets0.11"
PV = "0.11.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-annotate-snippets0.11+default-devel \
 rust-annotate-snippets0.11+memchr-devel \
 rust-annotate-snippets0.11+simd-devel \
 rust-annotate-snippets0.11+testing-colors-devel \
 rust-annotate-snippets0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-annotate-snippets0.11-0.11.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e28058c881649670595fa896d9f99705c4d835c426c3547a8635fd6af89ad32"

URI_x86_64_v2_rust-annotate-snippets0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.11+default-devel-0.11.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.11+default-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.11+default-devel.sha256sum] = "7ac2ac1cd6a45369e6c43596553427d59ccb0ee0a23c129e9868504487b452a1"

URI_x86_64_v2_rust-annotate-snippets0.11+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.11+memchr-devel-0.11.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.11+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.11+memchr-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.11+memchr-devel.sha256sum] = "f5ba7a87bf9c4090d454910de239e7a992eee83f36a426a030e47074e20096b0"

URI_x86_64_v2_rust-annotate-snippets0.11+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.11+simd-devel-0.11.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.11+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.11+simd-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.11+simd-devel.sha256sum] = "6724ab359f54faca25af51191d49b2c2a83045c832cf4796b3bdbaf736c10fe7"

URI_x86_64_v2_rust-annotate-snippets0.11+testing-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.11+testing-colors-devel-0.11.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.11+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.11+testing-colors-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.11+testing-colors-devel.sha256sum] = "ce4a8295511a69ab29e0a5fe0de2e37764daa45a4e0010659f70d42e69174023"

URI_x86_64_v2_rust-annotate-snippets0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-annotate-snippets0.11-devel-0.11.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-annotate-snippets0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-annotate-snippets0.11-devel}"
SRC_URI[x86_64_v2_rust-annotate-snippets0.11-devel.sha256sum] = "3304513480a0451d8db5e077e85d70f4052b76d6bfe8d8af8b78cc35cd85f70d"

URI_aarch64_rust-annotate-snippets0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.11+default-devel-0.11.5-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.11+default-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.11+default-devel.sha256sum] = "b65aac1576e0e1cc2c8c7bc37cda2e1748711a98da97c3fb2ac9ddd311edd345"

URI_aarch64_rust-annotate-snippets0.11+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.11+memchr-devel-0.11.5-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets0.11+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.11+memchr-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.11+memchr-devel.sha256sum] = "9c57e9f4217181ea94f2b8af2c43cd74288f4ef0a68249aabe14601aee2aa476"

URI_aarch64_rust-annotate-snippets0.11+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.11+simd-devel-0.11.5-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets0.11+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.11+simd-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.11+simd-devel.sha256sum] = "98e922b30087de109afccdae3d35ab81bd37c033981828feb90d4bf4b44adcb7"

URI_aarch64_rust-annotate-snippets0.11+testing-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.11+testing-colors-devel-0.11.5-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets0.11+testing-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.11+testing-colors-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.11+testing-colors-devel.sha256sum] = "3ac59bc1865c4c0c37eda305b2418159da9e06b13ebe4ca0b765b41c3ece50a8"

URI_aarch64_rust-annotate-snippets0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-annotate-snippets0.11-devel-0.11.5-1.el10_2.noarch.rpm;name=aarch64_rust-annotate-snippets0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-annotate-snippets0.11-devel}"
SRC_URI[aarch64_rust-annotate-snippets0.11-devel.sha256sum] = "5cf1cb59c32b8361964aea52958b3924dc57848675c62df1199ae2343db85caf"

RDEPENDS:rust-annotate-snippets0.11+default-devel = " \
 cargo \
 rust-annotate-snippets0.11-devel \
 "
RDEPENDS:rust-annotate-snippets0.11+memchr-devel = " \
 cargo \
 rust-annotate-snippets0.11-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-annotate-snippets0.11+simd-devel = " \
 cargo \
 rust-annotate-snippets0.11+memchr-devel \
 rust-annotate-snippets0.11-devel \
 "
RDEPENDS:rust-annotate-snippets0.11+testing-colors-devel = " \
 cargo \
 rust-annotate-snippets0.11-devel \
 "
RDEPENDS:rust-annotate-snippets0.11-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-unicode-width+default-devel \
 "
