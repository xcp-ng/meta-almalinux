# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libevent"
PV = "2.1.12"
PR = "16.el10"
PACKAGES = " \
 libevent \
 libevent-devel \
 libevent-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libevent-2.1.12-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a89b7ecaea233546fe83247ced35d8946a5a4eadb9c9261e46cecb4b7cbdf828"

URI_x86_64_v2_libevent = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libevent-2.1.12-16.el10.x86_64_v2.rpm;name=x86_64_v2_libevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libevent}"
SRC_URI[x86_64_v2_libevent.sha256sum] = "d52f9b12a6e5a62c71465090bf59f87241616ee47cf217645bd74903273834ec"

URI_x86_64_v2_libevent-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libevent-devel-2.1.12-16.el10.x86_64_v2.rpm;name=x86_64_v2_libevent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libevent-devel}"
SRC_URI[x86_64_v2_libevent-devel.sha256sum] = "730e672988db573f3ad50323edf22868a7c7d8658c250332a0c0a5344fd2eee3"

URI_x86_64_v2_libevent-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libevent-doc-2.1.12-16.el10.noarch.rpm;name=x86_64_v2_libevent-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libevent-doc}"
SRC_URI[x86_64_v2_libevent-doc.sha256sum] = "d1086f3495b2c44797e045301bd299ed44f6f33d9b90a4dc9ed99a20166caf34"

URI_aarch64_libevent = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libevent-2.1.12-16.el10.aarch64.rpm;name=aarch64_libevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_libevent}"
SRC_URI[aarch64_libevent.sha256sum] = "62bc62a17da2ab8e64b211e4125241b4c399d4972a8ccb5ce463861d4dca81ff"

URI_aarch64_libevent-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libevent-devel-2.1.12-16.el10.aarch64.rpm;name=aarch64_libevent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libevent-devel}"
SRC_URI[aarch64_libevent-devel.sha256sum] = "77be8ea9312f8aa7c28098ffe7e68d0cbd760dc4eab6a7626bc1b32f2524d85b"

URI_aarch64_libevent-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libevent-doc-2.1.12-16.el10.noarch.rpm;name=aarch64_libevent-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libevent-doc}"
SRC_URI[aarch64_libevent-doc.sha256sum] = "d1086f3495b2c44797e045301bd299ed44f6f33d9b90a4dc9ed99a20166caf34"

RDEPENDS:libevent = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:libevent-devel = " \
 libevent \
 libevent-devel \
 pkgconf-pkg-config \
 python3 \
 "
RDEPENDS:libevent-doc = " \
 "
