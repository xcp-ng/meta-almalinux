# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4cplus"
PV = "2.1.1"
PR = "10.el10"
PACKAGES = " \
 log4cplus \
 log4cplus-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/log4cplus-2.1.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e961c64fb8ca7aec44b3c6c339065092f3c37e0cd44fe2f67e7f2479a3d9d0ac"

URI_x86_64_v2_log4cplus = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/log4cplus-2.1.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_log4cplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cplus}"
SRC_URI[x86_64_v2_log4cplus.sha256sum] = "6c6cfa2694e94c0067e3eadd346d4d7bf51731f5d79fbf7d65ab89f701afb468"

URI_x86_64_v2_log4cplus-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/log4cplus-devel-2.1.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_log4cplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cplus-devel}"
SRC_URI[x86_64_v2_log4cplus-devel.sha256sum] = "ac2f0594467915235383ca49e0ecfe5b6d31ab70c47d4ed6e92be65eeab4de60"

URI_aarch64_log4cplus = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/log4cplus-2.1.1-10.el10.aarch64.rpm;name=aarch64_log4cplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cplus}"
SRC_URI[aarch64_log4cplus.sha256sum] = "0c28bf569341bfd4f8ad031691f5a5fa97ed0d6967d3db199d02bcc864015978"

URI_aarch64_log4cplus-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/log4cplus-devel-2.1.1-10.el10.aarch64.rpm;name=aarch64_log4cplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cplus-devel}"
SRC_URI[aarch64_log4cplus-devel.sha256sum] = "7111c55fe123a84229919cd16b732cf0e06733e707039b358e31085a5a035315"

RDEPENDS:log4cplus:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
"
RDEPENDS:log4cplus:aarch64 = " \
 glibc \
 libatomic \
 libgcc \
 libstdc++ \
"
RDEPENDS:log4cplus-devel = " \
 log4cplus \
 pkgconf-pkg-config \
 "
