# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-PyGithub"
PV = "2.6.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-pygithub \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-PyGithub-2.6.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4ff1f69e658ba6e07f9be334c6d61ee594622499efdbd2d81e0f31f1da8334d"

URI_x86_64_v2_python3-pygithub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pygithub-2.6.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pygithub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pygithub}"
SRC_URI[x86_64_v2_python3-pygithub.sha256sum] = "79bed82626fbff8766b343cf65f22f0a11f1620a188c12c56d4780620081af0c"

URI_aarch64_python3-pygithub = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pygithub-2.6.1-3.el10_1.noarch.rpm;name=aarch64_python3-pygithub;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pygithub}"
SRC_URI[aarch64_python3-pygithub.sha256sum] = "34f164c05bd6e58cda697a4d1fc1e2efbcb04d632dfe70b2c7c0ae6a72e02be8"

RDEPENDS:python3-pygithub = " \
 python3 \
 python3-deprecated \
 python3-jwt \
 python3-jwt+crypto \
 python3-pynacl \
 python3-requests \
 python3-typing-extensions \
 python3-urllib3 \
 "
