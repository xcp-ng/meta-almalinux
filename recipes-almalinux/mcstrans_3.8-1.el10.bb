# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mcstrans"
PV = "3.8"
PR = "1.el10"
PACKAGES = " \
 mcstrans \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mcstrans-3.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14c28d3c429bc84947a04496052f1c438711efcb208045724ee58b96276cf250"

URI_x86_64_v2_mcstrans = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mcstrans-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_mcstrans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mcstrans}"
SRC_URI[x86_64_v2_mcstrans.sha256sum] = "cd6b4b46d07024d13b8a3822602d751dced43cc17e5fc758791ac640be8f12c8"

URI_aarch64_mcstrans = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mcstrans-3.8-1.el10.aarch64.rpm;name=aarch64_mcstrans;unpack=0"
SRC_URI:append = " ${URI_aarch64_mcstrans}"
SRC_URI[aarch64_mcstrans.sha256sum] = "0916fad97c52434f0a494e82a48bf39eaf3c90dbddf4780359c43b4c7564042d"

RDEPENDS:mcstrans = " \
 bash \
 glibc \
 libcap \
 libselinux \
 pcre2 \
 systemd \
 "
