# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff-core"
PV = "0.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-jiff-core+alloc-devel \
 rust-jiff-core+arbitrary-devel \
 rust-jiff-core+default-devel \
 rust-jiff-core+logging-devel \
 rust-jiff-core+std-devel \
 rust-jiff-core+tz-fat-devel \
 rust-jiff-core-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-jiff-core-0.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e0f739c35d4c6971424e60f45bdc974528968027200ced80dc5b39850f6d46d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+alloc-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff-core+alloc-devel.sha256sum] = "a8372b7913b38ce01737abd5f5330c72a667161572fa89da08ea6d112d0bf1ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+arbitrary-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff-core+arbitrary-devel.sha256sum] = "531a28ad6d25431f120c69e4fbc911d19ec6109d0a1de02ff9bbe6ae911716af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+default-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff-core+default-devel.sha256sum] = "d2efabb3bc96986b725a0933a125ca74c6b8e1ad38810e3a490f8841dc7fc651"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+logging-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+logging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff-core+logging-devel.sha256sum] = "d56d0dc4223aa36ac2b208b2d7188e98645aa478ce0c5232cf46291275c29473"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+std-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff-core+std-devel.sha256sum] = "19b6885a8fd4c134ecaa317885bdc89f1add10f3c9b4a1db32d82c0fc17e1c98"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+tz-fat-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+tz-fat-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff-core+tz-fat-devel.sha256sum] = "013e2f53f019a7fb6af6dbef519361aa95e21233a2215c231e91386f2356b0d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core-devel-0.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-jiff-core-devel.sha256sum] = "57ecfd7fc57adfe6462c13694fef199dbdf303866b792fd973d21b83335acd7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+alloc-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-jiff-core+alloc-devel.sha256sum] = "47fcaa10ec9dbae3851beeea364daa78c8225837a8aec415476cacf0771677dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+arbitrary-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-jiff-core+arbitrary-devel.sha256sum] = "950b8205b92d19566ead0198ec0c0e57b78f97e443be4811c613278b0a2b5f7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+default-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+default-devel;unpack=0"
SRC_URI[aarch64_rust-jiff-core+default-devel.sha256sum] = "079ac12f429375349c46decf3cb6ac7e05808a2babde80425241f352e63bb185"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+logging-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+logging-devel;unpack=0"
SRC_URI[aarch64_rust-jiff-core+logging-devel.sha256sum] = "1f7c180243bb0de9a6b75d90dae67a38abbaa58f29a256bcd5143102420016cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+std-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+std-devel;unpack=0"
SRC_URI[aarch64_rust-jiff-core+std-devel.sha256sum] = "cf42e949f23a692d4a7977697550826cc6797b4c07962773c5238a6e2e2bdeed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+tz-fat-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core+tz-fat-devel;unpack=0"
SRC_URI[aarch64_rust-jiff-core+tz-fat-devel.sha256sum] = "58877e537b0cd596e72ebeeb6aabb5c22efa4c5df661663dd51db55473ded0d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core-devel-0.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-jiff-core-devel;unpack=0"
SRC_URI[aarch64_rust-jiff-core-devel.sha256sum] = "6d6b4b3566e50d7f342618d42f3bafa848b9a867bd4c860f447130fa4dc57ae3"

RDEPENDS:rust-jiff-core+alloc-devel = " \
 cargo \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-jiff-core+std-devel \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core+default-devel = " \
 cargo \
 rust-jiff-core+std-devel \
 rust-jiff-core+tz-fat-devel \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core+logging-devel = " \
 cargo \
 rust-jiff-core-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff-core+std-devel = " \
 cargo \
 rust-jiff-core+alloc-devel \
 rust-jiff-core-devel \
 rust-log+std-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff-core+tz-fat-devel = " \
 cargo \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core-devel = " \
 cargo \
 rust \
 "
