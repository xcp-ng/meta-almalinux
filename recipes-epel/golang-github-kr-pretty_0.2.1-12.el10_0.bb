# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kr-pretty"
PV = "0.2.1"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-kr-pretty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kr-pretty-0.2.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4964aaa3ed0af875d64014e2c2159120d9dc1ec32d5d877dbb95a98397a31e9"

URI_x86_64_v2_golang-github-kr-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-kr-pretty-devel-0.2.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-kr-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-kr-pretty-devel}"
SRC_URI[x86_64_v2_golang-github-kr-pretty-devel.sha256sum] = "5dcc624b1dff5f6fe7f1d37d1e0a2ad06e59080b5fcf4d5b3f4cc43f2fbe7f82"

URI_aarch64_golang-github-kr-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kr-pretty-devel-0.2.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-kr-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kr-pretty-devel}"
SRC_URI[aarch64_golang-github-kr-pretty-devel.sha256sum] = "e72b335359ca41948aa9036e8dbb4c9232203f50365ae4275fec5d87272d9232"

RDEPENDS:golang-github-kr-pretty-devel = " \
 go-filesystem \
 golang-github-kr-text-devel \
 "
