# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krdp"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 krdp \
 krdp-devel \
 krdp-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krdp-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9ff5271506e9f1a0bb04cecced08f474e70d759480078afa6197806147c9cce"

URI_x86_64_v2_krdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp}"
SRC_URI[x86_64_v2_krdp.sha256sum] = "9fbaf721b58947992ba4184c4891c8eced15fbd0f0228d97fe7fcc659ec903a5"

URI_x86_64_v2_krdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp-devel}"
SRC_URI[x86_64_v2_krdp-devel.sha256sum] = "aceeb7cd68ad3f9b64f9b03f31375985bf739c3681ca02e89d23a5efc80e8591"

URI_x86_64_v2_krdp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krdp-libs-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krdp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krdp-libs}"
SRC_URI[x86_64_v2_krdp-libs.sha256sum] = "94f495f12f271b6a706759023e8c24c20d781588f66ea63fe3d4583db57119f0"

URI_aarch64_krdp = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_krdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp}"
SRC_URI[aarch64_krdp.sha256sum] = "4dcb5c9896cb33eb860f6b8a3f3cd9ce8b4e6f2987237b0ad39efc039eb69464"

URI_aarch64_krdp-devel = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_krdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp-devel}"
SRC_URI[aarch64_krdp-devel.sha256sum] = "b33d6e335a64092a2ad8f81e321deea27606357809d9f5b4815e33f48f7163d9"

URI_aarch64_krdp-libs = "${EPEL_MIRROR}/aarch64/Packages/k/krdp-libs-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_krdp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krdp-libs}"
SRC_URI[aarch64_krdp-libs.sha256sum] = "f24e4a079f4ac7beda750310de9a1da91fb5d581ad7afbbf2d8857c994d142e1"

RDEPENDS:krdp = " \
 bash \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami-addons \
 kf6-kstatusnotifieritem \
 kpipewire \
 krdp-libs \
 libstdc++ \
 openssl \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:krdp-devel = " \
 cmake-filesystem \
 krdp-libs \
 "
RDEPENDS:krdp-libs = " \
 freerdp \
 freerdp-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kpipewire \
 libstdc++ \
 libwayland-client \
 libwinpr \
 libxkbcommon \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
