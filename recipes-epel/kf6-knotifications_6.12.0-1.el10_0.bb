# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifications"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-knotifications \
 kf6-knotifications-devel \
 kf6-knotifications-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifications-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8c0898b3899d54031efd31e7b42c4b9d934e7b4eb4e13636f35ffe2c6da3957"

URI_x86_64_v2_kf6-knotifications = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications}"
SRC_URI[x86_64_v2_kf6-knotifications.sha256sum] = "6c6010c7b9a1adba46cbefe06809a5f8c64be404c7131462c0f3cb859323bce6"

URI_x86_64_v2_kf6-knotifications-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-devel}"
SRC_URI[x86_64_v2_kf6-knotifications-devel.sha256sum] = "38e9f007fd3ade5519438ebc2774bdafbf093d20432d1d78ec86de4143e4e05f"

URI_x86_64_v2_kf6-knotifications-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifications-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knotifications-doc}"
SRC_URI[x86_64_v2_kf6-knotifications-doc.sha256sum] = "49bbd39827637a592f7ca1c83ec19241fc17f99fceeef709609fed4488c2e2ae"

URI_aarch64_kf6-knotifications = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-knotifications;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications}"
SRC_URI[aarch64_kf6-knotifications.sha256sum] = "57c85586d3056073405b93acb5f01e2af191f72a8ff974ec70b026af8087a4ce"

URI_aarch64_kf6-knotifications-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-knotifications-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-devel}"
SRC_URI[aarch64_kf6-knotifications-devel.sha256sum] = "d077097a8fc6182f16a1a1611aaf1903f82e11bd25611745f65431278436e039"

URI_aarch64_kf6-knotifications-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-knotifications-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knotifications-doc}"
SRC_URI[aarch64_kf6-knotifications-doc.sha256sum] = "863363533df737ae304c8b6d9aa525af331f12bf849391e89b9bfce2af067420"

RDEPENDS:kf6-knotifications = " \
 glibc \
 kf6-kconfig \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knotifications-devel = " \
 cmake-filesystem \
 kf6-knotifications \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifications-doc = " \
 "
