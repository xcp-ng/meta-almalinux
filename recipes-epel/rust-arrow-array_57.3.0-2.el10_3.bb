# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-array"
PV = "57.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-arrow-array+chrono-tz-devel \
 rust-arrow-array+default-devel \
 rust-arrow-array+ffi-devel \
 rust-arrow-array+force_validate-devel \
 rust-arrow-array-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-array-57.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4a47795cc4c193269757aaef5436d40d3003367e6b592d5a05874c1bf8f8f40"

URI_x86_64_v2_rust-arrow-array+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-array+chrono-tz-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-array+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-array+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-arrow-array+chrono-tz-devel.sha256sum] = "96a9ab7eb552e9e5281d0e4123bf660103cbf41adc46d569cf52678cc925de1e"

URI_x86_64_v2_rust-arrow-array+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-array+default-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-array+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-array+default-devel.sha256sum] = "bd5608948f3ac400d55bec5ef8c89798f6d346d9d4d337650da39699c7249210"

URI_x86_64_v2_rust-arrow-array+ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-array+ffi-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-array+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-array+ffi-devel}"
SRC_URI[x86_64_v2_rust-arrow-array+ffi-devel.sha256sum] = "6170a60a85e1607734de42e65cc6cf7d1d9605f29d02fdede31c914334e74116"

URI_x86_64_v2_rust-arrow-array+force_validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-array+force_validate-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-array+force_validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-array+force_validate-devel}"
SRC_URI[x86_64_v2_rust-arrow-array+force_validate-devel.sha256sum] = "f487ad85b7504b3bcb4d913d9e597f90abc1388ed602801c698a064d1bc800a3"

URI_x86_64_v2_rust-arrow-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-array-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-array-devel}"
SRC_URI[x86_64_v2_rust-arrow-array-devel.sha256sum] = "ba78204ff5850c393d9ed58ff2ea3f9a5145ed60742c2b363af2e96d8e7e5fba"

URI_aarch64_rust-arrow-array+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-array+chrono-tz-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-array+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-array+chrono-tz-devel}"
SRC_URI[aarch64_rust-arrow-array+chrono-tz-devel.sha256sum] = "398e6d9051e08dc997d46ac5fd9d08e87bb9f0797b40e2caa3fb71538949c1e9"

URI_aarch64_rust-arrow-array+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-array+default-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-array+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-array+default-devel}"
SRC_URI[aarch64_rust-arrow-array+default-devel.sha256sum] = "d25c2181dcc91964c7b3a567712c872074c90f2b64accb3008afffdb47944319"

URI_aarch64_rust-arrow-array+ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-array+ffi-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-array+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-array+ffi-devel}"
SRC_URI[aarch64_rust-arrow-array+ffi-devel.sha256sum] = "87b4293585b6cecbd27a72a55911bdc8c5cfcabe84dd9a94a4ea01fb160c2c52"

URI_aarch64_rust-arrow-array+force_validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-array+force_validate-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-array+force_validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-array+force_validate-devel}"
SRC_URI[aarch64_rust-arrow-array+force_validate-devel.sha256sum] = "51f4eb071f8e4266f931c462ecaeaf75505870506be87790707aaf50f3506382"

URI_aarch64_rust-arrow-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-array-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-array-devel}"
SRC_URI[aarch64_rust-arrow-array-devel.sha256sum] = "fca17d0462872a8cc7a99612038b21e726f7091ce9d564ddf77117e76821142a"

RDEPENDS:rust-arrow-array+chrono-tz-devel = " \
 cargo \
 rust-arrow-array-devel \
 rust-chrono-tz+default-devel \
 "
RDEPENDS:rust-arrow-array+default-devel = " \
 cargo \
 rust-arrow-array-devel \
 "
RDEPENDS:rust-arrow-array+ffi-devel = " \
 cargo \
 rust-arrow-array-devel \
 rust-arrow-data+ffi-devel \
 rust-arrow-schema+ffi-devel \
 "
RDEPENDS:rust-arrow-array+force_validate-devel = " \
 cargo \
 rust-arrow-array-devel \
 "
RDEPENDS:rust-arrow-array-devel = " \
 cargo \
 rust \
 rust-ahash+runtime-rng-devel \
 rust-ahash-devel \
 rust-arrow-buffer+default-devel \
 rust-arrow-data+default-devel \
 rust-arrow-schema+default-devel \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-half+num-traits-devel \
 rust-half-devel \
 rust-hashbrown0.16-devel \
 rust-num-complex+std-devel \
 rust-num-complex-devel \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 rust-num-traits+std-devel \
 rust-num-traits-devel \
 "
