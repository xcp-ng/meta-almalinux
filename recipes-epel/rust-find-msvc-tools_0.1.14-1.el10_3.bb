# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-find-msvc-tools"
PV = "0.1.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-find-msvc-tools+default-devel \
 rust-find-msvc-tools-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-find-msvc-tools-0.1.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "352a18df307be1ca6c1e59d62c084a62fbb9b813a5e39eb01daa911f760ae94f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools+default-devel-0.1.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-find-msvc-tools+default-devel.sha256sum] = "44945d7e26409971799f4b5353fc377700c96974bc1637fec4f5f40aa0d71465"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-msvc-tools-devel-0.1.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-msvc-tools-devel;unpack=0"
SRC_URI[x86_64_v2_rust-find-msvc-tools-devel.sha256sum] = "39dc8667764759d9140b28e2a8881b76719fd826e0ca0c86b1e749a5d12c20b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools+default-devel-0.1.14-1.el10_3.noarch.rpm;name=aarch64_rust-find-msvc-tools+default-devel;unpack=0"
SRC_URI[aarch64_rust-find-msvc-tools+default-devel.sha256sum] = "066db8c4c59c0209cd5e1c37543941e6d4310e939d58d208ed802df5188d4ecc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-find-msvc-tools-devel-0.1.14-1.el10_3.noarch.rpm;name=aarch64_rust-find-msvc-tools-devel;unpack=0"
SRC_URI[aarch64_rust-find-msvc-tools-devel.sha256sum] = "ce99e3c462ff476ae67735486760db0fef6093969dd7d99dd0531f380024cddf"

RDEPENDS:rust-find-msvc-tools+default-devel = " \
 cargo \
 rust-find-msvc-tools-devel \
 "
RDEPENDS:rust-find-msvc-tools-devel = " \
 cargo \
 rust \
 "
