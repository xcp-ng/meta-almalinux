# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http"
PV = "1.3.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-http+default-devel \
 rust-http+std-devel \
 rust-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-1.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a3f6afadd02002fda57c92c94478a0bbd537df3ebceda6387da1badf8927bfb"

URI_x86_64_v2_rust-http+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+default-devel-1.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http+default-devel}"
SRC_URI[x86_64_v2_rust-http+default-devel.sha256sum] = "ae5c18ff6b50ee4bf7b830c614a699bb22cea0ea276368a247ae8a69217a2c4a"

URI_x86_64_v2_rust-http+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+std-devel-1.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http+std-devel}"
SRC_URI[x86_64_v2_rust-http+std-devel.sha256sum] = "daa76af5a9fc29e3705d1d1703b398b5c4d54a33570899029c53445b4d278e51"

URI_x86_64_v2_rust-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-devel-1.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-devel}"
SRC_URI[x86_64_v2_rust-http-devel.sha256sum] = "59f937418af9f69ea8a1eb0f2cdb65eeff7c84994c56ed8e2de0a6239b97e2f9"

URI_aarch64_rust-http+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http+default-devel-1.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http+default-devel}"
SRC_URI[aarch64_rust-http+default-devel.sha256sum] = "2350cf57e1a8440187573a5ac268b39f0c607aef6306f47462d50f40a66ff3e1"

URI_aarch64_rust-http+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http+std-devel-1.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-http+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http+std-devel}"
SRC_URI[aarch64_rust-http+std-devel.sha256sum] = "b47e22baccff8cf0507ab9260452914fcb81d44c1d4bbae66ca0ddd9349f4f4d"

URI_aarch64_rust-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-devel-1.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-devel}"
SRC_URI[aarch64_rust-http-devel.sha256sum] = "f01a009520a82761760e8ff99fb140981b17aae10ef37a70667956e36d7fa734"

RDEPENDS:rust-http+default-devel = " \
 cargo \
 rust-http+std-devel \
 rust-http-devel \
 "
RDEPENDS:rust-http+std-devel = " \
 cargo \
 rust-http-devel \
 "
RDEPENDS:rust-http-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-fnv+default-devel \
 rust-itoa+default-devel \
 "
