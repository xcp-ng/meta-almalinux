# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udisks2"
PV = "2.10.90"
PR = "5.el10_0.1"
PACKAGES = " \
 libudisks2 \
 libudisks2-devel \
 udisks2 \
 udisks2-iscsi \
 udisks2-lsm \
 udisks2-lvm2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/udisks2-2.10.90-5.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e22674b7ebfd41ec97b1802945bf627143459fae8aad97d72e9a6508c9d9487"

URI_x86_64_v2_libudisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libudisks2-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_libudisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudisks2}"
SRC_URI[x86_64_v2_libudisks2.sha256sum] = "7c3cebf82b3c98a647f004f43abfe3a6879c2a7c47a3deafe3259028657b13dc"

URI_x86_64_v2_libudisks2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libudisks2-devel-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_libudisks2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libudisks2-devel}"
SRC_URI[x86_64_v2_libudisks2-devel.sha256sum] = "806b00a01550181e8d2ef30e67500a8d00e5b4942038242a2eca566a3a29c661"

URI_x86_64_v2_udisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_udisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2}"
SRC_URI[x86_64_v2_udisks2.sha256sum] = "ecef6ae1f94812714dd79174404d6d541b01a8478686a72697c7fbab9577fab6"

URI_x86_64_v2_udisks2-iscsi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-iscsi-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-iscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-iscsi}"
SRC_URI[x86_64_v2_udisks2-iscsi.sha256sum] = "827b5fd9f1b12ed67fcfe53421906e1a2204612493fa577cefd5ae122eb6970b"

URI_x86_64_v2_udisks2-lsm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lsm-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-lsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-lsm}"
SRC_URI[x86_64_v2_udisks2-lsm.sha256sum] = "e52003d31dcac87b387b9a7ee1d48f6c295ba1270ed41cedba48e7c32b3efec0"

URI_x86_64_v2_udisks2-lvm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/udisks2-lvm2-2.10.90-5.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_udisks2-lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_udisks2-lvm2}"
SRC_URI[x86_64_v2_udisks2-lvm2.sha256sum] = "bfbbb4136a88907fd6cc3d1d29e02b16a224256ccfd74d423b84132188fd70eb"

URI_aarch64_libudisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libudisks2-2.10.90-5.el10_0.1.aarch64.rpm;name=aarch64_libudisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudisks2}"
SRC_URI[aarch64_libudisks2.sha256sum] = "86b5247ffd9f2b38610f0c8b7a0d4835d6846ff2475e2954b7c733dfca52f9eb"

URI_aarch64_libudisks2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libudisks2-devel-2.10.90-5.el10_0.1.aarch64.rpm;name=aarch64_libudisks2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libudisks2-devel}"
SRC_URI[aarch64_libudisks2-devel.sha256sum] = "5f333480ecd9288203164e511800e4a70f845cd3624dbfc7a164c485e4b542f7"

URI_aarch64_udisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-2.10.90-5.el10_0.1.aarch64.rpm;name=aarch64_udisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2}"
SRC_URI[aarch64_udisks2.sha256sum] = "5d15613a0707d081bac3469e02177b13589d193ea973b8b6f0ccd2871ef19c39"

URI_aarch64_udisks2-iscsi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-iscsi-2.10.90-5.el10_0.1.aarch64.rpm;name=aarch64_udisks2-iscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-iscsi}"
SRC_URI[aarch64_udisks2-iscsi.sha256sum] = "1af654e92f524ca471c29d624493877a19b29d1b9f78886f7f754924a36a6abf"

URI_aarch64_udisks2-lsm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lsm-2.10.90-5.el10_0.1.aarch64.rpm;name=aarch64_udisks2-lsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-lsm}"
SRC_URI[aarch64_udisks2-lsm.sha256sum] = "c86ab67532abcc481089fc8ed5603458385af2704275db310eb46b5403aaacff"

URI_aarch64_udisks2-lvm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/udisks2-lvm2-2.10.90-5.el10_0.1.aarch64.rpm;name=aarch64_udisks2-lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_udisks2-lvm2}"
SRC_URI[aarch64_udisks2-lvm2.sha256sum] = "8da48e8ab6d80a89cb8f759754310770666228f47e4ba363bc53b332fb058b2d"

RDEPENDS:libudisks2 = " \
 glib2 \
 glibc \
 "
RDEPENDS:libudisks2-devel = " \
 glib2-devel \
 libudisks2 \
 libudisks2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:udisks2 = " \
 bash \
 dbus \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-crypto \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-mdraid \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-smart \
 libblockdev-swap \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit \
 polkit-libs \
 systemd-libs \
 systemd-udev \
 util-linux \
 "
RDEPENDS:udisks2-iscsi = " \
 glib2 \
 glibc \
 iscsi-initiator-utils \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lsm = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-utils \
 libconfig \
 libgcc \
 libgudev \
 libmount \
 libstoragemgmt \
 libudisks2 \
 libuuid \
 polkit-libs \
 systemd-libs \
 "
RDEPENDS:udisks2-lvm2 = " \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libblockdev \
 libblockdev-lvm \
 libblockdev-utils \
 libgcc \
 libgudev \
 libmount \
 libudisks2 \
 libuuid \
 lvm2 \
 polkit-libs \
 systemd-libs \
 "
