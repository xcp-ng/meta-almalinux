# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmailtransport"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmailtransport \
 kmailtransport-devel \
 kmailtransport-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmailtransport-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "48cd98837a07fe08d404bddc49cf69e3a8255c109286ff99dcf59ec516f2526f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmailtransport;unpack=0"
SRC_URI[x86_64_v2_kmailtransport.sha256sum] = "de9a5d32c6b10f133f3b0cea3d28e117602b6cdd1008d704183463ce115be1af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmailtransport-devel;unpack=0"
SRC_URI[x86_64_v2_kmailtransport-devel.sha256sum] = "de420e2bd225dfb870c538d635292447d9b05554d978506418648289707409de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kmailtransport-doc;unpack=0"
SRC_URI[x86_64_v2_kmailtransport-doc.sha256sum] = "bba3a00360453353f6e89ed617018a0768a71c18c5b09a9faee5aec8f3ca5ae5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmailtransport;unpack=0"
SRC_URI[aarch64_kmailtransport.sha256sum] = "5d04bab5293ea709cd55910723dfaf864559e683aecb2e5c3457a48077e26b78"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmailtransport-devel;unpack=0"
SRC_URI[aarch64_kmailtransport-devel.sha256sum] = "658604f2749fab9fdbcbeb23aaaa0013fefd7bb4d725b998b38a65d571d55049"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kmailtransport-doc;unpack=0"
SRC_URI[aarch64_kmailtransport-doc.sha256sum] = "dfd6d027fa06de9427ac4d022c77c99bb224e24f01b2fb4a0d4f3abd37416366"

RDEPENDS:kmailtransport = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 ksmtp \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kmailtransport-devel = " \
 akonadi-mime-devel \
 cmake-filesystem \
 kf6-kmime-devel \
 kmailtransport \
 "
RDEPENDS:kmailtransport-doc = " \
 "
