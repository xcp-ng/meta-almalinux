# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-network-bsd"
PV = "2.8.1.0"
PR = "21.el10_0"
PACKAGES = " \
 ghc-network-bsd \
 ghc-network-bsd-devel \
 ghc-network-bsd-doc \
 ghc-network-bsd-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-network-bsd-2.8.1.0-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98b490f91895e4b5b53db537aa13e6b9712b1fb8504b121ee54fc7d8c2a37972"

URI_x86_64_v2_ghc-network-bsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-bsd-2.8.1.0-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-bsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-bsd}"
SRC_URI[x86_64_v2_ghc-network-bsd.sha256sum] = "ee351022eec6bf999f63481664f381a642ee797fd187099831c80cb02b39b2a4"

URI_x86_64_v2_ghc-network-bsd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-bsd-devel-2.8.1.0-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-bsd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-bsd-devel}"
SRC_URI[x86_64_v2_ghc-network-bsd-devel.sha256sum] = "b5611f6ead9e5c8a0b3b8fb6b0213640387b5eb4df3a122a5ce2956f39542dc0"

URI_x86_64_v2_ghc-network-bsd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-bsd-doc-2.8.1.0-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-network-bsd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-bsd-doc}"
SRC_URI[x86_64_v2_ghc-network-bsd-doc.sha256sum] = "949dd0932faa331a6ff8442d98553397edc9173400c5befcb9dbf711759774d3"

URI_x86_64_v2_ghc-network-bsd-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-bsd-prof-2.8.1.0-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-bsd-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-bsd-prof}"
SRC_URI[x86_64_v2_ghc-network-bsd-prof.sha256sum] = "e75f1dad294509d449b4c44b50e9d1671f4b3404e366ab14cbd11bbda04922c8"

URI_aarch64_ghc-network-bsd = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-bsd-2.8.1.0-21.el10_0.aarch64.rpm;name=aarch64_ghc-network-bsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-bsd}"
SRC_URI[aarch64_ghc-network-bsd.sha256sum] = "9ab8dba0d0b9b876c3845eb227cbe6a9103a211d1704b4f7b7b4eb7783607669"

URI_aarch64_ghc-network-bsd-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-bsd-devel-2.8.1.0-21.el10_0.aarch64.rpm;name=aarch64_ghc-network-bsd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-bsd-devel}"
SRC_URI[aarch64_ghc-network-bsd-devel.sha256sum] = "c036a134c12a9a07d07c3887dae2eb88fcb106bfa60827a52a8566e15a9225d0"

URI_aarch64_ghc-network-bsd-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-bsd-doc-2.8.1.0-21.el10_0.noarch.rpm;name=aarch64_ghc-network-bsd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-bsd-doc}"
SRC_URI[aarch64_ghc-network-bsd-doc.sha256sum] = "f1876e505878058626d11feb58b2a273aa956983b0b1b129b88aeb993cc4a4e5"

URI_aarch64_ghc-network-bsd-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-bsd-prof-2.8.1.0-21.el10_0.aarch64.rpm;name=aarch64_ghc-network-bsd-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-bsd-prof}"
SRC_URI[aarch64_ghc-network-bsd-prof.sha256sum] = "04c9778701afe8f7077034f0b6a3b7af91bd439857a967ad2205dacfb31eb6e3"

RDEPENDS:ghc-network-bsd = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-network \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-network-bsd-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-network-bsd \
 ghc-network-devel \
 "
RDEPENDS:ghc-network-bsd-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-network-bsd-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-network-bsd-devel \
 ghc-network-prof \
 "
