# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gass-server-ez"
PV = "6.2"
PR = "4.el10_0"
PACKAGES = " \
 globus-gass-server-ez \
 globus-gass-server-ez-devel \
 globus-gass-server-ez-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gass-server-ez-6.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec0faa0c8001106d988b26f146bac2103f07f0c2bc5a0690d0c09923e3efa571"

URI_x86_64_v2_globus-gass-server-ez = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-server-ez-6.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-server-ez;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-server-ez}"
SRC_URI[x86_64_v2_globus-gass-server-ez.sha256sum] = "576207b43afdea22ac95cbaff86b3c9157b3212a8486194a96e9874e6f1df0b0"

URI_x86_64_v2_globus-gass-server-ez-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-server-ez-devel-6.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-server-ez-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-server-ez-devel}"
SRC_URI[x86_64_v2_globus-gass-server-ez-devel.sha256sum] = "b1d39ab275d0163a21af5786dc110f6fac7be2221cc9fa186d299fbe2590bc1c"

URI_x86_64_v2_globus-gass-server-ez-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-server-ez-progs-6.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-server-ez-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-server-ez-progs}"
SRC_URI[x86_64_v2_globus-gass-server-ez-progs.sha256sum] = "273dafbc155df178e299be2e6b6d893b92aa4472d06e38c2e0b6ccff27592332"

URI_aarch64_globus-gass-server-ez = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-server-ez-6.2-4.el10_0.aarch64.rpm;name=aarch64_globus-gass-server-ez;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-server-ez}"
SRC_URI[aarch64_globus-gass-server-ez.sha256sum] = "aacfebed0bfd610c16643af9607d0e67efb5162efbcaf3e82037ace0ad735bb3"

URI_aarch64_globus-gass-server-ez-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-server-ez-devel-6.2-4.el10_0.aarch64.rpm;name=aarch64_globus-gass-server-ez-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-server-ez-devel}"
SRC_URI[aarch64_globus-gass-server-ez-devel.sha256sum] = "4ad10626da991940f1ddb07d4249701d5fcd8ab3fa63b4afa0b3994e58bb5995"

URI_aarch64_globus-gass-server-ez-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-server-ez-progs-6.2-4.el10_0.aarch64.rpm;name=aarch64_globus-gass-server-ez-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-server-ez-progs}"
SRC_URI[aarch64_globus-gass-server-ez-progs.sha256sum] = "c28f0032ac5fb0932bde2869a0aaca79e08a54a09a6e6f0c2fe09d32fc96e12f"

RDEPENDS:globus-gass-server-ez = " \
 glibc \
 globus-common \
 globus-gass-transfer \
 "
RDEPENDS:globus-gass-server-ez-devel = " \
 globus-common-devel \
 globus-gass-server-ez \
 globus-gass-transfer-devel \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gass-server-ez-progs = " \
 bash \
 glibc \
 globus-common \
 globus-gass-server-ez \
 globus-gass-transfer \
 globus-gss-assist \
 globus-gssapi-gsi \
 "
