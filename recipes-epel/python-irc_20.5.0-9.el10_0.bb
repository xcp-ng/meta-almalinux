# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-irc"
PV = "20.5.0"
PR = "9.el10_0"
PACKAGES = " \
 python3-irc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-irc-20.5.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d511d057a62c681b4d83d31eaf544b6490491c956528f3d2e4c3b889b8ea2d06"

URI_x86_64_v2_python3-irc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-irc-20.5.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-irc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-irc}"
SRC_URI[x86_64_v2_python3-irc.sha256sum] = "977994d59ea0b300a924a0cc6dbef91b45b6842b5d51f68bb3a2323a83f5e696"

URI_aarch64_python3-irc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-irc-20.5.0-9.el10_0.noarch.rpm;name=aarch64_python3-irc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-irc}"
SRC_URI[aarch64_python3-irc.sha256sum] = "6d5877b3ba5aa8aafbaaf97cd7b51c1bcf0280958fbd8851f6ca813d2137d7d4"

RDEPENDS:python3-irc = " \
 python3 \
 python3-jaraco-collections \
 python3-jaraco-functools \
 python3-jaraco-logging \
 python3-jaraco-stream \
 python3-jaraco-text \
 python3-more-itertools \
 python3-pytz \
 python3-tempora \
 "
