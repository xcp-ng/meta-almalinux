# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi0.25"
PV = "0.25.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-pyo3-ffi0.25+abi3-devel \
 rust-pyo3-ffi0.25+abi3-py310-devel \
 rust-pyo3-ffi0.25+abi3-py311-devel \
 rust-pyo3-ffi0.25+abi3-py312-devel \
 rust-pyo3-ffi0.25+abi3-py313-devel \
 rust-pyo3-ffi0.25+abi3-py314-devel \
 rust-pyo3-ffi0.25+abi3-py37-devel \
 rust-pyo3-ffi0.25+abi3-py38-devel \
 rust-pyo3-ffi0.25+abi3-py39-devel \
 rust-pyo3-ffi0.25+default-devel \
 rust-pyo3-ffi0.25+extension-module-devel \
 rust-pyo3-ffi0.25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi0.25-0.25.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fcab7c207c8e088dcb39bf6bbc32b8d50364517087f801c7571c76705cf10c2"

URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+abi3-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+abi3-devel.sha256sum] = "88cb8d847fd46e54cc3be79de84fa2e40f7cbdc1219bf21eedc69cfe26ffdfa2"

URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+abi3-py310-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+abi3-py310-devel.sha256sum] = "886e2ad764d4f41d1533b2866772c8914a5c29da6e45e104beb6d284834bfeb8"

URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+abi3-py311-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+abi3-py311-devel.sha256sum] = "b529d8cb074c660db4f16fce33a6635beb00290a443fb83fc91a43738c30fef5"

URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+abi3-py312-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+abi3-py312-devel.sha256sum] = "a0935acf8b9748beb147f23510a43da3550d77f48e2e6d946351af0348153060"

URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+abi3-py313-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+abi3-py313-devel.sha256sum] = "1d392abc6b4919384c553bdd6c9d6ddb58cbdb7c234e757bc3892520410cd690"

URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+abi3-py314-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+abi3-py314-devel.sha256sum] = "2f37fcc1378b2965c6ded525723752012a78e4e1363afa8b9e69f1f301aeed5d"

URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+abi3-py37-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+abi3-py37-devel.sha256sum] = "b47c3d59fb4aa9eb2d7327dbeef844282b6c08c414e33da46f8c2e038b69dfa2"

URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+abi3-py38-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+abi3-py38-devel.sha256sum] = "c303ae0b28ec4eca53e202491022b808134244e0137da1cf2642a1d193f184e5"

URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+abi3-py39-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+abi3-py39-devel.sha256sum] = "5fe13ad52b70b7f524a6d341980121d5a605d936c09a12b4201cb959cfe96bfc"

URI_x86_64_v2_rust-pyo3-ffi0.25+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+default-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+default-devel.sha256sum] = "6850ba6dec78f5d6ffef99c1e9d74e8a5aabf8da55ca9051ac4e6a8c69a008b2"

URI_x86_64_v2_rust-pyo3-ffi0.25+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25+extension-module-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25+extension-module-devel.sha256sum] = "41ce5a249e91157ec93b1e584a4bb25bc73c63d87b98debcb7f3a4399378e9dc"

URI_x86_64_v2_rust-pyo3-ffi0.25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.25-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.25-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.25-devel.sha256sum] = "cd90263367a06d030d7139108e0b7329acb2d2211925a84165436cf2486d6d47"

URI_aarch64_rust-pyo3-ffi0.25+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+abi3-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+abi3-devel.sha256sum] = "68b1b4c200075a7535796bde436c0a2702e162001fd05c1b66e59605ef3e08a8"

URI_aarch64_rust-pyo3-ffi0.25+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+abi3-py310-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+abi3-py310-devel.sha256sum] = "f758ee55086eb4f02696061dbbbb86d77789442000cd1a4a2649e7e750b19d00"

URI_aarch64_rust-pyo3-ffi0.25+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+abi3-py311-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+abi3-py311-devel.sha256sum] = "9650f3a39135fbfff7040ea186f3cd3f9d3ac9394933349dd8617fd8feeebca2"

URI_aarch64_rust-pyo3-ffi0.25+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+abi3-py312-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+abi3-py312-devel.sha256sum] = "5ae1a4a8faf0b07e6c00dff06757691d13b350fc6fbf0b4290e6b3b4adf9571a"

URI_aarch64_rust-pyo3-ffi0.25+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+abi3-py313-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+abi3-py313-devel.sha256sum] = "d49eaa0090b951d19a73dae6abe12d07f05cd4f3b617f7d2d623ea3d01d83bab"

URI_aarch64_rust-pyo3-ffi0.25+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+abi3-py314-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+abi3-py314-devel.sha256sum] = "f75c0d95ba56df66be05d4db0a1f70650426e74dc2f9fd9a61e78aef9d683ca0"

URI_aarch64_rust-pyo3-ffi0.25+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+abi3-py37-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+abi3-py37-devel.sha256sum] = "82e359d6ff2053a15b275bd70474cd4855f628561686c0ae872d01617da1b8cc"

URI_aarch64_rust-pyo3-ffi0.25+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+abi3-py38-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+abi3-py38-devel.sha256sum] = "91c9490ab2de0de9cbc766e0e1d684e59c5aadc209b2d268805d0e083ebdac4b"

URI_aarch64_rust-pyo3-ffi0.25+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+abi3-py39-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+abi3-py39-devel.sha256sum] = "af105e44a9a0ad1c85f46083e6eb7cde2b46c953939c136b601d1a13249ad761"

URI_aarch64_rust-pyo3-ffi0.25+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+default-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+default-devel.sha256sum] = "5622260a102589799e815b95cb1b9b55815aec65b29251803f72234786d99ac2"

URI_aarch64_rust-pyo3-ffi0.25+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25+extension-module-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25+extension-module-devel.sha256sum] = "43d6775fa27c7e3bff63806d614b3cdb85984e5521847a800417233af8e3b7a1"

URI_aarch64_rust-pyo3-ffi0.25-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.25-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-ffi0.25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.25-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.25-devel.sha256sum] = "fe30d351024240d37f2520a98391251fc41cc54ace363c777dc29cdb7a669edc"

RDEPENDS:rust-pyo3-ffi0.25+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py311-devel \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py312-devel \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py313-devel \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py314-devel \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+abi3-py314-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-devel \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py38-devel \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py39-devel \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.25+abi3-py310-devel \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+default-devel = " \
 cargo \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.25-devel \
 "
RDEPENDS:rust-pyo3-ffi0.25-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config0.25+default-devel \
 rust-pyo3-build-config0.25+resolve-config-devel \
 "
