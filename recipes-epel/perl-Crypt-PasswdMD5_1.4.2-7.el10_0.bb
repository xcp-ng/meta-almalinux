# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-PasswdMD5"
PV = "1.4.2"
PR = "7.el10_0"
PACKAGES = " \
 perl-Crypt-PasswdMD5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-PasswdMD5-1.4.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90b9eda63e96860925fb925569e81c6f41612d6195156785c01d4d65a684fb90"

URI_x86_64_v2_perl-Crypt-PasswdMD5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-PasswdMD5-1.4.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-PasswdMD5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-PasswdMD5}"
SRC_URI[x86_64_v2_perl-Crypt-PasswdMD5.sha256sum] = "6c5e9d3869342df45c30236de5fec174d2075ec5d255519c69a82b72522fa2d6"

URI_aarch64_perl-Crypt-PasswdMD5 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-PasswdMD5-1.4.2-7.el10_0.noarch.rpm;name=aarch64_perl-Crypt-PasswdMD5;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-PasswdMD5}"
SRC_URI[aarch64_perl-Crypt-PasswdMD5.sha256sum] = "3bfbfe33d1c893abc02af14a77783fd4a5099e2cfbb914a51ae47f9df2bdf08f"

RDEPENDS:perl-Crypt-PasswdMD5 = " \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Exporter \
 perl-libs \
 "
