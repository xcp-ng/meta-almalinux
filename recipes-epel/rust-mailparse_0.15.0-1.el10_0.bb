# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mailparse"
PV = "0.15.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-mailparse+default-devel \
 rust-mailparse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mailparse-0.15.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf668e09d13a55e39c9b0231b244298453e7e48970e1011eca87fe9e411d3af5"

URI_x86_64_v2_rust-mailparse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mailparse+default-devel-0.15.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mailparse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mailparse+default-devel}"
SRC_URI[x86_64_v2_rust-mailparse+default-devel.sha256sum] = "1b4785f2c1c6fae3a99c4a1abe2eb8fb5883ecbc649b1122c75e0857546024ac"

URI_x86_64_v2_rust-mailparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mailparse-devel-0.15.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mailparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mailparse-devel}"
SRC_URI[x86_64_v2_rust-mailparse-devel.sha256sum] = "a2b04ca4d2cdf87dffae268fb67af33741104f520a71818eabc508a1deb79639"

URI_aarch64_rust-mailparse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mailparse+default-devel-0.15.0-1.el10_0.noarch.rpm;name=aarch64_rust-mailparse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mailparse+default-devel}"
SRC_URI[aarch64_rust-mailparse+default-devel.sha256sum] = "d5f2a88ae7a85d272871cf39f7afc2efcab7311bf8d40b941947433d2cfa8b32"

URI_aarch64_rust-mailparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mailparse-devel-0.15.0-1.el10_0.noarch.rpm;name=aarch64_rust-mailparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mailparse-devel}"
SRC_URI[aarch64_rust-mailparse-devel.sha256sum] = "87099d51b3d423fa09131d493dbae087729770711fed940fbea8ca6ec9041f66"

RDEPENDS:rust-mailparse+default-devel = " \
 cargo \
 rust-mailparse-devel \
 "
RDEPENDS:rust-mailparse-devel = " \
 cargo \
 rust-charset+default-devel \
 rust-data-encoding+default-devel \
 rust-quoted_printable+default-devel \
 "
