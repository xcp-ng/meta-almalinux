# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpng"
PE = "2"
PV = "1.6.40"
PR = "13.el10"
PACKAGES = " \
 libpng \
 libpng-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libpng-1.6.40-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60f5eaa9bb672c73e4c514fda8d7e00be565f4bd6c8049d7f689e906ce6e2529"

URI_x86_64_v2_libpng = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpng-1.6.40-13.el10.x86_64_v2.rpm;name=x86_64_v2_libpng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpng}"
SRC_URI[x86_64_v2_libpng.sha256sum] = "40bcd3c4d7d2f3d6206092c50d20f2c184ac57704ae67193080ae121a98f4845"

URI_x86_64_v2_libpng-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpng-devel-1.6.40-13.el10.x86_64_v2.rpm;name=x86_64_v2_libpng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpng-devel}"
SRC_URI[x86_64_v2_libpng-devel.sha256sum] = "41b7957f2e1bf8a780fbc8a57d75f715efd52400d51bed36e767b8098ca83a29"

URI_aarch64_libpng = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpng-1.6.40-13.el10.aarch64.rpm;name=aarch64_libpng;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpng}"
SRC_URI[aarch64_libpng.sha256sum] = "199e2fa632afcb476dde9de4a629c51417fa5c7dbafb3ea521ae1775e09f310d"

URI_aarch64_libpng-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpng-devel-1.6.40-13.el10.aarch64.rpm;name=aarch64_libpng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpng-devel}"
SRC_URI[aarch64_libpng-devel.sha256sum] = "e261d4fd386f0c5e65ca06062f493e176abc7b3b000e97752f7fb5c00552e085"

RDEPENDS:libpng = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libpng-devel = " \
 bash \
 glibc \
 libpng \
 pkgconf-pkg-config \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
