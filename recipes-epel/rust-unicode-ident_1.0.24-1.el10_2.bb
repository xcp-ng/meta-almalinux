# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-ident"
PV = "1.0.24"
PR = "1.el10_2"
PACKAGES = " \
 rust-unicode-ident+default-devel \
 rust-unicode-ident-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-ident-1.0.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b5f77c5e933ce01ea2779d14dd310e043638498983271b927cf22b0f2459a06"

URI_x86_64_v2_rust-unicode-ident+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident+default-devel-1.0.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-ident+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-ident+default-devel.sha256sum] = "c5d2f4c2cfdeca80cfcf3df8cad6f1e1bfea30f16cd74949b4e17c1ad1868e32"

URI_x86_64_v2_rust-unicode-ident-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident-devel-1.0.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-ident-devel}"
SRC_URI[x86_64_v2_rust-unicode-ident-devel.sha256sum] = "acee5247713812614177107bdaa1efa17a3580dc3421df84a01cd422594b98ae"

URI_aarch64_rust-unicode-ident+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident+default-devel-1.0.24-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-ident+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-ident+default-devel}"
SRC_URI[aarch64_rust-unicode-ident+default-devel.sha256sum] = "f701028170981c0829c99e56beebaa179a01b8283264f876b020c984b0836d32"

URI_aarch64_rust-unicode-ident-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident-devel-1.0.24-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-ident-devel}"
SRC_URI[aarch64_rust-unicode-ident-devel.sha256sum] = "e24c784348f781f2fb39ae9e1f7644d598c544046dd52bcaa2e3ef4e316bfa6a"

RDEPENDS:rust-unicode-ident+default-devel = " \
 cargo \
 rust-unicode-ident-devel \
 "
RDEPENDS:rust-unicode-ident-devel = " \
 cargo \
 rust \
 "
