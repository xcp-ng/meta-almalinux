# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lddtree"
PV = "0.3.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-lddtree+default-devel \
 rust-lddtree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lddtree-0.3.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1044d309795c4e8045ceea7d8ee539b75a11edcfbae1b89778f7074b71efe180"

URI_x86_64_v2_rust-lddtree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lddtree+default-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lddtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lddtree+default-devel}"
SRC_URI[x86_64_v2_rust-lddtree+default-devel.sha256sum] = "84367c2e6fe9ad4242af321939a55b93c92ece4e1db71b3cbda73eed0aa2e858"

URI_x86_64_v2_rust-lddtree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lddtree-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lddtree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lddtree-devel}"
SRC_URI[x86_64_v2_rust-lddtree-devel.sha256sum] = "891fe38f57cd5b3cb43993e571dcd7abd46a8b61901a8b6f959edbb5dbfcd46b"

URI_aarch64_rust-lddtree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lddtree+default-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-lddtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lddtree+default-devel}"
SRC_URI[aarch64_rust-lddtree+default-devel.sha256sum] = "750a97f723c9768987e28432631c89fec58306489015391cea3813cd4340d167"

URI_aarch64_rust-lddtree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lddtree-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-lddtree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lddtree-devel}"
SRC_URI[aarch64_rust-lddtree-devel.sha256sum] = "6f02795b4294266be3d94b3ab44896f0d72c5d39a521f4511ac68f08b6adce38"

RDEPENDS:rust-lddtree+default-devel = " \
 cargo \
 rust-lddtree-devel \
 "
RDEPENDS:rust-lddtree-devel = " \
 cargo \
 rust-fs-err+default-devel \
 rust-glob+default-devel \
 rust-goblin+default-devel \
 "
