# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtest"
PV = "1.14.0"
PR = "5.el10_0"
PACKAGES = " \
 gmock \
 gmock-devel \
 gtest \
 gtest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtest-1.14.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f315a959e423ad8aad242b87fcceeaeec52efb93af63078559ee476980210179"

URI_x86_64_v2_gmock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gmock-1.14.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gmock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmock}"
SRC_URI[x86_64_v2_gmock.sha256sum] = "3fc18e70f5c66304cde547cdf5bc01dc89d6db1c3c41f16d383cf24f026a1e93"

URI_x86_64_v2_gmock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gmock-devel-1.14.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gmock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmock-devel}"
SRC_URI[x86_64_v2_gmock-devel.sha256sum] = "43b1bca596e3f7ba635eb37bf2113ebe4926d86667e831ae7d6df96bc13a2504"

URI_x86_64_v2_gtest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtest-1.14.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtest}"
SRC_URI[x86_64_v2_gtest.sha256sum] = "eb7d7c5e2a2efe8fc8cf579f3db23da72c3805557bc75933f1d43f80d3b4d8b8"

URI_x86_64_v2_gtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtest-devel-1.14.0-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtest-devel}"
SRC_URI[x86_64_v2_gtest-devel.sha256sum] = "39740f1452ad26396824a3eb05eaf899a63f74eba26985ccd5c62e4010ff1116"

URI_aarch64_gmock = "${EPEL_MIRROR}/aarch64/Packages/g/gmock-1.14.0-5.el10_0.aarch64.rpm;name=aarch64_gmock;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmock}"
SRC_URI[aarch64_gmock.sha256sum] = "d1e8060771b737e4c0bfc4f1abe35600404c52ccd182eeca6f64f5bbf7c87391"

URI_aarch64_gmock-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gmock-devel-1.14.0-5.el10_0.aarch64.rpm;name=aarch64_gmock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmock-devel}"
SRC_URI[aarch64_gmock-devel.sha256sum] = "b778f3447bbfba3abbce9bf6c8a50017e5f3733eea15ab4e4d2b523f18a4b3c6"

URI_aarch64_gtest = "${EPEL_MIRROR}/aarch64/Packages/g/gtest-1.14.0-5.el10_0.aarch64.rpm;name=aarch64_gtest;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtest}"
SRC_URI[aarch64_gtest.sha256sum] = "1bdedc8b8cffb21e02b662dd2ccad38ee2147e1d26f18eec77689a3ac53a913f"

URI_aarch64_gtest-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gtest-devel-1.14.0-5.el10_0.aarch64.rpm;name=aarch64_gtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtest-devel}"
SRC_URI[aarch64_gtest-devel.sha256sum] = "029eeb57d6d89be2c4aff89fea4c032c68785b90d9e49f65f6df49b210296d09"

RDEPENDS:gmock = " \
 glibc \
 gtest \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gmock-devel = " \
 gmock \
 gtest-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gtest = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gtest-devel = " \
 cmake-filesystem \
 gmock \
 gtest \
 pkgconf-pkg-config \
 "
