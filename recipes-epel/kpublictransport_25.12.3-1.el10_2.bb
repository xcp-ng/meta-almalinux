# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpublictransport"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kpublictransport \
 kpublictransport-devel \
 kpublictransport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpublictransport-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fa13bb48701b9361822f2a487176bb4f59e6fc0136292d191e4b96b3c4284f3"

URI_x86_64_v2_kpublictransport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport}"
SRC_URI[x86_64_v2_kpublictransport.sha256sum] = "610d1c0cb7786456ebb742547e4db1f4b9891a7cd9575da19139d83b654a2dc1"

URI_x86_64_v2_kpublictransport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport-devel}"
SRC_URI[x86_64_v2_kpublictransport-devel.sha256sum] = "64bc52a133d5fa1ca5709ecd7ba5a442e812a669fada556b628f48e67eb32b6b"

URI_x86_64_v2_kpublictransport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kpublictransport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport-doc}"
SRC_URI[x86_64_v2_kpublictransport-doc.sha256sum] = "86ac9d40e1ce828e7f02321b555fca0d08391f964c77f5ff2ce5e0456e2411a3"

URI_aarch64_kpublictransport = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kpublictransport;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport}"
SRC_URI[aarch64_kpublictransport.sha256sum] = "4516e43266ad4ae4c6e83ba93421f4f860cadfb04b907ca63e32b16b4cfc66a1"

URI_aarch64_kpublictransport-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kpublictransport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport-devel}"
SRC_URI[aarch64_kpublictransport-devel.sha256sum] = "8b1518788ab4f5cee820d9e186c736960136a98960fe751af2254d93b28f163a"

URI_aarch64_kpublictransport-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kpublictransport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport-doc}"
SRC_URI[aarch64_kpublictransport-doc.sha256sum] = "6e71381865b27f2282173aa1536d7613d8e9acb7a64ed8ca7782768244eaf2a1"

RDEPENDS:kpublictransport = " \
 glibc \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-networkmanager-qt \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:kpublictransport-devel = " \
 cmake-filesystem \
 kpublictransport \
 "
RDEPENDS:kpublictransport-doc = " \
 "
