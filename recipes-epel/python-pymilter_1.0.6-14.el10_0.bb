# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pymilter"
PV = "1.0.6"
PR = "14.el10_0"
PACKAGES = " \
 python-pymilter-common \
 python-pymilter-selinux \
 python3-pymilter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pymilter-1.0.6-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5e45c47327e22f112f4246c9415e63b458128d069eafe8b4b678527c50c110e"

URI_x86_64_v2_python-pymilter-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pymilter-common-1.0.6-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-pymilter-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pymilter-common}"
SRC_URI[x86_64_v2_python-pymilter-common.sha256sum] = "ad8d4569b1fcf4c12c099d3d18986c5b53e64202d7721a31695de4868ad82797"

URI_x86_64_v2_python-pymilter-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pymilter-selinux-1.0.6-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-pymilter-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pymilter-selinux}"
SRC_URI[x86_64_v2_python-pymilter-selinux.sha256sum] = "8e813462ca850e6ff319efafa110db4b3540538532dee7b7ddb5503ed7f90c2c"

URI_x86_64_v2_python3-pymilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymilter-1.0.6-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymilter}"
SRC_URI[x86_64_v2_python3-pymilter.sha256sum] = "957549c389a86dc8b3a3bb5e0ae6192b0597fa7e33ac5e3331b9889b77676e40"

URI_aarch64_python-pymilter-common = "${EPEL_MIRROR}/aarch64/Packages/p/python-pymilter-common-1.0.6-14.el10_0.noarch.rpm;name=aarch64_python-pymilter-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pymilter-common}"
SRC_URI[aarch64_python-pymilter-common.sha256sum] = "c48511045b44a36784de303d9da93c2063635dbae2c125ab954b7bf55f74e9f0"

URI_aarch64_python-pymilter-selinux = "${EPEL_MIRROR}/aarch64/Packages/p/python-pymilter-selinux-1.0.6-14.el10_0.noarch.rpm;name=aarch64_python-pymilter-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pymilter-selinux}"
SRC_URI[aarch64_python-pymilter-selinux.sha256sum] = "c3f6d12bed1593909849e03a55def4880fcc8a09a4adae05ff9d32c3abb9be4e"

URI_aarch64_python3-pymilter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymilter-1.0.6-14.el10_0.aarch64.rpm;name=aarch64_python3-pymilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymilter}"
SRC_URI[aarch64_python3-pymilter.sha256sum] = "97b2b7f907c4186032bec612353694cf5b9a09e429a0874d8200395f087dc913"

RDEPENDS:python-pymilter-common = " \
 "
RDEPENDS:python-pymilter-selinux = " \
 bash \
 policycoreutils \
 python-pymilter-common \
 selinux-policy-targeted \
 "
RDEPENDS:python3-pymilter = " \
 glibc \
 python-pymilter-common \
 python3 \
 python3-py3dns \
 sendmail-milter \
 "
