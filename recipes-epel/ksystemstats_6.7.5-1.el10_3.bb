# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksystemstats"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 ksystemstats \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ksystemstats-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2773eac3a8d0feb766f560e200e6a6fbd9b1df7dbbdb5d30b19d2034130875a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksystemstats-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksystemstats;unpack=0"
SRC_URI[x86_64_v2_ksystemstats.sha256sum] = "613193b494b2ae322c38789f2ad161a3be9293d0a3563b7830c26de6dc05c408"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksystemstats-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_ksystemstats;unpack=0"
SRC_URI[aarch64_ksystemstats.sha256sum] = "8e8082de23cce14134ae8471bb80a03fc566c8b4edb81a2a8b908efabbdeba68"

RDEPENDS:ksystemstats = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-networkmanager-qt \
 kf6-solid \
 libksysguard \
 libnl3 \
 libstdc++ \
 lm_sensors-libs \
 qt6-qtbase \
 systemd-libs \
 "
