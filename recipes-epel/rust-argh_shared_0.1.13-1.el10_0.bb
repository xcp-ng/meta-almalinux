# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argh_shared"
PV = "0.1.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-argh_shared+default-devel \
 rust-argh_shared+serde-devel \
 rust-argh_shared-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argh_shared-0.1.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0440b56f972f67b918840a43f30adf1a1ef676b46df4e5ade5cce34aec2ca27c"

URI_x86_64_v2_rust-argh_shared+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh_shared+default-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh_shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argh_shared+default-devel}"
SRC_URI[x86_64_v2_rust-argh_shared+default-devel.sha256sum] = "7b5f071dbd9ca0ffe54ae423ffdc979f2dfc19ebf3ad6a0b91fbca0b1ba3d0dc"

URI_x86_64_v2_rust-argh_shared+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh_shared+serde-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh_shared+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argh_shared+serde-devel}"
SRC_URI[x86_64_v2_rust-argh_shared+serde-devel.sha256sum] = "df29b8e3a1bfd43e522442df1ad7028f49ab31762d69ece8088290e05cfeaf2a"

URI_x86_64_v2_rust-argh_shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh_shared-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh_shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argh_shared-devel}"
SRC_URI[x86_64_v2_rust-argh_shared-devel.sha256sum] = "a899ab5a1c2889aaeb03157fa2f4ea04e50c647743ff965a68f750454d4db1b2"

URI_aarch64_rust-argh_shared+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argh_shared+default-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh_shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argh_shared+default-devel}"
SRC_URI[aarch64_rust-argh_shared+default-devel.sha256sum] = "5d363d8bfc654d0d61dcebcc4b9669c999e29ca8147caa04b49b6f8931361a27"

URI_aarch64_rust-argh_shared+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argh_shared+serde-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh_shared+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argh_shared+serde-devel}"
SRC_URI[aarch64_rust-argh_shared+serde-devel.sha256sum] = "30923eb776528bb0d8827349a22b930a7ea96fd08a21f10487e789a66d69e9d5"

URI_aarch64_rust-argh_shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argh_shared-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh_shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argh_shared-devel}"
SRC_URI[aarch64_rust-argh_shared-devel.sha256sum] = "5f4944f878dd894f40bc4bcd4dbadcc7fe9f0f3dcb7217e4f66d021d652c4ab6"

RDEPENDS:rust-argh_shared+default-devel = " \
 cargo \
 rust-argh_shared-devel \
 "
RDEPENDS:rust-argh_shared+serde-devel = " \
 cargo \
 rust-argh_shared-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-argh_shared-devel = " \
 cargo \
 "
