# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmix"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmix \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmix-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "932ac44c757c5dd3a25f1fc533237cd55847b8b8dc6703944bcd8d5bb4276afb"

URI_x86_64_v2_kmix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmix-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmix}"
SRC_URI[x86_64_v2_kmix.sha256sum] = "82b81b00ce8041187701a28dfd1226252cf73d83347c656753ed2618674aed58"

URI_aarch64_kmix = "${EPEL_MIRROR}/aarch64/Packages/k/kmix-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmix;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmix}"
SRC_URI[aarch64_kmix.sha256sum] = "dae030b243033e212966641a1c69ccf5eaa287d385e1b7ae89eaf0fa3727759f"

RDEPENDS:kmix = " \
 alsa-lib \
 bash \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libcanberra \
 libstdc++ \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
