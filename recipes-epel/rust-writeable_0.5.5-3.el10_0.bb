# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-writeable"
PV = "0.5.5"
PR = "3.el10_0"
PACKAGES = " \
 rust-writeable+default-devel \
 rust-writeable+either-devel \
 rust-writeable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-writeable-0.5.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "daa06551f642a25287f1870b1d153faf16630612239e676b10071ec3b88fa182"

URI_x86_64_v2_rust-writeable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+default-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+default-devel}"
SRC_URI[x86_64_v2_rust-writeable+default-devel.sha256sum] = "cfc5c9c178812a3cee517ef5a05c759247d81d49609f09cdaf21e1514bc6dbe5"

URI_x86_64_v2_rust-writeable+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+either-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable+either-devel}"
SRC_URI[x86_64_v2_rust-writeable+either-devel.sha256sum] = "f7a0a42624df605ce57d484bc9b4b5fa7d753b7d9b68e1915cdbe056f0a7fb00"

URI_x86_64_v2_rust-writeable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-writeable-devel}"
SRC_URI[x86_64_v2_rust-writeable-devel.sha256sum] = "8dfcb34462ef74a113dc02fa5985d9dc9bf3334224dab94168ed15700344ecd6"

URI_aarch64_rust-writeable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+default-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-writeable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+default-devel}"
SRC_URI[aarch64_rust-writeable+default-devel.sha256sum] = "ebdc02ce31bf0ad277e3aff8fdce8de73bce4236846f3800bbef7d5d78e033eb"

URI_aarch64_rust-writeable+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+either-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-writeable+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable+either-devel}"
SRC_URI[aarch64_rust-writeable+either-devel.sha256sum] = "7844f085fda2c671431ac1f0f6ea768cba3b6f877a08fee9b9882f9d9613bcc9"

URI_aarch64_rust-writeable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-writeable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-writeable-devel}"
SRC_URI[aarch64_rust-writeable-devel.sha256sum] = "9dc4479856e407f5a4507b7909e28119365fd1bd6c319dd0b8c2d8ccdcdd1ec7"

RDEPENDS:rust-writeable+default-devel = " \
 cargo \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable+either-devel = " \
 cargo \
 rust-either-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable-devel = " \
 cargo \
 rust \
 "
