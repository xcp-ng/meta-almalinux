# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "castxml"
PV = "0.7.0"
PR = "1.el10_2"
PACKAGES = " \
 castxml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/castxml-0.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9630ff56cdc346b5f6737d52b7db09c44bc32444e1226069ef022353e2e6ada"

URI_x86_64_v2_castxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/castxml-0.7.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_castxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_castxml}"
SRC_URI[x86_64_v2_castxml.sha256sum] = "6264b394c1b3041cb2167474b8357bdccfa18d1762542714e883ee31ff08f34c"

URI_aarch64_castxml = "${EPEL_MIRROR}/aarch64/Packages/c/castxml-0.7.0-1.el10_2.aarch64.rpm;name=aarch64_castxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_castxml}"
SRC_URI[aarch64_castxml.sha256sum] = "8e9cf856e1ce608827ca806efda1942504c4588a2a943896152d969d050e967c"

RDEPENDS:castxml = " \
 clang-libs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
