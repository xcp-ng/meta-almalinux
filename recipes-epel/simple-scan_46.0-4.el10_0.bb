# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "simple-scan"
PV = "46.0"
PR = "4.el10_0"
PACKAGES = " \
 simple-scan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/simple-scan-46.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbfe6072409f8000c4f9f0d7900d48d7f0f22aec6d642165d2a2fc2c9622c3b0"

URI_x86_64_v2_simple-scan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/simple-scan-46.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_simple-scan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_simple-scan}"
SRC_URI[x86_64_v2_simple-scan.sha256sum] = "c09c9b4e0d56fde54a9665b6e49a3bf60fae522be290eb8631b3f0dc63472c38"

URI_aarch64_simple-scan = "${EPEL_MIRROR}/aarch64/Packages/s/simple-scan-46.0-4.el10_0.aarch64.rpm;name=aarch64_simple-scan;unpack=0"
SRC_URI:append = " ${URI_aarch64_simple-scan}"
SRC_URI[aarch64_simple-scan.sha256sum] = "42ed1bd395aad5bf07a1e59a46593032ff0286819f643aa62a936ba7bc51e18f"

RDEPENDS:simple-scan = " \
 PackageKit-glib \
 cairo \
 colord-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 libgusb \
 libwebp \
 sane-backends-libs \
 xdg-utils \
 zlib-ng-compat \
 "
