# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-trait"
PV = "0.1.92"
PR = "1.el10_3"
PACKAGES = " \
 rust-async-trait+default-devel \
 rust-async-trait-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-trait-0.1.92-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3200095c7c6fc4ede44213a7ef58dfa2be972e8875c48c0307d8db0f37cd43b"

URI_x86_64_v2_rust-async-trait+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-trait+default-devel-0.1.92-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-trait+default-devel}"
SRC_URI[x86_64_v2_rust-async-trait+default-devel.sha256sum] = "502a8ba7d29d8571990395d7cf17a3f8d825b55238b5c8f010c1c4af9a07ae72"

URI_x86_64_v2_rust-async-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-trait-devel-0.1.92-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-trait-devel}"
SRC_URI[x86_64_v2_rust-async-trait-devel.sha256sum] = "89706f9a2563e7d5e66c74e1a1c42b6bfbd72e37b6695da3e960c79c92f71b26"

URI_aarch64_rust-async-trait+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-trait+default-devel-0.1.92-1.el10_3.noarch.rpm;name=aarch64_rust-async-trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-trait+default-devel}"
SRC_URI[aarch64_rust-async-trait+default-devel.sha256sum] = "95f0958cbf42f57cc4d76949e85da2fa538db8613b0e6cadf230db79593ce722"

URI_aarch64_rust-async-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-trait-devel-0.1.92-1.el10_3.noarch.rpm;name=aarch64_rust-async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-trait-devel}"
SRC_URI[aarch64_rust-async-trait-devel.sha256sum] = "2a833395410d5da77fb43d64da1919e75fe6c3716e41c4185ec39ad478113b3d"

RDEPENDS:rust-async-trait+default-devel = " \
 cargo \
 rust-async-trait-devel \
 "
RDEPENDS:rust-async-trait-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
