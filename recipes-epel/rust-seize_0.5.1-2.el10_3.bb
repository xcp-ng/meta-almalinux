# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-seize"
PV = "0.5.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-seize+default-devel \
 rust-seize+fast-barrier-devel \
 rust-seize+libc-devel \
 rust-seize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-seize-0.5.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fef0c382455d2d725829e9f9efb835687bc24eddadaab73b6a9dad4a97d74630"

URI_x86_64_v2_rust-seize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-seize+default-devel-0.5.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-seize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-seize+default-devel}"
SRC_URI[x86_64_v2_rust-seize+default-devel.sha256sum] = "9246cd92908c8032ed601a916cd4f14f33fca627a95f5627f7bda25bdbc2f7c6"

URI_x86_64_v2_rust-seize+fast-barrier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-seize+fast-barrier-devel-0.5.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-seize+fast-barrier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-seize+fast-barrier-devel}"
SRC_URI[x86_64_v2_rust-seize+fast-barrier-devel.sha256sum] = "3ca917c75e4013d20a5f16667f25192610a8f77160826a5102ee63954c567bbf"

URI_x86_64_v2_rust-seize+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-seize+libc-devel-0.5.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-seize+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-seize+libc-devel}"
SRC_URI[x86_64_v2_rust-seize+libc-devel.sha256sum] = "a553b40b68009c817807047a4aa253c68e9539bfbd684d2f62482853e7c49dac"

URI_x86_64_v2_rust-seize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-seize-devel-0.5.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-seize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-seize-devel}"
SRC_URI[x86_64_v2_rust-seize-devel.sha256sum] = "31b19700a76358cdf63d252fdc704a7be62d6a3f1c8b41d3c89e21b713f1b8b9"

URI_aarch64_rust-seize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-seize+default-devel-0.5.1-2.el10_3.noarch.rpm;name=aarch64_rust-seize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-seize+default-devel}"
SRC_URI[aarch64_rust-seize+default-devel.sha256sum] = "b5d4b8e938d444e213dae81dea5e597cecd1eb0060f5afc1084648a423418787"

URI_aarch64_rust-seize+fast-barrier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-seize+fast-barrier-devel-0.5.1-2.el10_3.noarch.rpm;name=aarch64_rust-seize+fast-barrier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-seize+fast-barrier-devel}"
SRC_URI[aarch64_rust-seize+fast-barrier-devel.sha256sum] = "3302b686e350e42a6e0d4fd84f5465f3d521b6494a8099946c70ad1ef90d7b21"

URI_aarch64_rust-seize+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-seize+libc-devel-0.5.1-2.el10_3.noarch.rpm;name=aarch64_rust-seize+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-seize+libc-devel}"
SRC_URI[aarch64_rust-seize+libc-devel.sha256sum] = "e856a4fb3e3390e23fa28cd7b322e3d0e2f87ff9569daf8e1d5938efc47b2d39"

URI_aarch64_rust-seize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-seize-devel-0.5.1-2.el10_3.noarch.rpm;name=aarch64_rust-seize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-seize-devel}"
SRC_URI[aarch64_rust-seize-devel.sha256sum] = "018efeca4b814fbafdbc0b7f3a5fee2834f8c84ff2334d1cf59afd66d94d8d1d"

RDEPENDS:rust-seize+default-devel = " \
 cargo \
 rust-seize+fast-barrier-devel \
 rust-seize-devel \
 "
RDEPENDS:rust-seize+fast-barrier-devel = " \
 cargo \
 rust-seize+libc-devel \
 rust-seize-devel \
 "
RDEPENDS:rust-seize+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-seize-devel \
 "
RDEPENDS:rust-seize-devel = " \
 cargo \
 rust \
 "
