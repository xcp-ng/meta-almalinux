# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wrapt"
PV = "1.17.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-wrapt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-wrapt-1.17.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "504e31f39289f6a89fb4c9e7df8f814a749e755db3803619e9bf947a38a65d73"

URI_x86_64_v2_python3-wrapt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wrapt-1.17.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-wrapt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wrapt}"
SRC_URI[x86_64_v2_python3-wrapt.sha256sum] = "98962abf13a61dcdcce17f153e338689e3115354470e7eb95778e3e2f93a042d"

URI_aarch64_python3-wrapt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wrapt-1.17.1-1.el10_0.aarch64.rpm;name=aarch64_python3-wrapt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wrapt}"
SRC_URI[aarch64_python3-wrapt.sha256sum] = "9ef7f00ef7392846b756a28edef0be6f4bfa0873abb1229dfc8ca3e343c02c60"

RDEPENDS:python3-wrapt = " \
 glibc \
 python3 \
 "
