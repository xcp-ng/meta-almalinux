# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prometheus"
PV = "3.15.0"
PR = "1.el10_3"
PACKAGES = " \
 prometheus \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/prometheus-3.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0cc3d95325e27e5d903b1f462190fbb2bc01b374396e24d5394c78864696d38d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prometheus-3.15.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prometheus;unpack=0"
SRC_URI[x86_64_v2_prometheus.sha256sum] = "69c8425497422e007015b48a1ffac42fd7d51e69ca9a0caa267515a12336b58d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/prometheus-3.15.0-1.el10_3.aarch64.rpm;name=aarch64_prometheus;unpack=0"
SRC_URI[aarch64_prometheus.sha256sum] = "6c663c47d919757ab0a6a447a293f609485bc98ba2806e5e9c0e5e2dd51a4e1e"

RDEPENDS:prometheus = " \
 bash \
 glibc \
 shadow-utils \
 "
