# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Unicode-Map"
PV = "0.112"
PR = "59.el10_0"
PACKAGES = " \
 perl-Unicode-Map \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Unicode-Map-0.112-59.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9aa9448cfc4eff6c8c615e31bfaee975d4da3d058d6ac04eba631e98da220a71"

URI_x86_64_v2_perl-Unicode-Map = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Unicode-Map-0.112-59.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Unicode-Map;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Unicode-Map}"
SRC_URI[x86_64_v2_perl-Unicode-Map.sha256sum] = "86b12070e01055747f7359035ec97b85efe24de43abaad2da73b67f27d9f08dc"

URI_aarch64_perl-Unicode-Map = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Unicode-Map-0.112-59.el10_0.aarch64.rpm;name=aarch64_perl-Unicode-Map;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Unicode-Map}"
SRC_URI[aarch64_perl-Unicode-Map.sha256sum] = "73c7b812b6b891cf9c46157df7f8694f2866dd0837da64a1cc41cb7235ea4688"

RDEPENDS:perl-Unicode-Map = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-HTTP-Message \
 perl-Unicode-Map \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
