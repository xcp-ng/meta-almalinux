# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dropbear"
PV = "2025.88"
PR = "1.el10_1"
PACKAGES = " \
 dropbear \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dropbear-2025.88-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "022545077414e05a531200b6f5f58a6308bc686ba7488c36ec2d23a0c3b07968"

URI_x86_64_v2_dropbear = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dropbear-2025.88-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dropbear;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dropbear}"
SRC_URI[x86_64_v2_dropbear.sha256sum] = "6d75bd9bca4687054d5ff8b1258cce10e2e240169cda85faa565ba8b4d245de5"

URI_aarch64_dropbear = "${EPEL_MIRROR}/aarch64/Packages/d/dropbear-2025.88-1.el10_1.aarch64.rpm;name=aarch64_dropbear;unpack=0"
SRC_URI:append = " ${URI_aarch64_dropbear}"
SRC_URI[aarch64_dropbear.sha256sum] = "26100239de321a5607d488b66d1620b686c0c3cead86c5463708640b7d81d445"

RDEPENDS:dropbear = " \
 bash \
 glibc \
 libtomcrypt \
 libtommath \
 libxcrypt \
 systemd \
 zlib-ng-compat \
 "
