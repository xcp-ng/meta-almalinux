# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uriparser"
PV = "0.9.8"
PR = "2.el10_1"
PACKAGES = " \
 mingw32-uriparser \
 mingw64-uriparser \
 uriparser \
 uriparser-devel \
 uriparser-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uriparser-0.9.8-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87e3bc105bcf6436dd5cfbdda12b3041073cd21576149515271e616a2e49d1ba"

URI_x86_64_v2_mingw32-uriparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-uriparser-0.9.8-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-uriparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-uriparser}"
SRC_URI[x86_64_v2_mingw32-uriparser.sha256sum] = "aaf90102defc504226582283e6c23820fd92ec2bbcb10fbe12adf0707af9de50"

URI_x86_64_v2_mingw64-uriparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-uriparser-0.9.8-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-uriparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-uriparser}"
SRC_URI[x86_64_v2_mingw64-uriparser.sha256sum] = "6117865543995d94d9f5abfd312823dfb9da88adf1ec6f3b115a710c72d6fd88"

URI_x86_64_v2_uriparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uriparser-0.9.8-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uriparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uriparser}"
SRC_URI[x86_64_v2_uriparser.sha256sum] = "f909d139cef26964bf26c06a49255d0066be3010812c2f700622eb40171b6c15"

URI_x86_64_v2_uriparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uriparser-devel-0.9.8-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uriparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uriparser-devel}"
SRC_URI[x86_64_v2_uriparser-devel.sha256sum] = "36c657ecdbdf31f40ed29faa72ecb4c4cf8e7b73ddb31118a6e6ba76fe62bc9c"

URI_x86_64_v2_uriparser-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uriparser-doc-0.9.8-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_uriparser-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uriparser-doc}"
SRC_URI[x86_64_v2_uriparser-doc.sha256sum] = "1c02969c5cd31ebc4d0dd2a14fdd29e7a57b1ad97bfa0143ef662d633aeceb93"

URI_aarch64_mingw32-uriparser = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-uriparser-0.9.8-2.el10_1.noarch.rpm;name=aarch64_mingw32-uriparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-uriparser}"
SRC_URI[aarch64_mingw32-uriparser.sha256sum] = "d03e008a2f358e19b9e34f62d3aaab6ce92353751847b46c244c06df45f8ac27"

URI_aarch64_mingw64-uriparser = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-uriparser-0.9.8-2.el10_1.noarch.rpm;name=aarch64_mingw64-uriparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-uriparser}"
SRC_URI[aarch64_mingw64-uriparser.sha256sum] = "499dc5796d8d1456c339a640e7e03024fc640077662b9da309aeab66467e005a"

URI_aarch64_uriparser = "${EPEL_MIRROR}/aarch64/Packages/u/uriparser-0.9.8-2.el10_1.aarch64.rpm;name=aarch64_uriparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_uriparser}"
SRC_URI[aarch64_uriparser.sha256sum] = "b02eb1593ffc6ad3cacd7249282416974365fe7c638c5ed0312902861dee9ab2"

URI_aarch64_uriparser-devel = "${EPEL_MIRROR}/aarch64/Packages/u/uriparser-devel-0.9.8-2.el10_1.aarch64.rpm;name=aarch64_uriparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uriparser-devel}"
SRC_URI[aarch64_uriparser-devel.sha256sum] = "f8072bc1fabbdf27efd0d3ecac264d3e9fc2039e6e7db856a70d35b0a3b5a4f0"

URI_aarch64_uriparser-doc = "${EPEL_MIRROR}/aarch64/Packages/u/uriparser-doc-0.9.8-2.el10_1.noarch.rpm;name=aarch64_uriparser-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_uriparser-doc}"
SRC_URI[aarch64_uriparser-doc.sha256sum] = "1988a49ed0d2fa51cb9800a34dd44b5b16124743e2e788e54fddab8388e358fe"

RDEPENDS:mingw32-uriparser = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-uriparser = " \
 mingw64-crt \
 mingw64-filesystem \
 "
RDEPENDS:uriparser = " \
 glibc \
 "
RDEPENDS:uriparser-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 uriparser \
 "
RDEPENDS:uriparser-doc = " \
 "
