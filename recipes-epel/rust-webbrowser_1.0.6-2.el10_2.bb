# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-webbrowser"
PV = "1.0.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-webbrowser+default-devel \
 rust-webbrowser+disable-wsl-devel \
 rust-webbrowser+hardened-devel \
 rust-webbrowser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-webbrowser-1.0.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3637d420b8793a511ea96673c5ca4c4e2b5f536d0a6d6a45cc2167b3b39b8b56"

URI_x86_64_v2_rust-webbrowser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser+default-devel-1.0.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webbrowser+default-devel}"
SRC_URI[x86_64_v2_rust-webbrowser+default-devel.sha256sum] = "5b83e42b38d7423c6572cfbb9cce8f377ca503a167e5d25af3a56185e7833a0c"

URI_x86_64_v2_rust-webbrowser+disable-wsl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser+disable-wsl-devel-1.0.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser+disable-wsl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webbrowser+disable-wsl-devel}"
SRC_URI[x86_64_v2_rust-webbrowser+disable-wsl-devel.sha256sum] = "15a13c533bc035e623306a678cd1b6a6be085e2a4295092b1e8a579bf9609615"

URI_x86_64_v2_rust-webbrowser+hardened-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser+hardened-devel-1.0.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser+hardened-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webbrowser+hardened-devel}"
SRC_URI[x86_64_v2_rust-webbrowser+hardened-devel.sha256sum] = "f183978e0b076007f20e9684ebe0c7fe1cc64efed324cbde6a63cd83b2664c36"

URI_x86_64_v2_rust-webbrowser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webbrowser-devel-1.0.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webbrowser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webbrowser-devel}"
SRC_URI[x86_64_v2_rust-webbrowser-devel.sha256sum] = "b7fd970ae663baa593bd5f62e0695a222b3d3a509b66b1a8d270e47c788b333a"

URI_aarch64_rust-webbrowser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser+default-devel-1.0.6-2.el10_2.noarch.rpm;name=aarch64_rust-webbrowser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webbrowser+default-devel}"
SRC_URI[aarch64_rust-webbrowser+default-devel.sha256sum] = "533ec435bec5a8c0e14903a1bf0e2fd015b0092a896da5e5f2032bf048cf7f6a"

URI_aarch64_rust-webbrowser+disable-wsl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser+disable-wsl-devel-1.0.6-2.el10_2.noarch.rpm;name=aarch64_rust-webbrowser+disable-wsl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webbrowser+disable-wsl-devel}"
SRC_URI[aarch64_rust-webbrowser+disable-wsl-devel.sha256sum] = "74b293d2346533dd15f4af4b433a2aacdcec95dca9aff93943d3d1f7abdd5090"

URI_aarch64_rust-webbrowser+hardened-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser+hardened-devel-1.0.6-2.el10_2.noarch.rpm;name=aarch64_rust-webbrowser+hardened-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webbrowser+hardened-devel}"
SRC_URI[aarch64_rust-webbrowser+hardened-devel.sha256sum] = "30d51fd7ff51e0b86de724c925f3933ae3dd4acd93f4c8ad443f58c96bbc82fb"

URI_aarch64_rust-webbrowser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webbrowser-devel-1.0.6-2.el10_2.noarch.rpm;name=aarch64_rust-webbrowser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webbrowser-devel}"
SRC_URI[aarch64_rust-webbrowser-devel.sha256sum] = "e5de39fd10f3999ea26c735492519f1c0fa3a0b4580b9463bb0d8dfe1c1835d9"

RDEPENDS:rust-webbrowser+default-devel = " \
 cargo \
 rust-webbrowser-devel \
 "
RDEPENDS:rust-webbrowser+disable-wsl-devel = " \
 cargo \
 rust-webbrowser-devel \
 "
RDEPENDS:rust-webbrowser+hardened-devel = " \
 cargo \
 rust-webbrowser-devel \
 "
RDEPENDS:rust-webbrowser-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-url+default-devel \
 "
