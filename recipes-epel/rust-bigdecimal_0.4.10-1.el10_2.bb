# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bigdecimal"
PV = "0.4.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-bigdecimal+default-devel \
 rust-bigdecimal+serde-devel \
 rust-bigdecimal+serde-json-devel \
 rust-bigdecimal+serde_json-devel \
 rust-bigdecimal+std-devel \
 rust-bigdecimal+string-only-devel \
 rust-bigdecimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bigdecimal-0.4.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44fb786787f00f98c30e5acfd1828ad1753edf9815f340bfb85c9bd89937e7d2"

URI_x86_64_v2_rust-bigdecimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+default-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+default-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+default-devel.sha256sum] = "b49ed560e6bd275a2765ce7252abb0076fbf671a8d9666dcf24fd6416ee104fb"

URI_x86_64_v2_rust-bigdecimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde-devel.sha256sum] = "4be69389a665b4c2be105d31b127538727e1a65236dd9ed320d736bf97a28962"

URI_x86_64_v2_rust-bigdecimal+serde-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde-json-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde-json-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde-json-devel.sha256sum] = "4d18a3cbe050f60bd2fd6f6b62aa4c3e0ae0e76d0800b4c16b58859a26bcd50a"

URI_x86_64_v2_rust-bigdecimal+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde_json-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde_json-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde_json-devel.sha256sum] = "d434ec0e0319a05c0f45297f05e6aee16d5144852c9e070ec35db92ac18d3ce1"

URI_x86_64_v2_rust-bigdecimal+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+std-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+std-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+std-devel.sha256sum] = "f170e9a17d3bbb1c8e9fa319273c640eba62d7ff8b6adc0fd5dc9acb322226bc"

URI_x86_64_v2_rust-bigdecimal+string-only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+string-only-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+string-only-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+string-only-devel.sha256sum] = "f29b246c419068907becfa1d00d094d83b0592a2fda509181068b2f2194bd212"

URI_x86_64_v2_rust-bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal-devel.sha256sum] = "1dfbd725039cf7732ef370df92fcc7382d54f6b81d92fe0084871f9e693e5672"

URI_aarch64_rust-bigdecimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+default-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-bigdecimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+default-devel}"
SRC_URI[aarch64_rust-bigdecimal+default-devel.sha256sum] = "5d90e36ac58773a047fea05bf0f884eb8520a742ecc2efc52d707f5c750e443d"

URI_aarch64_rust-bigdecimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-bigdecimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde-devel.sha256sum] = "65be51c72681072acf8d89b658eef0dd1fb696748f2a491a0c0406ccfd6da245"

URI_aarch64_rust-bigdecimal+serde-json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde-json-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-bigdecimal+serde-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde-json-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde-json-devel.sha256sum] = "176a722446723f275d122993231adbe86d746804b7fb33b118f4f4c792ca17ca"

URI_aarch64_rust-bigdecimal+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde_json-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-bigdecimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde_json-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde_json-devel.sha256sum] = "7908f0edd0e5d8f7c675ed78725cda6a28a5ad9128d42c9660ce272fa540cfe3"

URI_aarch64_rust-bigdecimal+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+std-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-bigdecimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+std-devel}"
SRC_URI[aarch64_rust-bigdecimal+std-devel.sha256sum] = "cedf132da990358534c03e5d249171ae2ddc152c7f3247714b24a56b43b4a69b"

URI_aarch64_rust-bigdecimal+string-only-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+string-only-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-bigdecimal+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+string-only-devel}"
SRC_URI[aarch64_rust-bigdecimal+string-only-devel.sha256sum] = "cf00ee5ae7e8f62bb7a740d2e5ae566527d5bc66b02e8f1aa01cbb5c1e6594ab"

URI_aarch64_rust-bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal-devel}"
SRC_URI[aarch64_rust-bigdecimal-devel.sha256sum] = "86a2f9a28e06011269c31530e1bea513fe71b69768e48fa404d4084d6b6f35e2"

RDEPENDS:rust-bigdecimal+default-devel = " \
 cargo \
 rust-bigdecimal+std-devel \
 rust-bigdecimal-devel \
 "
RDEPENDS:rust-bigdecimal+serde-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bigdecimal+serde-json-devel = " \
 cargo \
 rust-bigdecimal+serde_json-devel \
 rust-bigdecimal-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bigdecimal+serde_json-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-serde_json+alloc-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-bigdecimal+std-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-num-bigint+std-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-bigdecimal+string-only-devel = " \
 cargo \
 rust-bigdecimal-devel \
 "
RDEPENDS:rust-bigdecimal-devel = " \
 cargo \
 rust-autocfg+default-devel \
 rust-libm+default-devel \
 rust-num-bigint-devel \
 rust-num-integer-devel \
 rust-num-traits-devel \
 "
