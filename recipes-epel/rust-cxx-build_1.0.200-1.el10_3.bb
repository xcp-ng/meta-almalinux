# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-build"
PV = "1.0.200"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxx-build+default-devel \
 rust-cxx-build+parallel-devel \
 rust-cxx-build-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-build-1.0.200-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7dca2ed045144bc9f5d694dfe59fc2ec7c9d4dcc7b54ead9a1ffa0219182677e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+default-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx-build+default-devel.sha256sum] = "ba1cb147fd717915c797d6da5c79c1f5d148ac025d377baad92e359fe55d4372"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+parallel-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx-build+parallel-devel.sha256sum] = "818e85e62207b7d360114f8a31af3b322d43f2f53549515daed9cb3e9ff14504"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx-build-devel.sha256sum] = "447d1665887ffcaeec3d79904ac115fbc00b28fda25a0b85afc7a312167f7575"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+default-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-build+default-devel;unpack=0"
SRC_URI[aarch64_rust-cxx-build+default-devel.sha256sum] = "b97e31fccb268b3f4cd467b294dcb01dc687d27a7f210d9bb35e0c4e783de4de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+parallel-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI[aarch64_rust-cxx-build+parallel-devel.sha256sum] = "5049ca1e299f57dc030de7622a715835ff21ec414ccbf3279697cf50e9cf687b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-build-devel;unpack=0"
SRC_URI[aarch64_rust-cxx-build-devel.sha256sum] = "f386d2950edb3f590dd8b385245063b326da4fc4239d9dffb8e7cd0edebfb1fb"

RDEPENDS:rust-cxx-build+default-devel = " \
 cargo \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build+parallel-devel = " \
 cargo \
 rust-cc+parallel-devel \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-codespan-reporting+default-devel \
 rust-indexmap+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-scratch+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
