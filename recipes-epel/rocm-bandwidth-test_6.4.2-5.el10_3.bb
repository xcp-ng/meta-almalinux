# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-bandwidth-test"
PV = "6.4.2"
PR = "5.el10_3"
PACKAGES:x86_64_v2 = " \
 rocm-bandwidth-test \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-bandwidth-test-6.4.2-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d6c36b5d961109879060b947a1d2effe7b24b4e5deeadd64496c23554e46b90"

URI_x86_64_v2_rocm-bandwidth-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-bandwidth-test-6.4.2-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-bandwidth-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-bandwidth-test}"
SRC_URI[x86_64_v2_rocm-bandwidth-test.sha256sum] = "a280e69c34d619e61fe52ce9d15792e62c58f7d55f8ef3f6f69a05b18b8e9e57"

RDEPENDS:rocm-bandwidth-test = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-runtime \
 "
