# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdivide"
PV = "5.4.0"
PR = "1.el10_3"
PACKAGES = " \
 libdivide-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libdivide-5.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b3cb8485c2d509021cb84cd875c0e6833947f640cff5e306fbb2a412897cf75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdivide-devel-5.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdivide-devel;unpack=0"
SRC_URI[x86_64_v2_libdivide-devel.sha256sum] = "95327e407a6e162303482c89658f4dc9ed4d43a09d95683cfedd7bb8c93ef1b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdivide-devel-5.4.0-1.el10_3.aarch64.rpm;name=aarch64_libdivide-devel;unpack=0"
SRC_URI[aarch64_libdivide-devel.sha256sum] = "5950dd04d47ab47abba78462aee01d3243a3186ad7de5f825de4ead071bea894"

RDEPENDS:libdivide-devel = " \
 cmake-filesystem \
 "
