# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PPIx-Regexp"
PV = "0.088"
PR = "5.el10_0"
PACKAGES = " \
 perl-PPIx-Regexp \
 perl-PPIx-Regexp-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-PPIx-Regexp-0.088-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04e74db6ce4e0fb3aa8edbcd09796312173207ca7b2a92c242b9016c28d1a0f2"

URI_x86_64_v2_perl-PPIx-Regexp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PPIx-Regexp-0.088-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PPIx-Regexp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PPIx-Regexp}"
SRC_URI[x86_64_v2_perl-PPIx-Regexp.sha256sum] = "cc0ca83fe0d96c0fe6fd1d3f285a2639def0a6d71bfed26026b2d836169008c8"

URI_x86_64_v2_perl-PPIx-Regexp-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PPIx-Regexp-tests-0.088-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PPIx-Regexp-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PPIx-Regexp-tests}"
SRC_URI[x86_64_v2_perl-PPIx-Regexp-tests.sha256sum] = "3209a16b9deaef8dd85c71c06bd1f5e4448b562ba96c994562f47e402d4ef899"

URI_aarch64_perl-PPIx-Regexp = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PPIx-Regexp-0.088-5.el10_0.noarch.rpm;name=aarch64_perl-PPIx-Regexp;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PPIx-Regexp}"
SRC_URI[aarch64_perl-PPIx-Regexp.sha256sum] = "38a0862f7ae26a22eacdee7b25ae7c5f02c14b12e01cf8b0189302a509e39300"

URI_aarch64_perl-PPIx-Regexp-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PPIx-Regexp-tests-0.088-5.el10_0.noarch.rpm;name=aarch64_perl-PPIx-Regexp-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PPIx-Regexp-tests}"
SRC_URI[aarch64_perl-PPIx-Regexp-tests.sha256sum] = "7550cc11eda4936159706e717ede04ad9b8e147d736769b6305b65ad3847f70c"

RDEPENDS:perl-PPIx-Regexp = " \
 perl-Carp \
 perl-Exporter \
 perl-PPI \
 perl-PPIx-Regexp \
 perl-Scalar-List-Utils \
 perl-Task-Weaken \
 perl-base \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-PPIx-Regexp-tests = " \
 bash \
 perl-Carp \
 perl-Exporter \
 perl-PPI \
 perl-PPIx-Regexp \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-open \
 "
