# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-notebook"
PV = "7.4.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-notebook \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-notebook-7.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1d855e8e956ab3a0a883bfb95d363a6e9e4779762e98b1db82be218119cef61"

URI_x86_64_v2_python3-notebook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-notebook-7.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-notebook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-notebook}"
SRC_URI[x86_64_v2_python3-notebook.sha256sum] = "9578c8925658b8d8e34e8681dfe0fe9345447bd73b0251fa4c0bea2604d75b1f"

URI_aarch64_python3-notebook = "${EPEL_MIRROR}/aarch64/Packages/p/python3-notebook-7.4.2-1.el10_1.noarch.rpm;name=aarch64_python3-notebook;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-notebook}"
SRC_URI[aarch64_python3-notebook.sha256sum] = "1375be9eb7c7b089e1dede36c9c9d91a96ca74f61ce1bc7c30f2d519afe83d04"

RDEPENDS:python3-notebook = " \
 jupyterlab \
 python-jupyter-filesystem \
 python3 \
 python3-jupyter-server \
 python3-jupyterlab-server \
 python3-notebook-shim \
 python3-tornado \
 "
