# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman"
PE = "7"
PV = "5.8.2"
PR = "9.el10_2.alma.1"
PACKAGES = " \
 podman \
 podman-docker \
 podman-remote \
 podman-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/podman-5.8.2-9.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4565f8b45d2c513367b8565c44fcfd53b91a03da9fb725e122ba50fd0a2a5d85"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-5.8.2-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman;unpack=0"
SRC_URI[x86_64_v2_podman.sha256sum] = "6bc18dc079aed31dda3260526b24aa74a59a1fe6cc16494d601d072136f4cf50"
RPROVIDES:podman:append:x86_64_v2 = " virtual/podman_or_/usr/bin/docker"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-docker-5.8.2-9.el10_2.alma.1.noarch.rpm;name=x86_64_v2_podman-docker;unpack=0"
SRC_URI[x86_64_v2_podman-docker.sha256sum] = "f46c4a2f1c8d19490236bd31637b67ed406bf45d03eeaf0ed986334693a23e6a"
RPROVIDES:podman-docker:append:x86_64_v2 = " virtual/podman_or_/usr/bin/docker"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-remote-5.8.2-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-remote;unpack=0"
SRC_URI[x86_64_v2_podman-remote.sha256sum] = "589192de9c1defdcd0f8326b8c7a5ea9a07f92d5e8ef3678e62340b38a490e6b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/podman-tests-5.8.2-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-tests;unpack=0"
SRC_URI[x86_64_v2_podman-tests.sha256sum] = "e86e752615ff2370e2d2d811537c2c764e01f4696ad3422938308eaf9b03e3af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-5.8.2-9.el10_2.alma.1.aarch64.rpm;name=aarch64_podman;unpack=0"
SRC_URI[aarch64_podman.sha256sum] = "01121f16d5ad2f5da3608eb0dd4825ca927e77d0dca5130e0b1347d9e648628c"
RPROVIDES:podman:append:aarch64 = " virtual/podman_or_/usr/bin/docker"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-docker-5.8.2-9.el10_2.alma.1.noarch.rpm;name=aarch64_podman-docker;unpack=0"
SRC_URI[aarch64_podman-docker.sha256sum] = "f46c4a2f1c8d19490236bd31637b67ed406bf45d03eeaf0ed986334693a23e6a"
RPROVIDES:podman-docker:append:aarch64 = " virtual/podman_or_/usr/bin/docker"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-remote-5.8.2-9.el10_2.alma.1.aarch64.rpm;name=aarch64_podman-remote;unpack=0"
SRC_URI[aarch64_podman-remote.sha256sum] = "af70314866593ac9649f0f793195805165ebc47522817d2cc27cfbea9e75ddad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/podman-tests-5.8.2-9.el10_2.alma.1.aarch64.rpm;name=aarch64_podman-tests;unpack=0"
SRC_URI[aarch64_podman-tests.sha256sum] = "b2468792044e1eb80fed2eacd44242f80d7e547c364a2047d9c7631144917347"

RDEPENDS:podman = " \
 catatonit \
 conmon \
 containers-common-extra \
 glibc \
 gpgme \
 libgcc \
 libseccomp \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-docker = " \
 bash \
 podman \
 "
RDEPENDS:podman-remote = " \
 glibc \
 gpgme \
 libgcc \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-tests = " \
 attr \
 bash \
 buildah \
 glibc \
 gnupg2 \
 gpgme \
 httpd-tools \
 jq \
 libgcc \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 skopeo \
 slirp4netns \
 socat \
 sqlite-libs \
 xfsprogs \
 "
