# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-BoundedChan"
PV = "1.0.3.0"
PR = "6.el10_0"
PACKAGES = " \
 ghc-BoundedChan \
 ghc-BoundedChan-devel \
 ghc-BoundedChan-doc \
 ghc-BoundedChan-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-BoundedChan-1.0.3.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d5f83f356436bdffb1d74e9cdf790557b536aa95dd77664dad9f34dd0c9240c"

URI_x86_64_v2_ghc-BoundedChan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-BoundedChan-1.0.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-BoundedChan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-BoundedChan}"
SRC_URI[x86_64_v2_ghc-BoundedChan.sha256sum] = "7d59967783526b2cd521da0ddea13420fbd111b67834070c2fd393d480ab4caf"

URI_x86_64_v2_ghc-BoundedChan-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-BoundedChan-devel-1.0.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-BoundedChan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-BoundedChan-devel}"
SRC_URI[x86_64_v2_ghc-BoundedChan-devel.sha256sum] = "546b218ba4dab3b9238572c5f912801227647964bcc3ec843d74dc03cd8dd68a"

URI_x86_64_v2_ghc-BoundedChan-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-BoundedChan-doc-1.0.3.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-BoundedChan-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-BoundedChan-doc}"
SRC_URI[x86_64_v2_ghc-BoundedChan-doc.sha256sum] = "b646bb671fcc5faa25e6e360a06ee539092dc8edc008ce38b4d18532d4bf9337"

URI_x86_64_v2_ghc-BoundedChan-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-BoundedChan-prof-1.0.3.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-BoundedChan-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-BoundedChan-prof}"
SRC_URI[x86_64_v2_ghc-BoundedChan-prof.sha256sum] = "3b9c9f057851e2442839160d60f5bc9d01d617d407d357b447c852e6cf385d3b"

URI_aarch64_ghc-BoundedChan = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-BoundedChan-1.0.3.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-BoundedChan;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-BoundedChan}"
SRC_URI[aarch64_ghc-BoundedChan.sha256sum] = "de422bc1c6342ef586c32d3fe02dbca5055d37ea3e7ef1c74b800a03653e2cbb"

URI_aarch64_ghc-BoundedChan-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-BoundedChan-devel-1.0.3.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-BoundedChan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-BoundedChan-devel}"
SRC_URI[aarch64_ghc-BoundedChan-devel.sha256sum] = "e917a346fa2f2537a7f9579cb80aeb1f6ef1a923d0ef1a196dcf5d6d0edc5d28"

URI_aarch64_ghc-BoundedChan-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-BoundedChan-doc-1.0.3.0-6.el10_0.noarch.rpm;name=aarch64_ghc-BoundedChan-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-BoundedChan-doc}"
SRC_URI[aarch64_ghc-BoundedChan-doc.sha256sum] = "219ae9df2ba92be5017d2e802de9c597e9f0c6344ecdf78e57e297c7ba3fbf24"

URI_aarch64_ghc-BoundedChan-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-BoundedChan-prof-1.0.3.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-BoundedChan-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-BoundedChan-prof}"
SRC_URI[aarch64_ghc-BoundedChan-prof.sha256sum] = "e0ff0aba9d47c79212391769fa67ff0a3b22026984762c67f86c0dc494f30d3e"

RDEPENDS:ghc-BoundedChan = " \
 ghc-array \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-BoundedChan-devel = " \
 ghc-BoundedChan \
 ghc-array-devel \
 ghc-base-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-BoundedChan-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-BoundedChan-prof = " \
 ghc-BoundedChan-devel \
 ghc-array-prof \
 ghc-base-prof \
 "
