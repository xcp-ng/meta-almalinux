# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gotcha"
PV = "1.0.8"
PR = "1.el10_3"
PACKAGES = " \
 gotcha \
 gotcha-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gotcha-1.0.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6a80f48570895a26587e4f79f06949ba9ccec8f9ddc66a9b651f5cfab02a10f"

URI_x86_64_v2_gotcha = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gotcha-1.0.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gotcha;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gotcha}"
SRC_URI[x86_64_v2_gotcha.sha256sum] = "bb1805bcd677552ae696bd2c5f118ec7d7a4f4f83a2b95520b5a8935378e96a8"

URI_x86_64_v2_gotcha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gotcha-devel-1.0.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gotcha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gotcha-devel}"
SRC_URI[x86_64_v2_gotcha-devel.sha256sum] = "03053cbc1e6dc51b5c7f16bc60759a5de7e5277d643d3157806f31b3d6c90ac0"

URI_aarch64_gotcha = "${EPEL_MIRROR}/aarch64/Packages/g/gotcha-1.0.8-1.el10_3.aarch64.rpm;name=aarch64_gotcha;unpack=0"
SRC_URI:append = " ${URI_aarch64_gotcha}"
SRC_URI[aarch64_gotcha.sha256sum] = "1ca23ef420155e6b4037eb7afbc169b7995ac9b4694b91c7f018c187df5cf4aa"

URI_aarch64_gotcha-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gotcha-devel-1.0.8-1.el10_3.aarch64.rpm;name=aarch64_gotcha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gotcha-devel}"
SRC_URI[aarch64_gotcha-devel.sha256sum] = "9688b4509d4279013686e7567030f102f08fbb4aef30362c44c1fc20dee3e294"

RDEPENDS:gotcha = " \
 glibc \
 "
RDEPENDS:gotcha-devel = " \
 cmake-filesystem \
 gotcha \
 "
