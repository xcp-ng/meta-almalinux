# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oneapi-level-zero"
PV = "1.21.9"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 oneapi-level-zero \
 oneapi-level-zero-devel \
 oneapi-level-zero-zello_world \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/o/oneapi-level-zero-1.21.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17b6ed6fd035c27629b28024906faed2409a3fb0900172fa61437089c8c4844d"

URI_x86_64_v2_oneapi-level-zero = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-1.21.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero}"
SRC_URI[x86_64_v2_oneapi-level-zero.sha256sum] = "cec05d27784c3d5192088a5cfdd2e965adcee679a7e8f0f293f5855af3eebd20"

URI_x86_64_v2_oneapi-level-zero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-devel-1.21.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero-devel}"
SRC_URI[x86_64_v2_oneapi-level-zero-devel.sha256sum] = "1f9e77f6936b77c808a05e64be5c42bd7d5ab2a1159bd0b1e7b2147652512c92"

URI_x86_64_v2_oneapi-level-zero-zello_world = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oneapi-level-zero-zello_world-1.21.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oneapi-level-zero-zello_world;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oneapi-level-zero-zello_world}"
SRC_URI[x86_64_v2_oneapi-level-zero-zello_world.sha256sum] = "a572f0a473632fc22b0096f19c02d1e25f2f7c721ed0c5ef35f554f93662d9a0"

RDEPENDS:oneapi-level-zero = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:oneapi-level-zero-devel = " \
 oneapi-level-zero \
 oneapi-level-zero-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:oneapi-level-zero-zello_world = " \
 glibc \
 libgcc \
 libstdc++ \
 oneapi-level-zero \
 "
