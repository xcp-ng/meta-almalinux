# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nmon"
PV = "16q"
PR = "3.el10_0"
PACKAGES = " \
 nmon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nmon-16q-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a9ff127b1a55a0be3a48814475da1b559d7f90b2b18381a82981f6b4e0b3a49"

URI_x86_64_v2_nmon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nmon-16q-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nmon}"
SRC_URI[x86_64_v2_nmon.sha256sum] = "b35a90bc5632d3c39a1bb6d533b76babe8cd985eafa8d36be871de04a78b9926"

URI_aarch64_nmon = "${EPEL_MIRROR}/aarch64/Packages/n/nmon-16q-3.el10_0.aarch64.rpm;name=aarch64_nmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_nmon}"
SRC_URI[aarch64_nmon.sha256sum] = "3071ff9ec7dfb86b68fe61106486cf07e2063da251aaaff842c395d4cb40f198"

RDEPENDS:nmon = " \
 glibc \
 ncurses-libs \
 "
