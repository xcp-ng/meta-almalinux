# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fennel"
PV = "1.5.3"
PR = "2.el10_0"
PACKAGES = " \
 fennel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fennel-1.5.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "505723216630bfb7fb53549c848e72642c0de9c61bbdcfc37b115741a2e284da"

URI_x86_64_v2_fennel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fennel-1.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fennel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fennel}"
SRC_URI[x86_64_v2_fennel.sha256sum] = "69d9df70fdae2deb43bf1dd2fabd62a2615d123a82ba1882cc9fcfa2ea77e924"

URI_aarch64_fennel = "${EPEL_MIRROR}/aarch64/Packages/f/fennel-1.5.3-2.el10_0.noarch.rpm;name=aarch64_fennel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fennel}"
SRC_URI[aarch64_fennel.sha256sum] = "f64abd9368bc9f967ef7a26aa277fbd0c7338487ca937d22f4fca03aaa8b703c"

RDEPENDS:fennel = " \
 lua \
 lua-libs \
 "
