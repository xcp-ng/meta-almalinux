# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-databake"
PV = "0.1.8"
PR = "2.el10_0"
PACKAGES = " \
 rust-databake+default-devel \
 rust-databake+derive-devel \
 rust-databake-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-databake-0.1.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8ae32690a8febbdf5c0ae60160298c3c588742e39beb7eb1818fae92369d16b"

URI_x86_64_v2_rust-databake+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake+default-devel-0.1.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake+default-devel}"
SRC_URI[x86_64_v2_rust-databake+default-devel.sha256sum] = "71680e168cdc721699e47f30762ea80bf9c23c3e2fdc072aa2c42b5df0921f9f"

URI_x86_64_v2_rust-databake+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake+derive-devel-0.1.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake+derive-devel}"
SRC_URI[x86_64_v2_rust-databake+derive-devel.sha256sum] = "98e5ccc19f3698bf8e14b65185dc10f734358f8619548460e3ff6bb33665dcd9"

URI_x86_64_v2_rust-databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-devel-0.1.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-devel}"
SRC_URI[x86_64_v2_rust-databake-devel.sha256sum] = "13dfc62b05f04111e169a26b684f125b0e3056560593665aea73123f9e30dafa"

URI_aarch64_rust-databake+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake+default-devel-0.1.8-2.el10_0.noarch.rpm;name=aarch64_rust-databake+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake+default-devel}"
SRC_URI[aarch64_rust-databake+default-devel.sha256sum] = "bcdcc8520ebdc30afee87f90521ff6255bee07e26bd45dda5284c9cd67785769"

URI_aarch64_rust-databake+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake+derive-devel-0.1.8-2.el10_0.noarch.rpm;name=aarch64_rust-databake+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake+derive-devel}"
SRC_URI[aarch64_rust-databake+derive-devel.sha256sum] = "3196046da6e56212d4bb6e49c9891cc33048987ba7c138b7361cb31df7e5b7a8"

URI_aarch64_rust-databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-devel-0.1.8-2.el10_0.noarch.rpm;name=aarch64_rust-databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-devel}"
SRC_URI[aarch64_rust-databake-devel.sha256sum] = "ed34ef37238066ad8614bf317acefb3633f5e542edd7eacb124e7a6afdbf842f"

RDEPENDS:rust-databake+default-devel = " \
 cargo \
 rust-databake-devel \
 "
RDEPENDS:rust-databake+derive-devel = " \
 cargo \
 rust-databake-derive-devel \
 rust-databake-devel \
 "
RDEPENDS:rust-databake-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
