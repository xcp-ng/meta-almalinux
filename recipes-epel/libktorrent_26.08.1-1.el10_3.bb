# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libktorrent"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 libktorrent \
 libktorrent-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libktorrent-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d8912fef0dd662017bc8f86b3b163b25b0365c9431462324a3e6adc60e571502"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent;unpack=0"
SRC_URI[x86_64_v2_libktorrent.sha256sum] = "157198e564b42d2e50517735d4ddad51d72e1b25b9b44b21bba33ab952d06afb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent-devel;unpack=0"
SRC_URI[x86_64_v2_libktorrent-devel.sha256sum] = "7b28f7f4112607dcfcf5cf13e202a0aec969dcb7d1491d9315554b143eaf79f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libktorrent;unpack=0"
SRC_URI[aarch64_libktorrent.sha256sum] = "3c13e6f17fcfc625b142ca4bab80e440de363eaef2c9f497f4d7c23c42b2f0c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_libktorrent-devel;unpack=0"
SRC_URI[aarch64_libktorrent-devel.sha256sum] = "7315a9928a9e3a20619aa2db23debf7fdd9d8ad15140eed19f6f590e9d24be24"

RDEPENDS:libktorrent = " \
 glibc \
 gmp \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libgcc \
 libgcrypt \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libktorrent-devel = " \
 boost-devel \
 cmake-filesystem \
 gmp-devel \
 kf6-karchive-devel \
 kf6-kconfig-devel \
 kf6-kio-devel \
 libgcrypt-devel \
 libktorrent \
 qt6-qtbase-devel \
 "
