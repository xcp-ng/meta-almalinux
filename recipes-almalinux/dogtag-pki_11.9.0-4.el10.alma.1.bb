# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dogtag-pki"
PV = "11.9.0"
PR = "4.el10.alma.1"
PACKAGES = " \
 idm-pki-acme \
 idm-pki-base \
 idm-pki-ca \
 idm-pki-java \
 idm-pki-kra \
 idm-pki-server \
 idm-pki-tools \
 python3-idm-pki \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dogtag-pki-11.9.0-4.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40ea0b6e073e480d22da0e9fb6f3e0d7f1d0824782a500731a80bdd77743d9c0"

URI_x86_64_v2_idm-pki-acme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-acme-11.9.0-4.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-acme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-acme}"
SRC_URI[x86_64_v2_idm-pki-acme.sha256sum] = "8470bb63313916d4001d1e7e9fdddca318a6c6dac82a4c6b077f692f3b8f0d20"

URI_x86_64_v2_idm-pki-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-base-11.9.0-4.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-base}"
SRC_URI[x86_64_v2_idm-pki-base.sha256sum] = "7b94d8852cd925865f03c1bc6c2775bad7f0f61883eaab99d3f07b5a3a35d109"

URI_x86_64_v2_idm-pki-ca = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-ca-11.9.0-4.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-ca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-ca}"
SRC_URI[x86_64_v2_idm-pki-ca.sha256sum] = "a6921b130214e29a24546e4d63c684feca115c054f438ea231cf293ba086e5ac"

URI_x86_64_v2_idm-pki-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-java-11.9.0-4.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-java}"
SRC_URI[x86_64_v2_idm-pki-java.sha256sum] = "f44033b4cfb49cafd265ce5f01e6b8f7fd539da39e2bc5c5fe172b9b1dafdf32"

URI_x86_64_v2_idm-pki-kra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-kra-11.9.0-4.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-kra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-kra}"
SRC_URI[x86_64_v2_idm-pki-kra.sha256sum] = "3a7b46225919f3c93af78a6a30e47767afe1e3998f322d32a923002b103b200a"

URI_x86_64_v2_idm-pki-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-server-11.9.0-4.el10.alma.1.noarch.rpm;name=x86_64_v2_idm-pki-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-server}"
SRC_URI[x86_64_v2_idm-pki-server.sha256sum] = "bd0338d2703036932119af2be8a82927893c278212d4928d4460f7eadff0a5ec"

URI_x86_64_v2_idm-pki-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-pki-tools-11.9.0-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_idm-pki-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-pki-tools}"
SRC_URI[x86_64_v2_idm-pki-tools.sha256sum] = "741bfd607a023fe541d53b6848c07418fb6d3256ee564097aacf7faf4d5752d9"

URI_x86_64_v2_python3-idm-pki = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-idm-pki-11.9.0-4.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-idm-pki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-idm-pki}"
SRC_URI[x86_64_v2_python3-idm-pki.sha256sum] = "74619592eabef0d339d68554df4c9d3fbc833e5cbaf12b0b82d366e7f883a54e"

URI_aarch64_idm-pki-acme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-acme-11.9.0-4.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-acme;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-acme}"
SRC_URI[aarch64_idm-pki-acme.sha256sum] = "8470bb63313916d4001d1e7e9fdddca318a6c6dac82a4c6b077f692f3b8f0d20"

URI_aarch64_idm-pki-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-base-11.9.0-4.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-base}"
SRC_URI[aarch64_idm-pki-base.sha256sum] = "7b94d8852cd925865f03c1bc6c2775bad7f0f61883eaab99d3f07b5a3a35d109"

URI_aarch64_idm-pki-ca = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-ca-11.9.0-4.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-ca;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-ca}"
SRC_URI[aarch64_idm-pki-ca.sha256sum] = "a6921b130214e29a24546e4d63c684feca115c054f438ea231cf293ba086e5ac"

URI_aarch64_idm-pki-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-java-11.9.0-4.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-java}"
SRC_URI[aarch64_idm-pki-java.sha256sum] = "f44033b4cfb49cafd265ce5f01e6b8f7fd539da39e2bc5c5fe172b9b1dafdf32"

URI_aarch64_idm-pki-kra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-kra-11.9.0-4.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-kra;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-kra}"
SRC_URI[aarch64_idm-pki-kra.sha256sum] = "3a7b46225919f3c93af78a6a30e47767afe1e3998f322d32a923002b103b200a"

URI_aarch64_idm-pki-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-server-11.9.0-4.el10.alma.1.noarch.rpm;name=aarch64_idm-pki-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-server}"
SRC_URI[aarch64_idm-pki-server.sha256sum] = "bd0338d2703036932119af2be8a82927893c278212d4928d4460f7eadff0a5ec"

URI_aarch64_idm-pki-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-pki-tools-11.9.0-4.el10.alma.1.aarch64.rpm;name=aarch64_idm-pki-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-pki-tools}"
SRC_URI[aarch64_idm-pki-tools.sha256sum] = "c37612d4ed9fc40461c30e939b5fd238ccf1665b3b6f3eda1a603a12b6b847d3"

URI_aarch64_python3-idm-pki = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-idm-pki-11.9.0-4.el10.alma.1.noarch.rpm;name=aarch64_python3-idm-pki;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-idm-pki}"
SRC_URI[aarch64_python3-idm-pki.sha256sum] = "74619592eabef0d339d68554df4c9d3fbc833e5cbaf12b0b82d366e7f883a54e"

RDEPENDS:idm-pki-acme = " \
 bash \
 idm-pki-server \
 "
RDEPENDS:idm-pki-base = " \
 bash \
 nss \
 python3-idm-pki \
 "
RDEPENDS:idm-pki-ca = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-java = " \
 apache-commons-cli \
 apache-commons-codec \
 apache-commons-io \
 apache-commons-lang3 \
 apache-commons-logging \
 apache-commons-net \
 httpcomponents-client \
 idm-jss \
 idm-ldapjdk \
 idm-pki-base \
 java-21-openjdk-headless \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-pki-kra = " \
 bash \
 idm-pki-server \
 systemd \
 "
RDEPENDS:idm-pki-server = " \
 bash \
 hostname \
 idm-jss-tomcat \
 idm-pki-tools \
 ipa-healthcheck-core \
 java-21-openjdk-headless \
 keyutils \
 openldap-clients \
 openssl \
 policycoreutils \
 policycoreutils-python-utils \
 procps-ng \
 python3 \
 python3-libselinux \
 python3-lxml \
 python3-policycoreutils \
 selinux-policy-targeted \
 shadow-utils \
 systemd \
 tomcat9 \
 unzip \
 "
RDEPENDS:idm-pki-tools = " \
 bash \
 file \
 glibc \
 idm-pki-java \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-tools \
 openldap \
 openldap-clients \
 openssl \
 p11-kit-trust \
 "
RDEPENDS:python3-idm-pki = " \
 idm-pki-base \
 python3 \
 python3-cryptography \
 python3-ldap \
 python3-lxml \
 python3-requests \
 python3-six \
 "
