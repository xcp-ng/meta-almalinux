# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-plist"
PV = "1.7.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-plist+default-devel \
 rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel \
 rust-plist+serde-devel \
 rust-plist-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-plist-1.7.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5368a62e70cfdb0b3a3a3f353bec2a8a4dd23e90b57e64375fa1bf05c5b3f023"

URI_x86_64_v2_rust-plist+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+default-devel-1.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+default-devel}"
SRC_URI[x86_64_v2_rust-plist+default-devel.sha256sum] = "59818d66b9a01a0e91c00ca9f9250c3dd881ed75d238ab1305b0c2cc5ba61bc7"

URI_x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel-1.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel}"
SRC_URI[x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel.sha256sum] = "53009d62af9567b162eb49e8eb5f087300a6cc410f5752df2cfc14a19571c019"

URI_x86_64_v2_rust-plist+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+serde-devel-1.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+serde-devel}"
SRC_URI[x86_64_v2_rust-plist+serde-devel.sha256sum] = "1080bca0cae255287e7f42e0f6ff89174c5b4771ee92e0c8797f0378d0e7af56"

URI_x86_64_v2_rust-plist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist-devel-1.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist-devel}"
SRC_URI[x86_64_v2_rust-plist-devel.sha256sum] = "899afa8c4320d3e7990f121bc881ff39cfa8306fa718a957d9b15076ff08c22d"

URI_aarch64_rust-plist+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+default-devel-1.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-plist+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+default-devel}"
SRC_URI[aarch64_rust-plist+default-devel.sha256sum] = "750a2103524068f68566f907f12f995f9bbe171d99a89e8903d089d14c24ef8c"

URI_aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel-1.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel}"
SRC_URI[aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel.sha256sum] = "af398b065742a289395a26e89661249602245bb241dc272a588e678dbacab8dc"

URI_aarch64_rust-plist+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+serde-devel-1.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-plist+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+serde-devel}"
SRC_URI[aarch64_rust-plist+serde-devel.sha256sum] = "b2a2e543f1d63e2402c5cfc3442e43bdfd9a823a5c89d955b0619ef55b1ce51a"

URI_aarch64_rust-plist-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist-devel-1.7.3-1.el10_0.noarch.rpm;name=aarch64_rust-plist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist-devel}"
SRC_URI[aarch64_rust-plist-devel.sha256sum] = "396b502f108f294f5b02dcef0d6de16e533b07b3fce57a958c097d8c299ce178"

RDEPENDS:rust-plist+default-devel = " \
 cargo \
 rust-plist+serde-devel \
 rust-plist-devel \
 "
RDEPENDS:rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = " \
 cargo \
 rust-plist-devel \
 "
RDEPENDS:rust-plist+serde-devel = " \
 cargo \
 rust-plist-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-plist-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-indexmap+default-devel \
 rust-quick-xml+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 "
