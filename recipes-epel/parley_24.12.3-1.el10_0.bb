# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parley"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 parley \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/parley-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d867fc231cc86c41c23d12748d121eb85a4002745026d0e1dba5673c0ea376d4"

URI_x86_64_v2_parley = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parley-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parley;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parley}"
SRC_URI[x86_64_v2_parley.sha256sum] = "8e7d90d5745d0983e01a40dde59a3724fc7e009eee49d633271c23fc6b288bf7"

URI_aarch64_parley = "${EPEL_MIRROR}/aarch64/Packages/p/parley-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_parley;unpack=0"
SRC_URI:append = " ${URI_aarch64_parley}"
SRC_URI[aarch64_parley.sha256sum] = "3577a7bba8ade364a0ddfd1eeeb5cf870f0511012d19e109362c741a5e06549d"

RDEPENDS:parley = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 qt6-qtwebengine \
 "
