# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cambozola"
PV = "0.936"
PR = "26.el10_0"
PACKAGES = " \
 cambozola \
 cambozola-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cambozola-0.936-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d1b22fac1be84d6fae90da09a6b727ac805a039eec597c6e17ba817a6606a83"

URI_x86_64_v2_cambozola = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cambozola-0.936-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cambozola;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cambozola}"
SRC_URI[x86_64_v2_cambozola.sha256sum] = "c00b29a258ed85d6abd54e106c6d650384ff137feabd8b60ff8ef25cc9dd9571"

URI_x86_64_v2_cambozola-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cambozola-javadoc-0.936-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_cambozola-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cambozola-javadoc}"
SRC_URI[x86_64_v2_cambozola-javadoc.sha256sum] = "54c5168937a1ecfc94e5fa3cdc97aa864d1129d3d7fd1ebf6b8d33f356a5b51d"

URI_aarch64_cambozola = "${EPEL_MIRROR}/aarch64/Packages/c/cambozola-0.936-26.el10_0.noarch.rpm;name=aarch64_cambozola;unpack=0"
SRC_URI:append = " ${URI_aarch64_cambozola}"
SRC_URI[aarch64_cambozola.sha256sum] = "6ac1e6994cd7a2309f28e33ebe3ada39e18b7fb2919de1bfd7d002896a22132f"

URI_aarch64_cambozola-javadoc = "${EPEL_MIRROR}/aarch64/Packages/c/cambozola-javadoc-0.936-26.el10_0.noarch.rpm;name=aarch64_cambozola-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cambozola-javadoc}"
SRC_URI[aarch64_cambozola-javadoc.sha256sum] = "86d998ab872e5d2816b1afc5df9fb34d9ff5be4491105f51f9238f0389cb209f"

RDEPENDS:cambozola = " \
 java-21-openjdk \
 javapackages-tools \
 "
RDEPENDS:cambozola-javadoc = " \
 javapackages-tools \
 "
