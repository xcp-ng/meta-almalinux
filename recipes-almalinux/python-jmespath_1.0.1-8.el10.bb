# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jmespath"
PV = "1.0.1"
PR = "8.el10"
PACKAGES = " \
 python3-jmespath \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-jmespath-1.0.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa69d2a256665a4971e9303f37a45264be0fcee57ca94e944521f81514fa3d12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-jmespath-1.0.1-8.el10.noarch.rpm;name=x86_64_v2_python3-jmespath;unpack=0"
SRC_URI[x86_64_v2_python3-jmespath.sha256sum] = "3f13c97801297ae411bef26603afc0fadc083fbf4dbbd2e94b777b540499f5f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-jmespath-1.0.1-8.el10.noarch.rpm;name=aarch64_python3-jmespath;unpack=0"
SRC_URI[aarch64_python3-jmespath.sha256sum] = "3f13c97801297ae411bef26603afc0fadc083fbf4dbbd2e94b777b540499f5f2"

RDEPENDS:python3-jmespath = " \
 python3 \
 "
