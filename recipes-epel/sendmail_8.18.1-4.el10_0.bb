# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sendmail"
PV = "8.18.1"
PR = "4.el10_0"
PACKAGES = " \
 sendmail \
 sendmail-cf \
 sendmail-doc \
 sendmail-milter \
 sendmail-milter-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sendmail-8.18.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2548863ef73029243addb139f2efffb4cb4fe8183b51b5fb9a3790e1a09b3cce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sendmail-8.18.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sendmail;unpack=0"
SRC_URI[x86_64_v2_sendmail.sha256sum] = "efbb35d175f489c48cc48c23ffaf4965b8f8482d4bc9979a2a7a2750fde9f6c8"
RPROVIDES:sendmail:append:x86_64_v2 = " virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sendmail-cf-8.18.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sendmail-cf;unpack=0"
SRC_URI[x86_64_v2_sendmail-cf.sha256sum] = "f91188ff8aaa89d1a962f2346d1672a2825fb123c7e68bb78512a024ea91b3d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sendmail-doc-8.18.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sendmail-doc;unpack=0"
SRC_URI[x86_64_v2_sendmail-doc.sha256sum] = "560d021c18cbda7dc0a6fef6c17617e947ed5a07fe5b0c8267219c0ee96c2aca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sendmail-milter-8.18.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sendmail-milter;unpack=0"
SRC_URI[x86_64_v2_sendmail-milter.sha256sum] = "39038e1a7fb3ad7bc97b02c1703d0d042fa86f5858d11dddaf74aa3d3c4a4c40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sendmail-milter-devel-8.18.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sendmail-milter-devel;unpack=0"
SRC_URI[x86_64_v2_sendmail-milter-devel.sha256sum] = "e460571b7e1468bef64f500e7f368a42c6d6a956ef41a737aa725a942cb753a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sendmail-8.18.1-4.el10_0.aarch64.rpm;name=aarch64_sendmail;unpack=0"
SRC_URI[aarch64_sendmail.sha256sum] = "bedfb44a1bd78903fa4b4378a981ec950c8f1e974dd822938079dea42e9ed68c"
RPROVIDES:sendmail:append:aarch64 = " virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sendmail-cf-8.18.1-4.el10_0.noarch.rpm;name=aarch64_sendmail-cf;unpack=0"
SRC_URI[aarch64_sendmail-cf.sha256sum] = "3d50ed7ca2569eed0ce22c9b968d070a27de8b9fd84b6c5179d55fa705e77b5a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sendmail-doc-8.18.1-4.el10_0.noarch.rpm;name=aarch64_sendmail-doc;unpack=0"
SRC_URI[aarch64_sendmail-doc.sha256sum] = "7f57ba6a09732b22115e2c1b1fbb6d4a851fec40a2500255ea00936fdf915582"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sendmail-milter-8.18.1-4.el10_0.aarch64.rpm;name=aarch64_sendmail-milter;unpack=0"
SRC_URI[aarch64_sendmail-milter.sha256sum] = "39758b65fc9248ad2b92f77dbd1ff421a24a3d72d97881dcf5c24aa2d2ea876d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sendmail-milter-devel-8.18.1-4.el10_0.aarch64.rpm;name=aarch64_sendmail-milter-devel;unpack=0"
SRC_URI[aarch64_sendmail-milter-devel.sha256sum] = "6afcd7204250cb57c7a52784b38fc587bc95566cf1f994e44bfa243ea088ec64"

RDEPENDS:sendmail = " \
 alternatives \
 bash \
 cyrus-sasl \
 cyrus-sasl-lib \
 glibc \
 openldap \
 openssl \
 openssl-libs \
 procmail \
 setup \
 shadow-utils \
 systemd \
 tinycdb \
 virtual/coreutils \
 "
RDEPENDS:sendmail-cf = " \
 bash \
 m4 \
 sendmail \
 "
RDEPENDS:sendmail-doc = " \
 sendmail \
 "
RDEPENDS:sendmail-milter = " \
 glibc \
 "
RDEPENDS:sendmail-milter-devel = " \
 sendmail-milter \
 "
