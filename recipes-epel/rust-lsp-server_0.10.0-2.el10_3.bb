# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lsp-server"
PV = "0.10.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-lsp-server+default-devel \
 rust-lsp-server-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lsp-server-0.10.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6420ec41a658ac12d828323df47a0694d4eb6b5aa7f44d26c99da133000e51f6"

URI_aarch64_rust-lsp-server+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lsp-server+default-devel-0.10.0-2.el10_3.noarch.rpm;name=aarch64_rust-lsp-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lsp-server+default-devel}"
SRC_URI[aarch64_rust-lsp-server+default-devel.sha256sum] = "dd7bf70d9eb000f86a941e5b5498f5ec8f15b104653cda68d40724759e65407e"

URI_aarch64_rust-lsp-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lsp-server-devel-0.10.0-2.el10_3.noarch.rpm;name=aarch64_rust-lsp-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lsp-server-devel}"
SRC_URI[aarch64_rust-lsp-server-devel.sha256sum] = "9ec4184ea5721f1a70c2bdbc60f046d2542033a8513cc20768753fa4034430af"

RDEPENDS:rust-lsp-server+default-devel = " \
 cargo \
 rust-lsp-server-devel \
 "
RDEPENDS:rust-lsp-server-devel = " \
 bash \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-log+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 "
