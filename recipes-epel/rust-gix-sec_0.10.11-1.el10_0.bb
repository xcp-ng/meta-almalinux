# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-sec"
PV = "0.10.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-sec+default-devel \
 rust-gix-sec+document-features-devel \
 rust-gix-sec+serde-devel \
 rust-gix-sec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-sec-0.10.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbe6d7c63021b59bddb5a915d01ff97c50f3691673a517f2c8bc14cbbc061072"

URI_x86_64_v2_rust-gix-sec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+default-devel-0.10.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+default-devel.sha256sum] = "6e3afa41210c39ea883a03f013140d9e5369a2feede75e07a537ce5d2a4ae025"

URI_x86_64_v2_rust-gix-sec+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+document-features-devel-0.10.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+document-features-devel.sha256sum] = "ee5d8d3ecc4fcf8b4a044af054bb300e41a42336d70a8e7e626ed9ecc60e47d7"

URI_x86_64_v2_rust-gix-sec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec+serde-devel-0.10.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-sec+serde-devel.sha256sum] = "52b3a50ff197c689b5457d9e24d9ce24b82184de8a1d62209c18d544335518e2"

URI_x86_64_v2_rust-gix-sec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-sec-devel-0.10.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-sec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-sec-devel}"
SRC_URI[x86_64_v2_rust-gix-sec-devel.sha256sum] = "81e7bf39e951bc0e20a834b9c3c40559da3901d2949f5ad167ad719bfb932e89"

URI_aarch64_rust-gix-sec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+default-devel-0.10.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-sec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+default-devel}"
SRC_URI[aarch64_rust-gix-sec+default-devel.sha256sum] = "f9a0de45a5a66b5b8cf54e14f9487c904905e93bb069a93c850aaea5dca15825"

URI_aarch64_rust-gix-sec+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+document-features-devel-0.10.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-sec+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+document-features-devel}"
SRC_URI[aarch64_rust-gix-sec+document-features-devel.sha256sum] = "cc397e40e3a374b42e40e3ab0553e11034d2ab43d04f66ced46be39135ae9cfc"

URI_aarch64_rust-gix-sec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec+serde-devel-0.10.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-sec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec+serde-devel}"
SRC_URI[aarch64_rust-gix-sec+serde-devel.sha256sum] = "dca0c6559c21842627dcdd9cf665fe6fe7351024c7523599d6ce429368e1fdbd"

URI_aarch64_rust-gix-sec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-sec-devel-0.10.11-1.el10_0.noarch.rpm;name=aarch64_rust-gix-sec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-sec-devel}"
SRC_URI[aarch64_rust-gix-sec-devel.sha256sum] = "9828fdfcfa90b37ef8cc50a09b40c2cea3aed3e646ee35e9f873eaf543e14703"

RDEPENDS:rust-gix-sec+default-devel = " \
 cargo \
 rust-gix-sec-devel \
 "
RDEPENDS:rust-gix-sec+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-sec-devel \
 "
RDEPENDS:rust-gix-sec+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-gix-sec-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-sec-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 "
