# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmailtransport"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmailtransport \
 kmailtransport-devel \
 kmailtransport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmailtransport-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddf0620641ba874007c9858e1dcf7112dab1ab0699ca0e9331f546400bb168e0"

URI_x86_64_v2_kmailtransport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmailtransport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmailtransport}"
SRC_URI[x86_64_v2_kmailtransport.sha256sum] = "224514321101d8574bd01785d6ab9a5f43d7405e666c4a1cf17a4f3b3f0a7e78"

URI_x86_64_v2_kmailtransport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmailtransport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmailtransport-devel}"
SRC_URI[x86_64_v2_kmailtransport-devel.sha256sum] = "166e98ce0bfc1b446ee08695743546c300b6fae6fa336afe57533554614df6d9"

URI_x86_64_v2_kmailtransport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmailtransport-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kmailtransport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmailtransport-doc}"
SRC_URI[x86_64_v2_kmailtransport-doc.sha256sum] = "d118ed2441ed5ef2c838e6d9092bfcc96432cbc077423c8ac5367336cd6f6ad8"

URI_aarch64_kmailtransport = "${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmailtransport;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmailtransport}"
SRC_URI[aarch64_kmailtransport.sha256sum] = "fbe580e370dd35503738c7e9789d551c60887ad062115fe2242d51bd4c0e7895"

URI_aarch64_kmailtransport-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmailtransport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmailtransport-devel}"
SRC_URI[aarch64_kmailtransport-devel.sha256sum] = "b71aa98855b4ab33020cfa04d9baf4a86f2908954b09557d79227f50fab4295b"

URI_aarch64_kmailtransport-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmailtransport-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kmailtransport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmailtransport-doc}"
SRC_URI[aarch64_kmailtransport-doc.sha256sum] = "fe14985cb5238900b8e18aa1605e063da733b1c5583dc5a0f6c31859636334ec"

RDEPENDS:kmailtransport = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 ksmtp \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
RDEPENDS:kmailtransport-devel = " \
 akonadi-mime-devel \
 cmake-filesystem \
 kmailtransport \
 kmime-devel \
 "
RDEPENDS:kmailtransport-doc = " \
 "
