# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pulldown-cmark"
PV = "0.13.4"
PR = "1.el10_3"
PACKAGES = " \
 pulldown-cmark \
 rust-pulldown-cmark+default-devel \
 rust-pulldown-cmark+gen-tests-devel \
 rust-pulldown-cmark+getopts-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark+pulldown-cmark-escape-devel \
 rust-pulldown-cmark+serde-devel \
 rust-pulldown-cmark+simd-devel \
 rust-pulldown-cmark-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pulldown-cmark-0.13.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38ca6753dcf9699d86a82dff2b8d4f804884b73dbc5e341cb0d2a909b9fefe52"

URI_x86_64_v2_pulldown-cmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulldown-cmark-0.13.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulldown-cmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulldown-cmark}"
SRC_URI[x86_64_v2_pulldown-cmark.sha256sum] = "1af58fa7333b796c44178c61dd43fd9a35291b2b76a2f1549c5b2c20a42e1e7d"

URI_x86_64_v2_rust-pulldown-cmark+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+default-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+default-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+default-devel.sha256sum] = "d623fe1f8346ef21bdc9f0b2f2348c940f14b68be0316ec8eeea1ccfbf8e9432"

URI_x86_64_v2_rust-pulldown-cmark+gen-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+gen-tests-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+gen-tests-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+gen-tests-devel.sha256sum] = "0b85ab4b379e132f2a9f665d2b672e4f6e5fe16d3c2cbd9bb03d3606696cf9cf"

URI_x86_64_v2_rust-pulldown-cmark+getopts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+getopts-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+getopts-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+getopts-devel.sha256sum] = "59456bbd8a2c6f50afaaa927d35e54278b69bb33303ab9e0904285b75508c519"

URI_x86_64_v2_rust-pulldown-cmark+html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+html-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+html-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+html-devel.sha256sum] = "99f30e9d9e9e2a4f2a151497f7fead1804531e17c5bb470d35d2ee11036d4748"

URI_x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+pulldown-cmark-escape-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel.sha256sum] = "2ea5f5bec72233abdf81d690df6a0a08dcc4c2541041a494f4e580bb6ae899a3"

URI_x86_64_v2_rust-pulldown-cmark+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+serde-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+serde-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+serde-devel.sha256sum] = "1519a6cf3c4b004f3f49219ae6049d1882e36796080fd0b7e29e41f629bfd275"

URI_x86_64_v2_rust-pulldown-cmark+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+simd-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+simd-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+simd-devel.sha256sum] = "1defaa8b50bf404b83401b6ce6db44ab16b06b65b81e7f16c764851ebc1ca9f7"

URI_x86_64_v2_rust-pulldown-cmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark-devel.sha256sum] = "42b66dafc93e8133041f94d8e78856f2a8b3ecad8f130aac79723e63389f3478"

URI_aarch64_pulldown-cmark = "${EPEL_MIRROR}/aarch64/Packages/p/pulldown-cmark-0.13.4-1.el10_3.aarch64.rpm;name=aarch64_pulldown-cmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulldown-cmark}"
SRC_URI[aarch64_pulldown-cmark.sha256sum] = "6e7639edc92dd6ccc656c8f7ef2c238cc69e0484c202e72322ab95d76e95120b"

URI_aarch64_rust-pulldown-cmark+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+default-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-pulldown-cmark+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+default-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+default-devel.sha256sum] = "aa928f5509b437786fb217cf86e2221a3619a588e19c58e882fff6fa894a6c6f"

URI_aarch64_rust-pulldown-cmark+gen-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+gen-tests-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-pulldown-cmark+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+gen-tests-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+gen-tests-devel.sha256sum] = "fe9851d772d37b33f3c7675f215e00bf35b252fd3c3bf73ffbbf3dc49bf04923"

URI_aarch64_rust-pulldown-cmark+getopts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+getopts-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-pulldown-cmark+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+getopts-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+getopts-devel.sha256sum] = "e52e485d7ca980455d01db100fc349a7d59836cd663b69ea0302fef1e2c616e1"

URI_aarch64_rust-pulldown-cmark+html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+html-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-pulldown-cmark+html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+html-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+html-devel.sha256sum] = "d4a27693cb943f5ac4e93c64a6fe48b2a07885012685c64b22c5f49101d3e879"

URI_aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+pulldown-cmark-escape-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel.sha256sum] = "29fbef1b0c64b986b3a6b095fb8b1c24d0698830be7217585e5f009ea894bc87"

URI_aarch64_rust-pulldown-cmark+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+serde-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-pulldown-cmark+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+serde-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+serde-devel.sha256sum] = "c148b2d5c6a02c949a178340dd6131a73335d95558dbf8a19cd9ffe70aea9a48"

URI_aarch64_rust-pulldown-cmark+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+simd-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-pulldown-cmark+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+simd-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+simd-devel.sha256sum] = "cf62b21ae4b610166977107f884c279f5476df7a4f1c3d5a2138fe8f63bd10d6"

URI_aarch64_rust-pulldown-cmark-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark-devel}"
SRC_URI[aarch64_rust-pulldown-cmark-devel.sha256sum] = "9543d13af35043ac4a07d1a2e35f1cf209c83ed796d39e8ffce9da233a9242cd"

RDEPENDS:pulldown-cmark = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-pulldown-cmark+default-devel = " \
 cargo \
 rust-pulldown-cmark+getopts-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+gen-tests-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+getopts-devel = " \
 cargo \
 rust-getopts+default-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+html-devel = " \
 cargo \
 rust-pulldown-cmark+pulldown-cmark-escape-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+pulldown-cmark-escape-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-pulldown-cmark-escape+default-devel \
 "
RDEPENDS:rust-pulldown-cmark+serde-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-pulldown-cmark+simd-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-pulldown-cmark-escape+default-devel \
 rust-pulldown-cmark-escape+simd-devel \
 "
RDEPENDS:rust-pulldown-cmark-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-memchr+default-devel \
 rust-unicase+default-devel \
 "
