# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksystemstats"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 ksystemstats \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksystemstats-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb96529f3f20dcb413ca469dcb530e0372c4428d0537d5b42b7e83d653ff42cb"

URI_x86_64_v2_ksystemstats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksystemstats-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksystemstats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksystemstats}"
SRC_URI[x86_64_v2_ksystemstats.sha256sum] = "7903cdf6b02d5f3b31063fd1f26f002cea0f9fc2cfa4cfd1df2a4a2bc4fb64b7"

URI_aarch64_ksystemstats = "${EPEL_MIRROR}/aarch64/Packages/k/ksystemstats-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_ksystemstats;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksystemstats}"
SRC_URI[aarch64_ksystemstats.sha256sum] = "10b0aaaba010ba8f62dfbb9b0c6c38d40242b66c108c977ee1220a73dc6ef05a"

RDEPENDS:ksystemstats = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-networkmanager-qt \
 kf6-solid \
 libksysguard \
 libnl3 \
 libstdc++ \
 lm_sensors-libs \
 qt6-qtbase \
 systemd-libs \
 "
