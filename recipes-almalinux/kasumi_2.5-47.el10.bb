# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kasumi"
PV = "2.5"
PR = "47.el10"
PACKAGES = " \
 kasumi-common \
 kasumi-unicode \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kasumi-2.5-47.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90f5a438241368e25cbb4f625c4507a256c38220f6d8cc66a1940311f35b7358"

URI_x86_64_v2_kasumi-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kasumi-common-2.5-47.el10.noarch.rpm;name=x86_64_v2_kasumi-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kasumi-common}"
SRC_URI[x86_64_v2_kasumi-common.sha256sum] = "8bfc9f29c27c5c43121fe73a5f920928e71f1a3c1ddd3ccf19e4d5a4df1b5548"

URI_x86_64_v2_kasumi-unicode = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kasumi-unicode-2.5-47.el10.x86_64_v2.rpm;name=x86_64_v2_kasumi-unicode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kasumi-unicode}"
SRC_URI[x86_64_v2_kasumi-unicode.sha256sum] = "bc17d117cd156df7559b4f7e6da8068823793abc4ebecd82c90d591abc0be615"

URI_aarch64_kasumi-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kasumi-common-2.5-47.el10.noarch.rpm;name=aarch64_kasumi-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kasumi-common}"
SRC_URI[aarch64_kasumi-common.sha256sum] = "8bfc9f29c27c5c43121fe73a5f920928e71f1a3c1ddd3ccf19e4d5a4df1b5548"

URI_aarch64_kasumi-unicode = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kasumi-unicode-2.5-47.el10.aarch64.rpm;name=aarch64_kasumi-unicode;unpack=0"
SRC_URI:append = " ${URI_aarch64_kasumi-unicode}"
SRC_URI[aarch64_kasumi-unicode.sha256sum] = "a459d85b4393e9c630bf78df3a0e85b6ab164cb757ac9c61a2acbbebb06b72e9"

RDEPENDS:kasumi-common = " \
 "
RDEPENDS:kasumi-unicode = " \
 anthy-unicode \
 glib2 \
 glibc \
 gtk3 \
 kasumi-common \
 libgcc \
 libstdc++ \
 "
