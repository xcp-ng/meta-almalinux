# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "authselect"
PV = "1.5.2"
PR = "1.el10"
PACKAGES = " \
 authselect \
 authselect-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/authselect-1.5.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81c4e47e209ef89aec29909fe95e25d4de20f154d3ab4100e2c861f44df8e24f"

URI_x86_64_v2_authselect = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/authselect-1.5.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_authselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_authselect}"
SRC_URI[x86_64_v2_authselect.sha256sum] = "58508426b02dca9e1f1df37736a12c1348edaafbda88acaccc3575bbd64bbc0a"

URI_x86_64_v2_authselect-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/authselect-libs-1.5.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_authselect-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_authselect-libs}"
SRC_URI[x86_64_v2_authselect-libs.sha256sum] = "e75846ffd7dd5e84885d5c2fa59b39282a9fbd9a00a2ba19f614fc9e39f1b3e4"

URI_aarch64_authselect = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/authselect-1.5.2-1.el10.aarch64.rpm;name=aarch64_authselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_authselect}"
SRC_URI[aarch64_authselect.sha256sum] = "abf63f0ae2e986002b86ce1fae1fea40840a47ca48a2d6e84a3237f299cc5a6a"

URI_aarch64_authselect-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/authselect-libs-1.5.2-1.el10.aarch64.rpm;name=aarch64_authselect-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_authselect-libs}"
SRC_URI[aarch64_authselect-libs.sha256sum] = "cf64e55df36643000fbeb65460cef4075c551c72c59b0b97c7da606fc335ac90"

RDEPENDS:authselect = " \
 authselect-libs \
 bash \
 glibc \
 popt \
 "
RDEPENDS:authselect-libs = " \
 bash \
 glibc \
 libselinux \
 sed \
 virtual/coreutils \
 "
