# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mdbook-core"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-mdbook-core+default-devel \
 rust-mdbook-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mdbook-core-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6363e80f9787ec60a86c52a5526867167e266fc02de4f423171e3a9983c38468"

URI_x86_64_v2_rust-mdbook-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-core+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-core+default-devel}"
SRC_URI[x86_64_v2_rust-mdbook-core+default-devel.sha256sum] = "c1fe70b4ec1c5b8bf18019eb4bec4365b77360d2aa7586cb428341717c719bb2"

URI_x86_64_v2_rust-mdbook-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-core-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-core-devel}"
SRC_URI[x86_64_v2_rust-mdbook-core-devel.sha256sum] = "23ae3cc349455ba05576af5f97e5d090f2e708a6ba682016bc8c5c98c3718b55"

URI_aarch64_rust-mdbook-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-core+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-core+default-devel}"
SRC_URI[aarch64_rust-mdbook-core+default-devel.sha256sum] = "3b9b3e7f1ef788a52793470beeed0ceb7d2202c505085ea9b54f49be4436d08a"

URI_aarch64_rust-mdbook-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-core-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-core-devel}"
SRC_URI[aarch64_rust-mdbook-core-devel.sha256sum] = "ae5784588c6651b86a136005d2db70e8e1119add574fb38e04475c16fc55871f"

RDEPENDS:rust-mdbook-core+default-devel = " \
 cargo \
 rust-mdbook-core-devel \
 "
RDEPENDS:rust-mdbook-core-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-toml+default-devel \
 rust-tracing+default-devel \
 "
