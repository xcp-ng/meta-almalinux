# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kongress"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kongress \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kongress-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b056a138f21444ad046875bd77eb75458750620305d2e4a7555c96b1b80cf249"

URI_x86_64_v2_kongress = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kongress-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kongress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kongress}"
SRC_URI[x86_64_v2_kongress.sha256sum] = "c790aa640752e527a6d02f5bdb1e8aec17a91031506978fb75a6227326e6c63f"

URI_aarch64_kongress = "${EPEL_MIRROR}/aarch64/Packages/k/kongress-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kongress;unpack=0"
SRC_URI:append = " ${URI_aarch64_kongress}"
SRC_URI[aarch64_kongress.sha256sum] = "615c7a00981efa41d71d94fb9d0284c393688ecbd1a5375dd1690292e955f50d"

RDEPENDS:kongress = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kosmindoormap \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtpositioning \
 "
