# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "AMF"
PE = "1"
PV = "1.5.2"
PR = "1.el10_2"
PACKAGES = " \
 AMF-devel \
 AMF-docs \
 AMF-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/AMF-1.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50fc397a39d92d5d2b70ce401e21ff0c900f8b66b35f2726ec7259aab3569145"

URI_x86_64_v2_AMF-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-devel-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-devel}"
SRC_URI[x86_64_v2_AMF-devel.sha256sum] = "ca957de9e5da2febd2696754e71944018775f9ce00e73bf3f2fb5d613bee02ae"

URI_x86_64_v2_AMF-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-docs-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-docs}"
SRC_URI[x86_64_v2_AMF-docs.sha256sum] = "7d372abf0e3620084b3081d3222a6eaf261fda1fa61510653116b6b40b221e76"

URI_x86_64_v2_AMF-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/AMF-samples-1.5.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_AMF-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_AMF-samples}"
SRC_URI[x86_64_v2_AMF-samples.sha256sum] = "96fc278db9965b1c0ba4f641a5263629881e94d44997ff31a9014747aa662b8f"

URI_aarch64_AMF-devel = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-devel-1.5.2-1.el10_2.noarch.rpm;name=aarch64_AMF-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-devel}"
SRC_URI[aarch64_AMF-devel.sha256sum] = "33388d882b20c20978233ab5155d358ecb0aa7db2aad96409d159830c965b3fe"

URI_aarch64_AMF-docs = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-docs-1.5.2-1.el10_2.noarch.rpm;name=aarch64_AMF-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-docs}"
SRC_URI[aarch64_AMF-docs.sha256sum] = "e30f2ecc34cf14dc8259d4bc12f0f91c2be8ffdfa23fcb5a90a83aa6189abed3"

URI_aarch64_AMF-samples = "${EPEL_MIRROR}/aarch64/Packages/a/AMF-samples-1.5.2-1.el10_2.noarch.rpm;name=aarch64_AMF-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_AMF-samples}"
SRC_URI[aarch64_AMF-samples.sha256sum] = "c53ecabb718006bacdd91f48b670cf3f0f8df91a6a8daf8af9db8cfca1f53b2c"

RDEPENDS:AMF-devel = " \
 "
RDEPENDS:AMF-docs = " \
 "
RDEPENDS:AMF-samples = " \
 "
