# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-embed-impl"
PV = "8.11.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rust-embed-impl+debug-embed-devel \
 rust-rust-embed-impl+default-devel \
 rust-rust-embed-impl+deterministic-timestamps-devel \
 rust-rust-embed-impl+include-exclude-devel \
 rust-rust-embed-impl+interpolate-folder-path-devel \
 rust-rust-embed-impl+shellexpand-devel \
 rust-rust-embed-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-embed-impl-8.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb4db76c504fbde92ec57dd75f1ce7874d0dcc4631d18e16f16dde99abee8601"

URI_x86_64_v2_rust-rust-embed-impl+debug-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+debug-embed-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+debug-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+debug-embed-devel.sha256sum] = "7f155b4f7563ffa16fa6f94d10ff0abead05916dea16d2d19fe25f4ed270e981"

URI_x86_64_v2_rust-rust-embed-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+default-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+default-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+default-devel.sha256sum] = "19ad3035b9d9080243ecdafcb9825d302ff26b3ed2038b30762c325e94afce47"

URI_x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+deterministic-timestamps-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel.sha256sum] = "d11a31062efc347005071393968f380a3ae8bb3f964c02d4612fecbab4634eb5"

URI_x86_64_v2_rust-rust-embed-impl+include-exclude-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+include-exclude-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+include-exclude-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+include-exclude-devel.sha256sum] = "4bffb7e2e923cbeac38f8b2493140b6c687946ba36f4b9d818907fc7099e5250"

URI_x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+interpolate-folder-path-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel.sha256sum] = "6619023e0c9f8f4bc185c5029f481c428d9a90a1743720c5b80d2a3beed0129e"

URI_x86_64_v2_rust-rust-embed-impl+shellexpand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+shellexpand-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+shellexpand-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+shellexpand-devel.sha256sum] = "6f28833ddecf3a8e2ee15b8ccf679bf2f35d00f7fdfec478a4085991609d6c4e"

URI_x86_64_v2_rust-rust-embed-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl-devel-8.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl-devel.sha256sum] = "d8a080d8b060f15d4e6aba9c10f46de0df52afe02fd7823f867b236c3a269773"

URI_aarch64_rust-rust-embed-impl+debug-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+debug-embed-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-impl+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+debug-embed-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+debug-embed-devel.sha256sum] = "49263e44c29aec848e4579a3897fca4a59cc1cf5b06dee398e9d4eb157c14673"

URI_aarch64_rust-rust-embed-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+default-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+default-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+default-devel.sha256sum] = "7732cdfcaa4de0a151e9520d8de8837e8261c489568d7b7104c51c87a722a478"

URI_aarch64_rust-rust-embed-impl+deterministic-timestamps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+deterministic-timestamps-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-impl+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+deterministic-timestamps-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+deterministic-timestamps-devel.sha256sum] = "b77b951aa581990450b82fe4bbf21ec2c5cf7b0a692c77e9358a4e8295736169"

URI_aarch64_rust-rust-embed-impl+include-exclude-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+include-exclude-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-impl+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+include-exclude-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+include-exclude-devel.sha256sum] = "bcd5105271100725ee83048351e2fc046fae469da49a278ebb60d4bd1c676efc"

URI_aarch64_rust-rust-embed-impl+interpolate-folder-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+interpolate-folder-path-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-impl+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+interpolate-folder-path-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+interpolate-folder-path-devel.sha256sum] = "ca563a3c4720ebf2ca2c1968473d34dbb8ff9893f933a6c475e1a55630a00b7e"

URI_aarch64_rust-rust-embed-impl+shellexpand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+shellexpand-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-impl+shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+shellexpand-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+shellexpand-devel.sha256sum] = "9a3ff6f1793f14e6d5f68f51aaca836c370c7547004972ef5de1e9e620ab3cb9"

URI_aarch64_rust-rust-embed-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl-devel-8.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust-embed-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl-devel}"
SRC_URI[aarch64_rust-rust-embed-impl-devel.sha256sum] = "78b8d11ba0ad3535659e2459e532be51f78fff2df452456ee5199792d08d13c2"

RDEPENDS:rust-rust-embed-impl+debug-embed-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+default-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+deterministic-timestamps-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+include-exclude-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 rust-rust-embed-utils+include-exclude-devel \
 "
RDEPENDS:rust-rust-embed-impl+interpolate-folder-path-devel = " \
 cargo \
 rust-rust-embed-impl+shellexpand-devel \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+shellexpand-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 rust-shellexpand+default-devel \
 "
RDEPENDS:rust-rust-embed-impl-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rust-embed-utils+default-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 rust-walkdir+default-devel \
 "
