# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailcommon"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 mailcommon \
 mailcommon-devel \
 mailcommon-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mailcommon-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5aaf5964f6fea65bdb97b8f4b1ae97aa7049b1533f7558381025d45fbe7a8d2"

URI_x86_64_v2_mailcommon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon}"
SRC_URI[x86_64_v2_mailcommon.sha256sum] = "aaf9f7c396c4abb4a5273f11627838b9d23b4a99c265e85d3e525df8c659a9ae"

URI_x86_64_v2_mailcommon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon-devel}"
SRC_URI[x86_64_v2_mailcommon-devel.sha256sum] = "f68c46e6a8d946312434cfbe8e360a1bf267980d2cfc7f1966575287843cf4cb"

URI_x86_64_v2_mailcommon-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mailcommon-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon-doc}"
SRC_URI[x86_64_v2_mailcommon-doc.sha256sum] = "ad0083249b531b18f3b345c601f519117e54b6b66ae2c53e6e604c39e786ae47"

URI_aarch64_mailcommon = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_mailcommon;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon}"
SRC_URI[aarch64_mailcommon.sha256sum] = "b50a3459434ae82668dd996945639b3fdc1bc1bcebe5997b03fd6e20060aef52"

URI_aarch64_mailcommon-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_mailcommon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon-devel}"
SRC_URI[aarch64_mailcommon-devel.sha256sum] = "2b307996ead83745ab6eabb4446f558141456f060184783dc9f9d7e41b22af1c"

URI_aarch64_mailcommon-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_mailcommon-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon-doc}"
SRC_URI[aarch64_mailcommon-doc.sha256sum] = "df97dc17af4db392bd6dad3b5695b7897360824894d99cd63f231c3b5848124f"

RDEPENDS:mailcommon = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgmepp \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libkleo \
 libstdc++ \
 mailimporter \
 messagelib \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
RDEPENDS:mailcommon-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib-devel \
 pimcommon-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailcommon-doc = " \
 "
