# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "at"
PV = "3.2.5"
PR = "13.el10_0"
PACKAGES = " \
 at \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/at-3.2.5-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8245cc3462825c956e5a91d63c797f1b3c63e7ba05899559a15678f4bec79416"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/at-3.2.5-13.el10_0.x86_64_v2.rpm;name=x86_64_v2_at;unpack=0"
SRC_URI[x86_64_v2_at.sha256sum] = "08e212800dd0d2f16a27455538e0bd5688d3dba60df1fd9f090f2dbaa1e6030a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/at-3.2.5-13.el10_0.aarch64.rpm;name=aarch64_at;unpack=0"
SRC_URI[aarch64_at.sha256sum] = "e85e8d30812781a33343f262d771fe716d2fb2d2bdeec4f21bba31e28cc66f26"

RDEPENDS:at = " \
 bash \
 glibc \
 libselinux \
 systemd \
 "
