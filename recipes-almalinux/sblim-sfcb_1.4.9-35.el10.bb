# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sblim-sfcb"
PV = "1.4.9"
PR = "35.el10"
PACKAGES = " \
 sblim-sfcb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sblim-sfcb-1.4.9-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28fb26d24875c475693c40044553eb458461e2d1b5eeb9a1635a6ccd45c0cc69"

URI_x86_64_v2_sblim-sfcb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sblim-sfcb-1.4.9-35.el10.x86_64_v2.rpm;name=x86_64_v2_sblim-sfcb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sblim-sfcb}"
SRC_URI[x86_64_v2_sblim-sfcb.sha256sum] = "0e4554b49c6e7b58ad5fdcfc7f0e9186c5861a982b47462eb04cd106798e1599"
RPROVIDES:sblim-sfcb:append:x86_64_v2 = " virtual/cim-server"

URI_aarch64_sblim-sfcb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sblim-sfcb-1.4.9-35.el10.aarch64.rpm;name=aarch64_sblim-sfcb;unpack=0"
SRC_URI:append = " ${URI_aarch64_sblim-sfcb}"
SRC_URI[aarch64_sblim-sfcb.sha256sum] = "9adef32624cf1c1cfc0c821e6ca67c0869a9b791cb7b77d38d5e5772cdde489a"
RPROVIDES:sblim-sfcb:append:aarch64 = " virtual/cim-server"

RDEPENDS:sblim-sfcb = " \
 bash \
 cim-schema \
 glibc \
 openslp \
 openssl-libs \
 pam-libs \
 perl-Getopt-Long \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 sblim-sfcCommon \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
