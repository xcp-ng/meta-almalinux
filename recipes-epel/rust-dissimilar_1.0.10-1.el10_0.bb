# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dissimilar"
PV = "1.0.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-dissimilar+default-devel \
 rust-dissimilar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dissimilar-1.0.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3542f20eb1666f112de82f0397f6cbcf3c2791e6229f2f9e6b7b442f58a7c78"

URI_x86_64_v2_rust-dissimilar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dissimilar+default-devel-1.0.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dissimilar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dissimilar+default-devel}"
SRC_URI[x86_64_v2_rust-dissimilar+default-devel.sha256sum] = "f236cf52d47eb5f894ae1b421ea980b91452cd88a65aed50a94e511241d0fe78"

URI_x86_64_v2_rust-dissimilar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dissimilar-devel-1.0.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dissimilar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dissimilar-devel}"
SRC_URI[x86_64_v2_rust-dissimilar-devel.sha256sum] = "3814d5236c2497f33210e8519e920e4de8a75a188c13528cd0e37074f7dd804c"

URI_aarch64_rust-dissimilar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dissimilar+default-devel-1.0.10-1.el10_0.noarch.rpm;name=aarch64_rust-dissimilar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dissimilar+default-devel}"
SRC_URI[aarch64_rust-dissimilar+default-devel.sha256sum] = "7e3f8bb37968b524c569f69b6d42bedc33a45082e2aa2c995c3d0fba8e8409c0"

URI_aarch64_rust-dissimilar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dissimilar-devel-1.0.10-1.el10_0.noarch.rpm;name=aarch64_rust-dissimilar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dissimilar-devel}"
SRC_URI[aarch64_rust-dissimilar-devel.sha256sum] = "ffebe49f7627fbad6f8221f5a094068fc9ef186160a7b1948cfe5741d9f4ef8b"

RDEPENDS:rust-dissimilar+default-devel = " \
 cargo \
 rust-dissimilar-devel \
 "
RDEPENDS:rust-dissimilar-devel = " \
 cargo \
 rust \
 "
