# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-buffer"
PV = "57.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-arrow-buffer+default-devel \
 rust-arrow-buffer+pool-devel \
 rust-arrow-buffer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-buffer-57.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4515e506b81f9329ffb7467ae0b94470a61ebab1af2d9454e3a957820a2d7ef"

URI_x86_64_v2_rust-arrow-buffer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-buffer+default-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-buffer+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-buffer+default-devel.sha256sum] = "0ed132edcbd8633ad30c010dee3450b2f95911f2ae68516bc8a0c8bcc1e87954"

URI_x86_64_v2_rust-arrow-buffer+pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-buffer+pool-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-buffer+pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-buffer+pool-devel}"
SRC_URI[x86_64_v2_rust-arrow-buffer+pool-devel.sha256sum] = "6229660c53d44a8a7fd8105433dee8c70762de2a4be38a930c33ce7bc2f2d2e0"

URI_x86_64_v2_rust-arrow-buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-buffer-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-buffer-devel}"
SRC_URI[x86_64_v2_rust-arrow-buffer-devel.sha256sum] = "713ed8f0a8ff0cf3385edd38d1b984a4b72c097f71261e0576c7f3becf233a56"

URI_aarch64_rust-arrow-buffer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-buffer+default-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-buffer+default-devel}"
SRC_URI[aarch64_rust-arrow-buffer+default-devel.sha256sum] = "54b1e33d45ea9968401e361ae2a099bb38f201b3de948fa8bd8b23718a817a6b"

URI_aarch64_rust-arrow-buffer+pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-buffer+pool-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-buffer+pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-buffer+pool-devel}"
SRC_URI[aarch64_rust-arrow-buffer+pool-devel.sha256sum] = "8857a8b3be594db1299c8e5c6c1995601f5b9409f4ddecc40a496c0fa82b9b28"

URI_aarch64_rust-arrow-buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-buffer-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-buffer-devel}"
SRC_URI[aarch64_rust-arrow-buffer-devel.sha256sum] = "bbb305fa26ebfcfb25991e124e3b78b726f4996ea7c76d036556495829c3a9f5"

RDEPENDS:rust-arrow-buffer+default-devel = " \
 cargo \
 rust-arrow-buffer-devel \
 "
RDEPENDS:rust-arrow-buffer+pool-devel = " \
 cargo \
 rust-arrow-buffer-devel \
 "
RDEPENDS:rust-arrow-buffer-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-half-devel \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 rust-num-traits+std-devel \
 rust-num-traits-devel \
 "
