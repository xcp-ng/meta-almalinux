# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-actor"
PV = "0.35.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-actor+default-devel \
 rust-gix-actor+document-features-devel \
 rust-gix-actor+serde-devel \
 rust-gix-actor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-actor-0.35.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6952eeafc0aea92d0b7aeff96dcb978af2fe189a43dfd650f4143f11beea8ab2"

URI_x86_64_v2_rust-gix-actor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+default-devel-0.35.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+default-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+default-devel.sha256sum] = "a05810e013cd263de7d589084bfc7c88cc2ae19e20b2d93d53dbd77caae1c4e3"

URI_x86_64_v2_rust-gix-actor+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+document-features-devel-0.35.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+document-features-devel.sha256sum] = "08c34385172881b5f646cb87bd0565c67517fc942ce758a93b9259b8a02ca50e"

URI_x86_64_v2_rust-gix-actor+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor+serde-devel-0.35.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-actor+serde-devel.sha256sum] = "88f91d438f27f86818511cc4f1f8e7760c02a62a780860fa804d4becf9235304"

URI_x86_64_v2_rust-gix-actor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-actor-devel-0.35.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-actor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-actor-devel}"
SRC_URI[x86_64_v2_rust-gix-actor-devel.sha256sum] = "09461c9c84627afeccd5639ee2ed213df332b1c128c930a281391fe7117b40ab"

URI_aarch64_rust-gix-actor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+default-devel-0.35.4-1.el10_1.noarch.rpm;name=aarch64_rust-gix-actor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+default-devel}"
SRC_URI[aarch64_rust-gix-actor+default-devel.sha256sum] = "32f342845a4553baad26c95ee0e35b141bd6b8da6e0b2ce3bc9e91b8bfc1a930"

URI_aarch64_rust-gix-actor+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+document-features-devel-0.35.4-1.el10_1.noarch.rpm;name=aarch64_rust-gix-actor+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+document-features-devel}"
SRC_URI[aarch64_rust-gix-actor+document-features-devel.sha256sum] = "3628978f06fc79087fd21d362d79ac6e5700789f850062443332792afa445c25"

URI_aarch64_rust-gix-actor+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor+serde-devel-0.35.4-1.el10_1.noarch.rpm;name=aarch64_rust-gix-actor+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor+serde-devel}"
SRC_URI[aarch64_rust-gix-actor+serde-devel.sha256sum] = "7734524caab10dd09914ec09dc090980ef5d3761a0449b909423306695fd4b9e"

URI_aarch64_rust-gix-actor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-actor-devel-0.35.4-1.el10_1.noarch.rpm;name=aarch64_rust-gix-actor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-actor-devel}"
SRC_URI[aarch64_rust-gix-actor-devel.sha256sum] = "fd1cbc8ecdb225c65280dc98f464fc11293d16437d22b72f3260b77e85974117"

RDEPENDS:rust-gix-actor+default-devel = " \
 cargo \
 rust-gix-actor-devel \
 "
RDEPENDS:rust-gix-actor+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-actor-devel \
 "
RDEPENDS:rust-gix-actor+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor-devel \
 rust-gix-date+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-actor-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-utils+default-devel \
 rust-itoa+default-devel \
 rust-thiserror+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
