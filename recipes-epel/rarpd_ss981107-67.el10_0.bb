# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rarpd"
PV = "ss981107"
PR = "67.el10_0"
PACKAGES = " \
 rarpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rarpd-ss981107-67.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97d0d5d2d7224b68cc2e18c594fcb429b0d7f507541d65b52312f56170a4209f"

URI_x86_64_v2_rarpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rarpd-ss981107-67.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rarpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rarpd}"
SRC_URI[x86_64_v2_rarpd.sha256sum] = "ee6b7e3a7f09023815af7f85b98b6831300a7fc1c83aa74cd84236b1306a2961"

URI_aarch64_rarpd = "${EPEL_MIRROR}/aarch64/Packages/r/rarpd-ss981107-67.el10_0.aarch64.rpm;name=aarch64_rarpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_rarpd}"
SRC_URI[aarch64_rarpd.sha256sum] = "2c1a143cd5a111f6f5de0e1f0723948d813974392900a803903934bf526dc90d"

RDEPENDS:rarpd = " \
 bash \
 glibc \
 systemd \
 "
