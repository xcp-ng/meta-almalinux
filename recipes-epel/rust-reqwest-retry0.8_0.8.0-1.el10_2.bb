# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-retry0.8"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqwest-retry0.8+default-devel \
 rust-reqwest-retry0.8+tracing-devel \
 rust-reqwest-retry0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-retry0.8-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7541dfcf883fc9f471c7357710ce90ba435a07ce1b2aaa489396cd6251474f8f"

URI_x86_64_v2_rust-reqwest-retry0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry0.8+default-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry0.8+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry0.8+default-devel.sha256sum] = "7dde135251b6312c32af7c112fe6d1eb39279b60d3f6c5117db37f7084a68084"

URI_x86_64_v2_rust-reqwest-retry0.8+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry0.8+tracing-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry0.8+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry0.8+tracing-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry0.8+tracing-devel.sha256sum] = "78f9fe40f824d44d32eab83544fc4868a1532868699c1aeb817cc22fbe3c658e"

URI_x86_64_v2_rust-reqwest-retry0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry0.8-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry0.8-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry0.8-devel.sha256sum] = "28bf77473abb36c0b48e6d41bb9ef3e26a91620c8ab0107e63bb476a611e6a66"

URI_aarch64_rust-reqwest-retry0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry0.8+default-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-retry0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry0.8+default-devel}"
SRC_URI[aarch64_rust-reqwest-retry0.8+default-devel.sha256sum] = "770801124896b1098ca22c40707b587d4e417b62f8b7a273cf3a5f736ece7958"

URI_aarch64_rust-reqwest-retry0.8+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry0.8+tracing-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-retry0.8+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry0.8+tracing-devel}"
SRC_URI[aarch64_rust-reqwest-retry0.8+tracing-devel.sha256sum] = "ac9f8ae686ab495c73bdf576eabdcb64b0aae81078d85b482c060800d939606f"

URI_aarch64_rust-reqwest-retry0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry0.8-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-retry0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry0.8-devel}"
SRC_URI[aarch64_rust-reqwest-retry0.8-devel.sha256sum] = "8f344e9aa5a291789c1deff1ee5346eee76c7b66be6f367a654b32ae6f958e9b"

RDEPENDS:rust-reqwest-retry0.8+default-devel = " \
 cargo \
 rust-reqwest-retry0.8+tracing-devel \
 rust-reqwest-retry0.8-devel \
 "
RDEPENDS:rust-reqwest-retry0.8+tracing-devel = " \
 cargo \
 rust-reqwest-retry0.8-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-reqwest-retry0.8-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-futures+default-devel \
 rust-http+default-devel \
 rust-hyper+default-devel \
 rust-reqwest-middleware0.4+default-devel \
 rust-reqwest0.12-devel \
 rust-retry-policies+default-devel \
 rust-thiserror+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
