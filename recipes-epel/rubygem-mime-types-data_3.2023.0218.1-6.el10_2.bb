# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-mime-types-data"
PV = "3.2023.0218.1"
PR = "6.el10_2"
PACKAGES = " \
 rubygem-mime-types-data \
 rubygem-mime-types-data-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-mime-types-data-3.2023.0218.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20754ea81fdd47c46e4cf64ddbd4e9a76d8aa63622e3c294efec33e0014ff453"

URI_x86_64_v2_rubygem-mime-types-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mime-types-data-3.2023.0218.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mime-types-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mime-types-data}"
SRC_URI[x86_64_v2_rubygem-mime-types-data.sha256sum] = "824cd117e6996acfb690d430c5b7674f43d62ddc872373df9780578fb467c90e"

URI_x86_64_v2_rubygem-mime-types-data-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mime-types-data-doc-3.2023.0218.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mime-types-data-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mime-types-data-doc}"
SRC_URI[x86_64_v2_rubygem-mime-types-data-doc.sha256sum] = "095bb292e1ec8c81fd31ca2c5b6b502549e2f06c0d8d38c144d4fe427a5bd192"

URI_aarch64_rubygem-mime-types-data = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mime-types-data-3.2023.0218.1-6.el10_2.noarch.rpm;name=aarch64_rubygem-mime-types-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mime-types-data}"
SRC_URI[aarch64_rubygem-mime-types-data.sha256sum] = "46d7d4ceaa70cc909ee5fb9819d0bca4f7086deefe54dc29ec0ea428624deeef"

URI_aarch64_rubygem-mime-types-data-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mime-types-data-doc-3.2023.0218.1-6.el10_2.noarch.rpm;name=aarch64_rubygem-mime-types-data-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mime-types-data-doc}"
SRC_URI[aarch64_rubygem-mime-types-data-doc.sha256sum] = "9134f032e28168042df8f8599e1bdaedf3f4d1b55791ca4829bacd8107d36c37"

RDEPENDS:rubygem-mime-types-data = " \
 rubygems \
 "
RDEPENDS:rubygem-mime-types-data-doc = " \
 rubygem-mime-types-data \
 "
