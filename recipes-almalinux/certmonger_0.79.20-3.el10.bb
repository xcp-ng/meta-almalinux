# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "certmonger"
PV = "0.79.20"
PR = "3.el10"
PACKAGES = " \
 certmonger \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/certmonger-0.79.20-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffefa96de39e8a96cf166f7a25f7c244330aa02a9b432cf1b1da30b25254763a"

URI_x86_64_v2_certmonger = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/certmonger-0.79.20-3.el10.x86_64_v2.rpm;name=x86_64_v2_certmonger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_certmonger}"
SRC_URI[x86_64_v2_certmonger.sha256sum] = "6a1e9d4bcee0799158be2fbc96325fc40d2fc8cb3f2c4596dda2a9d046826ef1"

URI_aarch64_certmonger = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/certmonger-0.79.20-3.el10.aarch64.rpm;name=aarch64_certmonger;unpack=0"
SRC_URI:append = " ${URI_aarch64_certmonger}"
SRC_URI[aarch64_certmonger.sha256sum] = "796eccffecf418e199ae3c99aeb8d8b751f83e5e225376b9257203e62cd24c38"

RDEPENDS:certmonger = " \
 bash \
 dbus \
 dbus-libs \
 dbus-tools \
 glibc \
 jansson \
 krb5-libs \
 libcom_err \
 libidn2 \
 libtalloc \
 libtevent \
 libuuid \
 libxml2 \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 popt \
 sed \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
