# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuna"
PV = "0.20"
PR = "4.el10"
PACKAGES = " \
 tuna \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tuna-0.20-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5b42f9848f9bd2fac3cb626a28683defa78d6aad0942ba84edf4ce601d9483e"

URI_x86_64_v2_tuna = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuna-0.20-4.el10.noarch.rpm;name=x86_64_v2_tuna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuna}"
SRC_URI[x86_64_v2_tuna.sha256sum] = "170aa71d8e59cda02b09be41b820b58fdc46341e3314bdd3de89e7010dea7642"

URI_aarch64_tuna = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuna-0.20-4.el10.noarch.rpm;name=aarch64_tuna;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuna}"
SRC_URI[aarch64_tuna.sha256sum] = "170aa71d8e59cda02b09be41b820b58fdc46341e3314bdd3de89e7010dea7642"

RDEPENDS:tuna = " \
 python3 \
 python3-linux-procfs \
 "
