# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdepim-runtime"
PE = "1"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdepim-runtime \
 kdepim-runtime-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdepim-runtime-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5aa006e8446f4cc68295e00b11b45264acb89561c474cfb3b9a75c77ee2cf9bd"

URI_x86_64_v2_kdepim-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-runtime-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdepim-runtime}"
SRC_URI[x86_64_v2_kdepim-runtime.sha256sum] = "29527111e3b9922f80bf4bde6a50b904a10442885003f50db3e6f719cf7a7ff9"

URI_x86_64_v2_kdepim-runtime-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-runtime-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-runtime-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdepim-runtime-libs}"
SRC_URI[x86_64_v2_kdepim-runtime-libs.sha256sum] = "b48d6bdbe95618a22dedd3e4fee02e052b6558f9d17d5510d12d1885dcb441d9"

URI_aarch64_kdepim-runtime = "${EPEL_MIRROR}/aarch64/Packages/k/kdepim-runtime-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdepim-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdepim-runtime}"
SRC_URI[aarch64_kdepim-runtime.sha256sum] = "8fe23912a76476f53b761e44e0cc7c57087a2bb7808dbe8661a94e439aa75f79"

URI_aarch64_kdepim-runtime-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kdepim-runtime-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdepim-runtime-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdepim-runtime-libs}"
SRC_URI[aarch64_kdepim-runtime-libs.sha256sum] = "d4d009c8926afb2c6550d44047a5771365dcf0a483c46ed09aec3f8bdb979a36"

RDEPENDS:kdepim-runtime = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 cyrus-sasl-lib \
 glibc \
 kdepim-runtime-libs \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdav \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kidentitymanagement \
 kimap \
 kmailtransport \
 kmbox \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libkgapi \
 libkolabxml \
 libstdc++ \
 qca-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtnetworkauth \
 qt6-qtspeech \
 qt6-qtwebengine \
 qtkeychain-qt6 \
 "
RDEPENDS:kdepim-runtime-libs = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifyconfig \
 kf6-kwidgetsaddons \
 kimap \
 kldap \
 kmailtransport \
 kmbox \
 kmime \
 libgcc \
 libkgapi \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
