# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cassandra-Client"
PV = "0.21"
PR = "3.el10_1"
PACKAGES = " \
 perl-Cassandra-Client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cassandra-Client-0.21-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b23fe22174cf69fa1fa9ce5d24c2f319977220b87cb9bb103aa675b58c6332b4"

URI_x86_64_v2_perl-Cassandra-Client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cassandra-Client-0.21-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Cassandra-Client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cassandra-Client}"
SRC_URI[x86_64_v2_perl-Cassandra-Client.sha256sum] = "7d85637cce2b2effa68131034a25ae469e35244f18914fc135ba9eccf32b760b"

URI_aarch64_perl-Cassandra-Client = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cassandra-Client-0.21-3.el10_1.aarch64.rpm;name=aarch64_perl-Cassandra-Client;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cassandra-Client}"
SRC_URI[aarch64_perl-Cassandra-Client.sha256sum] = "91fdcd7149b99abbef4fe16da00d08173144c0cb82ac497cabc1d0f93989f207"

RDEPENDS:perl-Cassandra-Client = " \
 glibc \
 perl-AnyEvent \
 perl-AnyEvent-XSPromises \
 perl-Cassandra-Client \
 perl-Clone \
 perl-Devel-GlobalDestruction \
 perl-EV \
 perl-Encode \
 perl-Errno \
 perl-Exporter \
 perl-IO \
 perl-IO-Socket-INET6 \
 perl-Math-BigInt \
 perl-Net-SSLeay \
 perl-Ref-Util \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Time-HiRes \
 perl-constant \
 perl-if \
 perl-libs \
 perl-overload \
 perl-parent \
 perl-vars \
 "
