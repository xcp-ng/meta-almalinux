# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-elixir"
PV = "0.3.5"
PR = "3.el10_3"
PACKAGES = " \
 rust-tree-sitter-elixir+default-devel \
 rust-tree-sitter-elixir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-elixir-0.3.5-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85a36beeb53ef9dec3bd371aae3f34303edd531eeb7dbabb80c33765677860a3"

URI_x86_64_v2_rust-tree-sitter-elixir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elixir+default-devel-0.3.5-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elixir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elixir+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elixir+default-devel.sha256sum] = "e6df2689c2216a90ecffd07d08b83d9f0331affbb07610e223b4c4b603e04ba2"

URI_x86_64_v2_rust-tree-sitter-elixir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-elixir-devel-0.3.5-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-elixir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-elixir-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-elixir-devel.sha256sum] = "b65f2e03b19c426fbfe5c9cc037e96b84ec6c07a3ecb1c41e9f8ba11ffde56ba"

URI_aarch64_rust-tree-sitter-elixir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elixir+default-devel-0.3.5-3.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-elixir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elixir+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-elixir+default-devel.sha256sum] = "4e8c6bdbe57df4e2f4e67da25d856fa89d4139ba20dd08165dd5dfda14554afe"

URI_aarch64_rust-tree-sitter-elixir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-elixir-devel-0.3.5-3.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-elixir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-elixir-devel}"
SRC_URI[aarch64_rust-tree-sitter-elixir-devel.sha256sum] = "b9eed333434d5c55eee396a2d44b250bb107fce081da2e1fed8b6c2b149b5e2f"

RDEPENDS:rust-tree-sitter-elixir+default-devel = " \
 cargo \
 rust-tree-sitter-elixir-devel \
 "
RDEPENDS:rust-tree-sitter-elixir-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
