# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sdl2-compat"
PV = "2.32.50"
PR = "1.el10"
PACKAGES = " \
 sdl2-compat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sdl2-compat-2.32.50-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4abef5ca5551965b03d944bab6046eb580206454234e794147336bd15b9aad9c"

URI_x86_64_v2_sdl2-compat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sdl2-compat-2.32.50-1.el10.x86_64_v2.rpm;name=x86_64_v2_sdl2-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sdl2-compat}"
SRC_URI[x86_64_v2_sdl2-compat.sha256sum] = "7083aafe6940e6ec249b64b15910115f2bcccc525376f20c4fda2ce5878910ae"

URI_aarch64_sdl2-compat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sdl2-compat-2.32.50-1.el10.aarch64.rpm;name=aarch64_sdl2-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_sdl2-compat}"
SRC_URI[aarch64_sdl2-compat.sha256sum] = "bb64bf6cae3d6cd79ed044a6854f4655a56946db87f312bdf45177739ba738a2"

RDEPENDS:sdl2-compat = " \
 SDL3 \
 glibc \
 "
