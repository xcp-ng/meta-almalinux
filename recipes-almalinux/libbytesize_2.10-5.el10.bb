# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbytesize"
PV = "2.10"
PR = "5.el10"
PACKAGES = " \
 libbytesize \
 libbytesize-devel \
 python3-bytesize \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libbytesize-2.10-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d9d022cbe81e6e2e7b155cc1f9471a27b998be521ae881bf9e9e962449c9da9"

URI_x86_64_v2_libbytesize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libbytesize-2.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_libbytesize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbytesize}"
SRC_URI[x86_64_v2_libbytesize.sha256sum] = "f658f3f59f7f821cf62090fbcbe3fc78266b1f4ed4d513f076e58b64e49612b8"

URI_x86_64_v2_libbytesize-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libbytesize-devel-2.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_libbytesize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbytesize-devel}"
SRC_URI[x86_64_v2_libbytesize-devel.sha256sum] = "13796ecc4bbd930dbd8635fd277475d902d6f7de0c84b5cef71c96eabac91583"

URI_x86_64_v2_python3-bytesize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-bytesize-2.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-bytesize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bytesize}"
SRC_URI[x86_64_v2_python3-bytesize.sha256sum] = "2fb0101955c0bd9f34aaa40783adb985a074020c9d7e419999f4d179ad2087f7"

URI_aarch64_libbytesize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libbytesize-2.10-5.el10.aarch64.rpm;name=aarch64_libbytesize;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbytesize}"
SRC_URI[aarch64_libbytesize.sha256sum] = "ecc0ef33a34d425f9edefad4c5502010549749e35c1347a66f6da5ba5cff0cf6"

URI_aarch64_libbytesize-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libbytesize-devel-2.10-5.el10.aarch64.rpm;name=aarch64_libbytesize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbytesize-devel}"
SRC_URI[aarch64_libbytesize-devel.sha256sum] = "632a44d178562f4f53284978d64630e94841006172888728f20bbfa6fe0e43f2"

URI_aarch64_python3-bytesize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-bytesize-2.10-5.el10.aarch64.rpm;name=aarch64_python3-bytesize;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bytesize}"
SRC_URI[aarch64_python3-bytesize.sha256sum] = "5a21b15089b182712e0a7c008c631ca1b3e5f26f6b4d7b93b2c8aa9f6aa78344"

RDEPENDS:libbytesize = " \
 glibc \
 gmp \
 mpfr \
 pcre2 \
 "
RDEPENDS:libbytesize-devel = " \
 libbytesize \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-bytesize = " \
 libbytesize \
 python3 \
 "
