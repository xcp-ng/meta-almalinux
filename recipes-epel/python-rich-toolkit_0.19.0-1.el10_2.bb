# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rich-toolkit"
PV = "0.19.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-rich-toolkit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rich-toolkit-0.19.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e31bc964c2f24b773f18038987f8aaa6b7d11af4d274ca0a3e5a2f6fb49d9c55"

URI_x86_64_v2_python3-rich-toolkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rich-toolkit-0.19.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rich-toolkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rich-toolkit}"
SRC_URI[x86_64_v2_python3-rich-toolkit.sha256sum] = "e2b2bdd866abd8eb5b79ab6f3cfda665b305b0e9a5f167d269298f941a041a23"

URI_aarch64_python3-rich-toolkit = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rich-toolkit-0.19.0-1.el10_2.noarch.rpm;name=aarch64_python3-rich-toolkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rich-toolkit}"
SRC_URI[aarch64_python3-rich-toolkit.sha256sum] = "5bc14de5b4ec05c18c46eef0c6860a220ab3fb9e0d38e88bed7c9e06eff4f1a5"

RDEPENDS:python3-rich-toolkit = " \
 python3 \
 python3-click \
 python3-rich \
 python3-typing-extensions \
 "
