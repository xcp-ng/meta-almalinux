# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-demangle"
PV = "0.1.26"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustc-demangle+default-devel \
 rust-rustc-demangle+std-devel \
 rust-rustc-demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-demangle-0.1.26-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "979329fed06a8923c1c78e4e8e2a421a2e1a570c9a7ba40665a410da01841637"

URI_x86_64_v2_rust-rustc-demangle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle+default-devel-0.1.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle+default-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle+default-devel.sha256sum] = "46d7d7b15ded149c0ab2f3ed03969227d5f7892b022c36a3f7f76375817ec844"

URI_x86_64_v2_rust-rustc-demangle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle+std-devel-0.1.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle+std-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle+std-devel.sha256sum] = "2d92ddaca99522a06f408c528f375819e31b1f5a11cdd53611bec0fba8041f0c"

URI_x86_64_v2_rust-rustc-demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle-devel-0.1.26-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle-devel.sha256sum] = "decfe2ef1646ee5e5ab93685953397615e629468219247f89a95fcab712fe3ef"

URI_aarch64_rust-rustc-demangle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle+default-devel-0.1.26-1.el10_1.noarch.rpm;name=aarch64_rust-rustc-demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle+default-devel}"
SRC_URI[aarch64_rust-rustc-demangle+default-devel.sha256sum] = "838c927ed0892f75823a725367607dfceafcd3e89a9a96dfc1486d3995d799aa"

URI_aarch64_rust-rustc-demangle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle+std-devel-0.1.26-1.el10_1.noarch.rpm;name=aarch64_rust-rustc-demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle+std-devel}"
SRC_URI[aarch64_rust-rustc-demangle+std-devel.sha256sum] = "77adef73c17b26afdd56f00a7d233bee4eb6a6ceac262c35d606e178f1a00c3f"

URI_aarch64_rust-rustc-demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle-devel-0.1.26-1.el10_1.noarch.rpm;name=aarch64_rust-rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle-devel}"
SRC_URI[aarch64_rust-rustc-demangle-devel.sha256sum] = "6f164ad89e0c45e3d5c5650d5c08e717faa661d39b4baa0449bf58c74cbe0796"

RDEPENDS:rust-rustc-demangle+default-devel = " \
 cargo \
 rust-rustc-demangle-devel \
 "
RDEPENDS:rust-rustc-demangle+std-devel = " \
 cargo \
 rust-rustc-demangle-devel \
 "
RDEPENDS:rust-rustc-demangle-devel = " \
 cargo \
 "
