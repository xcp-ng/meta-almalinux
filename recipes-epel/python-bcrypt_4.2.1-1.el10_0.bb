# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-bcrypt"
PV = "4.2.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-bcrypt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-bcrypt-4.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5eaa399ca9cb95787fcdf696ddccb65c2682e00cd625735a87423be4a240b41c"

URI_x86_64_v2_python3-bcrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bcrypt-4.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-bcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bcrypt}"
SRC_URI[x86_64_v2_python3-bcrypt.sha256sum] = "8969699da2720a37e3ff132ea57f19a1104b048cc74fb67778d96b76cb544bad"

URI_aarch64_python3-bcrypt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bcrypt-4.2.1-1.el10_0.aarch64.rpm;name=aarch64_python3-bcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bcrypt}"
SRC_URI[aarch64_python3-bcrypt.sha256sum] = "c1efc74a69775b32f9265fadb396e0f62f7a8a527172abc615e269ce0deb7f2f"

RDEPENDS:python3-bcrypt = " \
 glibc \
 libgcc \
 python3 \
 "
