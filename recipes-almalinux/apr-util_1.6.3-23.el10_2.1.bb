# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apr-util"
PV = "1.6.3"
PR = "23.el10_2.1"
PACKAGES = " \
 apr-util \
 apr-util-devel \
 apr-util-ldap \
 apr-util-lmdb \
 apr-util-mysql \
 apr-util-odbc \
 apr-util-openssl \
 apr-util-pgsql \
 apr-util-sqlite \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apr-util-1.6.3-23.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be0f78b1b8ed57f6a166d128034bc5f9dba3752829fea352e49dfce29e49719c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-1.6.3-23.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_apr-util;unpack=0"
SRC_URI[x86_64_v2_apr-util.sha256sum] = "5d310561dcd1c8af68c7d3f906ab06e96fdb1f62573aaf3b444e1dc526023524"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-devel-1.6.3-23.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_apr-util-devel;unpack=0"
SRC_URI[x86_64_v2_apr-util-devel.sha256sum] = "8e6754d5fbc6b0396c11bd2991452e0063767ceb8133129fbe50d42bfc127d52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-ldap-1.6.3-23.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_apr-util-ldap;unpack=0"
SRC_URI[x86_64_v2_apr-util-ldap.sha256sum] = "365ac18385ef74b6c2391c623d84eaa3e7a15c31a813edbd613eeea252be3e3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-lmdb-1.6.3-23.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_apr-util-lmdb;unpack=0"
SRC_URI[x86_64_v2_apr-util-lmdb.sha256sum] = "40466a173f587b19da8d09e42ef81b8f4c2747d708231b8552e02c62d11993d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-mysql-1.6.3-23.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_apr-util-mysql;unpack=0"
SRC_URI[x86_64_v2_apr-util-mysql.sha256sum] = "8d28421f87dacb3468b5f6adcec7de0537e33f85b4671820f6d4de49d96c86db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-odbc-1.6.3-23.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_apr-util-odbc;unpack=0"
SRC_URI[x86_64_v2_apr-util-odbc.sha256sum] = "23216192556cc699921d13524d5a3649fb080e23b8ef86e2422996ba387a92a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-openssl-1.6.3-23.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_apr-util-openssl;unpack=0"
SRC_URI[x86_64_v2_apr-util-openssl.sha256sum] = "d5939d757357192820462244ceee72c5615c770562b4984f6bb84c324ca2bf19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-pgsql-1.6.3-23.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_apr-util-pgsql;unpack=0"
SRC_URI[x86_64_v2_apr-util-pgsql.sha256sum] = "1e009d9b8f0c55b5442b5d5debaf7dba5a5c3e9d8f84c0b10a3bb23bcb4384a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-util-sqlite-1.6.3-23.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_apr-util-sqlite;unpack=0"
SRC_URI[x86_64_v2_apr-util-sqlite.sha256sum] = "25d255cfbd64d81b61345ee06785176ae1b25e5a614fb986272fed2b00658685"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-1.6.3-23.el10_2.1.aarch64.rpm;name=aarch64_apr-util;unpack=0"
SRC_URI[aarch64_apr-util.sha256sum] = "12a67814329594a9af92400c477ab38748f1ad05ce93506c0bc0586ca5059502"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-devel-1.6.3-23.el10_2.1.aarch64.rpm;name=aarch64_apr-util-devel;unpack=0"
SRC_URI[aarch64_apr-util-devel.sha256sum] = "c0e28250afee44d5a9c5c7d0c58d46d3c4066f9eeb321cad91a7a41eba851b54"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-ldap-1.6.3-23.el10_2.1.aarch64.rpm;name=aarch64_apr-util-ldap;unpack=0"
SRC_URI[aarch64_apr-util-ldap.sha256sum] = "d34943dea9e06261ae5e27ee9738604d3e5a91b2c2575fa2185cc27d72aacdc0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-lmdb-1.6.3-23.el10_2.1.aarch64.rpm;name=aarch64_apr-util-lmdb;unpack=0"
SRC_URI[aarch64_apr-util-lmdb.sha256sum] = "5af1b9178dc4683b5b4383974b5f67f7ad8fc571e196c8dd56324827ec8ba03e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-mysql-1.6.3-23.el10_2.1.aarch64.rpm;name=aarch64_apr-util-mysql;unpack=0"
SRC_URI[aarch64_apr-util-mysql.sha256sum] = "e7434cd10bc10cb0c11e8676422d53099d6bc453acf475104a3691e2a29090c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-odbc-1.6.3-23.el10_2.1.aarch64.rpm;name=aarch64_apr-util-odbc;unpack=0"
SRC_URI[aarch64_apr-util-odbc.sha256sum] = "3deb5ea27a4ebf4a63112792517294cbd199b2c45e7c0495f241f974c5c6b429"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-openssl-1.6.3-23.el10_2.1.aarch64.rpm;name=aarch64_apr-util-openssl;unpack=0"
SRC_URI[aarch64_apr-util-openssl.sha256sum] = "858b0ead7edb3f0c698b0b2bb6d6feb9340fab47cbacd18044627774a7730bf1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-pgsql-1.6.3-23.el10_2.1.aarch64.rpm;name=aarch64_apr-util-pgsql;unpack=0"
SRC_URI[aarch64_apr-util-pgsql.sha256sum] = "853602fcdadbd5c2bc7dcd523e00d7ea80d03119553e386e94822c07086e89fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-util-sqlite-1.6.3-23.el10_2.1.aarch64.rpm;name=aarch64_apr-util-sqlite;unpack=0"
SRC_URI[aarch64_apr-util-sqlite.sha256sum] = "d26e3f9ff377dcc61c49a7b4409563d2d59ff1485fa0fcc4a58a914c2cb8247f"

RDEPENDS:apr-util = " \
 apr \
 expat \
 glibc \
 libuuid \
 libxcrypt \
 "
RDEPENDS:apr-util-devel = " \
 apr-devel \
 apr-util \
 bash \
 expat-devel \
 openldap-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:apr-util-ldap = " \
 apr-util \
 glibc \
 openldap \
 "
RDEPENDS:apr-util-lmdb = " \
 apr-util \
 glibc \
 lmdb-libs \
 "
RDEPENDS:apr-util-mysql = " \
 apr-util \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:apr-util-odbc = " \
 apr-util \
 glibc \
 unixODBC \
 "
RDEPENDS:apr-util-openssl = " \
 apr-util \
 glibc \
 openssl-libs \
 "
RDEPENDS:apr-util-pgsql = " \
 apr-util \
 glibc \
 libpq \
 "
RDEPENDS:apr-util-sqlite = " \
 apr-util \
 glibc \
 sqlite-libs \
 "
