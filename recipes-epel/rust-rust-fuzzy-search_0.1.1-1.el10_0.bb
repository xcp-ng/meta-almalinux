# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-fuzzy-search"
PV = "0.1.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-rust-fuzzy-search+default-devel \
 rust-rust-fuzzy-search-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-fuzzy-search-0.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ab39f1bb697b03d7825ee7075077e1531eae24a1daf9e1b549c2690f4df4b7a"

URI_x86_64_v2_rust-rust-fuzzy-search+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-fuzzy-search+default-devel-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-fuzzy-search+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-fuzzy-search+default-devel}"
SRC_URI[x86_64_v2_rust-rust-fuzzy-search+default-devel.sha256sum] = "ea7a5221b7d9f2401e6fc3c134f14514358241958eca88620daa195ca8638d88"

URI_x86_64_v2_rust-rust-fuzzy-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-fuzzy-search-devel-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-fuzzy-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-fuzzy-search-devel}"
SRC_URI[x86_64_v2_rust-rust-fuzzy-search-devel.sha256sum] = "63289c26fad2742d8a43ab56d24786b6351c602854b42938590f3733faf500aa"

URI_aarch64_rust-rust-fuzzy-search+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-fuzzy-search+default-devel-0.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-rust-fuzzy-search+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-fuzzy-search+default-devel}"
SRC_URI[aarch64_rust-rust-fuzzy-search+default-devel.sha256sum] = "f4e4b8e88e553d69b7f4cc40e3a5a3fd16400331a596a89dc09abbeddf1809be"

URI_aarch64_rust-rust-fuzzy-search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-fuzzy-search-devel-0.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-rust-fuzzy-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-fuzzy-search-devel}"
SRC_URI[aarch64_rust-rust-fuzzy-search-devel.sha256sum] = "d1bc9eb7d7bf254138d01ab3f02165f9cb87fa685ca95c03ea92ec99517da15c"

RDEPENDS:rust-rust-fuzzy-search+default-devel = " \
 cargo \
 rust-rust-fuzzy-search-devel \
 "
RDEPENDS:rust-rust-fuzzy-search-devel = " \
 cargo \
 "
