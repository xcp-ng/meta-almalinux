# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-distributive"
PV = "0.6.2.1"
PR = "13.el10_0"
PACKAGES = " \
 ghc-distributive \
 ghc-distributive-devel \
 ghc-distributive-doc \
 ghc-distributive-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-distributive-0.6.2.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e89529b432dc1cdc34c8686bdd05b9fde5584ce8e6c017f85aa22d8c5b4d57c"

URI_x86_64_v2_ghc-distributive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-distributive-0.6.2.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-distributive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-distributive}"
SRC_URI[x86_64_v2_ghc-distributive.sha256sum] = "e38c028e89b97c601c46116407a74efbfc6df8db2c3b0868cc9f7abf46965824"

URI_x86_64_v2_ghc-distributive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-distributive-devel-0.6.2.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-distributive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-distributive-devel}"
SRC_URI[x86_64_v2_ghc-distributive-devel.sha256sum] = "c2434a157ea36554d9d34abef5d9609a343eedaefad7d749fa3df3d74b27de03"

URI_x86_64_v2_ghc-distributive-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-distributive-doc-0.6.2.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-distributive-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-distributive-doc}"
SRC_URI[x86_64_v2_ghc-distributive-doc.sha256sum] = "0e5d161f1e78aaab72a5c64a5b4bbfc6e8c02f2b22906ff130f2621501552765"

URI_x86_64_v2_ghc-distributive-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-distributive-prof-0.6.2.1-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-distributive-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-distributive-prof}"
SRC_URI[x86_64_v2_ghc-distributive-prof.sha256sum] = "99d62cb1d52d0a43c842e34e2a5b3c364010f85817ef34a68c3ac2d16a81dfa9"

URI_aarch64_ghc-distributive = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-distributive-0.6.2.1-13.el10_0.aarch64.rpm;name=aarch64_ghc-distributive;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-distributive}"
SRC_URI[aarch64_ghc-distributive.sha256sum] = "69c37783705990f5b6596438fce3e74ff9b7a792fec477645a0b534564d443cf"

URI_aarch64_ghc-distributive-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-distributive-devel-0.6.2.1-13.el10_0.aarch64.rpm;name=aarch64_ghc-distributive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-distributive-devel}"
SRC_URI[aarch64_ghc-distributive-devel.sha256sum] = "a5cb9c9f7aa66cc028293a739ab9505fd3e51705ec8ef9765e29ca78b5e56b17"

URI_aarch64_ghc-distributive-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-distributive-doc-0.6.2.1-13.el10_0.noarch.rpm;name=aarch64_ghc-distributive-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-distributive-doc}"
SRC_URI[aarch64_ghc-distributive-doc.sha256sum] = "09fb5c64e7ab3e4e72826c7bff93f7d54f44cf25cc966246e2e7c35cf508c8e3"

URI_aarch64_ghc-distributive-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-distributive-prof-0.6.2.1-13.el10_0.aarch64.rpm;name=aarch64_ghc-distributive-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-distributive-prof}"
SRC_URI[aarch64_ghc-distributive-prof.sha256sum] = "47a801897eaa2db8eae57f6c3f6fa6435de2241dd50dfba2e5f6931a4eb92df3"

RDEPENDS:ghc-distributive = " \
 ghc-array \
 ghc-base \
 ghc-base-orphans \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-tagged \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-distributive-devel = " \
 ghc-base-devel \
 ghc-base-orphans-devel \
 ghc-compiler \
 ghc-distributive \
 ghc-tagged-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-distributive-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-distributive-prof = " \
 ghc-base-orphans-prof \
 ghc-base-prof \
 ghc-distributive-devel \
 ghc-tagged-prof \
 ghc-transformers-prof \
 "
