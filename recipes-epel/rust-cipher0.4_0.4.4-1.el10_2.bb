# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cipher0.4"
PV = "0.4.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-cipher0.4+alloc-devel \
 rust-cipher0.4+blobby-devel \
 rust-cipher0.4+block-padding-devel \
 rust-cipher0.4+default-devel \
 rust-cipher0.4+dev-devel \
 rust-cipher0.4+rand_core-devel \
 rust-cipher0.4+std-devel \
 rust-cipher0.4+zeroize-devel \
 rust-cipher0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cipher0.4-0.4.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdca8f8784ef6cf2ee0825eb73091fe9d2ca23a6ea554e16173b69c73454a66d"

URI_x86_64_v2_rust-cipher0.4+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher0.4+alloc-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher0.4+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher0.4+alloc-devel}"
SRC_URI[x86_64_v2_rust-cipher0.4+alloc-devel.sha256sum] = "772706ddcc9274a5c86df0b04d086ee580059289373ce5c56748a249729d9cd4"

URI_x86_64_v2_rust-cipher0.4+blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher0.4+blobby-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher0.4+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher0.4+blobby-devel}"
SRC_URI[x86_64_v2_rust-cipher0.4+blobby-devel.sha256sum] = "bce6b1a6c16de6bb32ba3d15a3cdc0abd878c6d3ecbfbdc09869dc22db1ba475"

URI_x86_64_v2_rust-cipher0.4+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher0.4+block-padding-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher0.4+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher0.4+block-padding-devel}"
SRC_URI[x86_64_v2_rust-cipher0.4+block-padding-devel.sha256sum] = "9adc16492dbb12adccb17cbac960b9ee3f93db26aac9a6500cd4091e6835e2e8"

URI_x86_64_v2_rust-cipher0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher0.4+default-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher0.4+default-devel}"
SRC_URI[x86_64_v2_rust-cipher0.4+default-devel.sha256sum] = "967237a6e45985361e17904c8f1db372efbe87ba51da63eb08d61abd5a875f61"

URI_x86_64_v2_rust-cipher0.4+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher0.4+dev-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher0.4+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher0.4+dev-devel}"
SRC_URI[x86_64_v2_rust-cipher0.4+dev-devel.sha256sum] = "4e16f2733069f22f408ffa30474c3278e5fad980151ff4119640a377658ffb0b"

URI_x86_64_v2_rust-cipher0.4+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher0.4+rand_core-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher0.4+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher0.4+rand_core-devel}"
SRC_URI[x86_64_v2_rust-cipher0.4+rand_core-devel.sha256sum] = "2ed5eff62073cc85e3f94bf98250d3d78f1ffe5014dbbb328da7e9f8d565d192"

URI_x86_64_v2_rust-cipher0.4+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher0.4+std-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher0.4+std-devel}"
SRC_URI[x86_64_v2_rust-cipher0.4+std-devel.sha256sum] = "9b14d4ff5ac6035b78321fa5b0d4bcc9a03b3e96a6616948b4518e4620f5cece"

URI_x86_64_v2_rust-cipher0.4+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher0.4+zeroize-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher0.4+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher0.4+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cipher0.4+zeroize-devel.sha256sum] = "d8b35f8b61343f5669fdcffbf852a63e3fc109890736a2c5043be5dc9d24df1c"

URI_x86_64_v2_rust-cipher0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher0.4-devel-0.4.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher0.4-devel}"
SRC_URI[x86_64_v2_rust-cipher0.4-devel.sha256sum] = "f5ba0eee81e111c348cfe9e96a27e654ae40ec9a1c09eed9573a0d53a564d139"

URI_aarch64_rust-cipher0.4+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher0.4+alloc-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-cipher0.4+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher0.4+alloc-devel}"
SRC_URI[aarch64_rust-cipher0.4+alloc-devel.sha256sum] = "a8afd6930eb7c91a9a5dc2242224c85f1025fade7b5cc21b9e3edcb9a067d87c"

URI_aarch64_rust-cipher0.4+blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher0.4+blobby-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-cipher0.4+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher0.4+blobby-devel}"
SRC_URI[aarch64_rust-cipher0.4+blobby-devel.sha256sum] = "9c74ec83a0008d3dc46116cb18d11e26305d74e75bb4880c18e9f4dc066a1f9a"

URI_aarch64_rust-cipher0.4+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher0.4+block-padding-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-cipher0.4+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher0.4+block-padding-devel}"
SRC_URI[aarch64_rust-cipher0.4+block-padding-devel.sha256sum] = "e1858584ad7ba0c2f8ec9042d6013e60da823164b6c2a99a496ac9e49ab35479"

URI_aarch64_rust-cipher0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher0.4+default-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-cipher0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher0.4+default-devel}"
SRC_URI[aarch64_rust-cipher0.4+default-devel.sha256sum] = "d9fcf674b8c11721ad350f2d83521f51e4420e291c909f4d5da8f4d3e9f50f9f"

URI_aarch64_rust-cipher0.4+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher0.4+dev-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-cipher0.4+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher0.4+dev-devel}"
SRC_URI[aarch64_rust-cipher0.4+dev-devel.sha256sum] = "ccef83a12eedb22897a2eb463f44e5fdcf87cfaa711bcbe863e16d7b5e60de10"

URI_aarch64_rust-cipher0.4+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher0.4+rand_core-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-cipher0.4+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher0.4+rand_core-devel}"
SRC_URI[aarch64_rust-cipher0.4+rand_core-devel.sha256sum] = "a08ca629fd23c66b1734b36b0353261adc2dba8a104c7f4704db47dc02d25a20"

URI_aarch64_rust-cipher0.4+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher0.4+std-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-cipher0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher0.4+std-devel}"
SRC_URI[aarch64_rust-cipher0.4+std-devel.sha256sum] = "870b7f2143145bb69abb1310e12b752dab85f27a8a082362575bc3a7043ae9cf"

URI_aarch64_rust-cipher0.4+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher0.4+zeroize-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-cipher0.4+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher0.4+zeroize-devel}"
SRC_URI[aarch64_rust-cipher0.4+zeroize-devel.sha256sum] = "982abb3f0593a44257c9607499219311dddc8cb5c7cda097cbdbe740c939b5c5"

URI_aarch64_rust-cipher0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher0.4-devel-0.4.4-1.el10_2.noarch.rpm;name=aarch64_rust-cipher0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher0.4-devel}"
SRC_URI[aarch64_rust-cipher0.4-devel.sha256sum] = "dc983ade328ac25379868d49ce8440b58a42969305c6dfac18592dbbdf0879af"

RDEPENDS:rust-cipher0.4+alloc-devel = " \
 cargo \
 rust-cipher0.4-devel \
 "
RDEPENDS:rust-cipher0.4+blobby-devel = " \
 cargo \
 rust-blobby0.3+default-devel \
 rust-cipher0.4-devel \
 "
RDEPENDS:rust-cipher0.4+block-padding-devel = " \
 cargo \
 rust-cipher0.4-devel \
 rust-inout0.1+block-padding-devel \
 "
RDEPENDS:rust-cipher0.4+default-devel = " \
 cargo \
 rust-cipher0.4-devel \
 "
RDEPENDS:rust-cipher0.4+dev-devel = " \
 cargo \
 rust-cipher0.4+blobby-devel \
 rust-cipher0.4-devel \
 "
RDEPENDS:rust-cipher0.4+rand_core-devel = " \
 cargo \
 rust-cipher0.4-devel \
 rust-crypto-common0.1+rand_core-devel \
 "
RDEPENDS:rust-cipher0.4+std-devel = " \
 cargo \
 rust-cipher0.4+alloc-devel \
 rust-cipher0.4-devel \
 rust-crypto-common0.1+std-devel \
 rust-inout0.1+std-devel \
 "
RDEPENDS:rust-cipher0.4+zeroize-devel = " \
 cargo \
 rust-cipher0.4-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-cipher0.4-devel = " \
 cargo \
 rust \
 rust-crypto-common0.1+default-devel \
 rust-inout0.1+default-devel \
 "
