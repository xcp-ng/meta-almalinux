# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quote"
PV = "1.0.47"
PR = "1.el10_3"
PACKAGES = " \
 rust-quote+default-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quote-1.0.47-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1016a5e5701f52365974f61bf1206b7a337fa41957bfbdebc1de9d027e638972"

URI_x86_64_v2_rust-quote+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote+default-devel-1.0.47-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote+default-devel}"
SRC_URI[x86_64_v2_rust-quote+default-devel.sha256sum] = "a2aab454ea1d550fb332ad52bac65dfa7d2740fa1a05999786baf9e8e293112e"

URI_x86_64_v2_rust-quote+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote+proc-macro-devel-1.0.47-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-quote+proc-macro-devel.sha256sum] = "40c46e777adb831ea76832019151bfdbe9b5304955a834379501e33d5cccda59"

URI_x86_64_v2_rust-quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote-devel-1.0.47-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote-devel}"
SRC_URI[x86_64_v2_rust-quote-devel.sha256sum] = "6ea9bda49cc30ad5a600ed2cdf50a0c1398073fa0da1166229e81c25d6940d09"

URI_aarch64_rust-quote+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote+default-devel-1.0.47-1.el10_3.noarch.rpm;name=aarch64_rust-quote+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote+default-devel}"
SRC_URI[aarch64_rust-quote+default-devel.sha256sum] = "c4742d482604c22a4fdd440a733a9d10dc2b639e4fb6fc190eed2d22a597c188"

URI_aarch64_rust-quote+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote+proc-macro-devel-1.0.47-1.el10_3.noarch.rpm;name=aarch64_rust-quote+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote+proc-macro-devel}"
SRC_URI[aarch64_rust-quote+proc-macro-devel.sha256sum] = "24816199992245c8097d7e4e3bd64311046b9e991589b429faa90d51cc123eee"

URI_aarch64_rust-quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote-devel-1.0.47-1.el10_3.noarch.rpm;name=aarch64_rust-quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote-devel}"
SRC_URI[aarch64_rust-quote-devel.sha256sum] = "383cb895250c19b0be741e5b5938e18a3ed09a12d155df35b58dbbfbf523e69e"

RDEPENDS:rust-quote+default-devel = " \
 cargo \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 "
RDEPENDS:rust-quote+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote-devel \
 "
RDEPENDS:rust-quote-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 "
