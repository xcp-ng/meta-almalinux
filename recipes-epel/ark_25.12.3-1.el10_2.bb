# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ark"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ark \
 ark-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/ark-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f210ab157c7898f75a5db12711caaa0985133aac21e6552fcb91239549d97b79"

URI_x86_64_v2_ark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ark}"
SRC_URI[x86_64_v2_ark.sha256sum] = "95dd71f7e1117a71650f0f6d993a561d1ee0554d37301d9062c1ad0e73d9bff3"

URI_x86_64_v2_ark-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ark-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ark-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ark-libs}"
SRC_URI[x86_64_v2_ark-libs.sha256sum] = "b8850e8bdca197b39bcdbae7a205e4a139a036974394472d61178e314ca435fb"

URI_aarch64_ark = "${EPEL_MIRROR}/aarch64/Packages/a/ark-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ark;unpack=0"
SRC_URI:append = " ${URI_aarch64_ark}"
SRC_URI[aarch64_ark.sha256sum] = "efac4a26fbb9e72cd75d931735ecd54bb6df471b8dfc701c9c7c2c97be0a75c2"

URI_aarch64_ark-libs = "${EPEL_MIRROR}/aarch64/Packages/a/ark-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ark-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ark-libs}"
SRC_URI[aarch64_ark-libs.sha256sum] = "51b19172612953b242d1f0d7535ce32beae157696af292997b26a9345e4fdd8f"

RDEPENDS:ark = " \
 ark-libs \
 bzip2 \
 glibc \
 gzip \
 kf6-breeze-icons \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 unzip \
 "
RDEPENDS:ark-libs = " \
 ark \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kpty \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libgcc \
 libstdc++ \
 libzip \
 qt6-qtbase \
 qt6-qtbase-gui \
 zlib-ng-compat \
 "
