# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-classworlds"
PV = "2.8.0"
PR = "4.el10"
PACKAGES = " \
 plexus-classworlds \
 plexus-classworlds-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plexus-classworlds-2.8.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "024bbabfd982bb0d5e79fec9e70fc4084a75a676fbc936ac19704cac5dd052ae"

URI_x86_64_v2_plexus-classworlds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plexus-classworlds-2.8.0-4.el10.noarch.rpm;name=x86_64_v2_plexus-classworlds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-classworlds}"
SRC_URI[x86_64_v2_plexus-classworlds.sha256sum] = "ac54e23e95711f9d0d220861f7c256459ad710cd17affd1e4087b281680605a4"

URI_x86_64_v2_plexus-classworlds-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-classworlds-javadoc-2.8.0-4.el10.noarch.rpm;name=x86_64_v2_plexus-classworlds-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plexus-classworlds-javadoc}"
SRC_URI[x86_64_v2_plexus-classworlds-javadoc.sha256sum] = "8a2869740cf8e8d5786b58fe61ad4c12bf250ed8bcaa6b3c20e1313d306ab968"

URI_aarch64_plexus-classworlds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plexus-classworlds-2.8.0-4.el10.noarch.rpm;name=aarch64_plexus-classworlds;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-classworlds}"
SRC_URI[aarch64_plexus-classworlds.sha256sum] = "ac54e23e95711f9d0d220861f7c256459ad710cd17affd1e4087b281680605a4"

URI_aarch64_plexus-classworlds-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-classworlds-javadoc-2.8.0-4.el10.noarch.rpm;name=aarch64_plexus-classworlds-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plexus-classworlds-javadoc}"
SRC_URI[aarch64_plexus-classworlds-javadoc.sha256sum] = "8a2869740cf8e8d5786b58fe61ad4c12bf250ed8bcaa6b3c20e1313d306ab968"

RDEPENDS:plexus-classworlds = " \
 javapackages-filesystem \
 "
RDEPENDS:plexus-classworlds-javadoc = " \
 javapackages-filesystem \
 "
