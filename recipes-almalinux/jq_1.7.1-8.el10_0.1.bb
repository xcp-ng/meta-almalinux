# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jq"
PV = "1.7.1"
PR = "8.el10_0.1"
PACKAGES = " \
 jq \
 jq-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/jq-1.7.1-8.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5fe717cd8aef5917ffb19b131d1fce0038011c6b238555be863977a7061b053"

URI_x86_64_v2_jq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/jq-1.7.1-8.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_jq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jq}"
SRC_URI[x86_64_v2_jq.sha256sum] = "52904b1888d3ddb16602c27fcdce95f92b0c0592323d36359cfe03184ef24ba1"

URI_x86_64_v2_jq-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jq-devel-1.7.1-8.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_jq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jq-devel}"
SRC_URI[x86_64_v2_jq-devel.sha256sum] = "0a49b6f2d1f4e1292afbf149bf4dfb6c46ddb1aaa4979280a27af991ad66999a"

URI_aarch64_jq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/jq-1.7.1-8.el10_0.1.aarch64.rpm;name=aarch64_jq;unpack=0"
SRC_URI:append = " ${URI_aarch64_jq}"
SRC_URI[aarch64_jq.sha256sum] = "a54cad2bc25d71afd30fc5bf21b3c34bc5c6d50d7f097720678df5053ee27725"

URI_aarch64_jq-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jq-devel-1.7.1-8.el10_0.1.aarch64.rpm;name=aarch64_jq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jq-devel}"
SRC_URI[aarch64_jq-devel.sha256sum] = "a6b138899f03e683997314840bb9e918ea6a52ffe0611b4d766ac7fbdddf5552"

RDEPENDS:jq = " \
 glibc \
 oniguruma \
 "
RDEPENDS:jq-devel = " \
 jq \
 pkgconf-pkg-config \
 "
