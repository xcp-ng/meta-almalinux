# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpmdistro-repoquery"
PV = "0^20231102git539d4c0"
PR = "4.el10_0"
PACKAGES = " \
 rpmdistro-repoquery \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpmdistro-repoquery-0^20231102git539d4c0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b7f29b35696e1695d9ba6aa09f3081a4d2ce0bc8959ca1ef7513a5618b16165"

URI_x86_64_v2_rpmdistro-repoquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmdistro-repoquery-0^20231102git539d4c0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rpmdistro-repoquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmdistro-repoquery}"
SRC_URI[x86_64_v2_rpmdistro-repoquery.sha256sum] = "7a52df5147a8f1257b2b1ebcee4cdcb9949e61d2a47f86e1e8b8428eeba5f244"

URI_aarch64_rpmdistro-repoquery = "${EPEL_MIRROR}/aarch64/Packages/r/rpmdistro-repoquery-0^20231102git539d4c0-4.el10_0.noarch.rpm;name=aarch64_rpmdistro-repoquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmdistro-repoquery}"
SRC_URI[aarch64_rpmdistro-repoquery.sha256sum] = "8fefa5babcd619f8f0d42f1bddb34fd2d70f50756330f4c0a8edb1f643250e73"

RDEPENDS:rpmdistro-repoquery = " \
 bash \
 distribution-gpg-keys \
 dnf \
 "
