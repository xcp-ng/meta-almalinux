# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_filter"
PV = "0.1.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-env_filter+default-devel \
 rust-env_filter+regex-devel \
 rust-env_filter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_filter-0.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28d425fc1e118f861bb7f6deb7bcae2b711cc537b5eb842fd890e8d3c0d3a24d"

URI_x86_64_v2_rust-env_filter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter+default-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter+default-devel}"
SRC_URI[x86_64_v2_rust-env_filter+default-devel.sha256sum] = "10b5df3e8f8d686c395c024adb6247a493cd7d869473c8ba5e57a0a308f7fb24"

URI_x86_64_v2_rust-env_filter+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter+regex-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter+regex-devel}"
SRC_URI[x86_64_v2_rust-env_filter+regex-devel.sha256sum] = "20a70f9ff982f72894e4c308f58a1341a0ebdd77b1d6cb80b5ed7e2f1b75ca4b"

URI_x86_64_v2_rust-env_filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter-devel}"
SRC_URI[x86_64_v2_rust-env_filter-devel.sha256sum] = "74f25de5a2709d12d0de579390085821f1e93338c37f09ab4f57d79f69e1dce8"

URI_aarch64_rust-env_filter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter+default-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-env_filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter+default-devel}"
SRC_URI[aarch64_rust-env_filter+default-devel.sha256sum] = "aaeff63cc522cc22b3369db038d569f1adf4cc4944c12f2e574e9b328d7d5aa7"

URI_aarch64_rust-env_filter+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter+regex-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-env_filter+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter+regex-devel}"
SRC_URI[aarch64_rust-env_filter+regex-devel.sha256sum] = "ddf6f1ba2143fd58bf9b9bd307b9f394c8566844a67ab5e51652a037df2d033b"

URI_aarch64_rust-env_filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-env_filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter-devel}"
SRC_URI[aarch64_rust-env_filter-devel.sha256sum] = "2f3632dde431ba98077c7f007c55baf9db6a945795ecdd2d8c178e38add83a9d"

RDEPENDS:rust-env_filter+default-devel = " \
 cargo \
 rust-env_filter+regex-devel \
 rust-env_filter-devel \
 "
RDEPENDS:rust-env_filter+regex-devel = " \
 cargo \
 rust-env_filter-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_filter-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-log+std-devel \
 "
