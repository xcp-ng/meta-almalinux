# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bison"
PV = "3.8.2"
PR = "9.el10"
PACKAGES = " \
 bison \
 bison-devel \
 bison-runtime \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bison-3.8.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1dfd02ae10f43f94d3f68a450d24029ca61224a6dbb8dea76dbfd723c5ff052"

URI_x86_64_v2_bison = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bison-3.8.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_bison;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bison}"
SRC_URI[x86_64_v2_bison.sha256sum] = "1d610a685d92b791824c6c2432920ae65f100ea8b558467c3b2323bcf95cfec5"

URI_x86_64_v2_bison-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bison-devel-3.8.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_bison-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bison-devel}"
SRC_URI[x86_64_v2_bison-devel.sha256sum] = "2c96db11e49b29ab0dd3e2d7ff1aea55aea6528c254dd5b278826b3d50115a4d"

URI_x86_64_v2_bison-runtime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bison-runtime-3.8.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_bison-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bison-runtime}"
SRC_URI[x86_64_v2_bison-runtime.sha256sum] = "53d97d9ed3179fb9d3ca89812651b6548e09d78bd4551bc9139600d7f2b17b12"

URI_aarch64_bison = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bison-3.8.2-9.el10.aarch64.rpm;name=aarch64_bison;unpack=0"
SRC_URI:append = " ${URI_aarch64_bison}"
SRC_URI[aarch64_bison.sha256sum] = "753a014f094f9b1abae69456ac5f0a2f37cc883782936227f5e6dd4b6c0552a7"

URI_aarch64_bison-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bison-devel-3.8.2-9.el10.aarch64.rpm;name=aarch64_bison-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bison-devel}"
SRC_URI[aarch64_bison-devel.sha256sum] = "eef5189e7ec3df1a3fda410287d3d329f3110fc94a33bccca6776091a329fe5d"

URI_aarch64_bison-runtime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bison-runtime-3.8.2-9.el10.aarch64.rpm;name=aarch64_bison-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_bison-runtime}"
SRC_URI[aarch64_bison-runtime.sha256sum] = "d6defc92760aaff0ee8c66bf7190db46aa0a652d6c1e2098669f8ca797ebfe14"

RDEPENDS:bison = " \
 glibc \
 m4 \
 "
RDEPENDS:bison-devel = " \
 "
RDEPENDS:bison-runtime = " \
 "
