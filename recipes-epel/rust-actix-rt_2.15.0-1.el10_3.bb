# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-actix-rt"
PV = "2.15.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-actix-rt+actix-macros-devel \
 rust-actix-rt+default-devel \
 rust-actix-rt+macros-devel \
 rust-actix-rt+net-devel \
 rust-actix-rt+signal-devel \
 rust-actix-rt-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-actix-rt-2.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a0777910ed10a101e508074ad1a1cb2e51676ed85ba5c5ed37cbb302663a4445"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+actix-macros-devel-2.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+actix-macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+actix-macros-devel.sha256sum] = "d6604e0d8ede772e3c8ceb00c351d7921e49bca68158744dfcbacec743687e2f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+default-devel-2.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+default-devel.sha256sum] = "5ab8052865a15ae0139e95e31d5aa8716c6d9e7e60a3e3f2eae728679da0b1f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+macros-devel-2.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+macros-devel.sha256sum] = "7b64371263d0ff3816879c4c0f5d93f807f2aabe73fefef817679acc5b7a3d08"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+net-devel-2.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+net-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+net-devel.sha256sum] = "462a7431166ba83db6c39c8d7fee2d1f633f9bfe8ce44276b2c41c42cfa3360b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt+signal-devel-2.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt+signal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt+signal-devel.sha256sum] = "68f2bc72e534c4282ed37f8f8ac2507bde44f93c4ec403c94a801054e4d1e00f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-actix-rt-devel-2.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-actix-rt-devel;unpack=0"
SRC_URI[x86_64_v2_rust-actix-rt-devel.sha256sum] = "48a9e6a1201512326d41408287131f4b18be0edb03e769c79644b6e3bbbc3a6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+actix-macros-devel-2.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-actix-rt+actix-macros-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+actix-macros-devel.sha256sum] = "868367787b3496f3847062b6531eacce8c7b8e3945a0e6457902622e2ea0cb91"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+default-devel-2.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-actix-rt+default-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+default-devel.sha256sum] = "7d62c1ce1c06ddd51b0370ac8adedb78bd4d2df97d1176d60275f291e280cb13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+macros-devel-2.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-actix-rt+macros-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+macros-devel.sha256sum] = "ec0f0e52069fbd47bf7522e8334140629df4ba68e74ff15ff58f2147af55af1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+net-devel-2.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-actix-rt+net-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+net-devel.sha256sum] = "2c98541680387dd56ef0f4fcdd8e7901150435de97670134383c08ff44528da2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt+signal-devel-2.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-actix-rt+signal-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt+signal-devel.sha256sum] = "a6a54dfeecd8462f705c0e1699abe34228da816455e4a1e7e767a4c84c59cd65"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-actix-rt-devel-2.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-actix-rt-devel;unpack=0"
SRC_URI[aarch64_rust-actix-rt-devel.sha256sum] = "712731bb8e5c6cc96b90d2513bf975730a61536ff9e00fbb2a5fc089eb0d6cc6"

RDEPENDS:rust-actix-rt+actix-macros-devel = " \
 cargo \
 rust-actix-macros+default-devel \
 rust-actix-rt-devel \
 "
RDEPENDS:rust-actix-rt+default-devel = " \
 cargo \
 rust-actix-rt+macros-devel \
 rust-actix-rt+net-devel \
 rust-actix-rt+signal-devel \
 rust-actix-rt-devel \
 "
RDEPENDS:rust-actix-rt+macros-devel = " \
 cargo \
 rust-actix-rt+actix-macros-devel \
 rust-actix-rt-devel \
 "
RDEPENDS:rust-actix-rt+net-devel = " \
 cargo \
 rust-actix-rt-devel \
 rust-tokio+net-devel \
 "
RDEPENDS:rust-actix-rt+signal-devel = " \
 cargo \
 rust-actix-rt-devel \
 rust-tokio+signal-devel \
 "
RDEPENDS:rust-actix-rt-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 "
