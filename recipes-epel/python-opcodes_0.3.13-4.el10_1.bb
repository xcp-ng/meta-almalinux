# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-opcodes"
PV = "0.3.13"
PR = "4.el10_1"
PACKAGES = " \
 python3-opcodes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-opcodes-0.3.13-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5cf155dc23907c8b3710c766d5d22823aa3b6ee3ffdbd985db35ba3e3e9bff2"

URI_x86_64_v2_python3-opcodes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opcodes-0.3.13-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opcodes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opcodes}"
SRC_URI[x86_64_v2_python3-opcodes.sha256sum] = "1d18bcab6ef7e82a1864738664c7be8fadff8d51265c6f2a9d30e09b12ef81e5"

URI_aarch64_python3-opcodes = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opcodes-0.3.13-4.el10_1.noarch.rpm;name=aarch64_python3-opcodes;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opcodes}"
SRC_URI[aarch64_python3-opcodes.sha256sum] = "e8304a995cbd46d050765d7cc6039604c9f8ee7696abdb0589ea9492b8e4d93d"

RDEPENDS:python3-opcodes = " \
 python3 \
 python3-setuptools \
 "
