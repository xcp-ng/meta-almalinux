# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libzen"
PV = "0.4.41"
PR = "5.el10_0"
PACKAGES = " \
 libzen \
 libzen-devel \
 libzen-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libzen-0.4.41-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a583643ad478afc7e8d82b18708452d96c432333b3e63cbdc01d79ae7eb17924"

URI_x86_64_v2_libzen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libzen-0.4.41-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libzen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libzen}"
SRC_URI[x86_64_v2_libzen.sha256sum] = "8bf0a30e1132791610fbc44726183e546a25f990bd082f945794d274878c3056"

URI_x86_64_v2_libzen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libzen-devel-0.4.41-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libzen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libzen-devel}"
SRC_URI[x86_64_v2_libzen-devel.sha256sum] = "7c52670c56b1704371ec0f353f4834a89d4611bd87e5962ea2491e9ae242494f"

URI_x86_64_v2_libzen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libzen-doc-0.4.41-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libzen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libzen-doc}"
SRC_URI[x86_64_v2_libzen-doc.sha256sum] = "bae19d0a2e50ca5b2819ad2e052b901abcab2743e72c2cce7f243ef3987b6b29"

URI_aarch64_libzen = "${EPEL_MIRROR}/aarch64/Packages/l/libzen-0.4.41-5.el10_0.aarch64.rpm;name=aarch64_libzen;unpack=0"
SRC_URI:append = " ${URI_aarch64_libzen}"
SRC_URI[aarch64_libzen.sha256sum] = "d955e4ea0fa0c0317c8b7a81c455dd595b77cb3a9cd6f249d05c03b0f5603a47"

URI_aarch64_libzen-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libzen-devel-0.4.41-5.el10_0.aarch64.rpm;name=aarch64_libzen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libzen-devel}"
SRC_URI[aarch64_libzen-devel.sha256sum] = "c3dbaba9c2af28f77045adca58f6cee0907d8a364f7546766310c77214250449"

URI_aarch64_libzen-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libzen-doc-0.4.41-5.el10_0.noarch.rpm;name=aarch64_libzen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libzen-doc}"
SRC_URI[aarch64_libzen-doc.sha256sum] = "fcd5241c7eeced6081f793cec631356c41207c150a39da7af33ac9da25e1c4bf"

RDEPENDS:libzen = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libzen-devel = " \
 cmake-filesystem \
 libzen \
 pkgconf-pkg-config \
 "
RDEPENDS:libzen-doc = " \
 libzen \
 "
