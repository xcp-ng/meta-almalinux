# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-mmorph"
PV = "1.2.0"
PR = "7.el10_0"
PACKAGES = " \
 ghc-mmorph \
 ghc-mmorph-devel \
 ghc-mmorph-doc \
 ghc-mmorph-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-mmorph-1.2.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdc00cd1a93c0294d6c0af4b10a1f4c78684a9aad817de550fabce404beac9a6"

URI_x86_64_v2_ghc-mmorph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mmorph-1.2.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mmorph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mmorph}"
SRC_URI[x86_64_v2_ghc-mmorph.sha256sum] = "884d53a5174d33bf234034be378944a5b1fe4838c96e958765b2c9a7ff4209bb"

URI_x86_64_v2_ghc-mmorph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mmorph-devel-1.2.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mmorph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mmorph-devel}"
SRC_URI[x86_64_v2_ghc-mmorph-devel.sha256sum] = "2fce35741a904858177148cde1d041d6185e2d9ed9faf8f30b5f9aa1abd84711"

URI_x86_64_v2_ghc-mmorph-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mmorph-doc-1.2.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-mmorph-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mmorph-doc}"
SRC_URI[x86_64_v2_ghc-mmorph-doc.sha256sum] = "805cb44f9d7cb8e536b0029f5f8fd822da7d824fa83caea35edc18bfb0d4873f"

URI_x86_64_v2_ghc-mmorph-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mmorph-prof-1.2.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mmorph-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mmorph-prof}"
SRC_URI[x86_64_v2_ghc-mmorph-prof.sha256sum] = "55ceec56affca4499350585458b303b6dd73076227d795ee0a7e0e98b0c2329e"

URI_aarch64_ghc-mmorph = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mmorph-1.2.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-mmorph;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mmorph}"
SRC_URI[aarch64_ghc-mmorph.sha256sum] = "91509268113ab93d63f8455feb6a5cd1a12ef9d3caaaf8cbad5146632b4b97af"

URI_aarch64_ghc-mmorph-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mmorph-devel-1.2.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-mmorph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mmorph-devel}"
SRC_URI[aarch64_ghc-mmorph-devel.sha256sum] = "f92025155f20c22a3763adc9d605c7fd7ff159aaf7467c6195cc20b876e65e94"

URI_aarch64_ghc-mmorph-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mmorph-doc-1.2.0-7.el10_0.noarch.rpm;name=aarch64_ghc-mmorph-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mmorph-doc}"
SRC_URI[aarch64_ghc-mmorph-doc.sha256sum] = "13814121a6f56f3e1efc0ee98b159437ee0e40a3b54451b05241607addd64c0a"

URI_aarch64_ghc-mmorph-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mmorph-prof-1.2.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-mmorph-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mmorph-prof}"
SRC_URI[aarch64_ghc-mmorph-prof.sha256sum] = "bb4361a4ddab48f6888481882d5caf82481e8ff184c91821d8db934137a4c9fd"

RDEPENDS:ghc-mmorph = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-mtl \
 ghc-transformers \
 ghc-transformers-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-mmorph-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-mmorph \
 ghc-mtl-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-mmorph-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-mmorph-prof = " \
 ghc-base-prof \
 ghc-mmorph-devel \
 ghc-mtl-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
