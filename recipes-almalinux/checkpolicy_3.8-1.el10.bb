# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "checkpolicy"
PV = "3.8"
PR = "1.el10"
PACKAGES = " \
 checkpolicy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/checkpolicy-3.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15a4aa51ffee351b7fcfe81e271276e003dd71994ea351732feba449263e7e52"

URI_x86_64_v2_checkpolicy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/checkpolicy-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_checkpolicy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_checkpolicy}"
SRC_URI[x86_64_v2_checkpolicy.sha256sum] = "1e438aa0ef5f7bfa5e21b2c7dd84ef4b986f41d54af70a80979781ea715df9e8"

URI_aarch64_checkpolicy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/checkpolicy-3.8-1.el10.aarch64.rpm;name=aarch64_checkpolicy;unpack=0"
SRC_URI:append = " ${URI_aarch64_checkpolicy}"
SRC_URI[aarch64_checkpolicy.sha256sum] = "e8cb73109069179056cd6465b2f4a1b49a7f28ee826d1f975ac439cf1e6d2534"

RDEPENDS:checkpolicy = " \
 glibc \
 "
