# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fat-macho"
PV = "0.4.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho+default-devel \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fat-macho-0.4.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f680310496b7cd3b2729c0e45839484c96d3520d11f6bfa2ebb80b6f4c5ee4a"

URI_x86_64_v2_rust-fat-macho+bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+bitcode-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+bitcode-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+bitcode-devel.sha256sum] = "b44100d64836b3b01be0aa9525a16552ef7b5ba9d239f830d7ce89739b57504b"

URI_x86_64_v2_rust-fat-macho+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+default-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+default-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+default-devel.sha256sum] = "5ce2200deb939399fb7199a3d9e62657c40513aa025cb04dfcd9d3f5dd2bce0e"

URI_x86_64_v2_rust-fat-macho+llvm-bitcode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho+llvm-bitcode-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho+llvm-bitcode-devel}"
SRC_URI[x86_64_v2_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "a4daa0dd05fd85ec9e79c48982e0353a817c19206dca7839ed787ae07f26934d"

URI_x86_64_v2_rust-fat-macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fat-macho-devel-0.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fat-macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fat-macho-devel}"
SRC_URI[x86_64_v2_rust-fat-macho-devel.sha256sum] = "fea621464bc187dff5cfb32fde56a7e8d2f193ed6364ec89b8e3b142339d79dc"

URI_aarch64_rust-fat-macho+bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+bitcode-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-fat-macho+bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+bitcode-devel}"
SRC_URI[aarch64_rust-fat-macho+bitcode-devel.sha256sum] = "4eb5b5dbe0e9d12f3027907722ea98f6120f243eb1aa028c1decd916d7041bb6"

URI_aarch64_rust-fat-macho+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+default-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-fat-macho+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+default-devel}"
SRC_URI[aarch64_rust-fat-macho+default-devel.sha256sum] = "5e43579e51a85bf6d06bac4548ca0641d1e4a812c92b030f6d4b3abbedb6d71c"

URI_aarch64_rust-fat-macho+llvm-bitcode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho+llvm-bitcode-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-fat-macho+llvm-bitcode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho+llvm-bitcode-devel}"
SRC_URI[aarch64_rust-fat-macho+llvm-bitcode-devel.sha256sum] = "f31ae3961776c8339ae8a4f5360100c7159a414ab06a199850e3699f3fd3936f"

URI_aarch64_rust-fat-macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fat-macho-devel-0.4.10-1.el10_2.noarch.rpm;name=aarch64_rust-fat-macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fat-macho-devel}"
SRC_URI[aarch64_rust-fat-macho-devel.sha256sum] = "86472de668a79ebb40a14468d37dbf9560aaf7f9ddb32abec1ea8f4355021294"

RDEPENDS:rust-fat-macho+bitcode-devel = " \
 cargo \
 rust-fat-macho+llvm-bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+default-devel = " \
 cargo \
 rust-fat-macho+bitcode-devel \
 rust-fat-macho-devel \
 "
RDEPENDS:rust-fat-macho+llvm-bitcode-devel = " \
 cargo \
 rust-fat-macho-devel \
 rust-llvm-bitcode+default-devel \
 "
RDEPENDS:rust-fat-macho-devel = " \
 cargo \
 rust-goblin+default-devel \
 "
