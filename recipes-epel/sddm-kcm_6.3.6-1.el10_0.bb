# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sddm-kcm"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 sddm-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sddm-kcm-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24d907a4c8101475a4108b77a0f8a432e362632c3f760753a6259ccfb55e3c4a"

URI_x86_64_v2_sddm-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-kcm-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sddm-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-kcm}"
SRC_URI[x86_64_v2_sddm-kcm.sha256sum] = "b70d8d912d765200e1b5bc3c5277eddda99884ab1d913f709f692bb4fdfd453a"

URI_aarch64_sddm-kcm = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-kcm-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_sddm-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-kcm}"
SRC_URI[aarch64_sddm-kcm.sha256sum] = "aa40db53f4d60ed02d4c1c81aa4ed64bda2770cbcd73b1d01f66767277e1f13e"

RDEPENDS:sddm-kcm = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 sddm \
 "
