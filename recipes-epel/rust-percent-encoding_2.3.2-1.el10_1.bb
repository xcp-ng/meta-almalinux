# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-percent-encoding"
PV = "2.3.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-percent-encoding+alloc-devel \
 rust-percent-encoding+default-devel \
 rust-percent-encoding+std-devel \
 rust-percent-encoding-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-percent-encoding-2.3.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e1cd5226cd6fbd91719718ac246c56a8ab205f9edadd9627cc733f11cbc251b"

URI_x86_64_v2_rust-percent-encoding+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding+alloc-devel-2.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-percent-encoding+alloc-devel}"
SRC_URI[x86_64_v2_rust-percent-encoding+alloc-devel.sha256sum] = "95a8be61403e99f9ca3bf27e3f0d330b661337d4af6177bd07eb3cce9141d8e7"

URI_x86_64_v2_rust-percent-encoding+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding+default-devel-2.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-percent-encoding+default-devel}"
SRC_URI[x86_64_v2_rust-percent-encoding+default-devel.sha256sum] = "487e45f1d0cc0a129b108b4d27819b1ee6b1183caa76f479e983c648595c91eb"

URI_x86_64_v2_rust-percent-encoding+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding+std-devel-2.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-percent-encoding+std-devel}"
SRC_URI[x86_64_v2_rust-percent-encoding+std-devel.sha256sum] = "62b5784fcd8577d72326bb43bd1ac928d8c02033bbf3dae125632ac46aaf13d0"

URI_x86_64_v2_rust-percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-percent-encoding-devel-2.3.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-percent-encoding-devel.sha256sum] = "210cd0942302f2d02f741c7a66a41131704f81cdb65f609089079fbd64a240a5"

URI_aarch64_rust-percent-encoding+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding+alloc-devel-2.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-percent-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-percent-encoding+alloc-devel}"
SRC_URI[aarch64_rust-percent-encoding+alloc-devel.sha256sum] = "660c3483f13d6a20dd6a0f6a1cb9465de720fc7383a752b9b3214f2493b9fb2a"

URI_aarch64_rust-percent-encoding+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding+default-devel-2.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-percent-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-percent-encoding+default-devel}"
SRC_URI[aarch64_rust-percent-encoding+default-devel.sha256sum] = "30711c63661bb1967d3e499e8894cd5621bc19687db93e5b6649a6fadb6679ee"

URI_aarch64_rust-percent-encoding+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding+std-devel-2.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-percent-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-percent-encoding+std-devel}"
SRC_URI[aarch64_rust-percent-encoding+std-devel.sha256sum] = "016154c42c651977373860d5d1e294d87c8c23e07f8cd49a4e4023eff8cb128a"

URI_aarch64_rust-percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-percent-encoding-devel-2.3.2-1.el10_1.noarch.rpm;name=aarch64_rust-percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-percent-encoding-devel}"
SRC_URI[aarch64_rust-percent-encoding-devel.sha256sum] = "a35aa734df2cd2590e0c09051d84aeeb6861f544124489b2d33eff9d84a2ee0e"

RDEPENDS:rust-percent-encoding+alloc-devel = " \
 cargo \
 rust-percent-encoding-devel \
 "
RDEPENDS:rust-percent-encoding+default-devel = " \
 cargo \
 rust-percent-encoding+std-devel \
 rust-percent-encoding-devel \
 "
RDEPENDS:rust-percent-encoding+std-devel = " \
 cargo \
 rust-percent-encoding+alloc-devel \
 rust-percent-encoding-devel \
 "
RDEPENDS:rust-percent-encoding-devel = " \
 cargo \
 rust \
 "
