# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtdeclarative"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtdeclarative \
 qt5-qtdeclarative-devel \
 qt5-qtdeclarative-examples \
 qt5-qtdeclarative-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtdeclarative-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c5e5cfd87899201c014be4485a6e5a63bd20c4a8f4bcdd38693accc8d074822"

URI_x86_64_v2_qt5-qtdeclarative = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative}"
SRC_URI[x86_64_v2_qt5-qtdeclarative.sha256sum] = "2ec6bfbed5066cfa3c1ce61b581b3c996775e8398c179fe4802e66bc0210c2da"

URI_x86_64_v2_qt5-qtdeclarative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-devel}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-devel.sha256sum] = "768e9f63116cc494f1317aeba2cb7c52c8e35a0c47c6cd9a0897c6c049735e8b"

URI_x86_64_v2_qt5-qtdeclarative-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-examples}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-examples.sha256sum] = "7b313aceaa9702467d8e7c030d492a7f397d7ab019816f4c266a052623cbfe22"

URI_x86_64_v2_qt5-qtdeclarative-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdeclarative-static-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdeclarative-static}"
SRC_URI[x86_64_v2_qt5-qtdeclarative-static.sha256sum] = "0988b9f9602f32ce98d7622724641f184747963d20da6323cb8a7ef9a697f47f"

URI_aarch64_qt5-qtdeclarative = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative}"
SRC_URI[aarch64_qt5-qtdeclarative.sha256sum] = "f3272079ecabf7d33b02b1e3bdd3fc2b80f76d686d8d29acf7ace05f00bc5272"

URI_aarch64_qt5-qtdeclarative-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-devel}"
SRC_URI[aarch64_qt5-qtdeclarative-devel.sha256sum] = "14cd229f50cf9c1b9d8938012794f116b4a604cc187c1af5a527c26f1d6ff6fc"

URI_aarch64_qt5-qtdeclarative-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-examples}"
SRC_URI[aarch64_qt5-qtdeclarative-examples.sha256sum] = "66349bf1cbc119dcb6659df4fb70b0b722a446e6a72785eb907033a46d9675bb"

URI_aarch64_qt5-qtdeclarative-static = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdeclarative-static-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdeclarative-static}"
SRC_URI[aarch64_qt5-qtdeclarative-static.sha256sum] = "7a3f85192190480cb82f4961be75da447a5855f9381e0498f9c893bee623d5bf"

RDEPENDS:qt5-qtdeclarative:x86_64_v2 = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtdeclarative:aarch64 = " \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
"
RDEPENDS:qt5-qtdeclarative-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtdeclarative-devel \
 "
RDEPENDS:qt5-qtdeclarative-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtdeclarative-static = " \
 qt5-qtdeclarative-devel \
 "
