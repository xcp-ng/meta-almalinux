# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-context"
PV = "6.3.0"
PR = "2.el10_3"
PACKAGES = " \
 python-oslo-context-doc \
 python3-oslo-context \
 python3-oslo-context-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-context-6.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4baf12941e1c7478ac5b6669afe7890db2200f3f06c220a67116001a5acfd1c1"

URI_x86_64_v2_python-oslo-context-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-context-doc-6.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-context-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-context-doc}"
SRC_URI[x86_64_v2_python-oslo-context-doc.sha256sum] = "d001b45b3ad7b03c2c2e1e5b22f104e31e4b28ca93fbd9efd8e88a0e4e7ee4ae"

URI_x86_64_v2_python3-oslo-context = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-context-6.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-context;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-context}"
SRC_URI[x86_64_v2_python3-oslo-context.sha256sum] = "b9f74f7056517de315498e5b0a64b868c47d1cfa61a6d1200eb60445ead18d4f"

URI_x86_64_v2_python3-oslo-context-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-context-tests-6.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-context-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-context-tests}"
SRC_URI[x86_64_v2_python3-oslo-context-tests.sha256sum] = "fc2b0cf202ef84f593b915dd456f8d0c94d6bf00c66a89b8c1d6bc1940cd9fae"

URI_aarch64_python-oslo-context-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-context-doc-6.3.0-2.el10_3.noarch.rpm;name=aarch64_python-oslo-context-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-context-doc}"
SRC_URI[aarch64_python-oslo-context-doc.sha256sum] = "bca441d0b8cf775f0b4d47f2efae401733efff34fa25a75f6e07371f71cab201"

URI_aarch64_python3-oslo-context = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-context-6.3.0-2.el10_3.noarch.rpm;name=aarch64_python3-oslo-context;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-context}"
SRC_URI[aarch64_python3-oslo-context.sha256sum] = "4b1d7e634751bef4be02897df6f2b90dd08156e7c1131db8db6a87af33966425"

URI_aarch64_python3-oslo-context-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-context-tests-6.3.0-2.el10_3.noarch.rpm;name=aarch64_python3-oslo-context-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-context-tests}"
SRC_URI[aarch64_python3-oslo-context-tests.sha256sum] = "f4175cabae81c17f36b53692432cfff4d34138f3c5ee93e2f98ac8f5331c71af"

RDEPENDS:python-oslo-context-doc = " \
 "
RDEPENDS:python3-oslo-context = " \
 python3 \
 python3-pbr \
 python3-typing-extensions \
 "
RDEPENDS:python3-oslo-context-tests = " \
 python3 \
 python3-oslo-context \
 "
