# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror"
PV = "2.0.16"
PR = "1.el10_0"
PACKAGES = " \
 rust-thiserror+default-devel \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-2.0.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "449ada0c76e829a41a519170703a2c1409df4b84f0f2bd551f104d1289f296db"

URI_x86_64_v2_rust-thiserror+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+default-devel-2.0.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror+default-devel}"
SRC_URI[x86_64_v2_rust-thiserror+default-devel.sha256sum] = "7bce9e02a4b859a327d120078cfc6a65e5b48ef58657cf5719f4d5838886b615"

URI_x86_64_v2_rust-thiserror+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+std-devel-2.0.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror+std-devel}"
SRC_URI[x86_64_v2_rust-thiserror+std-devel.sha256sum] = "3788bd3a800a5394deb662f09e11793cab7f9eab21238bb7bb04e5f2c3d50f9e"

URI_x86_64_v2_rust-thiserror-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-devel-2.0.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-devel}"
SRC_URI[x86_64_v2_rust-thiserror-devel.sha256sum] = "87a52247475c885c7e10dba7aa2bf0151d0401ed7e878792b8ced48b426d284a"

URI_aarch64_rust-thiserror+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+default-devel-2.0.16-1.el10_0.noarch.rpm;name=aarch64_rust-thiserror+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror+default-devel}"
SRC_URI[aarch64_rust-thiserror+default-devel.sha256sum] = "4addf184fb216284adf4a96a99d12119b9b745aa9cfe815c8ae37bfe899702e7"

URI_aarch64_rust-thiserror+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+std-devel-2.0.16-1.el10_0.noarch.rpm;name=aarch64_rust-thiserror+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror+std-devel}"
SRC_URI[aarch64_rust-thiserror+std-devel.sha256sum] = "e996d7bd804f2070ed8b5b3719a580e69eea21ee7b2583454302499cfdb98470"

URI_aarch64_rust-thiserror-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-devel-2.0.16-1.el10_0.noarch.rpm;name=aarch64_rust-thiserror-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-devel}"
SRC_URI[aarch64_rust-thiserror-devel.sha256sum] = "1543438636e2fa5674df92e0b7643d17e1af5837cb166a3d14c1b97afbc0cb1f"

RDEPENDS:rust-thiserror+default-devel = " \
 cargo \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror+std-devel = " \
 cargo \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror-devel = " \
 cargo \
 rust \
 rust-thiserror-impl+default-devel \
 "
