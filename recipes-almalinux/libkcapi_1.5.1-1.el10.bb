# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcapi"
PV = "1.5.1"
PR = "1.el10"
PACKAGES = " \
 libkcapi \
 libkcapi-hasher \
 libkcapi-hmaccalc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libkcapi-1.5.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2159213f58d49f96b9d95e7997de5f7708ae328be0d1ece244a1e84721065d7a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkcapi-1.5.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libkcapi;unpack=0"
SRC_URI[x86_64_v2_libkcapi.sha256sum] = "6d4a39dfee7313fce3b3b080df7c481bc79d7658c799b88b7873af15ae4735c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkcapi-hasher-1.5.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libkcapi-hasher;unpack=0"
SRC_URI[x86_64_v2_libkcapi-hasher.sha256sum] = "4b0ff86108713c203857874c6c63c263545e2d3230c3844f8736f1ac84336036"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkcapi-hmaccalc-1.5.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libkcapi-hmaccalc;unpack=0"
SRC_URI[x86_64_v2_libkcapi-hmaccalc.sha256sum] = "17d7ad702cd702abe1e2f1651af7b438c02d21d02ace2b2e2b88521ede1f453d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkcapi-1.5.1-1.el10.aarch64.rpm;name=aarch64_libkcapi;unpack=0"
SRC_URI[aarch64_libkcapi.sha256sum] = "c786033e0069a3ba1afe34080903c7288b17795ca5c977d2d1154ff724c13d58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkcapi-hasher-1.5.1-1.el10.aarch64.rpm;name=aarch64_libkcapi-hasher;unpack=0"
SRC_URI[aarch64_libkcapi-hasher.sha256sum] = "6b3ecc14c9041dec798e918909e132b9b7f7d5c6f94da7a74b240dc1d602f663"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkcapi-hmaccalc-1.5.1-1.el10.aarch64.rpm;name=aarch64_libkcapi-hmaccalc;unpack=0"
SRC_URI[aarch64_libkcapi-hmaccalc.sha256sum] = "eeaf01d216ef2fe408c40f7d01b267f761819bb9834e75cc5b78beaf51f4ad4e"

RDEPENDS:libkcapi = " \
 glibc \
 systemd \
 "
RDEPENDS:libkcapi-hasher = " \
 glibc \
 libkcapi \
 "
RDEPENDS:libkcapi-hmaccalc = " \
 libkcapi-hasher \
 "
