# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-async-lru"
PV = "2.0.5"
PR = "1.el10_1"
PACKAGES = " \
 python3-async-lru \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-async-lru-2.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c86083c0be2a6a4c87e95b1ed7f8c5d349b01710902f47ddc70e4473c1912a9"

URI_x86_64_v2_python3-async-lru = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-async-lru-2.0.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-async-lru;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-async-lru}"
SRC_URI[x86_64_v2_python3-async-lru.sha256sum] = "374904f1f8b627cb116ed225d783432b1b8beef0cf2631db22f55408044b6e74"

URI_aarch64_python3-async-lru = "${EPEL_MIRROR}/aarch64/Packages/p/python3-async-lru-2.0.5-1.el10_1.noarch.rpm;name=aarch64_python3-async-lru;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-async-lru}"
SRC_URI[aarch64_python3-async-lru.sha256sum] = "98955676b12512b29c942d82ded84f224de5af4f14ac23a33f59699e7b6d0d3d"

RDEPENDS:python3-async-lru = " \
 python3 \
 "
