# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-XSAccessor"
PV = "1.19"
PR = "37.el10"
PACKAGES = " \
 perl-Class-XSAccessor \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Class-XSAccessor-1.19-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "213c1dc814d2c9b7807103daefe09c111a2c75a01347e58f6cff21e7e60391ab"

URI_x86_64_v2_perl-Class-XSAccessor = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Class-XSAccessor-1.19-37.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Class-XSAccessor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-XSAccessor}"
SRC_URI[x86_64_v2_perl-Class-XSAccessor.sha256sum] = "b6dfc35a9e226100294de385831736c0809880ecbe3b9f80d0cac9e0e8b2f144"

URI_aarch64_perl-Class-XSAccessor = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Class-XSAccessor-1.19-37.el10.aarch64.rpm;name=aarch64_perl-Class-XSAccessor;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-XSAccessor}"
SRC_URI[aarch64_perl-Class-XSAccessor.sha256sum] = "4f16acd42966983d672a474dc0eb667a21d4492e276e85515fb8bd260e900bfd"

RDEPENDS:perl-Class-XSAccessor = " \
 glibc \
 perl-Carp \
 perl-Class-XSAccessor \
 perl-libs \
 "
