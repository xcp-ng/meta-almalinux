# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pborman-getopt"
PV = "2.1.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-pborman-getopt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pborman-getopt-2.1.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8660181fb1bd81b7d41c13aa2b614af57a7b203cc06061b8b1aa3f1e1d2069a5"

URI_x86_64_v2_golang-github-pborman-getopt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pborman-getopt-devel-2.1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pborman-getopt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pborman-getopt-devel}"
SRC_URI[x86_64_v2_golang-github-pborman-getopt-devel.sha256sum] = "f25f47b40c61a4ab39e717d887ccb338b4f6cf9165570fb0a943e2d2a6a28c8f"

URI_aarch64_golang-github-pborman-getopt-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pborman-getopt-devel-2.1.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-pborman-getopt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pborman-getopt-devel}"
SRC_URI[aarch64_golang-github-pborman-getopt-devel.sha256sum] = "c7a3ee431fc2ae1814b85d46a402601a6862f45c9f6da7aef45bcedacbdc5409"

RDEPENDS:golang-github-pborman-getopt-devel = " \
 go-filesystem \
 "
