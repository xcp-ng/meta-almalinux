# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnetfilter_cthelper"
PV = "1.0.1"
PR = "1.el10"
PACKAGES = " \
 libnetfilter_cthelper \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnetfilter_cthelper-1.0.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2159ae30ba6da3f3395c061242c9a854d6bae6da6ddee47fe2ed147c31b2dce2"

URI_x86_64_v2_libnetfilter_cthelper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnetfilter_cthelper-1.0.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnetfilter_cthelper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetfilter_cthelper}"
SRC_URI[x86_64_v2_libnetfilter_cthelper.sha256sum] = "bc74220c16615879fe566fb765679f9e285a6f0cf28bb52dea26223a2bed3e28"

URI_aarch64_libnetfilter_cthelper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnetfilter_cthelper-1.0.1-1.el10.aarch64.rpm;name=aarch64_libnetfilter_cthelper;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetfilter_cthelper}"
SRC_URI[aarch64_libnetfilter_cthelper.sha256sum] = "4234440deb2c2dca0bfeec380eed591ce4095ab64f94854d49282a940e86bee5"

RDEPENDS:libnetfilter_cthelper = " \
 glibc \
 libmnl \
 "
