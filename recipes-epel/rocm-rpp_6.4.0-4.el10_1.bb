# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-rpp"
PV = "6.4.0"
PR = "4.el10_1"
PACKAGES:x86_64_v2 = " \
 rocm-rpp \
 rocm-rpp-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-rpp-6.4.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc39bba14359a6f71acccfad51b07a2e16da8de55e7b0f2afb48fdff7360fa03"

URI_x86_64_v2_rocm-rpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rpp-6.4.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-rpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-rpp}"
SRC_URI[x86_64_v2_rocm-rpp.sha256sum] = "f501b877f21e495bcb669136ec16d8b4c37cba5cbe25c5405ee954d94815fd20"

URI_x86_64_v2_rocm-rpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-rpp-devel-6.4.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-rpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-rpp-devel}"
SRC_URI[x86_64_v2_rocm-rpp-devel.sha256sum] = "1386040e4e7d8ae76c2d2d9033caa1a26d05e8b1356155970eec8bf6d0bd3198"

RDEPENDS:rocm-rpp = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 virtual/libomp.so_VERSION__64bit_ \
 virtual/libomp.so___64bit_ \
 "
RDEPENDS:rocm-rpp-devel = " \
 rocm-rpp \
 "
