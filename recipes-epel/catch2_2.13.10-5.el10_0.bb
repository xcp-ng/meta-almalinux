# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "catch2"
PV = "2.13.10"
PR = "5.el10_0"
PACKAGES = " \
 catch2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/catch2-2.13.10-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "693c21a77cd8a7a2928838b018cb1d03d57f497221904e4f210aaabc2990644a"

URI_x86_64_v2_catch2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/catch2-devel-2.13.10-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_catch2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_catch2-devel}"
SRC_URI[x86_64_v2_catch2-devel.sha256sum] = "e353257d6eee7306b793d24be8780d8ee4aebaa4c1896c569d4bef3a320b0c2d"

URI_aarch64_catch2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/catch2-devel-2.13.10-5.el10_0.aarch64.rpm;name=aarch64_catch2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_catch2-devel}"
SRC_URI[aarch64_catch2-devel.sha256sum] = "c3468a21aacbca897c3cd830dc8c4bddf9415ee2d3f7bc4d5fa74cea433d3bb7"

RDEPENDS:catch2-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
