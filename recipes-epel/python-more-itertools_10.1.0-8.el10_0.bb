# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-more-itertools"
PV = "10.1.0"
PR = "8.el10_0"
PACKAGES = " \
 python3-more-itertools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-more-itertools-10.1.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6dd1b65df0c58533378fa5358e83ae84554fd342f0ef84772771cd73d05c0210"

URI_x86_64_v2_python3-more-itertools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-more-itertools-10.1.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-more-itertools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-more-itertools}"
SRC_URI[x86_64_v2_python3-more-itertools.sha256sum] = "b5362cb3503b4d8e746d685a343dabd460753d5bfbee0e9c9e7901c4a4d1be43"

URI_aarch64_python3-more-itertools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-more-itertools-10.1.0-8.el10_0.noarch.rpm;name=aarch64_python3-more-itertools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-more-itertools}"
SRC_URI[aarch64_python3-more-itertools.sha256sum] = "21a59ba4e742c112a21c1a7b441e6e7de9f64e5105dc1515e084a09fac8a42ec"

RDEPENDS:python3-more-itertools = " \
 python3 \
 "
