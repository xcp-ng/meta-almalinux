# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-whoami"
PV = "1.6.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-whoami+default-devel \
 rust-whoami-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-whoami-1.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc6694a2219b4f8c63f7816309c491f44035f7cc1c8a2815ec01d42727c103bd"

URI_x86_64_v2_rust-whoami+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-whoami+default-devel-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-whoami+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-whoami+default-devel}"
SRC_URI[x86_64_v2_rust-whoami+default-devel.sha256sum] = "733bc0ede83104c9e058e701e2ccc4b1fc9f852c980c48c0c2636cdbd0071f25"

URI_x86_64_v2_rust-whoami-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-whoami-devel-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-whoami-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-whoami-devel}"
SRC_URI[x86_64_v2_rust-whoami-devel.sha256sum] = "94e97952e6583349f4d2fa7546a9d80e4692948299bdb7cfc53f69149b030674"

URI_aarch64_rust-whoami+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-whoami+default-devel-1.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-whoami+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-whoami+default-devel}"
SRC_URI[aarch64_rust-whoami+default-devel.sha256sum] = "9c5209959bca76b8dc7d77064e7b36870568fc376caa693f46dff68f00781f68"

URI_aarch64_rust-whoami-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-whoami-devel-1.6.1-1.el10_1.noarch.rpm;name=aarch64_rust-whoami-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-whoami-devel}"
SRC_URI[aarch64_rust-whoami-devel.sha256sum] = "a8d50cfd230fcca04fa48fb0a3444652373904c6ced5a498678210c427444a78"

RDEPENDS:rust-whoami+default-devel = " \
 cargo \
 rust-whoami-devel \
 "
RDEPENDS:rust-whoami-devel = " \
 cargo \
 rust \
 "
