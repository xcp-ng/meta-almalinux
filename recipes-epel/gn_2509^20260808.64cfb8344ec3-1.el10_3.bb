# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gn"
PV = "2509^20260808.64cfb8344ec3"
PR = "1.el10_3"
PACKAGES = " \
 gn \
 gn-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gn-2509^20260808.64cfb8344ec3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6db10a6c424bda60b74cdffb490bf1cf60fd37960bf5c930e634bcb25c2a1ce"

URI_x86_64_v2_gn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-2509^20260808.64cfb8344ec3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gn}"
SRC_URI[x86_64_v2_gn.sha256sum] = "d945a135ed0980ed8c96be4f9816434703f6529e688e6ad2b45653a9f141e6ef"

URI_x86_64_v2_gn-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gn-doc-2509^20260808.64cfb8344ec3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_gn-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gn-doc}"
SRC_URI[x86_64_v2_gn-doc.sha256sum] = "1af31e9220f3a28b0da7755be4c2f36be49b0f2ff457b0c0c3554744930212f0"

URI_aarch64_gn = "${EPEL_MIRROR}/aarch64/Packages/g/gn-2509^20260808.64cfb8344ec3-1.el10_3.aarch64.rpm;name=aarch64_gn;unpack=0"
SRC_URI:append = " ${URI_aarch64_gn}"
SRC_URI[aarch64_gn.sha256sum] = "f8d8b94bb752a2a23c2637a440a97d220f8f5c81766e88849b3342983260577c"

URI_aarch64_gn-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gn-doc-2509^20260808.64cfb8344ec3-1.el10_3.noarch.rpm;name=aarch64_gn-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gn-doc}"
SRC_URI[aarch64_gn-doc.sha256sum] = "6192f37534df7618607010e3bd474a64b7eb0063b86755cd1e26f9d06b3fbd65"

RDEPENDS:gn = " \
 emacs-filesystem \
 glibc \
 libstdc++ \
 python3 \
 vim-filesystem \
 "
RDEPENDS:gn-doc = " \
 "
