# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "human-theme-gtk"
PV = "3.1.0"
PR = "1.el10_1"
PACKAGES = " \
 human-theme-gtk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/human-theme-gtk-3.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ea5e92dcc669ef8ff6154c49739c2062621cf08a50d50e769c0a000c9c0ae9f"

URI_x86_64_v2_human-theme-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/human-theme-gtk-3.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_human-theme-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_human-theme-gtk}"
SRC_URI[x86_64_v2_human-theme-gtk.sha256sum] = "a9771f8f61b15c8bfb85cf284c4a79482b6b1ef886963e915557aefd265ccef1"

URI_aarch64_human-theme-gtk = "${EPEL_MIRROR}/aarch64/Packages/h/human-theme-gtk-3.1.0-1.el10_1.noarch.rpm;name=aarch64_human-theme-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_human-theme-gtk}"
SRC_URI[aarch64_human-theme-gtk.sha256sum] = "6ddc628ecac8e8b82e6cf275904ab9373c23b28378e68fb5e106607544edb355"

RDEPENDS:human-theme-gtk = " \
 "
