# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-number_prefix"
PV = "0.4.0"
PR = "12.el10_0"
PACKAGES = " \
 rust-number_prefix+default-devel \
 rust-number_prefix+std-devel \
 rust-number_prefix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-number_prefix-0.4.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "328548141e21261ca1ad6a6842f7b01cded123e844459fddfa59b99412a87916"

URI_x86_64_v2_rust-number_prefix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-number_prefix+default-devel-0.4.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-number_prefix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-number_prefix+default-devel}"
SRC_URI[x86_64_v2_rust-number_prefix+default-devel.sha256sum] = "a2686e1dbe960dc13617e635e028a21023e6a442b33affcc3678f3aa0417e571"

URI_x86_64_v2_rust-number_prefix+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-number_prefix+std-devel-0.4.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-number_prefix+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-number_prefix+std-devel}"
SRC_URI[x86_64_v2_rust-number_prefix+std-devel.sha256sum] = "5030fde25734ef4296a6307f0fcbddac409981cbea653b8643768fe67d97e636"

URI_x86_64_v2_rust-number_prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-number_prefix-devel-0.4.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-number_prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-number_prefix-devel}"
SRC_URI[x86_64_v2_rust-number_prefix-devel.sha256sum] = "a11fb9184fdca71ea1dc0f8c463bca046feeec17536ab385a96cd1abd48e8202"

URI_aarch64_rust-number_prefix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-number_prefix+default-devel-0.4.0-12.el10_0.noarch.rpm;name=aarch64_rust-number_prefix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-number_prefix+default-devel}"
SRC_URI[aarch64_rust-number_prefix+default-devel.sha256sum] = "7ef82be4951ddc00fb49696a50105a46f33595daa7dc5dd45813b26273d7edb7"

URI_aarch64_rust-number_prefix+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-number_prefix+std-devel-0.4.0-12.el10_0.noarch.rpm;name=aarch64_rust-number_prefix+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-number_prefix+std-devel}"
SRC_URI[aarch64_rust-number_prefix+std-devel.sha256sum] = "d92ffdfaaffc3577fdb29001607c8dbdaae998668779954b8f5eeb46a67c0d67"

URI_aarch64_rust-number_prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-number_prefix-devel-0.4.0-12.el10_0.noarch.rpm;name=aarch64_rust-number_prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-number_prefix-devel}"
SRC_URI[aarch64_rust-number_prefix-devel.sha256sum] = "b2a616973a334068fee3c235d0307439cfac006483097dfff4dda5306d1cf8b2"

RDEPENDS:rust-number_prefix+default-devel = " \
 cargo \
 rust-number_prefix+std-devel \
 rust-number_prefix-devel \
 "
RDEPENDS:rust-number_prefix+std-devel = " \
 cargo \
 rust-number_prefix-devel \
 "
RDEPENDS:rust-number_prefix-devel = " \
 cargo \
 "
