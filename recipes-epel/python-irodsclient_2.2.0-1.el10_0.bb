# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-irodsclient"
PV = "2.2.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-irodsclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-irodsclient-2.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e2fbeff730034a70be73a6589a8c79f28542b31139cbadbb46c4262d114c7f8"

URI_x86_64_v2_python3-irodsclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-irodsclient-2.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-irodsclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-irodsclient}"
SRC_URI[x86_64_v2_python3-irodsclient.sha256sum] = "93eaae15287b1c4a735e400c6c589ef16d88a7a0501bf6c01f3e5ffefe5db301"

URI_aarch64_python3-irodsclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-irodsclient-2.2.0-1.el10_0.noarch.rpm;name=aarch64_python3-irodsclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-irodsclient}"
SRC_URI[aarch64_python3-irodsclient.sha256sum] = "5f6f12c64aa9bd1f78e41c9442acabdd56d484c7074b0cc27e7ecc2a4040c719"

RDEPENDS:python3-irodsclient = " \
 python3 \
 python3-defusedxml \
 python3-prettytable \
 python3-six \
 "
