# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cryptopp"
PV = "8.8.0"
PR = "9.el10_1"
PACKAGES = " \
 cryptopp \
 cryptopp-devel \
 cryptopp-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cryptopp-8.8.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e83f6f3d0b39c96d893d4b46b1e794b39febf956380380b019127fbc8de36de7"

URI_x86_64_v2_cryptopp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cryptopp-8.8.0-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cryptopp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptopp}"
SRC_URI[x86_64_v2_cryptopp.sha256sum] = "447fd50727dd48a68788172225c0d9ae64da7b8d3eb914c7350d940f7d0ed1d6"

URI_x86_64_v2_cryptopp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cryptopp-devel-8.8.0-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cryptopp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptopp-devel}"
SRC_URI[x86_64_v2_cryptopp-devel.sha256sum] = "9e98c77b609b3294c070c1e90377d539f7e6a963ac12364c94a4fe0cf5909ecc"

URI_x86_64_v2_cryptopp-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cryptopp-static-8.8.0-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cryptopp-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptopp-static}"
SRC_URI[x86_64_v2_cryptopp-static.sha256sum] = "ad975f218713a328ec9a69f1fcd79776f77169ecc8e2edb4e64abeabe93778a0"

URI_aarch64_cryptopp = "${EPEL_MIRROR}/aarch64/Packages/c/cryptopp-8.8.0-9.el10_1.aarch64.rpm;name=aarch64_cryptopp;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptopp}"
SRC_URI[aarch64_cryptopp.sha256sum] = "dbf309516ae5e472d3bd3708293267ad23fc26cd62550128cd13e18365cd1793"

URI_aarch64_cryptopp-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cryptopp-devel-8.8.0-9.el10_1.aarch64.rpm;name=aarch64_cryptopp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptopp-devel}"
SRC_URI[aarch64_cryptopp-devel.sha256sum] = "f2c585e1a7a304d019efd6f4a62e248d737253dfdc8adeed49dcb2c963de108b"

URI_aarch64_cryptopp-static = "${EPEL_MIRROR}/aarch64/Packages/c/cryptopp-static-8.8.0-9.el10_1.aarch64.rpm;name=aarch64_cryptopp-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptopp-static}"
SRC_URI[aarch64_cryptopp-static.sha256sum] = "8293f9edb0b2262c8274e1e5263f7473f9ec1b8c94e9f3e05101101e8e11cfee"

RDEPENDS:cryptopp = " \
 glibc \
 libgcc \
 "
RDEPENDS:cryptopp-devel = " \
 cryptopp \
 pkgconf-pkg-config \
 "
RDEPENDS:cryptopp-static = " \
 cryptopp-devel \
 "
