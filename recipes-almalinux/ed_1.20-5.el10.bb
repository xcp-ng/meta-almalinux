# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ed"
PV = "1.20"
PR = "5.el10"
PACKAGES = " \
 ed \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ed-1.20-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84ffea7405834522a007221ca7c3b0c79ae4ca41e2a0ff954ae4cd34706c7825"

URI_x86_64_v2_ed = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ed-1.20-5.el10.x86_64_v2.rpm;name=x86_64_v2_ed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ed}"
SRC_URI[x86_64_v2_ed.sha256sum] = "0d5fa8cf5011f57c05db5b0db162ed71312b07343251096fc23f5bd83413d351"

URI_aarch64_ed = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ed-1.20-5.el10.aarch64.rpm;name=aarch64_ed;unpack=0"
SRC_URI:append = " ${URI_aarch64_ed}"
SRC_URI[aarch64_ed.sha256sum] = "6eaf7eab5cb0e9992b2f81def62b66b4d19d10030547fddae8ef227cd8747b0a"

RDEPENDS:ed = " \
 bash \
 glibc \
 "
