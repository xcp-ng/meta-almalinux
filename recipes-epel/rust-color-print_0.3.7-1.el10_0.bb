# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-color-print"
PV = "0.3.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-color-print+default-devel \
 rust-color-print+lazy_static-devel \
 rust-color-print-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-color-print-0.3.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55f6eb7b5ecac6efe0ed5dc98c378b55bef2d17f74b50e0c3324fa5321b3b06a"

URI_x86_64_v2_rust-color-print+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-print+default-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-print+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-color-print+default-devel}"
SRC_URI[x86_64_v2_rust-color-print+default-devel.sha256sum] = "36044015a5ffa4818d015c1c728368d6eb128627fc89fa9a97505aeb5f2f1053"

URI_x86_64_v2_rust-color-print+lazy_static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-print+lazy_static-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-print+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-color-print+lazy_static-devel}"
SRC_URI[x86_64_v2_rust-color-print+lazy_static-devel.sha256sum] = "0d15f87c2fa54edb522f4405d764786e6901d9e08f2b932073f3c586fb485f5d"

URI_x86_64_v2_rust-color-print-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-print-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-print-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-color-print-devel}"
SRC_URI[x86_64_v2_rust-color-print-devel.sha256sum] = "9a46e5668137b6e1e7693b9b26fa97202aa376bab7f1bbe7a8a7ef465afbd94d"

URI_aarch64_rust-color-print+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-color-print+default-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-color-print+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-color-print+default-devel}"
SRC_URI[aarch64_rust-color-print+default-devel.sha256sum] = "53196cef048e4c0a81f3a4fafbb9fbf68d35bb5188570bc7017c09dda47a2bbd"

URI_aarch64_rust-color-print+lazy_static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-color-print+lazy_static-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-color-print+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-color-print+lazy_static-devel}"
SRC_URI[aarch64_rust-color-print+lazy_static-devel.sha256sum] = "d4f7b5fc0689c148a357cdda9a52db3ffc87d7822316ef6786219de2a10b8926"

URI_aarch64_rust-color-print-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-color-print-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-color-print-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-color-print-devel}"
SRC_URI[aarch64_rust-color-print-devel.sha256sum] = "1683bf28246779db4e6860af20e7c7f163ff2ebcb63d06a38bf49360ed9a947b"

RDEPENDS:rust-color-print+default-devel = " \
 cargo \
 rust-color-print-devel \
 "
RDEPENDS:rust-color-print+lazy_static-devel = " \
 cargo \
 rust-color-print-devel \
 rust-lazy_static+default-devel \
 "
RDEPENDS:rust-color-print-devel = " \
 cargo \
 rust-color-print-proc-macro+default-devel \
 "
