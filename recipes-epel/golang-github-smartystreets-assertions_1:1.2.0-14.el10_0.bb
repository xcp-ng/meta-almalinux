# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-smartystreets-assertions"
PE = "1"
PV = "1.2.0"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-smartystreets-assertions-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-smartystreets-assertions-1.2.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60af36c5b91a9797b99ec2742d4c20fed1dc866bc204130bcaeab164e8ca4434"

URI_x86_64_v2_golang-github-smartystreets-assertions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-smartystreets-assertions-devel-1.2.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-smartystreets-assertions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-smartystreets-assertions-devel}"
SRC_URI[x86_64_v2_golang-github-smartystreets-assertions-devel.sha256sum] = "da271a52996daa98ee4afea0baa416a6803444fa574ba8ca376aeeb482f042cf"

URI_aarch64_golang-github-smartystreets-assertions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-smartystreets-assertions-devel-1.2.0-14.el10_0.noarch.rpm;name=aarch64_golang-github-smartystreets-assertions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-smartystreets-assertions-devel}"
SRC_URI[aarch64_golang-github-smartystreets-assertions-devel.sha256sum] = "2ca26dbd77c863e63002ed575915da4a460e04fef53b4c05f74d17472af07b11"

RDEPENDS:golang-github-smartystreets-assertions-devel = " \
 go-filesystem \
 "
