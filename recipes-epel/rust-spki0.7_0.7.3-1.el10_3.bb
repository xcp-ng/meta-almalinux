# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spki0.7"
PV = "0.7.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-spki0.7+alloc-devel \
 rust-spki0.7+arbitrary-devel \
 rust-spki0.7+base64-devel \
 rust-spki0.7+default-devel \
 rust-spki0.7+fingerprint-devel \
 rust-spki0.7+pem-devel \
 rust-spki0.7+sha2-devel \
 rust-spki0.7+std-devel \
 rust-spki0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spki0.7-0.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d4fb2ac07be605dc827094a2cbf1f62b5fd23b7b832b647d215cde04ed44c9a"

URI_x86_64_v2_rust-spki0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki0.7+alloc-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-spki0.7+alloc-devel.sha256sum] = "3a3ac313194646e63ff5d6aa2fd94f11c488d0610a9aa99ab2ed8bfa242a4970"

URI_x86_64_v2_rust-spki0.7+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki0.7+arbitrary-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki0.7+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki0.7+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-spki0.7+arbitrary-devel.sha256sum] = "4f7d78652f778dd9922adaa3f9bcc44aca43af6bf4310c248df8a586652f6408"

URI_x86_64_v2_rust-spki0.7+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki0.7+base64-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki0.7+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki0.7+base64-devel}"
SRC_URI[x86_64_v2_rust-spki0.7+base64-devel.sha256sum] = "2a4277f19ad23e0fb2756652eb043d3036f44066383f7a125a19e42c1eee655b"

URI_x86_64_v2_rust-spki0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki0.7+default-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki0.7+default-devel}"
SRC_URI[x86_64_v2_rust-spki0.7+default-devel.sha256sum] = "3e3b8240fbf85275abf9778b657f9caa0900f4c2eebac05bb629ef5918370c80"

URI_x86_64_v2_rust-spki0.7+fingerprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki0.7+fingerprint-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki0.7+fingerprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki0.7+fingerprint-devel}"
SRC_URI[x86_64_v2_rust-spki0.7+fingerprint-devel.sha256sum] = "ef7321c82466380ad4657ccf3f81d15ed3c5d31c9101e11fe7532d08b0e45e31"

URI_x86_64_v2_rust-spki0.7+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki0.7+pem-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki0.7+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki0.7+pem-devel}"
SRC_URI[x86_64_v2_rust-spki0.7+pem-devel.sha256sum] = "ffb2566f8d0be4e9275f0020c757e0d69c323c9cf7cdd2a384a0f8b3ccb69d01"

URI_x86_64_v2_rust-spki0.7+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki0.7+sha2-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki0.7+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki0.7+sha2-devel}"
SRC_URI[x86_64_v2_rust-spki0.7+sha2-devel.sha256sum] = "8441b0618ab0c480778ae97e864eb54228cb3020fbe22a6f0efe457b3be53c46"

URI_x86_64_v2_rust-spki0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki0.7+std-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki0.7+std-devel}"
SRC_URI[x86_64_v2_rust-spki0.7+std-devel.sha256sum] = "83a8a43d759c2f1ea2446c1d216934f52c7f246911cb00fe3cf072617fd68974"

URI_x86_64_v2_rust-spki0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki0.7-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki0.7-devel}"
SRC_URI[x86_64_v2_rust-spki0.7-devel.sha256sum] = "3fea96fd0c76ae4097625a2dacf750ed11979b2d1dbe2414a1c1595736c87047"

URI_aarch64_rust-spki0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki0.7+alloc-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-spki0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki0.7+alloc-devel}"
SRC_URI[aarch64_rust-spki0.7+alloc-devel.sha256sum] = "45a0ff040a35dcf743c3c052a9cf63473a92dadeb1597046a37a4049df969d56"

URI_aarch64_rust-spki0.7+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki0.7+arbitrary-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-spki0.7+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki0.7+arbitrary-devel}"
SRC_URI[aarch64_rust-spki0.7+arbitrary-devel.sha256sum] = "39cfa6472570143ff5e102f3412ce056005025b745338b2056649b8c41fae216"

URI_aarch64_rust-spki0.7+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki0.7+base64-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-spki0.7+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki0.7+base64-devel}"
SRC_URI[aarch64_rust-spki0.7+base64-devel.sha256sum] = "7641659fd31f70a6ca430b7e91fadadfe84ee5d7155624135035fdd55a1f2996"

URI_aarch64_rust-spki0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki0.7+default-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-spki0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki0.7+default-devel}"
SRC_URI[aarch64_rust-spki0.7+default-devel.sha256sum] = "6951e1e501d35db088a605dae6b81a1f9df31a1ae6d20e357e19598d871ced97"

URI_aarch64_rust-spki0.7+fingerprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki0.7+fingerprint-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-spki0.7+fingerprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki0.7+fingerprint-devel}"
SRC_URI[aarch64_rust-spki0.7+fingerprint-devel.sha256sum] = "a4eefa70e70e9b266fab693a0649b555195e6a96925f1db329524211a936fb20"

URI_aarch64_rust-spki0.7+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki0.7+pem-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-spki0.7+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki0.7+pem-devel}"
SRC_URI[aarch64_rust-spki0.7+pem-devel.sha256sum] = "a2d4e5ed40f89c8a6653cb391f3a9e02f097f65011836cf33fcd460121e49410"

URI_aarch64_rust-spki0.7+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki0.7+sha2-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-spki0.7+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki0.7+sha2-devel}"
SRC_URI[aarch64_rust-spki0.7+sha2-devel.sha256sum] = "13f318bba2cb19501fe8fedf161b0af0cd5a29d01e7e81bda80e396ca0ef579d"

URI_aarch64_rust-spki0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki0.7+std-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-spki0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki0.7+std-devel}"
SRC_URI[aarch64_rust-spki0.7+std-devel.sha256sum] = "7009db66a7698c0ce762460b269928290290cde03f315a11afb556a3bbe73417"

URI_aarch64_rust-spki0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki0.7-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-spki0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki0.7-devel}"
SRC_URI[aarch64_rust-spki0.7-devel.sha256sum] = "047137ad82b2d2adee8e767a48d752409b90dc10063282423730b42455b115f4"

RDEPENDS:rust-spki0.7+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-base64ct-devel \
 rust-der0.7+alloc-devel \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-spki0.7+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-der0.7+arbitrary-devel \
 rust-spki0.7+std-devel \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-spki0.7+base64-devel = " \
 cargo \
 rust-base64ct-devel \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-spki0.7+default-devel = " \
 cargo \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-spki0.7+fingerprint-devel = " \
 cargo \
 rust-spki0.7+sha2-devel \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-spki0.7+pem-devel = " \
 cargo \
 rust-der0.7+pem-devel \
 rust-spki0.7+alloc-devel \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-spki0.7+sha2-devel = " \
 cargo \
 rust-sha2_0.10-devel \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-spki0.7+std-devel = " \
 cargo \
 rust-der0.7+std-devel \
 rust-spki0.7+alloc-devel \
 rust-spki0.7-devel \
 "
RDEPENDS:rust-spki0.7-devel = " \
 cargo \
 rust \
 rust-der0.7+default-devel \
 rust-der0.7+oid-devel \
 "
