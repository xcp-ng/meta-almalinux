# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-coreos-iptables"
PV = "0.5.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-coreos-iptables-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-coreos-iptables-0.5.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40672f2dc45cdd61c062a12a5c866047730a7f7e20140ded8bd37f622aa8da46"

URI_x86_64_v2_golang-github-coreos-iptables-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-coreos-iptables-devel-0.5.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-coreos-iptables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-coreos-iptables-devel}"
SRC_URI[x86_64_v2_golang-github-coreos-iptables-devel.sha256sum] = "201525dfca24789918f2262c3a47016dd002fc672f7f2d0b4fa5c54242d7efbb"

URI_aarch64_golang-github-coreos-iptables-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-coreos-iptables-devel-0.5.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-coreos-iptables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-coreos-iptables-devel}"
SRC_URI[aarch64_golang-github-coreos-iptables-devel.sha256sum] = "cb262061224602718f5bbb78135175d2fe572f3f5db6b4cebdf2ecb9243cd3e6"

RDEPENDS:golang-github-coreos-iptables-devel = " \
 go-filesystem \
 "
