# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-theme-breeze"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plymouth-theme-breeze \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plymouth-theme-breeze-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "113fcf3c423000381ad700ad1c60e292935c443b2875bd3734f737a7718acecd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-theme-breeze-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-breeze;unpack=0"
SRC_URI[x86_64_v2_plymouth-theme-breeze.sha256sum] = "e7393cca20176aa767609f4f8babb342df96943d510f102780a6a308db91a8db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plymouth-theme-breeze-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plymouth-theme-breeze;unpack=0"
SRC_URI[aarch64_plymouth-theme-breeze.sha256sum] = "176817a18c8f82c52812e2e85de08dc2639766bd9e5aa4371d1de7f292927887"

RDEPENDS:plymouth-theme-breeze = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-plugin-script \
 "
