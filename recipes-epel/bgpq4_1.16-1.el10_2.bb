# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bgpq4"
PV = "1.16"
PR = "1.el10_2"
PACKAGES = " \
 bgpq4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bgpq4-1.16-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "590bd8311e29534fe2e9eb8975abbff3f6f41be1c98c1434cb629b82e8774965"

URI_x86_64_v2_bgpq4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bgpq4-1.16-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bgpq4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bgpq4}"
SRC_URI[x86_64_v2_bgpq4.sha256sum] = "6bb979afd8f346e33a6d9f6b9e53633747e17912168d25ae7da6263889a8e25f"

URI_aarch64_bgpq4 = "${EPEL_MIRROR}/aarch64/Packages/b/bgpq4-1.16-1.el10_2.aarch64.rpm;name=aarch64_bgpq4;unpack=0"
SRC_URI:append = " ${URI_aarch64_bgpq4}"
SRC_URI[aarch64_bgpq4.sha256sum] = "c89f460191e6773f3a6ce8a8e7c9e8b102aa6727147bfb159e2c31c574621bd0"

RDEPENDS:bgpq4 = " \
 glibc \
 "
