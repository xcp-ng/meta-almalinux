# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtevent"
PV = "0.16.1"
PR = "106.el10"
PACKAGES = " \
 libtevent \
 libtevent-devel \
 python3-tevent \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtevent-0.16.1-106.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "466a3abcc3b765120e46c979befa13a81572a608af0287153c84216b46abbf15"

URI_x86_64_v2_libtevent = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtevent-0.16.1-106.el10.x86_64_v2.rpm;name=x86_64_v2_libtevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtevent}"
SRC_URI[x86_64_v2_libtevent.sha256sum] = "ee7942e7e423a898f9026620d44f1018a0f980d89893b569a4e3262d90a1680d"

URI_x86_64_v2_libtevent-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtevent-devel-0.16.1-106.el10.x86_64_v2.rpm;name=x86_64_v2_libtevent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtevent-devel}"
SRC_URI[x86_64_v2_libtevent-devel.sha256sum] = "4eda2e8dbd1071ad20e1b2024dc92f7ddd9491806cb0ba2ce23b2ad6c0e9cd84"

URI_x86_64_v2_python3-tevent = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-tevent-0.16.1-106.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tevent}"
SRC_URI[x86_64_v2_python3-tevent.sha256sum] = "de48733bcdcb9436886ff2109111b781f6f9e7e359a641dfbdc453a0eb6a5b94"

URI_aarch64_libtevent = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtevent-0.16.1-106.el10.aarch64.rpm;name=aarch64_libtevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtevent}"
SRC_URI[aarch64_libtevent.sha256sum] = "28f54dc541e0b5a522b2781769f36284785629fcde5db02948572e31342d42e8"

URI_aarch64_libtevent-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtevent-devel-0.16.1-106.el10.aarch64.rpm;name=aarch64_libtevent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtevent-devel}"
SRC_URI[aarch64_libtevent-devel.sha256sum] = "90bccaa366b6fbb513f4d86dae58668dd4ad2552bf01e0f20824732d0f3efc84"

URI_aarch64_python3-tevent = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-tevent-0.16.1-106.el10.aarch64.rpm;name=aarch64_python3-tevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tevent}"
SRC_URI[aarch64_python3-tevent.sha256sum] = "9253ed1854f86ecbae6a467b88f8a33ed05ac61fa89c4778e135f1dcfc93762c"

RDEPENDS:libtevent = " \
 glibc \
 libtalloc \
 "
RDEPENDS:libtevent-devel = " \
 libtalloc-devel \
 libtevent \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-tevent = " \
 glibc \
 libtalloc \
 libtevent \
 python3 \
 "
