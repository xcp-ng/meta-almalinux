# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-pytest"
PV = "0.2.0"
PR = "5.el10_0"
PACKAGES = " \
 python3-sphinx-pytest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-pytest-0.2.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b17978fcdce80cae42fd95facba6058211b00afbfdccc104a293c47e2b276ad"

URI_x86_64_v2_python3-sphinx-pytest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-pytest-0.2.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-pytest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-pytest}"
SRC_URI[x86_64_v2_python3-sphinx-pytest.sha256sum] = "171de06432d878a8097295c391eb538c34f23bddda47279ae526c9f679e4084d"

URI_aarch64_python3-sphinx-pytest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-pytest-0.2.0-5.el10_0.noarch.rpm;name=aarch64_python3-sphinx-pytest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-pytest}"
SRC_URI[aarch64_python3-sphinx-pytest.sha256sum] = "ed5ae3cbb0ab9f65f815dd4bef94aae99bf95c2a8612747e4ade8043383dde44"

RDEPENDS:python3-sphinx-pytest = " \
 python3 \
 python3-pytest \
 python3-sphinx \
 "
