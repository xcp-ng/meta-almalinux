# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1-rs-derive"
PV = "0.5.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-asn1-rs-derive+default-devel \
 rust-asn1-rs-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-rs-derive-0.5.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8e5b7b3fc1aedd495aaede7462de2045949f03009857deb37c8e75195d63585"

URI_x86_64_v2_rust-asn1-rs-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-derive+default-devel-0.5.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-derive+default-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-derive+default-devel.sha256sum] = "da06523a80d6ffa9a7f48114d32aff1032d3be02e22f0feebbd898981a07cffe"

URI_x86_64_v2_rust-asn1-rs-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-derive-devel-0.5.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-derive-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-derive-devel.sha256sum] = "e9a88f278700c2515e26860c3309df742982ffafaa23e17d4a1c391768ef75e0"

URI_aarch64_rust-asn1-rs-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-derive+default-devel-0.5.1-2.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-derive+default-devel}"
SRC_URI[aarch64_rust-asn1-rs-derive+default-devel.sha256sum] = "f80470523104f4d8823e3066aac9c5ec8d84d0cc12e518ae1cbd1ce2337a77c8"

URI_aarch64_rust-asn1-rs-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-derive-devel-0.5.1-2.el10_1.noarch.rpm;name=aarch64_rust-asn1-rs-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-derive-devel}"
SRC_URI[aarch64_rust-asn1-rs-derive-devel.sha256sum] = "5e83e45b2b3486811e385f89d8c0ddc6ff117382564a9defc5163017cf60315c"

RDEPENDS:rust-asn1-rs-derive+default-devel = " \
 cargo \
 rust-asn1-rs-derive-devel \
 "
RDEPENDS:rust-asn1-rs-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 rust-synstructure+default-devel \
 "
