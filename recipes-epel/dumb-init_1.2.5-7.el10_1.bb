# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dumb-init"
PV = "1.2.5"
PR = "7.el10_1"
PACKAGES = " \
 dumb-init \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dumb-init-1.2.5-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d9c920cb55b780af1eecbbc1ead8e9534785a9ba679f8ecbc7307d1932c316b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dumb-init-1.2.5-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dumb-init;unpack=0"
SRC_URI[x86_64_v2_dumb-init.sha256sum] = "207411ccd90048c220ee520da7056a62ef7ec3540dc3740158358a9fb46fb8e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dumb-init-1.2.5-7.el10_1.aarch64.rpm;name=aarch64_dumb-init;unpack=0"
SRC_URI[aarch64_dumb-init.sha256sum] = "07db06bfbf7edf808cafb40e6c2008490e97d09cae994389153b1ac36819fbb8"

RDEPENDS:dumb-init = " \
 glibc \
 "
