# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_str_bytes"
PV = "7.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-os_str_bytes+checked_conversions-devel \
 rust-os_str_bytes+conversions-devel \
 rust-os_str_bytes+default-devel \
 rust-os_str_bytes+memchr-devel \
 rust-os_str_bytes+raw_os_str-devel \
 rust-os_str_bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_str_bytes-7.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63c3c94ac4be60b7bf533046d058d5d8d10ed84e670e87609fe720c315a0877a"

URI_x86_64_v2_rust-os_str_bytes+checked_conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+checked_conversions-devel-7.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+checked_conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+checked_conversions-devel.sha256sum] = "b8be762bd77022b1798d5e1c95868d1cce12442604e45b89ebf933318e228687"

URI_x86_64_v2_rust-os_str_bytes+conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+conversions-devel-7.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+conversions-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+conversions-devel.sha256sum] = "3b8da93917d1d42adeaac75f4aed01cc783f10d82ba549ae7bad66b4d5f92867"

URI_x86_64_v2_rust-os_str_bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+default-devel-7.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+default-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+default-devel.sha256sum] = "eb198264e4ceb63d20860dea2d4044700f55b31a89a113dc1195cee1569ce116"

URI_x86_64_v2_rust-os_str_bytes+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+memchr-devel-7.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+memchr-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+memchr-devel.sha256sum] = "7f90ad1867317b7f056d953f3ad5d3bec248048542805b4f87553d2befed6271"

URI_x86_64_v2_rust-os_str_bytes+raw_os_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes+raw_os_str-devel-7.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes+raw_os_str-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes+raw_os_str-devel.sha256sum] = "9fbd9efcb81c043d6f34c853a4ba67d245e8dd978c9e835eb8f3f3aab4d7c987"

URI_x86_64_v2_rust-os_str_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_str_bytes-devel-7.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_str_bytes-devel}"
SRC_URI[x86_64_v2_rust-os_str_bytes-devel.sha256sum] = "83794459e5543a1c09a7d7a02f320ab4ce09c8349f101575c349a4187b61fccf"

URI_aarch64_rust-os_str_bytes+checked_conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+checked_conversions-devel-7.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-os_str_bytes+checked_conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+checked_conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes+checked_conversions-devel.sha256sum] = "23bc0588483e34c4a9457e558de33ac3a356cc71e6358953e31e6d15d930df3a"

URI_aarch64_rust-os_str_bytes+conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+conversions-devel-7.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-os_str_bytes+conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+conversions-devel}"
SRC_URI[aarch64_rust-os_str_bytes+conversions-devel.sha256sum] = "1e92a85a80f778996698b8e04cfaf0f8aba3b42716a073a8fa8ec7d21b8ddce5"

URI_aarch64_rust-os_str_bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+default-devel-7.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-os_str_bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+default-devel}"
SRC_URI[aarch64_rust-os_str_bytes+default-devel.sha256sum] = "cf2619d9b66f387073237c1f148a81b33ee7be02c40d11e2371503018d56c90b"

URI_aarch64_rust-os_str_bytes+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+memchr-devel-7.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-os_str_bytes+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+memchr-devel}"
SRC_URI[aarch64_rust-os_str_bytes+memchr-devel.sha256sum] = "bd4aaf18355b0d23e1e4a3e160205f635144ebafb39edbae9756c95d271990bc"

URI_aarch64_rust-os_str_bytes+raw_os_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes+raw_os_str-devel-7.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-os_str_bytes+raw_os_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes+raw_os_str-devel}"
SRC_URI[aarch64_rust-os_str_bytes+raw_os_str-devel.sha256sum] = "c80e517325966e8dd250be70e213136314a3134211033a91828162288d3da3da"

URI_aarch64_rust-os_str_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_str_bytes-devel-7.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-os_str_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_str_bytes-devel}"
SRC_URI[aarch64_rust-os_str_bytes-devel.sha256sum] = "4bef0507b021c59ea4566d0eae59fa22f69509cf963b90af08b47cb8f9685701"

RDEPENDS:rust-os_str_bytes+checked_conversions-devel = " \
 cargo \
 rust-os_str_bytes+conversions-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+conversions-devel = " \
 cargo \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+default-devel = " \
 cargo \
 rust-os_str_bytes+memchr-devel \
 rust-os_str_bytes+raw_os_str-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes+raw_os_str-devel = " \
 cargo \
 rust-os_str_bytes-devel \
 "
RDEPENDS:rust-os_str_bytes-devel = " \
 cargo \
 rust \
 "
