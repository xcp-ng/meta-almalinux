# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2-util"
PV = "1.9.1"
PR = "1.el10_0"
PACKAGES = " \
 gfal2-util-scripts \
 python3-gfal2-util \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-util-1.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90b39b3b46576fa7a038f8d5345f79f4344e0b204bd309532ecb26f349426ea9"

URI_x86_64_v2_gfal2-util-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gfal2-util-scripts-1.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gfal2-util-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gfal2-util-scripts}"
SRC_URI[x86_64_v2_gfal2-util-scripts.sha256sum] = "0edc2b4160c8b801df29a69ef9350073dcd1e841d11e408e8d6161c82be0f983"

URI_x86_64_v2_python3-gfal2-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gfal2-util-1.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gfal2-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gfal2-util}"
SRC_URI[x86_64_v2_python3-gfal2-util.sha256sum] = "695193e6a50da16f68633bf6ee6f029f9eb1867824888f563f3ae5b1fc49cf64"

URI_aarch64_gfal2-util-scripts = "${EPEL_MIRROR}/aarch64/Packages/g/gfal2-util-scripts-1.9.1-1.el10_0.noarch.rpm;name=aarch64_gfal2-util-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gfal2-util-scripts}"
SRC_URI[aarch64_gfal2-util-scripts.sha256sum] = "7d037c0664c9940ad829ccaa45235108249c51c4eb15f5411d1d65c09f05c411"

URI_aarch64_python3-gfal2-util = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gfal2-util-1.9.1-1.el10_0.noarch.rpm;name=aarch64_python3-gfal2-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gfal2-util}"
SRC_URI[aarch64_python3-gfal2-util.sha256sum] = "be51814b04710e0a5359e70cffa464bc4f841719465658e37b042333529406bc"

RDEPENDS:gfal2-util-scripts = " \
 bash \
 python3-gfal2-util \
 "
RDEPENDS:python3-gfal2-util = " \
 gfal2-plugin-file \
 gfal2-util-scripts \
 python3 \
 python3-gfal2 \
 "
