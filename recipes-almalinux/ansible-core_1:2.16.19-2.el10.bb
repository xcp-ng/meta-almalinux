# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-core"
PE = "1"
PV = "2.16.19"
PR = "2.el10"
PACKAGES = " \
 ansible-core \
 ansible-test \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-core-2.16.19-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5e170cbe936751536cc6b0de323c827fc7d8957d45298a1dc0cc33172ff0fae2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-core-2.16.19-2.el10.noarch.rpm;name=x86_64_v2_ansible-core;unpack=0"
SRC_URI[x86_64_v2_ansible-core.sha256sum] = "97773e584687fd396a9486493f4d32c8808e9f0edbe906f245ada5bc81624353"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-test-2.16.19-2.el10.noarch.rpm;name=x86_64_v2_ansible-test;unpack=0"
SRC_URI[x86_64_v2_ansible-test.sha256sum] = "880bf8d2a20fedfeb599377922689f351c7860548d5473b3b697f781589fb31a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-core-2.16.19-2.el10.noarch.rpm;name=aarch64_ansible-core;unpack=0"
SRC_URI[aarch64_ansible-core.sha256sum] = "97773e584687fd396a9486493f4d32c8808e9f0edbe906f245ada5bc81624353"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-test-2.16.19-2.el10.noarch.rpm;name=aarch64_ansible-test;unpack=0"
SRC_URI[aarch64_ansible-test.sha256sum] = "880bf8d2a20fedfeb599377922689f351c7860548d5473b3b697f781589fb31a"

RDEPENDS:ansible-core = " \
 git-core \
 python3 \
 python3-cryptography \
 python3-jinja2 \
 python3-packaging \
 python3-pyyaml \
 python3-resolvelib \
 "
RDEPENDS:ansible-test = " \
 ansible-core \
 python3 \
 "
