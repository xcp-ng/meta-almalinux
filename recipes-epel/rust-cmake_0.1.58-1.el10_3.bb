# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cmake"
PV = "0.1.58"
PR = "1.el10_3"
PACKAGES = " \
 rust-cmake+default-devel \
 rust-cmake-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cmake-0.1.58-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2af39dcf23736cd8fc48863790d6477bd0ae42837149a5cc9a9e4522c665802d"

URI_x86_64_v2_rust-cmake+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmake+default-devel-0.1.58-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmake+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmake+default-devel}"
SRC_URI[x86_64_v2_rust-cmake+default-devel.sha256sum] = "8c834f26845ae79d9bb97c9884d1fb5c8010b0feaf6c7a5856bccd9bcb1cb810"

URI_x86_64_v2_rust-cmake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmake-devel-0.1.58-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmake-devel}"
SRC_URI[x86_64_v2_rust-cmake-devel.sha256sum] = "48e6682e9c5217db68cbd7f14d116f339f2d0a8875e5bd1a89e46d4e699b4772"

URI_aarch64_rust-cmake+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmake+default-devel-0.1.58-1.el10_3.noarch.rpm;name=aarch64_rust-cmake+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmake+default-devel}"
SRC_URI[aarch64_rust-cmake+default-devel.sha256sum] = "e0f77a65d28fdbf0b42746c5fd5d5d16cd3e3fb32c1b4208b0f8b70b88692a4f"

URI_aarch64_rust-cmake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmake-devel-0.1.58-1.el10_3.noarch.rpm;name=aarch64_rust-cmake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmake-devel}"
SRC_URI[aarch64_rust-cmake-devel.sha256sum] = "fad5cfe06d45eab4fff6beb9ac338a5457137b203cc1db6b2494723261fe3080"

RDEPENDS:rust-cmake+default-devel = " \
 cargo \
 rust-cmake-devel \
 "
RDEPENDS:rust-cmake-devel = " \
 cargo \
 cmake \
 rust \
 rust-cc+default-devel \
 "
