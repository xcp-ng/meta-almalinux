# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openscap"
PE = "1"
PV = "1.4.4"
PR = "1.el10.alma.1"
PACKAGES = " \
 openscap \
 openscap-engine-sce \
 openscap-scanner \
 openscap-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openscap-1.4.4-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6609c11d46fbd26c2207b9b6f5a446afdccbc8c48ff985e5205d6f9c04540ff0"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - openscap: libcap
# - openscap: libcap.so.2()(64bit)

URI_x86_64_v2_openscap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-1.4.4-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap}"
SRC_URI[x86_64_v2_openscap.sha256sum] = "3c35435e60095f37dbc153d6bedf98b6a3de8ed356fd1a551b2e5169497b5cc0"

URI_x86_64_v2_openscap-engine-sce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-engine-sce-1.4.4-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-engine-sce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-engine-sce}"
SRC_URI[x86_64_v2_openscap-engine-sce.sha256sum] = "df521a98e5319485ce4cb8a6ce9efdff9508f05aeecdca56804bfeb22fc52f06"

URI_x86_64_v2_openscap-scanner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-scanner-1.4.4-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-scanner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-scanner}"
SRC_URI[x86_64_v2_openscap-scanner.sha256sum] = "3b32b0a1148af41aa5ffbe8af7a4e3482172d4198e0deab8ab8b464e5805d215"

URI_x86_64_v2_openscap-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-utils-1.4.4-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-utils}"
SRC_URI[x86_64_v2_openscap-utils.sha256sum] = "c0c031a216e54b1b0ec8cf7786c1428cec1e5fa5406346c13071bd4d90c3a601"

URI_aarch64_openscap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-1.4.4-1.el10.alma.1.aarch64.rpm;name=aarch64_openscap;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap}"
SRC_URI[aarch64_openscap.sha256sum] = "38cdc293b552298c4b56ee5adfc3e2fc89d53355371b6a668ed5fc01ecc21713"

URI_aarch64_openscap-engine-sce = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-engine-sce-1.4.4-1.el10.alma.1.aarch64.rpm;name=aarch64_openscap-engine-sce;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-engine-sce}"
SRC_URI[aarch64_openscap-engine-sce.sha256sum] = "8ea043b4fffb4dd97e3ff6860c4f3e80dbb58738937f81c3b33c358c1388929e"

URI_aarch64_openscap-scanner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-scanner-1.4.4-1.el10.alma.1.aarch64.rpm;name=aarch64_openscap-scanner;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-scanner}"
SRC_URI[aarch64_openscap-scanner.sha256sum] = "2e604f1b537598a708befed2e190df0e59ea30c97d0328c9c997cfd457d77dc7"

URI_aarch64_openscap-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-utils-1.4.4-1.el10.alma.1.aarch64.rpm;name=aarch64_openscap-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-utils}"
SRC_URI[aarch64_openscap-utils.sha256sum] = "2e93eb101aba4f1f5943e57c5057d9175f967a6034e3969f73c42b894952c4a4"

RDEPENDS:openscap:x86_64_v2 = " \
 bash \
 bzip2-libs \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libcap \
 libgcc \
 libselinux \
 libxml2 \
 libxslt \
 libyaml \
 nss \
 openldap \
 pcre2 \
 popt \
 procps-ng \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 xmlsec1 \
 xmlsec1-openssl \
"
RDEPENDS:openscap:aarch64 = " \
 bash \
 bzip2-libs \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libgcc \
 libselinux \
 libxml2 \
 libxslt \
 libyaml \
 nss \
 openldap \
 pcre2 \
 popt \
 procps-ng \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 xmlsec1 \
 xmlsec1-openssl \
"
RDEPENDS:openscap-engine-sce = " \
 glibc \
 openscap \
 "
RDEPENDS:openscap-scanner = " \
 bash \
 glibc \
 openscap \
 virtual/libcurl_ge_7.12.0 \
 "
RDEPENDS:openscap-utils = " \
 bash \
 openscap \
 openscap-scanner \
 python3 \
 rpm-build \
 rpmdevtools \
 "
