# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fribidi"
PV = "1.0.14"
PR = "4.el10"
PACKAGES = " \
 fribidi \
 fribidi-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fribidi-1.0.14-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7dd06a678eb0582b91ad07a128ed90e8d165999a1239be270d21d09041ae88b"

URI_x86_64_v2_fribidi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fribidi-1.0.14-4.el10.x86_64_v2.rpm;name=x86_64_v2_fribidi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fribidi}"
SRC_URI[x86_64_v2_fribidi.sha256sum] = "196aff68e354cc2cf981fab8bb54c411dfb68373eb80c63fd7a5295aa188615a"

URI_x86_64_v2_fribidi-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fribidi-devel-1.0.14-4.el10.x86_64_v2.rpm;name=x86_64_v2_fribidi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fribidi-devel}"
SRC_URI[x86_64_v2_fribidi-devel.sha256sum] = "b24d571e3a8978ad892d2862a036a5de83b9987b887325f064d957876bdca11e"

URI_aarch64_fribidi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fribidi-1.0.14-4.el10.aarch64.rpm;name=aarch64_fribidi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fribidi}"
SRC_URI[aarch64_fribidi.sha256sum] = "1608425d32bdcc5ea4bd5721ffe53b2d2ec1ce5905071f37a35fd01d344eee72"

URI_aarch64_fribidi-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fribidi-devel-1.0.14-4.el10.aarch64.rpm;name=aarch64_fribidi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fribidi-devel}"
SRC_URI[aarch64_fribidi-devel.sha256sum] = "809bf4fdd2de8671865a490fc62665719ca5abc2f23fbf0d4e9f9dcec6cada38"

RDEPENDS:fribidi = " \
 glibc \
 "
RDEPENDS:fribidi-devel = " \
 fribidi \
 pkgconf-pkg-config \
 "
