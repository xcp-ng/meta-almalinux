# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_auth_openidc"
PV = "2.4.16.11"
PR = "1.el10_2.1"
PACKAGES = " \
 mod_auth_openidc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_auth_openidc-2.4.16.11-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b0383a1741642cbe9fc18f39914f42efa8c06324ce804553164524951ebe798a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_auth_openidc-2.4.16.11-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_mod_auth_openidc;unpack=0"
SRC_URI[x86_64_v2_mod_auth_openidc.sha256sum] = "2d2bb5a5e3c1c3911bdb59794041d1faadb5dbac0aca576651e7f1f592815b79"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_auth_openidc-2.4.16.11-1.el10_2.1.aarch64.rpm;name=aarch64_mod_auth_openidc;unpack=0"
SRC_URI[aarch64_mod_auth_openidc.sha256sum] = "c11e84983fb23d89d1544ea53509d81da32d91257e8d9380f0f2a945c02f5b3c"

RDEPENDS:mod_auth_openidc = " \
 apr \
 apr-util \
 cjose \
 expat \
 glibc \
 httpd-core \
 jansson \
 jq \
 libxcrypt \
 openldap \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
