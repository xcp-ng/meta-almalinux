# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "leveldb"
PV = "1.23"
PR = "9.el10_3"
PACKAGES = " \
 leveldb \
 leveldb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/leveldb-1.23-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f2800cf3fec937ff2c17e621c9168c9ed9e33abfd1693cc9e41d5fa011ee1f8"

URI_x86_64_v2_leveldb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/leveldb-1.23-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_leveldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_leveldb}"
SRC_URI[x86_64_v2_leveldb.sha256sum] = "cd1e3eca4ca77e720b1b7507b286746819d5a038a65158c2bd3ddec2becf4a5a"

URI_x86_64_v2_leveldb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/leveldb-devel-1.23-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_leveldb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_leveldb-devel}"
SRC_URI[x86_64_v2_leveldb-devel.sha256sum] = "80e6dc4de1853bbb7775a7e033bc17e59c2cbce2243ac32bb990eafa51c20ab3"

URI_aarch64_leveldb = "${EPEL_MIRROR}/aarch64/Packages/l/leveldb-1.23-9.el10_3.aarch64.rpm;name=aarch64_leveldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_leveldb}"
SRC_URI[aarch64_leveldb.sha256sum] = "52a2865a7e0be70c66fcfc76b2ba71e71c130c8ad21e3dff7151fb6f817d908c"

URI_aarch64_leveldb-devel = "${EPEL_MIRROR}/aarch64/Packages/l/leveldb-devel-1.23-9.el10_3.aarch64.rpm;name=aarch64_leveldb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_leveldb-devel}"
SRC_URI[aarch64_leveldb-devel.sha256sum] = "218b5992f47f6c38a7d81bcb56b05d887802ce85d7966a6937230c3a2a72f0fb"

RDEPENDS:leveldb = " \
 glibc \
 libstdc++ \
 snappy \
 "
RDEPENDS:leveldb-devel = " \
 cmake-filesystem \
 leveldb \
 pkgconf-pkg-config \
 "
