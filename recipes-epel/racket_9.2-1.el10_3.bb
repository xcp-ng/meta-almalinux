# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "racket"
PV = "9.2"
PR = "1.el10_3"
PACKAGES = " \
 racket \
 racket-collects \
 racket-devel \
 racket-doc \
 racket-minimal \
 racket-pkgs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/racket-9.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4ba36073fabf814359e80b2c1b42738b25b322ca155f607c06eec3d8868867a"

URI_x86_64_v2_racket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-9.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket}"
SRC_URI[x86_64_v2_racket.sha256sum] = "03bdb1041654dd2cacb9b0ae76c571885c59313954cb8a954c61f655cedddb4e"

URI_x86_64_v2_racket-collects = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-collects-9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_racket-collects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-collects}"
SRC_URI[x86_64_v2_racket-collects.sha256sum] = "d9958f2fb6b5cd2e7c3f305add74f0deed46f8fcf99982282656683c97ecaff3"

URI_x86_64_v2_racket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-devel-9.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-devel}"
SRC_URI[x86_64_v2_racket-devel.sha256sum] = "b3916911dc30afd69dc8cb26f1120fdf4d32cd4e3f4d6be9efff1534f882868a"

URI_x86_64_v2_racket-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-doc-9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_racket-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-doc}"
SRC_URI[x86_64_v2_racket-doc.sha256sum] = "4b7e864ecbffc404c1f80e6a6d31750b1f375d2748bb82b5263c949f567cf31d"

URI_x86_64_v2_racket-minimal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-minimal-9.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-minimal}"
SRC_URI[x86_64_v2_racket-minimal.sha256sum] = "0d6d1a3e93cfc96ce0a738f2e6ffa202af4ac652dc67d4b562eb622ffa08200a"

URI_x86_64_v2_racket-pkgs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-pkgs-9.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_racket-pkgs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-pkgs}"
SRC_URI[x86_64_v2_racket-pkgs.sha256sum] = "2b655dc28f11c357c28b17da8dc2df80d26fed8dfbfbb4d229f86aeaaf82f9ea"

URI_aarch64_racket = "${EPEL_MIRROR}/aarch64/Packages/r/racket-9.2-1.el10_3.aarch64.rpm;name=aarch64_racket;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket}"
SRC_URI[aarch64_racket.sha256sum] = "2d8556dfb96f6870b27f05637b7cb17bf1ba0144268ea6540af2b459d69d0298"

URI_aarch64_racket-collects = "${EPEL_MIRROR}/aarch64/Packages/r/racket-collects-9.2-1.el10_3.noarch.rpm;name=aarch64_racket-collects;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-collects}"
SRC_URI[aarch64_racket-collects.sha256sum] = "880661aaf29f6c2d77550849feb205965c35060b6db4c04cb54e6a4518813cc7"

URI_aarch64_racket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/racket-devel-9.2-1.el10_3.aarch64.rpm;name=aarch64_racket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-devel}"
SRC_URI[aarch64_racket-devel.sha256sum] = "e2af21e4069fa5121b9f60c2a6738559abcd541ca3b711683e689724ccfe235d"

URI_aarch64_racket-doc = "${EPEL_MIRROR}/aarch64/Packages/r/racket-doc-9.2-1.el10_3.noarch.rpm;name=aarch64_racket-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-doc}"
SRC_URI[aarch64_racket-doc.sha256sum] = "5ec5dab2a949c2a2f15314e48c4325726700b2d2f91559d8c3133d19cad14c39"

URI_aarch64_racket-minimal = "${EPEL_MIRROR}/aarch64/Packages/r/racket-minimal-9.2-1.el10_3.aarch64.rpm;name=aarch64_racket-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-minimal}"
SRC_URI[aarch64_racket-minimal.sha256sum] = "2a295bd52d75d2f7b474a6ee34cabd3c3cc4b71cecaf3dba0a62dac4fbbaa7f3"

URI_aarch64_racket-pkgs = "${EPEL_MIRROR}/aarch64/Packages/r/racket-pkgs-9.2-1.el10_3.noarch.rpm;name=aarch64_racket-pkgs;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-pkgs}"
SRC_URI[aarch64_racket-pkgs.sha256sum] = "880dc611ae1924967fc1cadd05dccfc3ebc8e6267dbda351f254526ce8a9713b"

RDEPENDS:racket = " \
 bash \
 glibc \
 racket-minimal \
 racket-pkgs \
 "
RDEPENDS:racket-collects = " \
 "
RDEPENDS:racket-devel = " \
 racket-minimal \
 "
RDEPENDS:racket-doc = " \
 "
RDEPENDS:racket-minimal = " \
 bash \
 glibc \
 libgcc \
 racket-collects \
 "
RDEPENDS:racket-pkgs = " \
 bash \
 cairo \
 glib2 \
 gtk3 \
 libjpeg-turbo \
 libpng \
 pango \
 racket-minimal \
 "
