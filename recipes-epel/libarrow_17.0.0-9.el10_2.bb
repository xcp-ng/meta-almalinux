# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libarrow"
PV = "17.0.0"
PR = "9.el10_2"
PACKAGES = " \
 libarrow \
 libarrow-acero-devel \
 libarrow-acero-libs \
 libarrow-dataset-devel \
 libarrow-dataset-glib-devel \
 libarrow-dataset-glib-libs \
 libarrow-dataset-libs \
 libarrow-devel \
 libarrow-doc \
 libarrow-flight-devel \
 libarrow-flight-libs \
 libarrow-glib-devel \
 libarrow-glib-libs \
 libarrow-python-devel \
 libarrow-python-flight-devel \
 libarrow-python-flight-libs \
 libarrow-python-libs \
 parquet-glib-devel \
 parquet-glib-libs \
 parquet-libs \
 parquet-libs-devel \
 python3-pyarrow \
 python3-pyarrow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libarrow-17.0.0-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c40060d89e05c15d0d7c25648c09b77195888fc9fd8a26c33affce98050c8b66"

URI_x86_64_v2_libarrow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow}"
SRC_URI[x86_64_v2_libarrow.sha256sum] = "5c6262ce0a5da19b1b4098f535b75662e9c0e0069e5abf6d88b6e1f02d4ad39c"

URI_x86_64_v2_libarrow-acero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-acero-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-acero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-acero-devel}"
SRC_URI[x86_64_v2_libarrow-acero-devel.sha256sum] = "359cc60eed5c90cd9be6ca835cddbefa34b276146de24566cbac9695e1097f48"

URI_x86_64_v2_libarrow-acero-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-acero-libs-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-acero-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-acero-libs}"
SRC_URI[x86_64_v2_libarrow-acero-libs.sha256sum] = "af2c1048d2315f961fb2386d3208920440a4864dbb7c9d079dbd08eba36da545"

URI_x86_64_v2_libarrow-dataset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-devel}"
SRC_URI[x86_64_v2_libarrow-dataset-devel.sha256sum] = "6d6308432e5f6e1eea360cd7dc548a1bfec883b500dedcd5edd12a7297733da1"

URI_x86_64_v2_libarrow-dataset-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-glib-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-glib-devel}"
SRC_URI[x86_64_v2_libarrow-dataset-glib-devel.sha256sum] = "9be16998a8cc800e757a69c7f193be0c576ee7a2e2a81545686f7e9b68d948bd"

URI_x86_64_v2_libarrow-dataset-glib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-glib-libs-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-glib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-glib-libs}"
SRC_URI[x86_64_v2_libarrow-dataset-glib-libs.sha256sum] = "c308d22680b9cf5d127a785f0ba0784d6ff8b67627450d90d8b86fbdfca2c87c"

URI_x86_64_v2_libarrow-dataset-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-libs-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-libs}"
SRC_URI[x86_64_v2_libarrow-dataset-libs.sha256sum] = "c87546acaf6772f8bb11f48e21f41955bbed301bc922a8a83b86dee18afb63bb"

URI_x86_64_v2_libarrow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-devel}"
SRC_URI[x86_64_v2_libarrow-devel.sha256sum] = "64229333a86b54f1f4502069fe64ddaadd5e37770f7e2ee03b3b186c797a68bd"

URI_x86_64_v2_libarrow-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-doc-17.0.0-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libarrow-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-doc}"
SRC_URI[x86_64_v2_libarrow-doc.sha256sum] = "2ee4be89997d0900502bdc646e9ad917aa4ec9f19417dd5d1e5f329bb6b091a1"

URI_x86_64_v2_libarrow-flight-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-flight-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-flight-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-flight-devel}"
SRC_URI[x86_64_v2_libarrow-flight-devel.sha256sum] = "139a6d59982008bd62c5fa73dfb5c2a1c202b3cab786d6b85cf58edeb14b83e2"

URI_x86_64_v2_libarrow-flight-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-flight-libs-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-flight-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-flight-libs}"
SRC_URI[x86_64_v2_libarrow-flight-libs.sha256sum] = "376728aceb4ab2eb2eb9fc33beaca24b5c8974beb6656f63414e8f04d4d0d23d"

URI_x86_64_v2_libarrow-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-glib-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-glib-devel}"
SRC_URI[x86_64_v2_libarrow-glib-devel.sha256sum] = "518fdb6d8c139fcb790ff2948d37884070e4dbba39122daf3680304d79a51cd6"

URI_x86_64_v2_libarrow-glib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-glib-libs-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-glib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-glib-libs}"
SRC_URI[x86_64_v2_libarrow-glib-libs.sha256sum] = "99ea784c7bcb3db2a1a24056c6021cb98a60d55c3791bdd129d3e82573c7f26a"

URI_x86_64_v2_libarrow-python-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-devel}"
SRC_URI[x86_64_v2_libarrow-python-devel.sha256sum] = "a24e3dfa6a487471c0b753e378a3f8cb210d891a49109dc54c8e56e39cb20d5f"

URI_x86_64_v2_libarrow-python-flight-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-flight-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-flight-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-flight-devel}"
SRC_URI[x86_64_v2_libarrow-python-flight-devel.sha256sum] = "a37d0c5af4656d82e5c49f0cf3589af3f6807180a8b167ce371a7389fcbe23e1"

URI_x86_64_v2_libarrow-python-flight-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-flight-libs-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-flight-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-flight-libs}"
SRC_URI[x86_64_v2_libarrow-python-flight-libs.sha256sum] = "f215ceb573fef55affc1daa4c7218dfab26be1df55faee4cc435a72f85a442da"

URI_x86_64_v2_libarrow-python-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-libs-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-libs}"
SRC_URI[x86_64_v2_libarrow-python-libs.sha256sum] = "fa4bbe59a45e889d2b80aa5b7581d952b9d68124092bcbb0db0362d399bbfd59"

URI_x86_64_v2_parquet-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-glib-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-glib-devel}"
SRC_URI[x86_64_v2_parquet-glib-devel.sha256sum] = "ca354341c8aa09c3d52fe47f60ef5e025113855f1829ed1821a8de23f08688c3"

URI_x86_64_v2_parquet-glib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-glib-libs-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-glib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-glib-libs}"
SRC_URI[x86_64_v2_parquet-glib-libs.sha256sum] = "eae1be3e73a0ef8e3f274ee8f44baa782c4c3350bf248d97d3d83fdef4ee68c2"

URI_x86_64_v2_parquet-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-libs-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-libs}"
SRC_URI[x86_64_v2_parquet-libs.sha256sum] = "8ab8456a57b3afbc3c77eb3ca98d95917dd1f82f97a4dc10350c4a1c59b38d48"

URI_x86_64_v2_parquet-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-libs-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-libs-devel}"
SRC_URI[x86_64_v2_parquet-libs-devel.sha256sum] = "f4de612d7a1b6e2ac61cb7babcc238a0ab69b4bad0337011806f3e5ea5a1dbbc"

URI_x86_64_v2_python3-pyarrow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyarrow-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyarrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyarrow}"
SRC_URI[x86_64_v2_python3-pyarrow.sha256sum] = "969878585480c781fe7df267834eb4fe1423805128cce942ae4abe9cf0cff6a5"

URI_x86_64_v2_python3-pyarrow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyarrow-devel-17.0.0-9.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyarrow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyarrow-devel}"
SRC_URI[x86_64_v2_python3-pyarrow-devel.sha256sum] = "60d9a0483140f08d7af9de7df24cae45ca888a831db0f4c00a747927adb605ff"

URI_aarch64_libarrow = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow}"
SRC_URI[aarch64_libarrow.sha256sum] = "8196e04580fc6056fa405f06e547c3b5ce14f4edd1b5b1c3987f586ea25b8139"

URI_aarch64_libarrow-acero-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-acero-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-acero-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-acero-devel}"
SRC_URI[aarch64_libarrow-acero-devel.sha256sum] = "154bd63253224c91fcf165479e9e87868212fb9f508597589244734e78520b87"

URI_aarch64_libarrow-acero-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-acero-libs-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-acero-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-acero-libs}"
SRC_URI[aarch64_libarrow-acero-libs.sha256sum] = "1a33808c4cdd12353c7b5e41688b1a572f936680205aecb2d13e16520be76d9a"

URI_aarch64_libarrow-dataset-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-dataset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-devel}"
SRC_URI[aarch64_libarrow-dataset-devel.sha256sum] = "a9597b9f4cd26a4065cc9a6e94a491094135c9ad04dff4be77c362c4da0bcb1a"

URI_aarch64_libarrow-dataset-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-glib-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-dataset-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-glib-devel}"
SRC_URI[aarch64_libarrow-dataset-glib-devel.sha256sum] = "71bebb254b4736b58f746386e8e3fd3e533f79a2e608ae364c3f015e91935fa4"

URI_aarch64_libarrow-dataset-glib-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-glib-libs-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-dataset-glib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-glib-libs}"
SRC_URI[aarch64_libarrow-dataset-glib-libs.sha256sum] = "b93bb3453102c897873967beaca2f1ce329e4bded5c8fdb22b41da08776a99ad"

URI_aarch64_libarrow-dataset-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-libs-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-dataset-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-libs}"
SRC_URI[aarch64_libarrow-dataset-libs.sha256sum] = "7558fabd20931d3e510856501a3a40112190bb1bcb11629b6849bfb5a0dd9e8e"

URI_aarch64_libarrow-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-devel}"
SRC_URI[aarch64_libarrow-devel.sha256sum] = "9deed0cb3bcbece094c2c94575c36713d1eae5ddac57131beee87ad1ad70bcff"

URI_aarch64_libarrow-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-doc-17.0.0-9.el10_2.noarch.rpm;name=aarch64_libarrow-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-doc}"
SRC_URI[aarch64_libarrow-doc.sha256sum] = "de1e8deea4dc6911dcc4dc7fa3150fda6c682de26cf59f44642db91b2a8b94a2"

URI_aarch64_libarrow-flight-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-flight-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-flight-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-flight-devel}"
SRC_URI[aarch64_libarrow-flight-devel.sha256sum] = "fe6a6030fb415bfdb710b988acb600dcd1cc56da2d35c1ec9791ac02ef4a4e6d"

URI_aarch64_libarrow-flight-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-flight-libs-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-flight-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-flight-libs}"
SRC_URI[aarch64_libarrow-flight-libs.sha256sum] = "71c9774cb88e87aa3f0f28cec02920a794f3c4b1bfa8f66c2807421706e491db"

URI_aarch64_libarrow-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-glib-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-glib-devel}"
SRC_URI[aarch64_libarrow-glib-devel.sha256sum] = "4784f96438b54665392a3a0301371c80546aa57fc56c05635963118d0b0d60bc"

URI_aarch64_libarrow-glib-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-glib-libs-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-glib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-glib-libs}"
SRC_URI[aarch64_libarrow-glib-libs.sha256sum] = "16e703e07f309e1eca7bc29246ce33cc056719c3454657c3be485298580dfb97"

URI_aarch64_libarrow-python-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-python-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-devel}"
SRC_URI[aarch64_libarrow-python-devel.sha256sum] = "a7bd4ff9d87b9595262881b249f77fc5ecb74177f090cfdaeccddccd2e7eda46"

URI_aarch64_libarrow-python-flight-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-flight-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-python-flight-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-flight-devel}"
SRC_URI[aarch64_libarrow-python-flight-devel.sha256sum] = "e2e85aea598d6f0d7d4d1791820127cb40e15b9d0cf995981aabb1a24e86311c"

URI_aarch64_libarrow-python-flight-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-flight-libs-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-python-flight-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-flight-libs}"
SRC_URI[aarch64_libarrow-python-flight-libs.sha256sum] = "c0ffa8d92db845fae69db04af40a629e76f6debfa8f23534a489c56364721bc1"

URI_aarch64_libarrow-python-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-libs-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_libarrow-python-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-libs}"
SRC_URI[aarch64_libarrow-python-libs.sha256sum] = "882e2dd792a0bcbb34c86fea3c74106fe71291522587d6f9f8d7211bf2d088c6"

URI_aarch64_parquet-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-glib-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_parquet-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-glib-devel}"
SRC_URI[aarch64_parquet-glib-devel.sha256sum] = "f6aa6496f018de7b96a8de591ccf6f31b2c768e3d9e5d5fbe5f692a6fdbfaa16"

URI_aarch64_parquet-glib-libs = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-glib-libs-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_parquet-glib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-glib-libs}"
SRC_URI[aarch64_parquet-glib-libs.sha256sum] = "3d8e96a3ca1d6169c8c96118874429b6761e93825bb962365df98522cad973b9"

URI_aarch64_parquet-libs = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-libs-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_parquet-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-libs}"
SRC_URI[aarch64_parquet-libs.sha256sum] = "07addcdafddee67c40c4a6e271053d378faf0411a6c5b75ccbe2146ce6227658"

URI_aarch64_parquet-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-libs-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_parquet-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-libs-devel}"
SRC_URI[aarch64_parquet-libs-devel.sha256sum] = "0432807709cce9a6680f012d041d8a13012e8be3d65b67113debb2e561c5ca92"

URI_aarch64_python3-pyarrow = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyarrow-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_python3-pyarrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyarrow}"
SRC_URI[aarch64_python3-pyarrow.sha256sum] = "cae875a6ce7a86909f6a726048c96b34ed00bf28249a107f7b52a90b3aaf6453"

URI_aarch64_python3-pyarrow-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyarrow-devel-17.0.0-9.el10_2.aarch64.rpm;name=aarch64_python3-pyarrow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyarrow-devel}"
SRC_URI[aarch64_python3-pyarrow-devel.sha256sum] = "1fd01c139a29dc2f1dd54c3e2e81ced8d2398dc831b96b47370a65973a4a8064"

RDEPENDS:libarrow = " \
 bzip2-libs \
 glibc \
 libarrow-doc \
 libbrotli \
 libgcc \
 liborc2 \
 libstdc++ \
 libzstd \
 lz4-libs \
 re2 \
 snappy \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:libarrow-acero-devel = " \
 cmake-filesystem \
 libarrow \
 libarrow-acero-libs \
 libarrow-devel \
 libarrow-flight-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-acero-libs = " \
 glibc \
 libarrow \
 libarrow-doc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libarrow-dataset-devel = " \
 cmake-filesystem \
 libarrow \
 libarrow-acero-devel \
 libarrow-dataset-libs \
 parquet-libs-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-dataset-glib-devel = " \
 glib2-devel \
 libarrow \
 libarrow-dataset-devel \
 libarrow-dataset-glib-libs \
 libarrow-glib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-dataset-glib-libs = " \
 glib2 \
 glibc \
 libarrow \
 libarrow-dataset-libs \
 libarrow-doc \
 libarrow-glib-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libarrow-dataset-libs = " \
 glibc \
 libarrow \
 libarrow-acero-libs \
 libarrow-doc \
 libgcc \
 libstdc++ \
 parquet-libs \
 "
RDEPENDS:libarrow-devel = " \
 brotli-devel \
 bzip2-devel \
 cmake-filesystem \
 libarrow \
 libarrow-devel \
 libzstd-devel \
 lz4-devel \
 openssl-devel \
 pkgconf-pkg-config \
 rapidjson-devel \
 re2-devel \
 snappy-devel \
 utf8proc-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libarrow-doc = " \
 "
RDEPENDS:libarrow-flight-devel = " \
 cmake-filesystem \
 glib2-devel \
 libarrow \
 libarrow-devel \
 libarrow-flight-devel \
 libarrow-flight-libs \
 libarrow-glib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-flight-libs = " \
 abseil-cpp \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 libarrow \
 libarrow-doc \
 libarrow-glib-libs \
 libgcc \
 libstdc++ \
 protobuf \
 "
RDEPENDS:libarrow-glib-devel = " \
 glib2-devel \
 gobject-introspection-devel \
 libarrow \
 libarrow-devel \
 libarrow-glib-devel \
 libarrow-glib-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-glib-libs = " \
 glib2 \
 glibc \
 libarrow \
 libarrow-acero-libs \
 libarrow-doc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libarrow-python-devel = " \
 libarrow \
 libarrow-devel \
 libarrow-python-libs \
 python3-devel \
 "
RDEPENDS:libarrow-python-flight-devel = " \
 libarrow \
 libarrow-flight-devel \
 libarrow-python-devel \
 libarrow-python-flight-libs \
 "
RDEPENDS:libarrow-python-flight-libs = " \
 glibc \
 libarrow \
 libarrow-doc \
 libarrow-flight-libs \
 libarrow-python-libs \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:libarrow-python-libs = " \
 glibc \
 libarrow \
 libarrow-doc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "
RDEPENDS:parquet-glib-devel = " \
 glib2-devel \
 libarrow \
 libarrow-glib-devel \
 parquet-glib-libs \
 parquet-libs-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:parquet-glib-libs = " \
 glib2 \
 glibc \
 libarrow \
 libarrow-doc \
 libarrow-glib-libs \
 libgcc \
 libstdc++ \
 parquet-libs \
 "
RDEPENDS:parquet-libs = " \
 boost-program-options \
 glibc \
 libarrow \
 libarrow-doc \
 libgcc \
 libstdc++ \
 openssl-libs \
 thrift \
 "
RDEPENDS:parquet-libs-devel = " \
 cmake-filesystem \
 glib2-devel \
 libarrow \
 libarrow-devel \
 libarrow-glib-devel \
 parquet-libs \
 parquet-libs-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:python3-pyarrow = " \
 glibc \
 libarrow \
 libarrow-acero-libs \
 libarrow-dataset-libs \
 libarrow-flight-libs \
 libgcc \
 libstdc++ \
 parquet-libs \
 python3 \
 python3-numpy \
 "
RDEPENDS:python3-pyarrow-devel = " \
 python3-pyarrow \
 "
