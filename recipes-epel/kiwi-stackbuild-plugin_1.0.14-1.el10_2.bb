# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-stackbuild-plugin"
PV = "1.0.14"
PR = "1.el10_2"
PACKAGES = " \
 kiwi-stackbuild-plugin \
 python3-kiwi-stackbuild-plugin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiwi-stackbuild-plugin-1.0.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b2d81919d61ae8e82a4f48f75c8be18f8bf07f5ea424ff1a5c17b5daf8924d7c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-stackbuild-plugin-1.0.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-stackbuild-plugin;unpack=0"
SRC_URI[x86_64_v2_kiwi-stackbuild-plugin.sha256sum] = "d74ada03556fd13c26818b962ae48762c21c16159983329ea9c0ff8077b78fdc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-stackbuild-plugin-1.0.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-stackbuild-plugin;unpack=0"
SRC_URI[x86_64_v2_python3-kiwi-stackbuild-plugin.sha256sum] = "0c9e6608c1f978b044a67210c8ef298f8e21dc4facddb4a5cb2fe1169ad07867"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-stackbuild-plugin-1.0.14-1.el10_2.noarch.rpm;name=aarch64_kiwi-stackbuild-plugin;unpack=0"
SRC_URI[aarch64_kiwi-stackbuild-plugin.sha256sum] = "5e564d822d7baf742f9d6e264d7c869cf959dcf6bde87a2002764d3cbab7b512"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-stackbuild-plugin-1.0.14-1.el10_2.noarch.rpm;name=aarch64_python3-kiwi-stackbuild-plugin;unpack=0"
SRC_URI[aarch64_python3-kiwi-stackbuild-plugin.sha256sum] = "cba78f6dd0456ee7332ce90b924dbd246806ff73a1a4143fd828abe885f926ba"

RDEPENDS:kiwi-stackbuild-plugin = " \
 python3-kiwi-stackbuild-plugin \
 "
RDEPENDS:python3-kiwi-stackbuild-plugin = " \
 kiwi-systemdeps-containers \
 python3 \
 python3-docopt-ng \
 python3-kiwi \
 "
