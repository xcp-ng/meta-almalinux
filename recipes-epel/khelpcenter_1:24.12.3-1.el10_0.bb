# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khelpcenter"
PE = "1"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 khelpcenter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khelpcenter-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8460bded9aa65e374fff87c186db6177348c2e672baab59f4d8f40cca34743b1"

URI_x86_64_v2_khelpcenter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khelpcenter-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khelpcenter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khelpcenter}"
SRC_URI[x86_64_v2_khelpcenter.sha256sum] = "cbe5a2d2f1e43d2b5e724898a7bfae54e82c00cbaec8153859eb965aa45a14ec"

URI_aarch64_khelpcenter = "${EPEL_MIRROR}/aarch64/Packages/k/khelpcenter-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_khelpcenter;unpack=0"
SRC_URI:append = " ${URI_aarch64_khelpcenter}"
SRC_URI[aarch64_khelpcenter.sha256sum] = "f72c5c73818d6c88009795c6822ac6c29a8aa4c1f1bbccef1ef3f683408188d8"

RDEPENDS:khelpcenter = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdoctools \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 libxml2 \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 xapian-core-libs \
 "
