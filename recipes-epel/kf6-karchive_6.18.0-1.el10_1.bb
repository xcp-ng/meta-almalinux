# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-karchive"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-karchive \
 kf6-karchive-devel \
 kf6-karchive-doc \
 kf6-karchive-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-karchive-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "681aed5367dcbd684d9669ac8714ce210eb29b0236a58063150b5beff08d9edb"

URI_x86_64_v2_kf6-karchive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive}"
SRC_URI[x86_64_v2_kf6-karchive.sha256sum] = "1da8ecbc346a5995c3a5471c861e23c437140e749d9e66dcc8edb20c62e02847"

URI_x86_64_v2_kf6-karchive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-devel}"
SRC_URI[x86_64_v2_kf6-karchive-devel.sha256sum] = "051538fd1e7f386e887d19b5b6ef97e023502430788ed75a728ad35f589bbbd8"

URI_x86_64_v2_kf6-karchive-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-karchive-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-doc}"
SRC_URI[x86_64_v2_kf6-karchive-doc.sha256sum] = "55637e47b45dcdb4447d8f9f6b8c2189b21c53773229fd04b5cde4fd5731f110"

URI_x86_64_v2_kf6-karchive-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-karchive-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-karchive-html}"
SRC_URI[x86_64_v2_kf6-karchive-html.sha256sum] = "0b1c8a83e466255eed8d22d5487f610f4dfb89142a351c37f43f25070191a7ea"

URI_aarch64_kf6-karchive = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-karchive;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive}"
SRC_URI[aarch64_kf6-karchive.sha256sum] = "b434350e8a2a0b79823346f4d26600ee273838052a10551cb2ec04d901678e16"

URI_aarch64_kf6-karchive-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-karchive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-devel}"
SRC_URI[aarch64_kf6-karchive-devel.sha256sum] = "1d47093de5392f19d227e4cd9b8365997508407c210a779cc7d15bf1b192689a"

URI_aarch64_kf6-karchive-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-karchive-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-doc}"
SRC_URI[aarch64_kf6-karchive-doc.sha256sum] = "0e005eacf0ba5ed4a2a2f135b04816e5d4b99dd14e2d005e2b3ac75bac2e19ab"

URI_aarch64_kf6-karchive-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-karchive-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-karchive-html}"
SRC_URI[aarch64_kf6-karchive-html.sha256sum] = "9b157ccf4e822dd5fcd7da29035446448b3b5a2cb5b3be0a501085f01b7b0c00"

RDEPENDS:kf6-karchive = " \
 bzip2-libs \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libzstd \
 openssl-libs \
 qt6-qtbase \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:kf6-karchive-devel = " \
 cmake-filesystem \
 kf6-karchive \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-karchive-doc = " \
 "
RDEPENDS:kf6-karchive-html = " \
 "
