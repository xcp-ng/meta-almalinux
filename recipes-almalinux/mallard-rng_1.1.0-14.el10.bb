# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mallard-rng"
PV = "1.1.0"
PR = "14.el10"
PACKAGES = " \
 mallard-rng \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mallard-rng-1.1.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15ffc5e6b965ad290cae1fe8ad5476a78bf08b8dd39f51148ff419fb087ec4b9"

URI_x86_64_v2_mallard-rng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mallard-rng-1.1.0-14.el10.noarch.rpm;name=x86_64_v2_mallard-rng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mallard-rng}"
SRC_URI[x86_64_v2_mallard-rng.sha256sum] = "2e3afab086fd78bb16f33bc4ef86581771ec4142059e912449d197e275b01ad0"

URI_aarch64_mallard-rng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mallard-rng-1.1.0-14.el10.noarch.rpm;name=aarch64_mallard-rng;unpack=0"
SRC_URI:append = " ${URI_aarch64_mallard-rng}"
SRC_URI[aarch64_mallard-rng.sha256sum] = "2e3afab086fd78bb16f33bc4ef86581771ec4142059e912449d197e275b01ad0"

RDEPENDS:mallard-rng = " \
 bash \
 libxml2 \
 pkgconf-pkg-config \
 xml-common \
 "
