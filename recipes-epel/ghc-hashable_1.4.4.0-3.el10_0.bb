# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hashable"
PV = "1.4.4.0"
PR = "3.el10_0"
PACKAGES = " \
 ghc-hashable \
 ghc-hashable-devel \
 ghc-hashable-doc \
 ghc-hashable-prof \
 ghc-os-string \
 ghc-os-string-devel \
 ghc-os-string-doc \
 ghc-os-string-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hashable-1.4.4.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b23ec8aba615da57031db94683320d7747ef54f58407c7ad1502d65c6753c4c7"

URI_x86_64_v2_ghc-hashable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hashable-1.4.4.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hashable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hashable}"
SRC_URI[x86_64_v2_ghc-hashable.sha256sum] = "21ee4f2aa251b51f9d1de1e46e716531619fc2e6a14058145dfa7589b6f4dc0d"

URI_x86_64_v2_ghc-hashable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hashable-devel-1.4.4.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hashable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hashable-devel}"
SRC_URI[x86_64_v2_ghc-hashable-devel.sha256sum] = "9a86cf79898d4b26d5856a9c66b41bd2d11da0b1360bbf0b76c732c45c6558b2"

URI_x86_64_v2_ghc-hashable-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hashable-doc-1.4.4.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hashable-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hashable-doc}"
SRC_URI[x86_64_v2_ghc-hashable-doc.sha256sum] = "b3e93728d44d8eb77d28052542c93f03834641409e79c29f8d80bfd237992310"

URI_x86_64_v2_ghc-hashable-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hashable-prof-1.4.4.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hashable-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hashable-prof}"
SRC_URI[x86_64_v2_ghc-hashable-prof.sha256sum] = "0876543f38563071af81d7c4604c2e9f2d3202ff07786a0b61d65b1a424cb65c"

URI_x86_64_v2_ghc-os-string = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-os-string-2.0.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-os-string;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-os-string}"
SRC_URI[x86_64_v2_ghc-os-string.sha256sum] = "99f5c9a61206d451d5cff9e70d0d65b4885d7525f6bc763e181d6a36b647dca5"

URI_x86_64_v2_ghc-os-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-os-string-devel-2.0.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-os-string-devel}"
SRC_URI[x86_64_v2_ghc-os-string-devel.sha256sum] = "a0babd70fc32bb135ca47251ef0ac0c00b9c2e1b616630875d26442442f525ca"

URI_x86_64_v2_ghc-os-string-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-os-string-doc-2.0.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-os-string-doc}"
SRC_URI[x86_64_v2_ghc-os-string-doc.sha256sum] = "76555586a5b13f6107ee01cca1df415fc30ef1e8bf315d484446ec17ae46e642"

URI_x86_64_v2_ghc-os-string-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-os-string-prof-2.0.6-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-os-string-prof}"
SRC_URI[x86_64_v2_ghc-os-string-prof.sha256sum] = "18409f11ef8c669fb8e2163ab7dfd37963246b5cf5395c6046645e7cb9e4b2ba"

URI_aarch64_ghc-hashable = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hashable-1.4.4.0-3.el10_0.aarch64.rpm;name=aarch64_ghc-hashable;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hashable}"
SRC_URI[aarch64_ghc-hashable.sha256sum] = "82fc4b3d51deeb0447d486d100a6b4c2a0242b5f1ce145e1aa72c5976dc03b6a"

URI_aarch64_ghc-hashable-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hashable-devel-1.4.4.0-3.el10_0.aarch64.rpm;name=aarch64_ghc-hashable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hashable-devel}"
SRC_URI[aarch64_ghc-hashable-devel.sha256sum] = "2b0466a91565a2a87c280878889d36054100da72a5cb4e25c38b08b5e5e3ef09"

URI_aarch64_ghc-hashable-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hashable-doc-1.4.4.0-3.el10_0.noarch.rpm;name=aarch64_ghc-hashable-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hashable-doc}"
SRC_URI[aarch64_ghc-hashable-doc.sha256sum] = "061f87df2df09bded834566fc1d6a04f086768489fe7c83254094c1814cee899"

URI_aarch64_ghc-hashable-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hashable-prof-1.4.4.0-3.el10_0.aarch64.rpm;name=aarch64_ghc-hashable-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hashable-prof}"
SRC_URI[aarch64_ghc-hashable-prof.sha256sum] = "b4319dd597d5125cf4d172efb3b72b53ae8d473333325e741664c09b65ef45b0"

URI_aarch64_ghc-os-string = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-os-string-2.0.6-3.el10_0.aarch64.rpm;name=aarch64_ghc-os-string;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-os-string}"
SRC_URI[aarch64_ghc-os-string.sha256sum] = "dc8b19c26bb77a8e7194cfeb192c2a9d8ccb74b7427988f928a4fd8cd7874f04"

URI_aarch64_ghc-os-string-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-os-string-devel-2.0.6-3.el10_0.aarch64.rpm;name=aarch64_ghc-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-os-string-devel}"
SRC_URI[aarch64_ghc-os-string-devel.sha256sum] = "b547d05b95c996da06e81de937c78a55136812ecd3ed3e96637bf6cdc9106ae7"

URI_aarch64_ghc-os-string-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-os-string-doc-2.0.6-3.el10_0.noarch.rpm;name=aarch64_ghc-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-os-string-doc}"
SRC_URI[aarch64_ghc-os-string-doc.sha256sum] = "e971bc089b3e37398c806c8be897a39ba0fc843bdb621d701deef7ccca512b8d"

URI_aarch64_ghc-os-string-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-os-string-prof-2.0.6-3.el10_0.aarch64.rpm;name=aarch64_ghc-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-os-string-prof}"
SRC_URI[aarch64_ghc-os-string-prof.sha256sum] = "efeda619a36e75fc7739ec30eaf59d94bc0f6006232b341285dce3853387e846"

RDEPENDS:ghc-hashable = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hashable-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-filepath-devel \
 ghc-ghc-bignum-devel \
 ghc-hashable \
 ghc-os-string-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-hashable-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hashable-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-filepath-prof \
 ghc-ghc-bignum-prof \
 ghc-hashable-devel \
 ghc-os-string-prof \
 ghc-text-prof \
 "
RDEPENDS:ghc-os-string = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-os-string-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-exceptions-devel \
 ghc-os-string \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-os-string-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-os-string-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-deepseq-prof \
 ghc-exceptions-prof \
 ghc-os-string-devel \
 ghc-template-haskell-prof \
 "
