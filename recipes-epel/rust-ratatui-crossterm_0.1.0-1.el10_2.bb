# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ratatui-crossterm"
PV = "0.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ratatui-crossterm+crossterm_0_29-devel \
 rust-ratatui-crossterm+default-devel \
 rust-ratatui-crossterm+document-features-devel \
 rust-ratatui-crossterm+scrolling-regions-devel \
 rust-ratatui-crossterm+serde-devel \
 rust-ratatui-crossterm+underline-color-devel \
 rust-ratatui-crossterm+unstable-backend-writer-devel \
 rust-ratatui-crossterm+unstable-devel \
 rust-ratatui-crossterm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ratatui-crossterm-0.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf3573f3c4b01b49cef91866030932df45bb4a7429b83761fb834df8dbece940"

URI_x86_64_v2_rust-ratatui-crossterm+crossterm_0_29-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-crossterm+crossterm_0_29-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-crossterm+crossterm_0_29-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-crossterm+crossterm_0_29-devel}"
SRC_URI[x86_64_v2_rust-ratatui-crossterm+crossterm_0_29-devel.sha256sum] = "423a7bff3fac831e148de8092330f903fa05b45a761155f8f717db62430f33ec"

URI_x86_64_v2_rust-ratatui-crossterm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-crossterm+default-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-crossterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-crossterm+default-devel}"
SRC_URI[x86_64_v2_rust-ratatui-crossterm+default-devel.sha256sum] = "5c1372b700330792872bba989c8a562fa1b75b5c489ddf5e64ab92660de89b4a"

URI_x86_64_v2_rust-ratatui-crossterm+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-crossterm+document-features-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-crossterm+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-crossterm+document-features-devel}"
SRC_URI[x86_64_v2_rust-ratatui-crossterm+document-features-devel.sha256sum] = "aadc6d376a27921d9a9ec84d735abddc5d3f8ba4ffbf12e43b1bcf5f7050f296"

URI_x86_64_v2_rust-ratatui-crossterm+scrolling-regions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-crossterm+scrolling-regions-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-crossterm+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-crossterm+scrolling-regions-devel}"
SRC_URI[x86_64_v2_rust-ratatui-crossterm+scrolling-regions-devel.sha256sum] = "3280f4d59a4eaa0a589b8f5bfdda808e70562431a15cac2c4be90d699ade59aa"

URI_x86_64_v2_rust-ratatui-crossterm+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-crossterm+serde-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-crossterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-crossterm+serde-devel}"
SRC_URI[x86_64_v2_rust-ratatui-crossterm+serde-devel.sha256sum] = "7fa75010a7730af56852b2f7196e5aafe54545eb27940bc4fb7a861a4ab6e0b5"

URI_x86_64_v2_rust-ratatui-crossterm+underline-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-crossterm+underline-color-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-crossterm+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-crossterm+underline-color-devel}"
SRC_URI[x86_64_v2_rust-ratatui-crossterm+underline-color-devel.sha256sum] = "7f5a6d4fb0688431821840f23411a5e5113167739fb93656775e206133c316f9"

URI_x86_64_v2_rust-ratatui-crossterm+unstable-backend-writer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-crossterm+unstable-backend-writer-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-crossterm+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-crossterm+unstable-backend-writer-devel}"
SRC_URI[x86_64_v2_rust-ratatui-crossterm+unstable-backend-writer-devel.sha256sum] = "4107dd956dda3401fdfe3dea4600a9fcfcec494b2d895ffe137eb715e2d2ac78"

URI_x86_64_v2_rust-ratatui-crossterm+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-crossterm+unstable-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-crossterm+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-crossterm+unstable-devel}"
SRC_URI[x86_64_v2_rust-ratatui-crossterm+unstable-devel.sha256sum] = "1269fb7b0b0b9687d5fc0cb8c2f096321e998cddd64a28fe98e3fd9af3841e51"

URI_x86_64_v2_rust-ratatui-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-crossterm-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-crossterm-devel}"
SRC_URI[x86_64_v2_rust-ratatui-crossterm-devel.sha256sum] = "db23a277fcf65dbfff999accdba955517b5346f884e71954a5704e58f165a73d"

URI_aarch64_rust-ratatui-crossterm+crossterm_0_29-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-crossterm+crossterm_0_29-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-crossterm+crossterm_0_29-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-crossterm+crossterm_0_29-devel}"
SRC_URI[aarch64_rust-ratatui-crossterm+crossterm_0_29-devel.sha256sum] = "279982c7af0ec51dede5e48fa953aa3719a5fe7fc4eab22d2f231d21c55d657e"

URI_aarch64_rust-ratatui-crossterm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-crossterm+default-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-crossterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-crossterm+default-devel}"
SRC_URI[aarch64_rust-ratatui-crossterm+default-devel.sha256sum] = "f6538eee019ecc5d7059438d733bf25af3164f953bb1f15c598a9e257fd171db"

URI_aarch64_rust-ratatui-crossterm+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-crossterm+document-features-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-crossterm+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-crossterm+document-features-devel}"
SRC_URI[aarch64_rust-ratatui-crossterm+document-features-devel.sha256sum] = "91d44bc8bd2646dac5521bdfadae5f17ccc8f1a1421a4ff9232b9fff34ab7b65"

URI_aarch64_rust-ratatui-crossterm+scrolling-regions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-crossterm+scrolling-regions-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-crossterm+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-crossterm+scrolling-regions-devel}"
SRC_URI[aarch64_rust-ratatui-crossterm+scrolling-regions-devel.sha256sum] = "e42bd9a39a5efdb18e0a7d9c01257d7b52608a4fc0952bb4bca870b22b5c6d16"

URI_aarch64_rust-ratatui-crossterm+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-crossterm+serde-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-crossterm+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-crossterm+serde-devel}"
SRC_URI[aarch64_rust-ratatui-crossterm+serde-devel.sha256sum] = "4f813d605e39c905c10190eb0b8278e87df85a4da546ca8432e2f949a6b17fcf"

URI_aarch64_rust-ratatui-crossterm+underline-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-crossterm+underline-color-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-crossterm+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-crossterm+underline-color-devel}"
SRC_URI[aarch64_rust-ratatui-crossterm+underline-color-devel.sha256sum] = "4a394055fd532f8895f9a2912598264ddcb99a1707e99eedd828166e1be94d57"

URI_aarch64_rust-ratatui-crossterm+unstable-backend-writer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-crossterm+unstable-backend-writer-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-crossterm+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-crossterm+unstable-backend-writer-devel}"
SRC_URI[aarch64_rust-ratatui-crossterm+unstable-backend-writer-devel.sha256sum] = "935f22988873a318e75e141ff3a1886368688ec97292471c9835172c7cdc5c1a"

URI_aarch64_rust-ratatui-crossterm+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-crossterm+unstable-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-crossterm+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-crossterm+unstable-devel}"
SRC_URI[aarch64_rust-ratatui-crossterm+unstable-devel.sha256sum] = "235b3a71cfafca349fecafb0d833498d3583608678ef932b0c719217de92f3ae"

URI_aarch64_rust-ratatui-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-crossterm-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-ratatui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-crossterm-devel}"
SRC_URI[aarch64_rust-ratatui-crossterm-devel.sha256sum] = "7e93d8ec3a1a63c5392882f3cf2688a3feca32d2f1ed50de2cf1e4e6d9b1e27e"

RDEPENDS:rust-ratatui-crossterm+crossterm_0_29-devel = " \
 cargo \
 rust-crossterm+default-devel \
 rust-ratatui-crossterm-devel \
 "
RDEPENDS:rust-ratatui-crossterm+default-devel = " \
 cargo \
 rust-ratatui-crossterm+crossterm_0_29-devel \
 rust-ratatui-crossterm+underline-color-devel \
 rust-ratatui-crossterm-devel \
 "
RDEPENDS:rust-ratatui-crossterm+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-ratatui-crossterm-devel \
 "
RDEPENDS:rust-ratatui-crossterm+scrolling-regions-devel = " \
 cargo \
 rust-ratatui-core+scrolling-regions-devel \
 rust-ratatui-crossterm-devel \
 "
RDEPENDS:rust-ratatui-crossterm+serde-devel = " \
 cargo \
 rust-crossterm+default-devel \
 rust-crossterm+serde-devel \
 rust-ratatui-crossterm-devel \
 "
RDEPENDS:rust-ratatui-crossterm+underline-color-devel = " \
 cargo \
 rust-ratatui-core+underline-color-devel \
 rust-ratatui-crossterm-devel \
 "
RDEPENDS:rust-ratatui-crossterm+unstable-backend-writer-devel = " \
 cargo \
 rust-ratatui-crossterm-devel \
 "
RDEPENDS:rust-ratatui-crossterm+unstable-devel = " \
 cargo \
 rust-ratatui-crossterm+unstable-backend-writer-devel \
 rust-ratatui-crossterm-devel \
 "
RDEPENDS:rust-ratatui-crossterm-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-instability+default-devel \
 rust-ratatui-core+default-devel \
 "
