# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "relaxng-datatype-java"
PV = "2011.1"
PR = "6.el10"
PACKAGES = " \
 relaxng-datatype-java \
 relaxng-datatype-java-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/relaxng-datatype-java-2011.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f24904470978140ffdea0731b92377764c0204814968d059b1ef4e6e9757f206"

URI_x86_64_v2_relaxng-datatype-java = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/relaxng-datatype-java-2011.1-6.el10.noarch.rpm;name=x86_64_v2_relaxng-datatype-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_relaxng-datatype-java}"
SRC_URI[x86_64_v2_relaxng-datatype-java.sha256sum] = "8d5b7faef0a7abd861576cae54c3e5d722cd8c568fd56999265a269c10422817"

URI_x86_64_v2_relaxng-datatype-java-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/relaxng-datatype-java-javadoc-2011.1-6.el10.noarch.rpm;name=x86_64_v2_relaxng-datatype-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_relaxng-datatype-java-javadoc}"
SRC_URI[x86_64_v2_relaxng-datatype-java-javadoc.sha256sum] = "dbf1511980c1ae8532e06408f21e7f6b306f13156da6165ed608535dd1d6d314"

URI_aarch64_relaxng-datatype-java = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/relaxng-datatype-java-2011.1-6.el10.noarch.rpm;name=aarch64_relaxng-datatype-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_relaxng-datatype-java}"
SRC_URI[aarch64_relaxng-datatype-java.sha256sum] = "8d5b7faef0a7abd861576cae54c3e5d722cd8c568fd56999265a269c10422817"

URI_aarch64_relaxng-datatype-java-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/relaxng-datatype-java-javadoc-2011.1-6.el10.noarch.rpm;name=aarch64_relaxng-datatype-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_relaxng-datatype-java-javadoc}"
SRC_URI[aarch64_relaxng-datatype-java-javadoc.sha256sum] = "dbf1511980c1ae8532e06408f21e7f6b306f13156da6165ed608535dd1d6d314"

RDEPENDS:relaxng-datatype-java = " \
 javapackages-filesystem \
 "
RDEPENDS:relaxng-datatype-java-javadoc = " \
 javapackages-filesystem \
 "
