# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libjwt"
PV = "2.1.2"
PR = "1.el10_1"
PACKAGES = " \
 libjwt \
 libjwt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libjwt-2.1.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0414de58ad0ff76f958aaa83cd6608696751186e9a6741f04ee20ad8a04a7a2"

URI_x86_64_v2_libjwt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjwt-2.1.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjwt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjwt}"
SRC_URI[x86_64_v2_libjwt.sha256sum] = "ddad1e3057da7d49612d5aac7559ae748b210d23add01ff3037b0696c85e48b3"

URI_x86_64_v2_libjwt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjwt-devel-2.1.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjwt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjwt-devel}"
SRC_URI[x86_64_v2_libjwt-devel.sha256sum] = "c9967440abd9718a6ad7a66210192bf0eec0eb3f5ce7c2c55d74a230211dd08b"

URI_aarch64_libjwt = "${EPEL_MIRROR}/aarch64/Packages/l/libjwt-2.1.2-1.el10_1.aarch64.rpm;name=aarch64_libjwt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjwt}"
SRC_URI[aarch64_libjwt.sha256sum] = "128c0bae465a1ded22a3797efd8138aa1292de094c8435d38b9173cc0000d032"

URI_aarch64_libjwt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libjwt-devel-2.1.2-1.el10_1.aarch64.rpm;name=aarch64_libjwt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjwt-devel}"
SRC_URI[aarch64_libjwt-devel.sha256sum] = "2cc37065adc60b11223aeb7c07cc5331d3c8754a6826ac4a974e7e5c6cd0e013"

RDEPENDS:libjwt = " \
 glibc \
 jansson \
 openssl-libs \
 "
RDEPENDS:libjwt-devel = " \
 libjwt \
 pkgconf-pkg-config \
 "
