# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blis"
PV = "2.0"
PR = "2.el10_0"
PACKAGES = " \
 blis \
 blis-devel \
 blis-openmp \
 blis-openmp64 \
 blis-serial64 \
 blis-srpm-macros \
 blis-threads \
 blis-threads64 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blis-2.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c364420d2a3ab99759e9fa922ea5e98497b9c1afc0cc199ac0d4db122c59a6ac"

URI_x86_64_v2_blis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-2.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis}"
SRC_URI[x86_64_v2_blis.sha256sum] = "cc63cff45566088e3e3133880881d1a12e3c453b20e1111e7e5f6919c3053293"
RPROVIDES:blis:x86_64_v2 = "virtual/libblas.so.3___64bit_"

URI_x86_64_v2_blis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-devel-2.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-devel}"
SRC_URI[x86_64_v2_blis-devel.sha256sum] = "c3d80f7685966fe7b48d43c56807265fcf3c22321cc97198deb1e002c5084a3c"

URI_x86_64_v2_blis-openmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-openmp-2.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-openmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-openmp}"
SRC_URI[x86_64_v2_blis-openmp.sha256sum] = "bc6d7d93509233855c3f1d4207c8f8911de8e05823f52afd6cc667b08fec43a9"
RPROVIDES:blis-openmp:x86_64_v2 = "virtual/libblas.so.3___64bit_"

URI_x86_64_v2_blis-openmp64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-openmp64-2.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-openmp64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-openmp64}"
SRC_URI[x86_64_v2_blis-openmp64.sha256sum] = "fdbfb45f02f1be28dbe000acfcdf5a61d9269b3d5f8693e2bf1a97fcaebd3450"
RPROVIDES:blis-openmp64:x86_64_v2 = "virtual/libblas64.so.3___64bit_"

URI_x86_64_v2_blis-serial64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-serial64-2.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-serial64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-serial64}"
SRC_URI[x86_64_v2_blis-serial64.sha256sum] = "3ff0b51c339157e627828b65b4a9e01a865d89fbff6cf8b7faf153aa659f7ffb"
RPROVIDES:blis-serial64:x86_64_v2 = "virtual/libblas64.so.3___64bit_"

URI_x86_64_v2_blis-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-srpm-macros-2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_blis-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-srpm-macros}"
SRC_URI[x86_64_v2_blis-srpm-macros.sha256sum] = "e0199bc519e933f795edc53d00c6cd775e2495f27afebf27dc4f4b021f20abd7"

URI_x86_64_v2_blis-threads = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-threads-2.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-threads;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-threads}"
SRC_URI[x86_64_v2_blis-threads.sha256sum] = "9dd0373de47780850d83df8eb2c4a03e9b0efdce6afae37c4cc4e84c729903b9"
RPROVIDES:blis-threads:x86_64_v2 = "virtual/libblas.so.3___64bit_"

URI_x86_64_v2_blis-threads64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blis-threads64-2.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blis-threads64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blis-threads64}"
SRC_URI[x86_64_v2_blis-threads64.sha256sum] = "26f103cd72ffa48d6dd9cdb7e3b8ae2c7e5aba3a3e99ff08d0b10369f6ce6441"
RPROVIDES:blis-threads64:x86_64_v2 = "virtual/libblas64.so.3___64bit_"

URI_aarch64_blis = "${EPEL_MIRROR}/aarch64/Packages/b/blis-2.0-2.el10_0.aarch64.rpm;name=aarch64_blis;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis}"
SRC_URI[aarch64_blis.sha256sum] = "8ddbd12c83d2fa301e2ab9d61d932a1a99b9c93decfc69d4b332b4186a38cd8d"
RPROVIDES:blis:aarch64 = "virtual/libblas.so.3___64bit_"

URI_aarch64_blis-devel = "${EPEL_MIRROR}/aarch64/Packages/b/blis-devel-2.0-2.el10_0.aarch64.rpm;name=aarch64_blis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-devel}"
SRC_URI[aarch64_blis-devel.sha256sum] = "dbd0b9bea24eb694078f8995bf61ba28495c64eea2af103f4163c650a38de4cd"

URI_aarch64_blis-openmp = "${EPEL_MIRROR}/aarch64/Packages/b/blis-openmp-2.0-2.el10_0.aarch64.rpm;name=aarch64_blis-openmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-openmp}"
SRC_URI[aarch64_blis-openmp.sha256sum] = "4776607a555a8ca377526a211171750255efb726637b5041f18903fba40a069c"
RPROVIDES:blis-openmp:aarch64 = "virtual/libblas.so.3___64bit_"

URI_aarch64_blis-openmp64 = "${EPEL_MIRROR}/aarch64/Packages/b/blis-openmp64-2.0-2.el10_0.aarch64.rpm;name=aarch64_blis-openmp64;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-openmp64}"
SRC_URI[aarch64_blis-openmp64.sha256sum] = "94683b84a4c8e4e0f711d3932927beb92fada11eef1ca80d66b7e9f2e7e8eaf3"
RPROVIDES:blis-openmp64:aarch64 = "virtual/libblas64.so.3___64bit_"

URI_aarch64_blis-serial64 = "${EPEL_MIRROR}/aarch64/Packages/b/blis-serial64-2.0-2.el10_0.aarch64.rpm;name=aarch64_blis-serial64;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-serial64}"
SRC_URI[aarch64_blis-serial64.sha256sum] = "f1325167756822da09fa88d2649716745b2be4d1051f151ab2b3d06c6e8bfcf6"
RPROVIDES:blis-serial64:aarch64 = "virtual/libblas64.so.3___64bit_"

URI_aarch64_blis-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/b/blis-srpm-macros-2.0-2.el10_0.noarch.rpm;name=aarch64_blis-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-srpm-macros}"
SRC_URI[aarch64_blis-srpm-macros.sha256sum] = "9788bb6446a41ba22429415c4c09ffe251f75535f945bdf7db41259b810d7ebb"

URI_aarch64_blis-threads = "${EPEL_MIRROR}/aarch64/Packages/b/blis-threads-2.0-2.el10_0.aarch64.rpm;name=aarch64_blis-threads;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-threads}"
SRC_URI[aarch64_blis-threads.sha256sum] = "6f433eee504374b5b1c0b08f0544d81bc320f4337817f6e06e8505d5954b1179"
RPROVIDES:blis-threads:aarch64 = "virtual/libblas.so.3___64bit_"

URI_aarch64_blis-threads64 = "${EPEL_MIRROR}/aarch64/Packages/b/blis-threads64-2.0-2.el10_0.aarch64.rpm;name=aarch64_blis-threads64;unpack=0"
SRC_URI:append = " ${URI_aarch64_blis-threads64}"
SRC_URI[aarch64_blis-threads64.sha256sum] = "ea62bb87e6df5ff48b096b7ad02ce074085b98031d01003e8be88f6d02499873"
RPROVIDES:blis-threads64:aarch64 = "virtual/libblas64.so.3___64bit_"

RDEPENDS:blis = " \
 glibc \
 "
RDEPENDS:blis-devel = " \
 blis \
 blis-openmp \
 blis-openmp64 \
 blis-serial64 \
 blis-threads \
 blis-threads64 \
 "
RDEPENDS:blis-openmp = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:blis-openmp64 = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:blis-serial64 = " \
 glibc \
 "
RDEPENDS:blis-srpm-macros = " \
 "
RDEPENDS:blis-threads = " \
 glibc \
 "
RDEPENDS:blis-threads64 = " \
 glibc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libblas.so.3___64bit_ rpm/virtual/libblas64.so.3___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libblas.so.3___64bit_ rpm/virtual/libblas64.so.3___64bit_"
