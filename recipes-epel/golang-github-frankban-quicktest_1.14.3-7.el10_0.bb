# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-frankban-quicktest"
PV = "1.14.3"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-frankban-quicktest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-frankban-quicktest-1.14.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6aaee48913d3530dd5f03721bb253bc65651a3aee94945d16fc121c734d2941"

URI_x86_64_v2_golang-github-frankban-quicktest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-frankban-quicktest-devel-1.14.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-frankban-quicktest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-frankban-quicktest-devel}"
SRC_URI[x86_64_v2_golang-github-frankban-quicktest-devel.sha256sum] = "c650a58092d3a5a1c56248fc389bf47c05da56144876892fa47ff98bb50d2d7d"

URI_aarch64_golang-github-frankban-quicktest-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-frankban-quicktest-devel-1.14.3-7.el10_0.noarch.rpm;name=aarch64_golang-github-frankban-quicktest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-frankban-quicktest-devel}"
SRC_URI[aarch64_golang-github-frankban-quicktest-devel.sha256sum] = "cdfc5c85c81b5f3b13ffa801f1e7d5454b408b6d1cb24b011cf848756130a58a"

RDEPENDS:golang-github-frankban-quicktest-devel = " \
 go-filesystem \
 golang-github-google-cmp-devel \
 golang-github-kr-pretty-devel \
 "
