# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snmpcheck"
PV = "1.9"
PR = "19.el10_0"
PACKAGES = " \
 snmpcheck \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/snmpcheck-1.9-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "28689e786d7fdc68a74bc9ea5fd9cacdf12651eb1bc719874f538cb22d16b4ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snmpcheck-1.9-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_snmpcheck;unpack=0"
SRC_URI[x86_64_v2_snmpcheck.sha256sum] = "1ba2a1dcfd1482cc174695566d5563bb4ce506b894aef9ed4afc93bd72fd0efe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/snmpcheck-1.9-19.el10_0.noarch.rpm;name=aarch64_snmpcheck;unpack=0"
SRC_URI[aarch64_snmpcheck.sha256sum] = "4e57b638fb226fb5f26e741ba8786fd55505b906a6b84de713b079ea6f8c7d5d"

RDEPENDS:snmpcheck = " \
 ruby \
 rubygem-snmp \
 virtual/ruby_release_ \
 "
