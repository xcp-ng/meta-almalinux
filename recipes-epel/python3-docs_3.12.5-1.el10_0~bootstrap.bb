# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-docs"
PV = "3.12.5"
PR = "1.el10_0~bootstrap"
PACKAGES = " \
 python3-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-docs-3.12.5-1.el10_0~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3af60a406bdc62bbcbf33e832456317a366b2f6ffd96432cf2ed19447952c94"

URI_x86_64_v2_python3-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-docs-3.12.5-1.el10_0~bootstrap.alma_altarch.noarch.rpm;name=x86_64_v2_python3-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-docs}"
SRC_URI[x86_64_v2_python3-docs.sha256sum] = "22153ef692a11fcefbb83615da4b706e3a68c6f9ce9ac6580a85b42d604b9497"

URI_aarch64_python3-docs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-docs-3.12.5-1.el10_0~bootstrap.noarch.rpm;name=aarch64_python3-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-docs}"
SRC_URI[aarch64_python3-docs.sha256sum] = "db252d9b40f0bb92cc8bdaf96a7fc8ea8c49d77e3d039487dc80fe0ba217b6c7"

RDEPENDS:python3-docs = " \
 "
