# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kfind"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kfind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kfind-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c769dbe2b7579c05187b65857cdbc7ed90ba229f9d56b78e09867d85037ba8a1"

URI_x86_64_v2_kfind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfind-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kfind}"
SRC_URI[x86_64_v2_kfind.sha256sum] = "76b07f146cfe4d49f63d2169b8ced67a5e5d5d7b64d7c879c75b569fc57e8860"

URI_aarch64_kfind = "${EPEL_MIRROR}/aarch64/Packages/k/kfind-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kfind;unpack=0"
SRC_URI:append = " ${URI_aarch64_kfind}"
SRC_URI[aarch64_kfind.sha256sum] = "cd0708d91dfb69f4a0d2ad2e1dedbc21452d3bf0d89baf88b09b5c243ccfc2f5"

RDEPENDS:kfind = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
