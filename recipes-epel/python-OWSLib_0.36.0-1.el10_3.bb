# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-OWSLib"
PV = "0.36.0"
PR = "1.el10_3"
PACKAGES = " \
 python-OWSLib-doc \
 python3-OWSLib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-OWSLib-0.36.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5be969dd43087b253a27ab8fe897cd2d89d49ba39ba15ac41a22793c5083e3c0"

URI_x86_64_v2_python-OWSLib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-OWSLib-doc-0.36.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-OWSLib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-OWSLib-doc}"
SRC_URI[x86_64_v2_python-OWSLib-doc.sha256sum] = "e4e7845d96726d6f4fbd818da94ad49e9814ed3b1710c31221e31b0dea1aaa9c"

URI_x86_64_v2_python3-OWSLib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-OWSLib-0.36.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-OWSLib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-OWSLib}"
SRC_URI[x86_64_v2_python3-OWSLib.sha256sum] = "36e82e91fbbcfc9155e00dd98f19aa9ba15f8de84af517404620bb902fa742be"

URI_aarch64_python-OWSLib-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-OWSLib-doc-0.36.0-1.el10_3.noarch.rpm;name=aarch64_python-OWSLib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-OWSLib-doc}"
SRC_URI[aarch64_python-OWSLib-doc.sha256sum] = "57fa5db45c80e044ef86fa3170cc0cf91a1aaf93ef0efe4257bd8ef73c40f4b3"

URI_aarch64_python3-OWSLib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-OWSLib-0.36.0-1.el10_3.noarch.rpm;name=aarch64_python3-OWSLib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-OWSLib}"
SRC_URI[aarch64_python3-OWSLib.sha256sum] = "8ff25cb7b0b1a9bd2fa3ca338622996531dae7d4cb9f80dcecb5064f5b26eb22"

RDEPENDS:python-OWSLib-doc = " \
 "
RDEPENDS:python3-OWSLib = " \
 python3 \
 python3-dateutil \
 python3-lxml \
 python3-pyyaml \
 python3-requests \
 "
