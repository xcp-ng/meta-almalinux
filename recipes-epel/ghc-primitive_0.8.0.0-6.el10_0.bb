# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-primitive"
PV = "0.8.0.0"
PR = "6.el10_0"
PACKAGES = " \
 ghc-primitive \
 ghc-primitive-devel \
 ghc-primitive-doc \
 ghc-primitive-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-primitive-0.8.0.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f50e63e1ff2030e831cf8bcebea08c7ecea8a9de2be7c88b8b6318b8d40ad8dc"

URI_x86_64_v2_ghc-primitive = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-primitive-0.8.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-primitive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-primitive}"
SRC_URI[x86_64_v2_ghc-primitive.sha256sum] = "133b1579348586983052a1d00923709736d3ac80496a65319fd1b330ca8d891f"

URI_x86_64_v2_ghc-primitive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-primitive-devel-0.8.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-primitive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-primitive-devel}"
SRC_URI[x86_64_v2_ghc-primitive-devel.sha256sum] = "2b6938fceb22b7e58a4787a11a5919f795e8a5c1532eb70c6a828c6496d711be"

URI_x86_64_v2_ghc-primitive-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-primitive-doc-0.8.0.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-primitive-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-primitive-doc}"
SRC_URI[x86_64_v2_ghc-primitive-doc.sha256sum] = "0ddce68488308c6eb2b25b292016300a20ae6d4b457b2ce8df5f24392dd237cb"

URI_x86_64_v2_ghc-primitive-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-primitive-prof-0.8.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-primitive-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-primitive-prof}"
SRC_URI[x86_64_v2_ghc-primitive-prof.sha256sum] = "775aa1e5fb6cd76a9d684dc943adcb3b0ce59088e5a3b9c004ff42dfbdaf1239"

URI_aarch64_ghc-primitive = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-primitive-0.8.0.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-primitive;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-primitive}"
SRC_URI[aarch64_ghc-primitive.sha256sum] = "0dcc41bdfd0c24bc9d21d77e04f3baf8b691086ccd29a3ea11eb7bb2eeb4a1c4"

URI_aarch64_ghc-primitive-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-primitive-devel-0.8.0.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-primitive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-primitive-devel}"
SRC_URI[aarch64_ghc-primitive-devel.sha256sum] = "d39b4c24cb87abb43d5a1cb71df6598d9a53ca9db9d76155adbb73d449584f44"

URI_aarch64_ghc-primitive-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-primitive-doc-0.8.0.0-6.el10_0.noarch.rpm;name=aarch64_ghc-primitive-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-primitive-doc}"
SRC_URI[aarch64_ghc-primitive-doc.sha256sum] = "9e68b0c6bd433f0baf13046fb634619e3b3c363aaba0a078aebd789abaa3cf14"

URI_aarch64_ghc-primitive-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-primitive-prof-0.8.0.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-primitive-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-primitive-prof}"
SRC_URI[aarch64_ghc-primitive-prof.sha256sum] = "bc18e5a0b8bcfca56ad0c46100a4a97d1432e76d38958481bcb9264b5fe61473"

RDEPENDS:ghc-primitive = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-primitive-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-primitive \
 ghc-template-haskell-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-primitive-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-primitive-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-primitive-devel \
 ghc-template-haskell-prof \
 ghc-transformers-prof \
 "
