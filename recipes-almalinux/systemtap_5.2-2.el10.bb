# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemtap"
PV = "5.2"
PR = "2.el10"
PACKAGES = " \
 systemtap \
 systemtap-client \
 systemtap-devel \
 systemtap-exporter \
 systemtap-initscript \
 systemtap-runtime \
 systemtap-runtime-java \
 systemtap-runtime-python3 \
 systemtap-runtime-virtguest \
 systemtap-runtime-virthost \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 systemtap-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/systemtap-5.2-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f1ff6d42b2be08442c37967ee4253ab100550426154ec7d5ba95b5d62f4c4fd"

URI_x86_64_v2_systemtap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap}"
SRC_URI[x86_64_v2_systemtap.sha256sum] = "0421411e96e86bed61a5465ae1e2511c48065042308453b12c16de88391463fe"

URI_x86_64_v2_systemtap-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-client-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-client}"
SRC_URI[x86_64_v2_systemtap-client.sha256sum] = "afc953d371ad1f067b08da274aeb88a6808dea6747120c6cb498fd465293571e"

URI_x86_64_v2_systemtap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-devel-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-devel}"
SRC_URI[x86_64_v2_systemtap-devel.sha256sum] = "190a0a25444166f4d5cef154ac92ff00c5324c10d6aa0f6264ff5fd721ac7f21"

URI_x86_64_v2_systemtap-exporter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-exporter-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-exporter}"
SRC_URI[x86_64_v2_systemtap-exporter.sha256sum] = "127bd38dc68d95157c9ef0dbad2d2bb942bc446e7b149e7961c6a5b9336823ab"

URI_x86_64_v2_systemtap-initscript = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-initscript-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-initscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-initscript}"
SRC_URI[x86_64_v2_systemtap-initscript.sha256sum] = "0c380e8eea950bcd9deb0d1d4ee3899455bd5ce4808978d28b10bde397b4f1a6"

URI_x86_64_v2_systemtap-runtime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime}"
SRC_URI[x86_64_v2_systemtap-runtime.sha256sum] = "723fdf14d49520b10ff119aad9fe314fb9f7b6a7804310082765fb5da53ba9c1"

URI_x86_64_v2_systemtap-runtime-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-java-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-java}"
SRC_URI[x86_64_v2_systemtap-runtime-java.sha256sum] = "2d2376e4831e0d669863cb6dd8814a9950eacdaf0c79a6dac71bd722bd4d1d34"

URI_x86_64_v2_systemtap-runtime-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-python3-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-python3}"
SRC_URI[x86_64_v2_systemtap-runtime-python3.sha256sum] = "40d9f3bdbdae1702cf2ccf8aeba31682b1ab3ae1ecbfb91c946617a8709355ec"

URI_x86_64_v2_systemtap-runtime-virtguest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virtguest-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virtguest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-virtguest}"
SRC_URI[x86_64_v2_systemtap-runtime-virtguest.sha256sum] = "2a3048b1964a1d1e98e82c3ebc5ef0bc50ed7b557f940be01c884915954c0494"

URI_x86_64_v2_systemtap-runtime-virthost = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virthost-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virthost;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-virthost}"
SRC_URI[x86_64_v2_systemtap-runtime-virthost.sha256sum] = "171deb6634171cbd340f6b23f8e2e9e20a6b1faf7e7b2a7bed418c1eca9c197e"

URI_x86_64_v2_systemtap-sdt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-devel-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-sdt-devel}"
SRC_URI[x86_64_v2_systemtap-sdt-devel.sha256sum] = "0061e0e83f0c907cf8b6b58249e364239e41342455d05793a70da8d7dd94d608"

URI_x86_64_v2_systemtap-sdt-dtrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-dtrace-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-dtrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-sdt-dtrace}"
SRC_URI[x86_64_v2_systemtap-sdt-dtrace.sha256sum] = "f1ab58cb45b2a9a793bad90d4ff853f768939c25760b9d488d04476e0a11f1c4"

URI_x86_64_v2_systemtap-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-server-5.2-2.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-server}"
SRC_URI[x86_64_v2_systemtap-server.sha256sum] = "fae8700a0b9c739baaba3b1f21f1afcbe1583beff95e49c5bd9f764c594f904a"

URI_aarch64_systemtap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap}"
SRC_URI[aarch64_systemtap.sha256sum] = "11f3a10d21a58a33ee75a010fc3e3632b9f23b0179ec69487e5089a95bdda995"

URI_aarch64_systemtap-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-client-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-client}"
SRC_URI[aarch64_systemtap-client.sha256sum] = "0cee478f9fdb2190e35e3ab417b53a413cb4e5fd732dc7448ca76bba85eca13b"

URI_aarch64_systemtap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-devel-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-devel}"
SRC_URI[aarch64_systemtap-devel.sha256sum] = "f8dc05d5648e24367dc5d811392467e26ed317c16cc52cc305d18bf00c521620"

URI_aarch64_systemtap-exporter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-exporter-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-exporter}"
SRC_URI[aarch64_systemtap-exporter.sha256sum] = "95c375705ab4bc4b5dd2518d9d12a7eabc03252c15d8abc28d3cdf4d2924c7dd"

URI_aarch64_systemtap-initscript = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-initscript-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-initscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-initscript}"
SRC_URI[aarch64_systemtap-initscript.sha256sum] = "23189dc4aa5e571a84b22ea8b397337ea2f3824d74b0fab8ccdb5e72211bfc24"

URI_aarch64_systemtap-runtime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime}"
SRC_URI[aarch64_systemtap-runtime.sha256sum] = "0dc31f2b6251cb80a9ad8fdabd2017046c6b8808e38da0c0beb893b6c6252311"

URI_aarch64_systemtap-runtime-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-java-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-java}"
SRC_URI[aarch64_systemtap-runtime-java.sha256sum] = "6dcd36eeb696a6f22ad731797519482ba3cee289d559745778dbf7a0d48388f6"

URI_aarch64_systemtap-runtime-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-python3-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-python3}"
SRC_URI[aarch64_systemtap-runtime-python3.sha256sum] = "78400b2f1bd6ed0d67ee011b3754d4bd3664a652b1c89f2887e047608dc33639"

URI_aarch64_systemtap-runtime-virtguest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virtguest-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virtguest;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-virtguest}"
SRC_URI[aarch64_systemtap-runtime-virtguest.sha256sum] = "414b98325a42cd5f4ba6ee27ae220d968fe7985a65ba22534e9740959d1a2b2c"

URI_aarch64_systemtap-runtime-virthost = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virthost-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virthost;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-virthost}"
SRC_URI[aarch64_systemtap-runtime-virthost.sha256sum] = "6aa117516a9d2606877e14cbf780bb0030b3b8940b4e6abd7a412bc5d1c62bc0"

URI_aarch64_systemtap-sdt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-devel-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-sdt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-sdt-devel}"
SRC_URI[aarch64_systemtap-sdt-devel.sha256sum] = "0590a64118286d8cdc537f80c383e879f18a6d72cb6f375eccf2c37ebe9fcf47"

URI_aarch64_systemtap-sdt-dtrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-dtrace-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-sdt-dtrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-sdt-dtrace}"
SRC_URI[aarch64_systemtap-sdt-dtrace.sha256sum] = "911a431bc6a81d40aa6ba0ef60ca1465901f009e65739284402c0ca6cab50650"

URI_aarch64_systemtap-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-server-5.2-2.el10.aarch64.rpm;name=aarch64_systemtap-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-server}"
SRC_URI[aarch64_systemtap-server.sha256sum] = "84b6abcabd773c7e02a1448b7961d15f046718f1f76ac635f14de5dd3baf420a"

RDEPENDS:systemtap = " \
 bash \
 systemtap-client \
 systemtap-devel \
 "
RDEPENDS:systemtap-client:x86_64_v2 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 mokutil \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-client:aarch64 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-devel = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-devel \
 elfutils-libelf \
 elfutils-libs \
 gcc \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 make \
 nspr \
 nss \
 python3 \
 readline \
 rpm-libs \
 sqlite-libs \
 "
RDEPENDS:systemtap-exporter = " \
 bash \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-initscript = " \
 bash \
 systemd \
 systemtap \
 "
RDEPENDS:systemtap-runtime = " \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 glibc \
 json-c \
 libgcc \
 libselinux \
 libstdc++ \
 ncurses-libs \
 nspr \
 nss \
 shadow-utils \
 "
RDEPENDS:systemtap-runtime-java = " \
 bash \
 byteman \
 glibc \
 iproute \
 java-21-openjdk-devel \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-python3 = " \
 glibc \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-virtguest = " \
 bash \
 findutils \
 grep \
 systemtap-runtime \
 virtual/coreutils \
 "
RDEPENDS:systemtap-runtime-virthost = " \
 glibc \
 libvirt-libs \
 libxml2 \
 "
RDEPENDS:systemtap-sdt-devel = " \
 python3 \
 "
RDEPENDS:systemtap-sdt-dtrace = " \
 python3 \
 python3-pyparsing \
 "
RDEPENDS:systemtap-server:x86_64_v2 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssl \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-server:aarch64 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
