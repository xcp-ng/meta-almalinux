# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-newtype-uuid"
PV = "1.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-newtype-uuid+alloc-devel \
 rust-newtype-uuid+default-devel \
 rust-newtype-uuid+proptest1-devel \
 rust-newtype-uuid+schemars08-devel \
 rust-newtype-uuid+serde-devel \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid+v4-devel \
 rust-newtype-uuid+v7-devel \
 rust-newtype-uuid-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-newtype-uuid-1.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a4201b25127920c6752f164017ac593bdb773b4a021e31eedfb95fffc8824162"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+alloc-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+alloc-devel.sha256sum] = "7b15d292eb840ad8fc0b4eadf0d827c1bb2ee37c14ec7c4bdf35f9445b1f3b51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+default-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+default-devel.sha256sum] = "8c496c275135b2f962da79e272ff128110c189071d06f11656c5c48ae9cf8993"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+proptest1-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+proptest1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+proptest1-devel.sha256sum] = "b1b2509d3dc42469590feb29da3df44b753140b033d34cb2bdd5b06f712612f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+schemars08-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+schemars08-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+schemars08-devel.sha256sum] = "68798faec01d168c995695d6f37051630a23913f7fac4fe509e306265ba5756c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+serde-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+serde-devel.sha256sum] = "0fbf08a76cc0fade6e599b0cfef4b390020133277b213b5512686680867f7566"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+std-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+std-devel.sha256sum] = "f72ea289a3d59447cb15a28f54ef460a5e34ed7575f0d79a871b397e6014d102"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+v4-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+v4-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+v4-devel.sha256sum] = "2a270464c01939dcbca65739b80bed1474f74f9c006daa89c0104aa11441de8c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+v7-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+v7-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+v7-devel.sha256sum] = "cfa675ba359c68bb6937f8841a22cf262ef58c1c5444584da00d6e1d4eed335d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid-devel-1.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid-devel.sha256sum] = "53ad39a0428c4665aadb9c2344581244342f5b76319dbacea9e955ed63f3658e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+alloc-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+alloc-devel.sha256sum] = "dacb5f80066fca5b6368f87ddd94ed3469c4ca32be1f6761b037f39d3e72d2f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+default-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+default-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+default-devel.sha256sum] = "3319e355077bacd3b071e657e3c8e5d1a32741fe3e473e7d50a2702186dc7d0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+proptest1-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+proptest1-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+proptest1-devel.sha256sum] = "67362935e993059cd629b03a24be0a7dc34c9e11de859237c290e4fe774daf5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+schemars08-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+schemars08-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+schemars08-devel.sha256sum] = "ab5b8701804ab89e367164b6a0b591fa91e8ddb1a7d5101bd493a9ec1a9d980c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+serde-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+serde-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+serde-devel.sha256sum] = "dbebbbba483e74c3f61f6a31c0e32dffa69ec7f57179b0dbfec3eac33be42f2a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+std-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+std-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+std-devel.sha256sum] = "cac22b6e82e2b0f63969436565761ab8f37205937f459df937ae988b5820efc3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+v4-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+v4-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+v4-devel.sha256sum] = "a16465f71e8d40423775be96eaf4151a8eecb1e15e74783dee8a7eb0f6f72247"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+v7-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid+v7-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+v7-devel.sha256sum] = "1c8708292a63cf319a729e43a4dae78af4210d8f2cfa7bf2cb3fce8148c5b733"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid-devel-1.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-newtype-uuid-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid-devel.sha256sum] = "881507bcd061dfe554bacfb80afceac13e3dd8f02d8ee5b949902413b401ba6b"

RDEPENDS:rust-newtype-uuid+alloc-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 "
RDEPENDS:rust-newtype-uuid+default-devel = " \
 cargo \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-newtype-uuid+proptest1-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-newtype-uuid+schemars08-devel = " \
 cargo \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid-devel \
 rust-schemars0.8+default-devel \
 rust-schemars0.8+uuid1-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-newtype-uuid+serde-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-uuid+serde-devel \
 "
RDEPENDS:rust-newtype-uuid+std-devel = " \
 cargo \
 rust-newtype-uuid+alloc-devel \
 rust-newtype-uuid-devel \
 rust-uuid+std-devel \
 "
RDEPENDS:rust-newtype-uuid+v4-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-uuid+v4-devel \
 "
RDEPENDS:rust-newtype-uuid+v7-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-uuid+v7-devel \
 "
RDEPENDS:rust-newtype-uuid-devel = " \
 cargo \
 rust \
 rust-uuid-devel \
 "
