# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cache-LRU"
PV = "0.04"
PR = "27.el10_0"
PACKAGES = " \
 perl-Cache-LRU \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Cache-LRU-0.04-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f39ea04de88a9786c829a256520192c62d8bc46c4642dd877ac9b488b4bb2383"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cache-LRU-0.04-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Cache-LRU;unpack=0"
SRC_URI[x86_64_v2_perl-Cache-LRU.sha256sum] = "5b6574ef98c28303c0f31038933cbcfaf4a8171591c3c9165d3c627a6dcdb4de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Cache-LRU-0.04-27.el10_0.noarch.rpm;name=aarch64_perl-Cache-LRU;unpack=0"
SRC_URI[aarch64_perl-Cache-LRU.sha256sum] = "0c553469dec1d1880286428c728d2291ffcfc35ef65b2746bbdeb8a4bff0e1bc"

RDEPENDS:perl-Cache-LRU = " \
 perl-Scalar-List-Utils \
 perl-libs \
 "
