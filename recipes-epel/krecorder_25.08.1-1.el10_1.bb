# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krecorder"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 krecorder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krecorder-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b7df4cd688da675c89580b64ad4bc1ed8d923a496a5a6d70858f0f9a9fd756e"

URI_x86_64_v2_krecorder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krecorder-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krecorder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krecorder}"
SRC_URI[x86_64_v2_krecorder.sha256sum] = "3b9b58548ac14ae5612eb3eee75e0218d2ef88b4de6d19f455469da68aaf8fda"

URI_aarch64_krecorder = "${EPEL_MIRROR}/aarch64/Packages/k/krecorder-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_krecorder;unpack=0"
SRC_URI:append = " ${URI_aarch64_krecorder}"
SRC_URI[aarch64_krecorder.sha256sum] = "7d3da8b2f90f4a4693d3164e6e7dbcfa2e094ea675d79fa27f006a9d3b200b6c"

RDEPENDS:krecorder = " \
 glibc \
 gstreamer1-plugins-good \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
