# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-native-tls"
PV = "0.2.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-native-tls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-native-tls-0.2.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e983648480b4b842892d5a88f844484d1d247cab108791ba5fd258d40f3119f"

URI_x86_64_v2_rust-native-tls+alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls+alpn-devel-0.2.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls+alpn-devel}"
SRC_URI[x86_64_v2_rust-native-tls+alpn-devel.sha256sum] = "fe0bde8709ec9ee510d6ef13f666ea5721d6ba8d6810d59eff24b99acd13d485"

URI_x86_64_v2_rust-native-tls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls+default-devel-0.2.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls+default-devel}"
SRC_URI[x86_64_v2_rust-native-tls+default-devel.sha256sum] = "72309f86028bc02c9708cd4094ffdf93a689da22a9202856ef2605988f23d180"

URI_x86_64_v2_rust-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls-devel-0.2.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls-devel}"
SRC_URI[x86_64_v2_rust-native-tls-devel.sha256sum] = "223b586423613392c5839e99ec570073537811378c13382f7a4bf46f35cd2d6e"

URI_aarch64_rust-native-tls+alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls+alpn-devel-0.2.15-1.el10_2.noarch.rpm;name=aarch64_rust-native-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls+alpn-devel}"
SRC_URI[aarch64_rust-native-tls+alpn-devel.sha256sum] = "f4571d0b5f63d5913abd098b3327304394ac1a30b573ca0ab67fa8c0bf6f291c"

URI_aarch64_rust-native-tls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls+default-devel-0.2.15-1.el10_2.noarch.rpm;name=aarch64_rust-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls+default-devel}"
SRC_URI[aarch64_rust-native-tls+default-devel.sha256sum] = "cf9b5fae927553c65c4276cd745a05cad9d556b95731c3ccfd68551fd0e3f2af"

URI_aarch64_rust-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls-devel-0.2.15-1.el10_2.noarch.rpm;name=aarch64_rust-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls-devel}"
SRC_URI[aarch64_rust-native-tls-devel.sha256sum] = "dcce31dcbdf172249772cd5b7a6443a42b48c6948c00199ce1fbabb7444cfe76"

RDEPENDS:rust-native-tls+alpn-devel = " \
 cargo \
 rust-native-tls-devel \
 "
RDEPENDS:rust-native-tls+default-devel = " \
 cargo \
 rust-native-tls-devel \
 "
RDEPENDS:rust-native-tls-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-openssl+default-devel \
 rust-openssl-probe+default-devel \
 rust-openssl-sys+default-devel \
 "
