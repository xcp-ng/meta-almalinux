# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-i18n"
PV = "6.7.2"
PR = "3.el10_2"
PACKAGES = " \
 python-oslo-i18n-doc \
 python-oslo-i18n-lang \
 python3-oslo-i18n \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-i18n-6.7.2-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "360ca1ab76cf2ab9666743305886ac008766f72dbdf422c63f430bb8c8765e12"

URI_x86_64_v2_python-oslo-i18n-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-i18n-doc-6.7.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-i18n-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-i18n-doc}"
SRC_URI[x86_64_v2_python-oslo-i18n-doc.sha256sum] = "a1ebd9ff4e540893288b225e9ebee0e988356bd1df50204c2b8b60293c6b54a0"

URI_x86_64_v2_python-oslo-i18n-lang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-i18n-lang-6.7.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-i18n-lang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-i18n-lang}"
SRC_URI[x86_64_v2_python-oslo-i18n-lang.sha256sum] = "30f4e4db25f1852465f338a631f0b31edf18b7f88a76c95122eb22f69093b403"

URI_x86_64_v2_python3-oslo-i18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-i18n-6.7.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-i18n}"
SRC_URI[x86_64_v2_python3-oslo-i18n.sha256sum] = "af4c5e41f2c24aa3a561e61f0a020f18b53e78e875eed108aa7d3df510807554"

URI_aarch64_python-oslo-i18n-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-i18n-doc-6.7.2-3.el10_2.noarch.rpm;name=aarch64_python-oslo-i18n-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-i18n-doc}"
SRC_URI[aarch64_python-oslo-i18n-doc.sha256sum] = "fc1d234bd784857f0a0b897029aff23677447023187257579362a09fe5942046"

URI_aarch64_python-oslo-i18n-lang = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-i18n-lang-6.7.2-3.el10_2.noarch.rpm;name=aarch64_python-oslo-i18n-lang;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-i18n-lang}"
SRC_URI[aarch64_python-oslo-i18n-lang.sha256sum] = "46fdba213bed598e7be27b18ecc6b7c4d9c4026c578f440f0b903bc157158544"

URI_aarch64_python3-oslo-i18n = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-i18n-6.7.2-3.el10_2.noarch.rpm;name=aarch64_python3-oslo-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-i18n}"
SRC_URI[aarch64_python3-oslo-i18n.sha256sum] = "b36285538217f7454e40995bd1378544a940738661eacc7600737b9b0a2d897c"

RDEPENDS:python-oslo-i18n-doc = " \
 "
RDEPENDS:python-oslo-i18n-lang = " \
 "
RDEPENDS:python3-oslo-i18n = " \
 python-oslo-i18n-lang \
 python3 \
 python3-pbr \
 "
