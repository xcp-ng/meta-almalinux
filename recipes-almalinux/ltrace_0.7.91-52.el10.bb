# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ltrace"
PV = "0.7.91"
PR = "52.el10"
PACKAGES = " \
 ltrace \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ltrace-0.7.91-52.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "849881be9daa1200d877fd70da3af18248d4ffe6efe9e3383d493fc305727149"

URI_x86_64_v2_ltrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ltrace-0.7.91-52.el10.x86_64_v2.rpm;name=x86_64_v2_ltrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ltrace}"
SRC_URI[x86_64_v2_ltrace.sha256sum] = "36502f556825d113cc3e91112961d54c61be5698f90dde1cf9be9dacaa29df28"

URI_aarch64_ltrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ltrace-0.7.91-52.el10.aarch64.rpm;name=aarch64_ltrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_ltrace}"
SRC_URI[aarch64_ltrace.sha256sum] = "dedd5f21f931d316d4ba0de027f7f6538bc797c0314e46b3708977967cbccc85"

RDEPENDS:ltrace = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libselinux \
 libstdc++ \
 "
