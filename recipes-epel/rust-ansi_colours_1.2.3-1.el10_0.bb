# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ansi_colours"
PV = "1.2.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-ansi_colours+ansi_term-devel \
 rust-ansi_colours+anstyle-devel \
 rust-ansi_colours+default-devel \
 rust-ansi_colours+rgb-devel \
 rust-ansi_colours+termcolor-devel \
 rust-ansi_colours-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ansi_colours-1.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a50c690a951813c797796f12a030141b7aa3df3794d6333caa339efae53cd94"

URI_x86_64_v2_rust-ansi_colours+ansi_term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_colours+ansi_term-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_colours+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_colours+ansi_term-devel}"
SRC_URI[x86_64_v2_rust-ansi_colours+ansi_term-devel.sha256sum] = "6ff8ef5b99f77e213454d748b3bff693ad67395f621596c99efdf48964c881a6"

URI_x86_64_v2_rust-ansi_colours+anstyle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_colours+anstyle-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_colours+anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_colours+anstyle-devel}"
SRC_URI[x86_64_v2_rust-ansi_colours+anstyle-devel.sha256sum] = "0b8d8851ed1ba426f7db198d9b61bb42486c11d99275cbe999a435424e8fd0af"

URI_x86_64_v2_rust-ansi_colours+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_colours+default-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_colours+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_colours+default-devel}"
SRC_URI[x86_64_v2_rust-ansi_colours+default-devel.sha256sum] = "1cb24e645bf11a0b6a06613bd39604bca4e1006cdc968c6a90b888c23d8f36c4"

URI_x86_64_v2_rust-ansi_colours+rgb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_colours+rgb-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_colours+rgb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_colours+rgb-devel}"
SRC_URI[x86_64_v2_rust-ansi_colours+rgb-devel.sha256sum] = "9f0e1ca23bbaee8009dc833e712f9174486eba9a5db24ab0a42777ea72e6a3aa"

URI_x86_64_v2_rust-ansi_colours+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_colours+termcolor-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_colours+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_colours+termcolor-devel}"
SRC_URI[x86_64_v2_rust-ansi_colours+termcolor-devel.sha256sum] = "c55eb03917a9333e0346f12c06250b7ada7bef20fc838890cdd49957fa947375"

URI_x86_64_v2_rust-ansi_colours-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_colours-devel-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_colours-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_colours-devel}"
SRC_URI[x86_64_v2_rust-ansi_colours-devel.sha256sum] = "9db2226dc3e9f27111b61eaa04f8cd99c5ddf15e349ea3c789f7f184ac9704fd"

URI_aarch64_rust-ansi_colours+ansi_term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_colours+ansi_term-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-ansi_colours+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_colours+ansi_term-devel}"
SRC_URI[aarch64_rust-ansi_colours+ansi_term-devel.sha256sum] = "bc3bfd534cf87121a2dc25c0beeb8458f88b99c8179ad88c27d189711b9962e1"

URI_aarch64_rust-ansi_colours+anstyle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_colours+anstyle-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-ansi_colours+anstyle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_colours+anstyle-devel}"
SRC_URI[aarch64_rust-ansi_colours+anstyle-devel.sha256sum] = "e3ec7a94ab241599a7a9dea0701a7d47f046cf9a366e58bed71737ec57d2df6f"

URI_aarch64_rust-ansi_colours+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_colours+default-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-ansi_colours+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_colours+default-devel}"
SRC_URI[aarch64_rust-ansi_colours+default-devel.sha256sum] = "a136a6c1f5fd4cf06045c99e266074fe3444b54f59db5cf8776697e79b400ff6"

URI_aarch64_rust-ansi_colours+rgb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_colours+rgb-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-ansi_colours+rgb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_colours+rgb-devel}"
SRC_URI[aarch64_rust-ansi_colours+rgb-devel.sha256sum] = "f8fe14c003e6eee49537e22fe5f53958c6220a6abfe447a89a4909d3206f1a87"

URI_aarch64_rust-ansi_colours+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_colours+termcolor-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-ansi_colours+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_colours+termcolor-devel}"
SRC_URI[aarch64_rust-ansi_colours+termcolor-devel.sha256sum] = "a96c214264c182a0177634eb14cc0b4bfb66d4ce20b4a5bb52c92f784f4e7340"

URI_aarch64_rust-ansi_colours-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_colours-devel-1.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-ansi_colours-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_colours-devel}"
SRC_URI[aarch64_rust-ansi_colours-devel.sha256sum] = "0b90ce5e16e1b75702b4c7249a42c56a78a679482a6979e4bb17cb5a90613118"

RDEPENDS:rust-ansi_colours+ansi_term-devel = " \
 cargo \
 rust-ansi_colours-devel \
 rust-ansi_term+default-devel \
 "
RDEPENDS:rust-ansi_colours+anstyle-devel = " \
 cargo \
 rust-ansi_colours-devel \
 rust-anstyle+default-devel \
 "
RDEPENDS:rust-ansi_colours+default-devel = " \
 cargo \
 rust-ansi_colours+rgb-devel \
 rust-ansi_colours-devel \
 "
RDEPENDS:rust-ansi_colours+rgb-devel = " \
 cargo \
 rust-ansi_colours-devel \
 rust-rgb+default-devel \
 "
RDEPENDS:rust-ansi_colours+termcolor-devel = " \
 cargo \
 rust-ansi_colours-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-ansi_colours-devel = " \
 cargo \
 "
