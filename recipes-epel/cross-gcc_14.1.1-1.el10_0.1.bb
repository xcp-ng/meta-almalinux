# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cross-gcc"
PV = "14.1.1"
PR = "1.el10_0.1"
PACKAGES = " \
 cross-gcc-common \
 gcc-aarch64-linux-gnu \
 gcc-alpha-linux-gnu \
 gcc-arc-linux-gnu \
 gcc-arm-linux-gnu \
 gcc-avr32-linux-gnu \
 gcc-bfin-linux-gnu \
 gcc-c++-aarch64-linux-gnu \
 gcc-c++-alpha-linux-gnu \
 gcc-c++-arc-linux-gnu \
 gcc-c++-arm-linux-gnu \
 gcc-c++-avr32-linux-gnu \
 gcc-c++-bfin-linux-gnu \
 gcc-c++-c6x-linux-gnu \
 gcc-c++-frv-linux-gnu \
 gcc-c++-h8300-linux-gnu \
 gcc-c++-hppa-linux-gnu \
 gcc-c++-hppa64-linux-gnu \
 gcc-c++-ia64-linux-gnu \
 gcc-c++-loongarch64-linux-gnu \
 gcc-c++-m68k-linux-gnu \
 gcc-c++-microblaze-linux-gnu \
 gcc-c++-mips64-linux-gnu \
 gcc-c++-mn10300-linux-gnu \
 gcc-c++-nios2-linux-gnu \
 gcc-c++-openrisc-linux-gnu \
 gcc-c++-powerpc64-linux-gnu \
 gcc-c++-powerpc64le-linux-gnu \
 gcc-c++-ppc64-linux-gnu \
 gcc-c++-ppc64le-linux-gnu \
 gcc-c++-riscv64-linux-gnu \
 gcc-c++-s390x-linux-gnu \
 gcc-c++-sparc64-linux-gnu \
 gcc-c++-x86_64-linux-gnu \
 gcc-c++-xtensa-linux-gnu \
 gcc-c6x-linux-gnu \
 gcc-frv-linux-gnu \
 gcc-h8300-linux-gnu \
 gcc-hppa-linux-gnu \
 gcc-hppa64-linux-gnu \
 gcc-ia64-linux-gnu \
 gcc-loongarch64-linux-gnu \
 gcc-m68k-linux-gnu \
 gcc-microblaze-linux-gnu \
 gcc-mips64-linux-gnu \
 gcc-mn10300-linux-gnu \
 gcc-nios2-linux-gnu \
 gcc-openrisc-linux-gnu \
 gcc-powerpc64-linux-gnu \
 gcc-powerpc64le-linux-gnu \
 gcc-ppc64-linux-gnu \
 gcc-ppc64le-linux-gnu \
 gcc-riscv64-linux-gnu \
 gcc-s390x-linux-gnu \
 gcc-sparc64-linux-gnu \
 gcc-x86_64-linux-gnu \
 gcc-xtensa-linux-gnu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cross-gcc-14.1.1-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b18156db931d0e5e596b67e944604aa6bdaf0032ba6989b2b86b54d1d32d5c7a"

URI_x86_64_v2_cross-gcc-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cross-gcc-common-14.1.1-1.el10_0.1.alma_altarch.1.noarch.rpm;name=x86_64_v2_cross-gcc-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cross-gcc-common}"
SRC_URI[x86_64_v2_cross-gcc-common.sha256sum] = "1d84168b16a012824294a4ec4b26eb0e2a3e0e6fa46dc41a4522f58b5e2153f5"

URI_x86_64_v2_gcc-aarch64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-aarch64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-aarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-aarch64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-aarch64-linux-gnu.sha256sum] = "e161d647775ab37c7564a82aefd6f1f71edaac92e0401a26b81f5c446d6d652c"

URI_x86_64_v2_gcc-alpha-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-alpha-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-alpha-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-alpha-linux-gnu}"
SRC_URI[x86_64_v2_gcc-alpha-linux-gnu.sha256sum] = "262971c0cbbeed9e2b8d93748190602633ca46cf6c9b716b2398c9d7a18e35b9"

URI_x86_64_v2_gcc-arc-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-arc-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-arc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-arc-linux-gnu}"
SRC_URI[x86_64_v2_gcc-arc-linux-gnu.sha256sum] = "4a93bf57fe7f33fc40a830b92725d1ca0fb401db224d3f2d75b65988f4907ac8"

URI_x86_64_v2_gcc-arm-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-arm-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-arm-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-arm-linux-gnu}"
SRC_URI[x86_64_v2_gcc-arm-linux-gnu.sha256sum] = "9508bc74245eb377660ccfb7d09bec1cebf7952d073e0cdcdcc7173d4c19abb9"

URI_x86_64_v2_gcc-avr32-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-avr32-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-avr32-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-avr32-linux-gnu}"
SRC_URI[x86_64_v2_gcc-avr32-linux-gnu.sha256sum] = "b691a45040615453c6cffcddc7c8b6ef3b1023c2c0ba43d527d01783284a7c5c"

URI_x86_64_v2_gcc-bfin-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-bfin-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-bfin-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-bfin-linux-gnu}"
SRC_URI[x86_64_v2_gcc-bfin-linux-gnu.sha256sum] = "6aa35dd6f6daad30b62cd05f7963948db49e148c3185b152dcc4756183376d03"

URI_x86_64_v2_gcc-c++-aarch64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-aarch64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-aarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-aarch64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-aarch64-linux-gnu.sha256sum] = "7b2e24e85f5de4b2838830356eeb3599fadaa6752afe75788819c984c3f38158"

URI_x86_64_v2_gcc-c++-alpha-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-alpha-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-alpha-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-alpha-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-alpha-linux-gnu.sha256sum] = "e55da422e6328b0ccb1b2cf4874afb2f047cc120936993125904287a6c50940d"

URI_x86_64_v2_gcc-c++-arc-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-arc-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-arc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-arc-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-arc-linux-gnu.sha256sum] = "ac24b17ed581c52b7aaf5d781954ff206908ab2411fef51e3bf4d2000af5f393"

URI_x86_64_v2_gcc-c++-arm-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-arm-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-arm-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-arm-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-arm-linux-gnu.sha256sum] = "632176758d7aef558d77debf219c4faf20ea0f29dc9ca7e5d9957cfe78c93df2"

URI_x86_64_v2_gcc-c++-avr32-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-avr32-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-avr32-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-avr32-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-avr32-linux-gnu.sha256sum] = "44b5a71eaac37fb446386c7c6fb1619b6b577062a258f9c131cae1cd5470ff51"

URI_x86_64_v2_gcc-c++-bfin-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-bfin-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-bfin-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-bfin-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-bfin-linux-gnu.sha256sum] = "9362a850bad44bf78d289e2c758bec42d80d3ecf354e656caeb90c914e9166fe"

URI_x86_64_v2_gcc-c++-c6x-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-c6x-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-c6x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-c6x-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-c6x-linux-gnu.sha256sum] = "cbbf8defc25e386ef7e4a32b871de97ebddcb144e47d093ae95e5a0af139b530"

URI_x86_64_v2_gcc-c++-frv-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-frv-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-frv-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-frv-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-frv-linux-gnu.sha256sum] = "d91ea88d9ef556e04c884a26af505b2403f9db21e1921b3f176c80b12808a99b"

URI_x86_64_v2_gcc-c++-h8300-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-h8300-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-h8300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-h8300-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-h8300-linux-gnu.sha256sum] = "7ef6d35f75e6ef1bc8e96b89ea6e166b5d5a8d6c3003b0cf813805a6b42afc73"

URI_x86_64_v2_gcc-c++-hppa-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-hppa-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-hppa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-hppa-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-hppa-linux-gnu.sha256sum] = "5f71f7b3b9598baa7467362432a384e8bd44941aa990a535007ce72b9eb586c9"

URI_x86_64_v2_gcc-c++-hppa64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-hppa64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-hppa64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-hppa64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-hppa64-linux-gnu.sha256sum] = "23da4be8ae24fd41439208f7a9f78f92500c202fa3ecf6d5a7835f407aa541ba"

URI_x86_64_v2_gcc-c++-ia64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-ia64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-ia64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-ia64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-ia64-linux-gnu.sha256sum] = "bc3764c7f6c0502653b86d07c612766eb01c59cdbbfd75e6ff141b4ddaf4012c"

URI_x86_64_v2_gcc-c++-loongarch64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-loongarch64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-loongarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-loongarch64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-loongarch64-linux-gnu.sha256sum] = "909020f4dd86f373243be1bb57daf47a962a1f153b158e035577e3fe546ca630"

URI_x86_64_v2_gcc-c++-m68k-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-m68k-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-m68k-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-m68k-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-m68k-linux-gnu.sha256sum] = "cebc99858158e0add67e70aa0929112ed10bc2cd9ce4280d5dee75e6fa79c0d1"

URI_x86_64_v2_gcc-c++-microblaze-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-microblaze-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-microblaze-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-microblaze-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-microblaze-linux-gnu.sha256sum] = "7741519c829e2d550e0e80b4a76f974a340c4f70f9f62899da90536597e342db"

URI_x86_64_v2_gcc-c++-mips64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-mips64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-mips64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-mips64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-mips64-linux-gnu.sha256sum] = "ef5d8456f06928ee057f588a30cd874c74421ac9d10bfbc695fe835986b73dbc"

URI_x86_64_v2_gcc-c++-mn10300-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-mn10300-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-mn10300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-mn10300-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-mn10300-linux-gnu.sha256sum] = "19179d980c39a102ea29752a28dc4c7aa150ed541984219800fb58a5de4f83ba"

URI_x86_64_v2_gcc-c++-nios2-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-nios2-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-nios2-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-nios2-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-nios2-linux-gnu.sha256sum] = "be774e260c8725535a8b9879a8409ab6ffe485f4ebe54a5a258fa869a869d60c"

URI_x86_64_v2_gcc-c++-openrisc-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-openrisc-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-openrisc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-openrisc-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-openrisc-linux-gnu.sha256sum] = "e51f6f6dda27f50ea1d8d1e2dc03e26ce2f9567c773ba37a750bdae6ff37ca53"

URI_x86_64_v2_gcc-c++-powerpc64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-powerpc64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-powerpc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-powerpc64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-powerpc64-linux-gnu.sha256sum] = "06eefe4080ebe2562e2bab523eb43348e2776beb8c2edfadbcd30f5a5dd2d005"

URI_x86_64_v2_gcc-c++-powerpc64le-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-powerpc64le-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-powerpc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-powerpc64le-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-powerpc64le-linux-gnu.sha256sum] = "2e9b9c97f9e677c7ba8d6c0a64c730f4aac9761b9a25461752e6dca777cdd2e2"

URI_x86_64_v2_gcc-c++-ppc64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-ppc64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-ppc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-ppc64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-ppc64-linux-gnu.sha256sum] = "d212a9eef4543be44c20c13ab446bd4e1c8d91a8f3b22a04289edab5f201ecbb"

URI_x86_64_v2_gcc-c++-ppc64le-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-ppc64le-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-ppc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-ppc64le-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-ppc64le-linux-gnu.sha256sum] = "63d7319368593c18cd3da99b7b51325ff89927f29e8b829ecea8a248ba5db057"

URI_x86_64_v2_gcc-c++-riscv64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-riscv64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-riscv64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-riscv64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-riscv64-linux-gnu.sha256sum] = "f7bb74a9722b41b4df273e7d77555ba4a90526ea0ea137ddd52b58f31b62b3be"

URI_x86_64_v2_gcc-c++-s390x-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-s390x-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-s390x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-s390x-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-s390x-linux-gnu.sha256sum] = "b9e17b25656c3fd4ae4027b692aec086dae12314f4f2a7a283896714df21a1cd"

URI_x86_64_v2_gcc-c++-sparc64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-sparc64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-sparc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-sparc64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-sparc64-linux-gnu.sha256sum] = "284e31612977c9d357bef6e4aa89b164664c87cf3ef11ed0ea7dd7f7b7e63367"

URI_x86_64_v2_gcc-c++-x86_64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-x86_64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-x86_64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-x86_64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-x86_64-linux-gnu.sha256sum] = "3895037762cb1924d27cc3613d34abb8fd6ef4f6997592dd6cf0174c86eaa461"

URI_x86_64_v2_gcc-c++-xtensa-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c++-xtensa-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c++-xtensa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c++-xtensa-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c++-xtensa-linux-gnu.sha256sum] = "0566545683fe553a32a14608fa3eea0b233b9af8d2266d827633bef708e00afb"

URI_x86_64_v2_gcc-c6x-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-c6x-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-c6x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-c6x-linux-gnu}"
SRC_URI[x86_64_v2_gcc-c6x-linux-gnu.sha256sum] = "ac2c641f3bb4aa35d4467d58aebe6cb490449cfd0732a6eb306949a4247bf937"

URI_x86_64_v2_gcc-frv-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-frv-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-frv-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-frv-linux-gnu}"
SRC_URI[x86_64_v2_gcc-frv-linux-gnu.sha256sum] = "d2e3bcecee77f2d35d5040ba94d35e089a36ebb14ecd866d6c7ba294ef5a351a"

URI_x86_64_v2_gcc-h8300-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-h8300-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-h8300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-h8300-linux-gnu}"
SRC_URI[x86_64_v2_gcc-h8300-linux-gnu.sha256sum] = "42ad6b84e4c22df158d7c52ecc30f8f51de771b0d175e8319d7b004120399752"

URI_x86_64_v2_gcc-hppa-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-hppa-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-hppa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-hppa-linux-gnu}"
SRC_URI[x86_64_v2_gcc-hppa-linux-gnu.sha256sum] = "94916f2d15ecf72d1cc03267c5cc7017a67c640db6d6b901303ba818582bfa8c"

URI_x86_64_v2_gcc-hppa64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-hppa64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-hppa64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-hppa64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-hppa64-linux-gnu.sha256sum] = "48367fc1b9033945c29e8cdafbf96259afc3a0ea450dc0cfafb2619889fb4c2d"

URI_x86_64_v2_gcc-ia64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-ia64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-ia64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-ia64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-ia64-linux-gnu.sha256sum] = "c97e75667264aca68157e35e06147cfe6cd556798d3bdeb88d97989ba4eb6842"

URI_x86_64_v2_gcc-loongarch64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-loongarch64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-loongarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-loongarch64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-loongarch64-linux-gnu.sha256sum] = "0ef226df3e4e81c1c971e44e2061262d467bf2b7447f75b9eb53243be21e67e5"

URI_x86_64_v2_gcc-m68k-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-m68k-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-m68k-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-m68k-linux-gnu}"
SRC_URI[x86_64_v2_gcc-m68k-linux-gnu.sha256sum] = "4e567edede5ebbd7c707ba29bad0e5cee45de178f001f5619c0cdb2f2807f391"

URI_x86_64_v2_gcc-microblaze-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-microblaze-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-microblaze-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-microblaze-linux-gnu}"
SRC_URI[x86_64_v2_gcc-microblaze-linux-gnu.sha256sum] = "44fb6614ec8dd7e55bb700cc7faba7150a52d58bf8334328798a35200f3cb4ba"

URI_x86_64_v2_gcc-mips64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-mips64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-mips64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-mips64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-mips64-linux-gnu.sha256sum] = "b5a751c1cfa1c3733391145ea808483018619f3b82fb1ed928f4bdb1aceceb0e"

URI_x86_64_v2_gcc-mn10300-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-mn10300-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-mn10300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-mn10300-linux-gnu}"
SRC_URI[x86_64_v2_gcc-mn10300-linux-gnu.sha256sum] = "44287568d375f1bb6bfde67ff1378fb47f36cd78e8c79b54b96d0aff6698ef7d"

URI_x86_64_v2_gcc-nios2-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-nios2-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-nios2-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-nios2-linux-gnu}"
SRC_URI[x86_64_v2_gcc-nios2-linux-gnu.sha256sum] = "fa9cbc3d7024bcf809d56b977c750111396120dd34a4e08752ab2243c66df064"

URI_x86_64_v2_gcc-openrisc-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-openrisc-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-openrisc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-openrisc-linux-gnu}"
SRC_URI[x86_64_v2_gcc-openrisc-linux-gnu.sha256sum] = "ba1e3f9879aaa20bd9363c7ffe46e2ff6f83c7e148b3e64bbbde1a4b310bd8cf"

URI_x86_64_v2_gcc-powerpc64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-powerpc64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-powerpc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-powerpc64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-powerpc64-linux-gnu.sha256sum] = "218cb74c01c342ddcb08854263d0bf158e75e408f3f80bc96bd5d0bdafc2d1be"

URI_x86_64_v2_gcc-powerpc64le-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-powerpc64le-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-powerpc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-powerpc64le-linux-gnu}"
SRC_URI[x86_64_v2_gcc-powerpc64le-linux-gnu.sha256sum] = "14ed748de1cc029169b53d7e3ed0f9b764976aae3852b7d468fc05105c822033"

URI_x86_64_v2_gcc-ppc64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-ppc64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-ppc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-ppc64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-ppc64-linux-gnu.sha256sum] = "30c55ea08df45f316acfaafe78da34646235d0edb58f14136765420267135fe7"

URI_x86_64_v2_gcc-ppc64le-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-ppc64le-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-ppc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-ppc64le-linux-gnu}"
SRC_URI[x86_64_v2_gcc-ppc64le-linux-gnu.sha256sum] = "6e7e64b704395f686a50c967e75a86542d56fc45e621c595e12b4b1936c748ac"

URI_x86_64_v2_gcc-riscv64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-riscv64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-riscv64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-riscv64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-riscv64-linux-gnu.sha256sum] = "dcd150e97740f827816640238e04936f0921e7db7e4c9f93213eddcbeb079d49"

URI_x86_64_v2_gcc-s390x-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-s390x-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-s390x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-s390x-linux-gnu}"
SRC_URI[x86_64_v2_gcc-s390x-linux-gnu.sha256sum] = "77494fee892ae57b33d7911e4ec8759bafdccbda22187f0b05547cd5180c9714"

URI_x86_64_v2_gcc-sparc64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-sparc64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-sparc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-sparc64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-sparc64-linux-gnu.sha256sum] = "cf1d526a94af18361e7469af1cdc661aaf668eff782bb9c41f374076045b18e8"

URI_x86_64_v2_gcc-x86_64-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-x86_64-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-x86_64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-x86_64-linux-gnu}"
SRC_URI[x86_64_v2_gcc-x86_64-linux-gnu.sha256sum] = "904f69b105ee994d6b358de6e35de8fb4d9e2ad1a91df638aca47b895a58744c"

URI_x86_64_v2_gcc-xtensa-linux-gnu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gcc-xtensa-linux-gnu-14.1.1-1.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_gcc-xtensa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-xtensa-linux-gnu}"
SRC_URI[x86_64_v2_gcc-xtensa-linux-gnu.sha256sum] = "398142d062c0bca4a6d83d2eea6201583f77710bd2700b63ee176f1e2ed0ff1f"

URI_aarch64_cross-gcc-common = "${EPEL_MIRROR}/aarch64/Packages/c/cross-gcc-common-14.1.1-1.el10_0.1.noarch.rpm;name=aarch64_cross-gcc-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_cross-gcc-common}"
SRC_URI[aarch64_cross-gcc-common.sha256sum] = "03de222347b80a9e66d990296c5a3581a0d3bccfa52f48b8109b1b45aae01882"

URI_aarch64_gcc-aarch64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-aarch64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-aarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-aarch64-linux-gnu}"
SRC_URI[aarch64_gcc-aarch64-linux-gnu.sha256sum] = "94d35820cd040c8f28b528674cabd25429adc43e320de26b40cf38427c4f4daf"

URI_aarch64_gcc-alpha-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-alpha-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-alpha-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-alpha-linux-gnu}"
SRC_URI[aarch64_gcc-alpha-linux-gnu.sha256sum] = "0970e3af7e34390ca0071c615e5173aa85bb7f86d43e19fffccbff2f3f4af93e"

URI_aarch64_gcc-arc-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-arc-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-arc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-arc-linux-gnu}"
SRC_URI[aarch64_gcc-arc-linux-gnu.sha256sum] = "bf9243ab624bd8cc0d1296c206021329c0fc27096ebab7a6f710356288613ea4"

URI_aarch64_gcc-arm-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-arm-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-arm-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-arm-linux-gnu}"
SRC_URI[aarch64_gcc-arm-linux-gnu.sha256sum] = "0a500d835b2de0a54d1534438b8129a44fe15dea34aca8f740a1d00835c641e8"

URI_aarch64_gcc-avr32-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-avr32-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-avr32-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-avr32-linux-gnu}"
SRC_URI[aarch64_gcc-avr32-linux-gnu.sha256sum] = "b786402dadfcb291909aad70f30dd0c9f55a3ba9cbe71cac8aade1d86b8592c4"

URI_aarch64_gcc-bfin-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-bfin-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-bfin-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-bfin-linux-gnu}"
SRC_URI[aarch64_gcc-bfin-linux-gnu.sha256sum] = "b51fb9c2f89a25b9ecbf748597734e035c21f6518242d5c4d0a47d87e534afa1"

URI_aarch64_gcc-c++-aarch64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-aarch64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-aarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-aarch64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-aarch64-linux-gnu.sha256sum] = "71d86c5c5ec2e21d179214d82e7a3b7f51a48e7ce41d726b5d08c348540fb70a"

URI_aarch64_gcc-c++-alpha-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-alpha-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-alpha-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-alpha-linux-gnu}"
SRC_URI[aarch64_gcc-c++-alpha-linux-gnu.sha256sum] = "afb2e97180214815ab7ac087646f409fe12cf281decf61da8f94236161537124"

URI_aarch64_gcc-c++-arc-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-arc-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-arc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-arc-linux-gnu}"
SRC_URI[aarch64_gcc-c++-arc-linux-gnu.sha256sum] = "1f61a67095ace16beb374172d06bbfe20f8a1f939a03c291ed25fb4900385e52"

URI_aarch64_gcc-c++-arm-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-arm-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-arm-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-arm-linux-gnu}"
SRC_URI[aarch64_gcc-c++-arm-linux-gnu.sha256sum] = "432c242c1f3a68c63f8d624e595e7a9cda74063b60ba06370598e65e10713cad"

URI_aarch64_gcc-c++-avr32-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-avr32-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-avr32-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-avr32-linux-gnu}"
SRC_URI[aarch64_gcc-c++-avr32-linux-gnu.sha256sum] = "9893fb022bf7efc2cf1eb5a26d1cef36da84781e0d782af04085c6fcb1cd7426"

URI_aarch64_gcc-c++-bfin-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-bfin-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-bfin-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-bfin-linux-gnu}"
SRC_URI[aarch64_gcc-c++-bfin-linux-gnu.sha256sum] = "a2c95aadfd66442d27e761416dee4fc6f9122c70c900446db262c7546ff02433"

URI_aarch64_gcc-c++-c6x-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-c6x-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-c6x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-c6x-linux-gnu}"
SRC_URI[aarch64_gcc-c++-c6x-linux-gnu.sha256sum] = "61c6bea42cf0c767f45e8135071a7ecf74218077c9bea8f06553b4c263228575"

URI_aarch64_gcc-c++-frv-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-frv-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-frv-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-frv-linux-gnu}"
SRC_URI[aarch64_gcc-c++-frv-linux-gnu.sha256sum] = "f9413584c1ece352265fbdb3e0d9134d7ee283e24bab3a6866eef53c930a56bd"

URI_aarch64_gcc-c++-h8300-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-h8300-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-h8300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-h8300-linux-gnu}"
SRC_URI[aarch64_gcc-c++-h8300-linux-gnu.sha256sum] = "b0697932e2768f147053386c1121422c5bee476c95f676654a6558ccabf458c4"

URI_aarch64_gcc-c++-hppa-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-hppa-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-hppa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-hppa-linux-gnu}"
SRC_URI[aarch64_gcc-c++-hppa-linux-gnu.sha256sum] = "d65afe83e9e2f89398e10e0be615180dedcb9961749ea1f5e8291aa9375ed2b6"

URI_aarch64_gcc-c++-hppa64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-hppa64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-hppa64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-hppa64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-hppa64-linux-gnu.sha256sum] = "47feb1a0d1533536af373e2647d89e41c5e7fbe7416e7e3066f5f48bc01508a8"

URI_aarch64_gcc-c++-ia64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-ia64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-ia64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-ia64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-ia64-linux-gnu.sha256sum] = "a5af80befab4264b5ff19de90fb80f825f3ea7f623162cddaab6943721f72cef"

URI_aarch64_gcc-c++-loongarch64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-loongarch64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-loongarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-loongarch64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-loongarch64-linux-gnu.sha256sum] = "52808cda66de963cf41d9377aa3710a19af402c2931a5b2e67c8a1b0397978a7"

URI_aarch64_gcc-c++-m68k-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-m68k-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-m68k-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-m68k-linux-gnu}"
SRC_URI[aarch64_gcc-c++-m68k-linux-gnu.sha256sum] = "b9671456bdca9eecaca70687bf37b6b8655547cd6f5c8d877fb8e1fcfa571623"

URI_aarch64_gcc-c++-microblaze-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-microblaze-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-microblaze-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-microblaze-linux-gnu}"
SRC_URI[aarch64_gcc-c++-microblaze-linux-gnu.sha256sum] = "9cc1a5ea6c9e987d60b809f2f48f5f87c9343f522e8ae2caf222c848b7aa4bfc"

URI_aarch64_gcc-c++-mips64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-mips64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-mips64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-mips64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-mips64-linux-gnu.sha256sum] = "e590a78408bc80d6c8839c938a4e8d57bcf333ef590f262816096f258415d8bb"

URI_aarch64_gcc-c++-mn10300-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-mn10300-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-mn10300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-mn10300-linux-gnu}"
SRC_URI[aarch64_gcc-c++-mn10300-linux-gnu.sha256sum] = "7ba64868fea6680233175502c8829c4650f640f8eece4c97d355a48cd9609164"

URI_aarch64_gcc-c++-nios2-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-nios2-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-nios2-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-nios2-linux-gnu}"
SRC_URI[aarch64_gcc-c++-nios2-linux-gnu.sha256sum] = "247536f99d84aac69b0974340a7c4e126d345f638ab53eab87c45adcf43ad9d8"

URI_aarch64_gcc-c++-openrisc-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-openrisc-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-openrisc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-openrisc-linux-gnu}"
SRC_URI[aarch64_gcc-c++-openrisc-linux-gnu.sha256sum] = "85de32c47b10186337815bf1224d8ec7493f904ed51b65dd4878d9e6e0f7d360"

URI_aarch64_gcc-c++-powerpc64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-powerpc64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-powerpc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-powerpc64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-powerpc64-linux-gnu.sha256sum] = "4910736d8e474eef9ac1bd39df834bbde3c479d299102095c49fc20da8dd6255"

URI_aarch64_gcc-c++-powerpc64le-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-powerpc64le-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-powerpc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-powerpc64le-linux-gnu}"
SRC_URI[aarch64_gcc-c++-powerpc64le-linux-gnu.sha256sum] = "335fb0ca89b7f370a46635c6571f4568abc4de762f07b6592627ef40ecb7d0a9"

URI_aarch64_gcc-c++-ppc64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-ppc64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-ppc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-ppc64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-ppc64-linux-gnu.sha256sum] = "6771f660fd8c10ca8ffa2a5301907c2a1fea5e8cd2cfec3cb54032366b9bcff0"

URI_aarch64_gcc-c++-ppc64le-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-ppc64le-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-ppc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-ppc64le-linux-gnu}"
SRC_URI[aarch64_gcc-c++-ppc64le-linux-gnu.sha256sum] = "4d7528e3eb46736b52039cd3c1d2eaf697f9985cbfa2a30827984d782ca5b3b5"

URI_aarch64_gcc-c++-riscv64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-riscv64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-riscv64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-riscv64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-riscv64-linux-gnu.sha256sum] = "9d31f014dee8ff52abd5e2adab90500023635802e522ca048b1efb7d6a4e42f7"

URI_aarch64_gcc-c++-s390x-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-s390x-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-s390x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-s390x-linux-gnu}"
SRC_URI[aarch64_gcc-c++-s390x-linux-gnu.sha256sum] = "cc72d6829c730091d26a2f226420d957f1e228a6a315709bede86173687f9bef"

URI_aarch64_gcc-c++-sparc64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-sparc64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-sparc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-sparc64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-sparc64-linux-gnu.sha256sum] = "053cc5166912f92976b5c71cf5bc38bd7cd55c225ff4f71c04fe3e9f8b93142c"

URI_aarch64_gcc-c++-x86_64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-x86_64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-x86_64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-x86_64-linux-gnu}"
SRC_URI[aarch64_gcc-c++-x86_64-linux-gnu.sha256sum] = "93555bec802c302cb5f03226f520c704ba69711146ba8621587f1836e1d16e7c"

URI_aarch64_gcc-c++-xtensa-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c++-xtensa-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c++-xtensa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c++-xtensa-linux-gnu}"
SRC_URI[aarch64_gcc-c++-xtensa-linux-gnu.sha256sum] = "f063d9af7d638f55ef156e525a3944185d1b6d3d6c9bfd353a5a51bd8c98c7f4"

URI_aarch64_gcc-c6x-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-c6x-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-c6x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-c6x-linux-gnu}"
SRC_URI[aarch64_gcc-c6x-linux-gnu.sha256sum] = "df75179512824ca795f0d6f09b3303236fc7d4870554650fdfab785d25998d42"

URI_aarch64_gcc-frv-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-frv-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-frv-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-frv-linux-gnu}"
SRC_URI[aarch64_gcc-frv-linux-gnu.sha256sum] = "819cfd4cfc291547543e3658d01eff2ae17b7daebca06ad91707da015e840381"

URI_aarch64_gcc-h8300-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-h8300-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-h8300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-h8300-linux-gnu}"
SRC_URI[aarch64_gcc-h8300-linux-gnu.sha256sum] = "0ef0466b4cb0c8580622bc90d3e74b36ae5eed0100b0844e341171181350f6f9"

URI_aarch64_gcc-hppa-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-hppa-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-hppa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-hppa-linux-gnu}"
SRC_URI[aarch64_gcc-hppa-linux-gnu.sha256sum] = "1c40a5bf7fc8482b2b210e9346511c114107e4fa316a4cbe0af1928ec28cc9c4"

URI_aarch64_gcc-hppa64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-hppa64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-hppa64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-hppa64-linux-gnu}"
SRC_URI[aarch64_gcc-hppa64-linux-gnu.sha256sum] = "3d3c190c33308f7e9a40f0b6c923819768d5a7fc42b435b7aed8baa80c43165b"

URI_aarch64_gcc-ia64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-ia64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-ia64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-ia64-linux-gnu}"
SRC_URI[aarch64_gcc-ia64-linux-gnu.sha256sum] = "b511a72cd010821493d355b68fbb21602286f23e9f28645a0e479cdf7e56c331"

URI_aarch64_gcc-loongarch64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-loongarch64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-loongarch64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-loongarch64-linux-gnu}"
SRC_URI[aarch64_gcc-loongarch64-linux-gnu.sha256sum] = "e29b930c647b7cb510f5c4589e793a62420174f6e9dacd29d60ae3737204143b"

URI_aarch64_gcc-m68k-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-m68k-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-m68k-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-m68k-linux-gnu}"
SRC_URI[aarch64_gcc-m68k-linux-gnu.sha256sum] = "94dba9ede5d8e46bf881de1a7886ba69b855d1f83130adea034f8bc3f078c86b"

URI_aarch64_gcc-microblaze-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-microblaze-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-microblaze-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-microblaze-linux-gnu}"
SRC_URI[aarch64_gcc-microblaze-linux-gnu.sha256sum] = "9a9c7c78b86e905c22fd20850556bae86d8f8b9a1f453aeb70c729e6b495cfd4"

URI_aarch64_gcc-mips64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-mips64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-mips64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-mips64-linux-gnu}"
SRC_URI[aarch64_gcc-mips64-linux-gnu.sha256sum] = "1da44f8f0933e9e9f1b52a0f98eb3c3b12d305a5859fcc4993ac567c31e0277b"

URI_aarch64_gcc-mn10300-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-mn10300-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-mn10300-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-mn10300-linux-gnu}"
SRC_URI[aarch64_gcc-mn10300-linux-gnu.sha256sum] = "782d1b6a94bb52880edc70a702c211f9a345e276e9c9720c33707749a8bd037b"

URI_aarch64_gcc-nios2-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-nios2-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-nios2-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-nios2-linux-gnu}"
SRC_URI[aarch64_gcc-nios2-linux-gnu.sha256sum] = "55141683071ea6d78b06a36558cfe99c7727c81e076afe39d824c9a6a676a5a6"

URI_aarch64_gcc-openrisc-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-openrisc-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-openrisc-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-openrisc-linux-gnu}"
SRC_URI[aarch64_gcc-openrisc-linux-gnu.sha256sum] = "12f87882ab0980141775685611fe9ac7763dc201fd6c27b353679469776f357e"

URI_aarch64_gcc-powerpc64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-powerpc64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-powerpc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-powerpc64-linux-gnu}"
SRC_URI[aarch64_gcc-powerpc64-linux-gnu.sha256sum] = "07a30fb08090ad52dd4ca0acf463dc44728801a8bbdcda8e30fd848fe674466e"

URI_aarch64_gcc-powerpc64le-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-powerpc64le-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-powerpc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-powerpc64le-linux-gnu}"
SRC_URI[aarch64_gcc-powerpc64le-linux-gnu.sha256sum] = "847a40368f176d49d2cb544dcff6df79053ecfb69345f43acac3bc6f2fba2e95"

URI_aarch64_gcc-ppc64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-ppc64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-ppc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-ppc64-linux-gnu}"
SRC_URI[aarch64_gcc-ppc64-linux-gnu.sha256sum] = "894be5aa918db2199a8cbaf9ee705c2c196e0a3c79b0caad09e4897494fd20e5"

URI_aarch64_gcc-ppc64le-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-ppc64le-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-ppc64le-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-ppc64le-linux-gnu}"
SRC_URI[aarch64_gcc-ppc64le-linux-gnu.sha256sum] = "c67d6b0d4b10b1fd6f040324dde2a86b11f4c5e95442c470e2c9c6b6fe9327c4"

URI_aarch64_gcc-riscv64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-riscv64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-riscv64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-riscv64-linux-gnu}"
SRC_URI[aarch64_gcc-riscv64-linux-gnu.sha256sum] = "3fe67f73bea3e3ce0b98e3d4999b502fee1f222e4f8d29e3bdf4ddc4a7498811"

URI_aarch64_gcc-s390x-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-s390x-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-s390x-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-s390x-linux-gnu}"
SRC_URI[aarch64_gcc-s390x-linux-gnu.sha256sum] = "bdcd1ff16ec7dc3628bfbeaaff2585d6d945d7d5e950d14aaf122525c15936e2"

URI_aarch64_gcc-sparc64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-sparc64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-sparc64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-sparc64-linux-gnu}"
SRC_URI[aarch64_gcc-sparc64-linux-gnu.sha256sum] = "60b1d3ef0efe345540b409cfad9fa08bf9b65c07d27a54d10c87812a19967f3c"

URI_aarch64_gcc-x86_64-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-x86_64-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-x86_64-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-x86_64-linux-gnu}"
SRC_URI[aarch64_gcc-x86_64-linux-gnu.sha256sum] = "a15b242ef4b2796cf41bc9f616c264fb4c37200e20037456ad3e8e400a02ebd0"

URI_aarch64_gcc-xtensa-linux-gnu = "${EPEL_MIRROR}/aarch64/Packages/g/gcc-xtensa-linux-gnu-14.1.1-1.el10_0.1.aarch64.rpm;name=aarch64_gcc-xtensa-linux-gnu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-xtensa-linux-gnu}"
SRC_URI[aarch64_gcc-xtensa-linux-gnu.sha256sum] = "9bd760af9ad552e7619f2364905015cdf5b4515546f07ab8ba30ec16efe58930"

RDEPENDS:cross-gcc-common = " \
 "
RDEPENDS:gcc-aarch64-linux-gnu = " \
 bash \
 binutils-aarch64-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-alpha-linux-gnu = " \
 bash \
 binutils-alpha-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-arc-linux-gnu = " \
 bash \
 binutils-arc-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-arm-linux-gnu = " \
 bash \
 binutils-arm-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-avr32-linux-gnu = " \
 bash \
 binutils-avr32-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-bfin-linux-gnu = " \
 bash \
 binutils-bfin-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-aarch64-linux-gnu = " \
 gcc-aarch64-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-alpha-linux-gnu = " \
 gcc-alpha-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-arc-linux-gnu = " \
 gcc-arc-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-arm-linux-gnu = " \
 gcc-arm-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-avr32-linux-gnu = " \
 gcc-avr32-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-bfin-linux-gnu = " \
 gcc-bfin-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-c6x-linux-gnu = " \
 gcc-c6x-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-frv-linux-gnu = " \
 gcc-frv-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-h8300-linux-gnu = " \
 gcc-h8300-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-hppa-linux-gnu = " \
 gcc-hppa-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-hppa64-linux-gnu = " \
 gcc-hppa64-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-ia64-linux-gnu = " \
 gcc-ia64-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-loongarch64-linux-gnu = " \
 gcc-loongarch64-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-m68k-linux-gnu = " \
 gcc-m68k-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-microblaze-linux-gnu = " \
 gcc-microblaze-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-mips64-linux-gnu = " \
 gcc-mips64-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-mn10300-linux-gnu = " \
 gcc-mn10300-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-nios2-linux-gnu = " \
 gcc-nios2-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-openrisc-linux-gnu = " \
 gcc-openrisc-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-powerpc64-linux-gnu = " \
 gcc-powerpc64-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-powerpc64le-linux-gnu = " \
 gcc-powerpc64le-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-ppc64-linux-gnu = " \
 gcc-c++-powerpc64-linux-gnu \
 gcc-ppc64-linux-gnu \
 "
RDEPENDS:gcc-c++-ppc64le-linux-gnu = " \
 gcc-c++-powerpc64le-linux-gnu \
 gcc-ppc64le-linux-gnu \
 "
RDEPENDS:gcc-c++-riscv64-linux-gnu = " \
 gcc-riscv64-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-s390x-linux-gnu = " \
 gcc-s390x-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-sparc64-linux-gnu = " \
 gcc-sparc64-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-x86_64-linux-gnu = " \
 gcc-x86_64-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c++-xtensa-linux-gnu = " \
 gcc-xtensa-linux-gnu \
 glibc \
 gmp \
 libgcc \
 libmpc \
 libstdc++ \
 libzstd \
 mpfr \
 zlib-ng-compat \
 "
RDEPENDS:gcc-c6x-linux-gnu = " \
 bash \
 binutils-c6x-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-frv-linux-gnu = " \
 bash \
 binutils-frv-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-h8300-linux-gnu = " \
 bash \
 binutils-h8300-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-hppa-linux-gnu = " \
 bash \
 binutils-hppa-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-hppa64-linux-gnu = " \
 bash \
 binutils-hppa64-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-ia64-linux-gnu = " \
 bash \
 binutils-ia64-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-loongarch64-linux-gnu = " \
 bash \
 binutils-loongarch64-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-m68k-linux-gnu = " \
 bash \
 binutils-m68k-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-microblaze-linux-gnu = " \
 bash \
 binutils-microblaze-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-mips64-linux-gnu = " \
 bash \
 binutils-mips64-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-mn10300-linux-gnu = " \
 bash \
 binutils-mn10300-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-nios2-linux-gnu = " \
 bash \
 binutils-nios2-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-openrisc-linux-gnu = " \
 bash \
 binutils-openrisc-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-powerpc64-linux-gnu = " \
 bash \
 binutils-powerpc64-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-powerpc64le-linux-gnu = " \
 bash \
 binutils-powerpc64le-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-ppc64-linux-gnu = " \
 gcc-powerpc64-linux-gnu \
 "
RDEPENDS:gcc-ppc64le-linux-gnu = " \
 gcc-powerpc64le-linux-gnu \
 "
RDEPENDS:gcc-riscv64-linux-gnu = " \
 bash \
 binutils-riscv64-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-s390x-linux-gnu = " \
 bash \
 binutils-s390x-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-sparc64-linux-gnu = " \
 bash \
 binutils-sparc64-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-x86_64-linux-gnu = " \
 bash \
 binutils-x86_64-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
RDEPENDS:gcc-xtensa-linux-gnu = " \
 bash \
 binutils-xtensa-linux-gnu \
 cross-gcc-common \
 glibc \
 gmp \
 gmp-devel \
 isl \
 libgcc \
 libmpc \
 libmpc-devel \
 libstdc++ \
 libzstd \
 mpfr \
 mpfr-devel \
 zlib-ng-compat \
 "
