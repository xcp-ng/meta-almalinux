# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sratom"
PV = "0.6.22"
PR = "1.el10_3"
PACKAGES = " \
 sratom \
 sratom-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sratom-0.6.22-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4fc7d58ab27c33df8e22dd5551b8affe7221415dda1a0f7639f89dd770a02d6c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sratom-0.6.22-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sratom;unpack=0"
SRC_URI[x86_64_v2_sratom.sha256sum] = "267d020340e82cf33bf334535d2c527fcae720fe9a7670e0bef6a07dffe275da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sratom-devel-0.6.22-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sratom-devel;unpack=0"
SRC_URI[x86_64_v2_sratom-devel.sha256sum] = "9240f276307339d744d10922452228da631c3bae5c38467da9c0629164fc8125"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sratom-0.6.22-1.el10_3.aarch64.rpm;name=aarch64_sratom;unpack=0"
SRC_URI[aarch64_sratom.sha256sum] = "c161b93278e1ec7b6dfd83620d903c50fc5aeb701eefc30e6b5e97276edb0427"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sratom-devel-0.6.22-1.el10_3.aarch64.rpm;name=aarch64_sratom-devel;unpack=0"
SRC_URI[aarch64_sratom-devel.sha256sum] = "4c4088886a87b60d7de92995ea1a92fd05eb9142c7c8e400b25891c9b0c8dade"

RDEPENDS:sratom = " \
 glibc \
 serd \
 sord \
 "
RDEPENDS:sratom-devel = " \
 lv2-devel \
 pkgconf-pkg-config \
 serd-devel \
 sord-devel \
 sratom \
 "
