# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-object"
PV = "0.50.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-object+default-devel \
 rust-gix-object+document-features-devel \
 rust-gix-object+serde-devel \
 rust-gix-object+verbose-object-parsing-errors-devel \
 rust-gix-object-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-object-0.50.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf2a252c9bb67ea4be0f9514b9350998629081094b1feb392dbc845d19ce9f07"

URI_x86_64_v2_rust-gix-object+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+default-devel-0.50.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+default-devel}"
SRC_URI[x86_64_v2_rust-gix-object+default-devel.sha256sum] = "9e060cb803cb2546eea304f8d8f42185b06a0fd7b1cc1e2fad51d31bae36baff"

URI_x86_64_v2_rust-gix-object+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+document-features-devel-0.50.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-object+document-features-devel.sha256sum] = "05363899f46d5486adabcd6d38f35dca3f225ba05936974839c5ae36550de5cb"

URI_x86_64_v2_rust-gix-object+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+serde-devel-0.50.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-object+serde-devel.sha256sum] = "a5013f34849f61e8558e29843ca9560a7e9d2d94f3383c9ecd472716ca76e734"

URI_x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object+verbose-object-parsing-errors-devel-0.50.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel}"
SRC_URI[x86_64_v2_rust-gix-object+verbose-object-parsing-errors-devel.sha256sum] = "95e7dd0366835727863401fad3bcaeb54dd81ffcbb7780f27a5f20179c794c27"

URI_x86_64_v2_rust-gix-object-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-object-devel-0.50.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-object-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-object-devel}"
SRC_URI[x86_64_v2_rust-gix-object-devel.sha256sum] = "811116b3bf5927673bc03c0739800d8e264ed422be8d171210a35f7ab66d7cda"

URI_aarch64_rust-gix-object+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+default-devel-0.50.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-object+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+default-devel}"
SRC_URI[aarch64_rust-gix-object+default-devel.sha256sum] = "f3608b322cc349970a9d1dd5a841ed6c80bb5826eea79848cc26ea5ad16c51c6"

URI_aarch64_rust-gix-object+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+document-features-devel-0.50.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-object+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+document-features-devel}"
SRC_URI[aarch64_rust-gix-object+document-features-devel.sha256sum] = "3b3e2c3fe2e6936932146e05b1a4547848826d32b15ecaffc179e6fc7c0fcc5b"

URI_aarch64_rust-gix-object+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+serde-devel-0.50.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-object+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+serde-devel}"
SRC_URI[aarch64_rust-gix-object+serde-devel.sha256sum] = "e269195c1a444ece0a099ac3c7117a0726c082a182f98b4b5244b5c24f5d120c"

URI_aarch64_rust-gix-object+verbose-object-parsing-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object+verbose-object-parsing-errors-devel-0.50.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-object+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object+verbose-object-parsing-errors-devel}"
SRC_URI[aarch64_rust-gix-object+verbose-object-parsing-errors-devel.sha256sum] = "e979fb9f68f16cc81cc724e1914532d38f3e8b2c00f0db6d2e7b72fba97328ee"

URI_aarch64_rust-gix-object-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-object-devel-0.50.2-1.el10_1.noarch.rpm;name=aarch64_rust-gix-object-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-object-devel}"
SRC_URI[aarch64_rust-gix-object-devel.sha256sum] = "a60aefbd3d31a6c80c5768f7f7c76b50623244ccccc9d3f3d8c23aea123e7ba1"

RDEPENDS:rust-gix-object+default-devel = " \
 cargo \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-object-devel \
 "
RDEPENDS:rust-gix-object+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-object-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-smallvec+serde-devel \
 "
RDEPENDS:rust-gix-object+verbose-object-parsing-errors-devel = " \
 cargo \
 rust-gix-object-devel \
 rust-winnow+std-devel \
 "
RDEPENDS:rust-gix-object-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-actor+default-devel \
 rust-gix-date+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-path+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-itoa+default-devel \
 rust-smallvec+default-devel \
 rust-smallvec+write-devel \
 rust-thiserror+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
