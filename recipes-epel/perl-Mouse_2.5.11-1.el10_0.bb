# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mouse"
PV = "2.5.11"
PR = "1.el10_0"
PACKAGES = " \
 perl-Mouse \
 perl-Test-Mouse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mouse-2.5.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4877956f576c4d51ff913fa3f8e7ef6367b590bfc8502bb3ec82ce95c07ebd01"

URI_x86_64_v2_perl-Mouse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mouse-2.5.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Mouse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mouse}"
SRC_URI[x86_64_v2_perl-Mouse.sha256sum] = "f4d4dfd6394044176437da29073a061f0796ec47d75f858de924a30e0109c513"
RPROVIDES:perl-Mouse:x86_64_v2 = "virtual/perl_Any-Moose__ge_0.40"

URI_x86_64_v2_perl-Test-Mouse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Mouse-2.5.11-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Test-Mouse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Mouse}"
SRC_URI[x86_64_v2_perl-Test-Mouse.sha256sum] = "0ba0f004b43b2dd71ded823e2f6210f49d9f270be89960c2e1d88abb20fe8eff"

URI_aarch64_perl-Mouse = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mouse-2.5.11-1.el10_0.aarch64.rpm;name=aarch64_perl-Mouse;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mouse}"
SRC_URI[aarch64_perl-Mouse.sha256sum] = "418be5ef57632c1c0e13bae88f6a759bf71633bf72a3a5116fbf5391a8d429a1"
RPROVIDES:perl-Mouse:aarch64 = "virtual/perl_Any-Moose__ge_0.40"

URI_aarch64_perl-Test-Mouse = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Mouse-2.5.11-1.el10_0.aarch64.rpm;name=aarch64_perl-Test-Mouse;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Mouse}"
SRC_URI[aarch64_perl-Test-Mouse.sha256sum] = "7b62a6efb346911767230ca6f4403f41e5bcaa1f1f8f13cd81a54a39d2288bc3"

RDEPENDS:perl-Mouse = " \
 glibc \
 perl-B \
 perl-Carp \
 perl-Data-Dumper \
 perl-Filter-Simple \
 perl-Mouse \
 perl-Scalar-List-Utils \
 perl-base \
 perl-constant \
 perl-libs \
 perl-mro \
 perl-overload \
 perl-version \
 "
RDEPENDS:perl-Test-Mouse = " \
 perl-Mouse \
 perl-Test-Simple \
 perl-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/perl_Any-Moose__ge_0.40"

PROVIDES:append:aarch64 = " rpm/virtual/perl_Any-Moose__ge_0.40"
