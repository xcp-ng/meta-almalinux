# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Template-Toolkit"
PV = "3.102"
PR = "1.el10_0"
PACKAGES = " \
 perl-Template-Toolkit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Template-Toolkit-3.102-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "834ec632866671bc68a9aa50bb4d8b00866309a16e43947cee9d4ca9ae2e8473"

URI_x86_64_v2_perl-Template-Toolkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Template-Toolkit-3.102-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Template-Toolkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Template-Toolkit}"
SRC_URI[x86_64_v2_perl-Template-Toolkit.sha256sum] = "e03918799f87d319be41cfe7a33ff634f9f593cfb7ca3e48149ec846b1d268f7"

URI_aarch64_perl-Template-Toolkit = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Template-Toolkit-3.102-1.el10_0.aarch64.rpm;name=aarch64_perl-Template-Toolkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Template-Toolkit}"
SRC_URI[aarch64_perl-Template-Toolkit.sha256sum] = "d6a519b0c70083ed41dd6dae29cb977f8e4451a8fb83ab6326d4e4c17e6e9770"

RDEPENDS:perl-Template-Toolkit = " \
 glibc \
 perl-AppConfig \
 perl-Data-Dumper \
 perl-Encode \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-HTML-Parser \
 perl-Image-Info \
 perl-Math-Complex \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-POM \
 perl-Scalar-List-Utils \
 perl-Template-Toolkit \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-locale \
 perl-overload \
 "
