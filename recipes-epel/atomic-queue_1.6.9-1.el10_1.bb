# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "atomic-queue"
PV = "1.6.9"
PR = "1.el10_1"
PACKAGES = " \
 atomic-queue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/atomic-queue-1.6.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c1f1f9ed38923c3604a38390093c737b45d45cf2d940181511129c3116616f6"

URI_x86_64_v2_atomic-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/atomic-queue-devel-1.6.9-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_atomic-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_atomic-queue-devel}"
SRC_URI[x86_64_v2_atomic-queue-devel.sha256sum] = "8db6b004b4dc4a806688eeebf11bcaf39cf31707bec6764560267d3b637bf143"

URI_aarch64_atomic-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/a/atomic-queue-devel-1.6.9-1.el10_1.aarch64.rpm;name=aarch64_atomic-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_atomic-queue-devel}"
SRC_URI[aarch64_atomic-queue-devel.sha256sum] = "b4d625920b243480fe495980c835c6ac71b7331ee6198c8215ea15d12bfd90de"

RDEPENDS:atomic-queue-devel = " \
 pkgconf-pkg-config \
 "
