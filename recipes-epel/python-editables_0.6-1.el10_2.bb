# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-editables"
PV = "0.6"
PR = "1.el10_2"
PACKAGES = " \
 python3-editables \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-editables-0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5461226d78defb1260bb87c12fdcabd0da8b488a1a87f23196bedf53ae170ad"

URI_x86_64_v2_python3-editables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-editables-0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-editables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-editables}"
SRC_URI[x86_64_v2_python3-editables.sha256sum] = "ce1b28d915ac3d0b984fd7bcc8cda704f188b31c4231c8b757dab5fcf4b4f60a"

URI_aarch64_python3-editables = "${EPEL_MIRROR}/aarch64/Packages/p/python3-editables-0.6-1.el10_2.noarch.rpm;name=aarch64_python3-editables;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-editables}"
SRC_URI[aarch64_python3-editables.sha256sum] = "61567c826ad4d37337eccdf5c026f01e726ee04f50ff4d9fe7ad1fb2890017e5"

RDEPENDS:python3-editables = " \
 python3 \
 "
