# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yelp"
PE = "2"
PV = "42.2"
PR = "6.el10_0"
PACKAGES = " \
 yelp \
 yelp-devel \
 yelp-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yelp-42.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23c248c3f3c19c0c1b1df440c542350d77c45d37ff225eea97ec84febae2033e"

URI_x86_64_v2_yelp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yelp-42.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yelp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yelp}"
SRC_URI[x86_64_v2_yelp.sha256sum] = "0f07c02797d1e4c7cbfbb915914381e9021ef72c14be5ba2b7c90efe3ce576fa"

URI_x86_64_v2_yelp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yelp-devel-42.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yelp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yelp-devel}"
SRC_URI[x86_64_v2_yelp-devel.sha256sum] = "12c83d9535eb9f6850fd0fd6cd8cc0bf0d38f7d58cd742a2f3186adb947f3371"

URI_x86_64_v2_yelp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yelp-libs-42.2-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yelp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yelp-libs}"
SRC_URI[x86_64_v2_yelp-libs.sha256sum] = "fe226231f35cfa2fcc47156e5000506edaded4782f67e7ae2f374ad5b2124314"

URI_aarch64_yelp = "${EPEL_MIRROR}/aarch64/Packages/y/yelp-42.2-6.el10_0.aarch64.rpm;name=aarch64_yelp;unpack=0"
SRC_URI:append = " ${URI_aarch64_yelp}"
SRC_URI[aarch64_yelp.sha256sum] = "919308947eae7efe02e6d26aebb4a7b2e0d0d2dcd1e12e186e2126b2fa741792"

URI_aarch64_yelp-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yelp-devel-42.2-6.el10_0.aarch64.rpm;name=aarch64_yelp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yelp-devel}"
SRC_URI[aarch64_yelp-devel.sha256sum] = "3e562c40fe314d68a1e2f0f829ab4e7e59c0fc964fe6d9c097f0854b4bd324c3"

URI_aarch64_yelp-libs = "${EPEL_MIRROR}/aarch64/Packages/y/yelp-libs-42.2-6.el10_0.aarch64.rpm;name=aarch64_yelp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_yelp-libs}"
SRC_URI[aarch64_yelp-libs.sha256sum] = "aafb1d29c4e84e3ae601814e8fa713c95d6a15452f8f59a78f613c265b551fbd"

RDEPENDS:yelp = " \
 glib2 \
 glibc \
 gtk3 \
 libhandy \
 webkit2gtk4.1 \
 yelp-libs \
 yelp-xsl \
 "
RDEPENDS:yelp-devel = " \
 yelp-libs \
 "
RDEPENDS:yelp-libs = " \
 atk \
 bzip2-libs \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 javascriptcoregtk4.1 \
 libhandy \
 libsoup3 \
 libxml2 \
 libxslt \
 pango \
 sqlite-libs \
 webkit2gtk4.1 \
 xz-libs \
 "
