# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ddrescue"
PV = "1.28"
PR = "2.el10_0"
PACKAGES = " \
 ddrescue \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/ddrescue-1.28-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3d6bee3f921946a1a301c9f73241d24a0bc21a82de4f0af64945c0eab52d4e34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ddrescue-1.28-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ddrescue;unpack=0"
SRC_URI[x86_64_v2_ddrescue.sha256sum] = "da583c312f2bf55c72427e8ae67ff5fe94fd407124e2fd8d2bbf9fb866c0db2a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/ddrescue-1.28-2.el10_0.aarch64.rpm;name=aarch64_ddrescue;unpack=0"
SRC_URI[aarch64_ddrescue.sha256sum] = "5d93cfc3c92745b9877df421c0ef20e3c8e808fc3c7595853985659916579978"

RDEPENDS:ddrescue = " \
 glibc \
 libgcc \
 libstdc++ \
 "
