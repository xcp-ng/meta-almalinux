# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-assertpy"
PV = "1.1"
PR = "2.el10_2"
PACKAGES = " \
 python3-assertpy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-assertpy-1.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2cf676c7ab0c1456e35b85602c656dec7856550136f752d3765934fc135e39a"

URI_x86_64_v2_python3-assertpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-assertpy-1.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-assertpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-assertpy}"
SRC_URI[x86_64_v2_python3-assertpy.sha256sum] = "d1f44751b8ee798e9d3385bbb2167c70513e8231e8c23b36cec9c394b26dad10"

URI_aarch64_python3-assertpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-assertpy-1.1-2.el10_2.noarch.rpm;name=aarch64_python3-assertpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-assertpy}"
SRC_URI[aarch64_python3-assertpy.sha256sum] = "3c8a50f6c5cf8df2a821aac47107f2eb68adbc4285cd3284d49d9ffc91214aad"

RDEPENDS:python3-assertpy = " \
 python3 \
 "
