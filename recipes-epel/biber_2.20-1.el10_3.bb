# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "biber"
PV = "2.20"
PR = "1.el10_3"
PACKAGES = " \
 biber \
 biber-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/biber-2.20-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b85da562c92d1623300bf0917060383c8796121051230843597de4b8d51aaed0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/biber-2.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_biber;unpack=0"
SRC_URI[x86_64_v2_biber.sha256sum] = "6a8059c9a3495b19b82ec01c7b626f2ea517d9a40fa585642fe3838282f95495"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/biber-tests-2.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_biber-tests;unpack=0"
SRC_URI[x86_64_v2_biber-tests.sha256sum] = "263faa6b4c273467b38e082961ebcabc05768cc7ac7dcf58494096ec2d82affa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/biber-2.20-1.el10_3.noarch.rpm;name=aarch64_biber;unpack=0"
SRC_URI[aarch64_biber.sha256sum] = "7006d784eb14930ef93b0067c000f6659a15eb8e19098d17ca04474bbdcfa81e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/biber-tests-2.20-1.el10_3.noarch.rpm;name=aarch64_biber-tests;unpack=0"
SRC_URI[aarch64_biber-tests.sha256sum] = "71057cccb83f8bc5cae00d29aea428941d6d09258f5dac4b92af03ec6bcf1ebd"

RDEPENDS:biber = " \
 biber \
 perl-Business-ISBN \
 perl-Business-ISMN \
 perl-Business-ISSN \
 perl-Carp \
 perl-Class-Accessor \
 perl-Data-Compare \
 perl-Data-Dump \
 perl-Data-Uniqid \
 perl-DateTime \
 perl-DateTime-Calendar-Julian \
 perl-DateTime-Format-Builder \
 perl-DateTime-TimeZone \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Slurper \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-String \
 perl-IPC-Cmd \
 perl-IPC-Run3 \
 perl-LWP-Protocol-https \
 perl-Lingua-Translit \
 perl-List-AllUtils \
 perl-Log-Log4perl \
 perl-POSIX \
 perl-Parse-RecDescent \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Regexp-Common \
 perl-Scalar-List-Utils \
 perl-Sort-Key \
 perl-Storable \
 perl-Text-Balanced \
 perl-Text-BibTeX \
 perl-Text-CSV \
 perl-Text-Roman \
 perl-Text-Tabs+Wrap \
 perl-URI \
 perl-Unicode-Collate \
 perl-Unicode-LineBreak \
 perl-Unicode-Normalize \
 perl-Unicode-UCD \
 perl-XML-LibXML \
 perl-XML-LibXML-Simple \
 perl-XML-LibXSLT \
 perl-XML-Writer \
 perl-autovivification \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-locale \
 perl-parent \
 perl-sigtrap \
 perl-vars \
 "
RDEPENDS:biber-tests = " \
 bash \
 biber \
 perl-Capture-Tiny \
 perl-Encode \
 perl-File-Compare \
 perl-File-Temp \
 perl-File-Which \
 perl-IPC-Cmd \
 perl-IPC-Run3 \
 perl-List-AllUtils \
 perl-Log-Log4perl \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Test-Differences \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Text-Diff \
 perl-Unicode-Normalize \
 perl-XML-LibXML \
 perl-interpreter \
 perl-libs \
 perl-open \
 virtual/coreutils \
 "
