# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-insta"
PV = "1.46.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-insta+_cargo_insta_internal-devel \
 rust-insta+clap-devel \
 rust-insta+colors-devel \
 rust-insta+console-devel \
 rust-insta+csv-devel \
 rust-insta+default-devel \
 rust-insta+filters-devel \
 rust-insta+glob-devel \
 rust-insta+globset-devel \
 rust-insta+json-devel \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+redactions-devel \
 rust-insta+regex-devel \
 rust-insta+ron-devel \
 rust-insta+serde-devel \
 rust-insta+toml-devel \
 rust-insta+walkdir-devel \
 rust-insta+yaml-devel \
 rust-insta-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-insta-1.46.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f8e6b77e9503ed8f4c3f23f5643d32b5bf515de06a4984920bf7919fa2290f65"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+_cargo_insta_internal-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+_cargo_insta_internal-devel.sha256sum] = "ab4a408a9729c5b75db304041fb404be055542083a2a3136a12ea50e28c61daa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+clap-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+clap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+clap-devel.sha256sum] = "dbf0c52079f1451fd19ca4a3c267e7cda1b3e8401fd5c7b57c211f8068b74f4b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+colors-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+colors-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+colors-devel.sha256sum] = "27391614c58a2511e02920b674a035e0d6d2d223370aed9f795e272a5ca8318e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+console-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+console-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+console-devel.sha256sum] = "3a54fd83b01721a105ae4f9f59b74d9f433af79afffa842a75252ca471abfc6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+csv-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+csv-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+csv-devel.sha256sum] = "648c00bc120834e1a73c0df553291f963ea8b672525706b6467bd5cb17a3a93a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+default-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+default-devel.sha256sum] = "5b1f69ed73fe4a57196723633189dfb654bd6a41b12dc5a6cb1b1aee5256c1c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+filters-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+filters-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+filters-devel.sha256sum] = "c5e141e038123892781d2f336d621c76e430b94808db1ac921b5f190a0325874"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+glob-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+glob-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+glob-devel.sha256sum] = "f475e87dc086e2e8582735dea1fe643f9c3ace6a6fa113be49e3ea3f7257ac15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+globset-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+globset-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+globset-devel.sha256sum] = "be4290461c815e214a2c545006a44bcb1aceb27d0b08ecc52a05546051ef6a3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+json-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+json-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+json-devel.sha256sum] = "25b6bfc5080a4122b521a882bc56f15ca208b3f60dd907137928456440eea891"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+pest-devel.sha256sum] = "518f0bbde11317c69d25b1709686a18a707f1d256daf69e414b6e01fc0336556"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+pest_derive-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+pest_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+pest_derive-devel.sha256sum] = "f92dea64f4cbaa6efcf4ae10872054353489d1d045b9e5409faa584cb93258ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+redactions-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+redactions-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+redactions-devel.sha256sum] = "5df833376e6a8f4742e2b1b730b7a20cf974fbb7c8ae23a17c3aa54b15c908ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+regex-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+regex-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+regex-devel.sha256sum] = "494d5b32658f57745ec4f25093ea577c2ad9e6698c745ad6648a49fa7ab95513"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+ron-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+ron-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+ron-devel.sha256sum] = "602a8691e6306b822c438224011fb76b80570a482ee7628a851859a97395c884"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+serde-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+serde-devel.sha256sum] = "8b5c6f222db6a1a2bd36dd7537df6a738692ff5ddf8d0320a5bdbe1de1ffdadd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+toml-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+toml-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+toml-devel.sha256sum] = "a406b01e8cc03872a873fc2be64287110535eb4bfda2960129066baab33d1558"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+walkdir-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+walkdir-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+walkdir-devel.sha256sum] = "9a958b5936c0bc123e949b666f86a0d74c70f8b28c24165b4924ad7ca9af3db7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta+yaml-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta+yaml-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta+yaml-devel.sha256sum] = "06dc5c88bd228967d52ba0190853645f572e851b606a927017797162c33de73e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta-devel-1.46.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta-devel;unpack=0"
SRC_URI[x86_64_v2_rust-insta-devel.sha256sum] = "f10abe04fdd16e1116eb7df05eee08d6363edc2493e486ca7dfa29b1d7761a50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+_cargo_insta_internal-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+_cargo_insta_internal-devel;unpack=0"
SRC_URI[aarch64_rust-insta+_cargo_insta_internal-devel.sha256sum] = "13c9660d66c8435b21ca9c67aaa86e61f6461a4a3fec701d077f743eeec14ff2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+clap-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+clap-devel;unpack=0"
SRC_URI[aarch64_rust-insta+clap-devel.sha256sum] = "9b187a388a2897468077c039c4ed31865c57983923cce35a92882d115024ba36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+colors-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+colors-devel;unpack=0"
SRC_URI[aarch64_rust-insta+colors-devel.sha256sum] = "024976d538c9cd089a523a6c807d948abe46e0058b6cf9b09b7fde99d50f9351"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+console-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+console-devel;unpack=0"
SRC_URI[aarch64_rust-insta+console-devel.sha256sum] = "833e8320482e5226e234f9760540190e63e068593011e48ea025ce44500aa00b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+csv-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+csv-devel;unpack=0"
SRC_URI[aarch64_rust-insta+csv-devel.sha256sum] = "6d7b3925e4e5d23246d546bae40a85b8584dc2782ec86cc8ade6bde21bc94cf7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+default-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+default-devel;unpack=0"
SRC_URI[aarch64_rust-insta+default-devel.sha256sum] = "b6b9e33591a4f1b62e21a443af3bde830ecfd498bf539fd87bd8fd17612b26fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+filters-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+filters-devel;unpack=0"
SRC_URI[aarch64_rust-insta+filters-devel.sha256sum] = "4f865946452c40724b9e444d53f6522b86cecd695d9e575f314bae1f382d08a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+glob-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+glob-devel;unpack=0"
SRC_URI[aarch64_rust-insta+glob-devel.sha256sum] = "b43d92e217895a1d0dc881c10aa97640b3eeb9dfec36bc0771893b3db09609e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+globset-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+globset-devel;unpack=0"
SRC_URI[aarch64_rust-insta+globset-devel.sha256sum] = "35d06d25babee13d0af6267d758c673b82785f27801f66de739177315df25018"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+json-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+json-devel;unpack=0"
SRC_URI[aarch64_rust-insta+json-devel.sha256sum] = "0cfa6b0b2022cb74ad887b34dc07e8b79fd527efa89e746f47f8c7b15793302f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+pest-devel;unpack=0"
SRC_URI[aarch64_rust-insta+pest-devel.sha256sum] = "cbcbcfc63136f3e6593bd23f52c3b0585e3e5987b8bb3f3a76276f7a66273871"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+pest_derive-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+pest_derive-devel;unpack=0"
SRC_URI[aarch64_rust-insta+pest_derive-devel.sha256sum] = "33ee15d459bd0651d8e11fb9666d6a9113458af0edd4e4c1cc7dfebafb4eb89e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+redactions-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+redactions-devel;unpack=0"
SRC_URI[aarch64_rust-insta+redactions-devel.sha256sum] = "e205f99215ddc732f5311404209c2f794d82031cc39f0183ab94ac30f314aa09"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+regex-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+regex-devel;unpack=0"
SRC_URI[aarch64_rust-insta+regex-devel.sha256sum] = "e4b59e17cbea1746b7b34acbb36a429a0e2389c35a412693234f197dadb41f13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+ron-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+ron-devel;unpack=0"
SRC_URI[aarch64_rust-insta+ron-devel.sha256sum] = "ca80a4ab7405268b8bef28d111f1826913a775448cd84a2341d1240f68420419"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+serde-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+serde-devel;unpack=0"
SRC_URI[aarch64_rust-insta+serde-devel.sha256sum] = "3a11530645b078de6e48c097ed93b933dffa1e58c114ff2bf79e6f04f7eb59da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+toml-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+toml-devel;unpack=0"
SRC_URI[aarch64_rust-insta+toml-devel.sha256sum] = "4bf7485cdb36353a94c19faaccb832285fbfb4ab968b8d82fa43d2b155e6f57c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+walkdir-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+walkdir-devel;unpack=0"
SRC_URI[aarch64_rust-insta+walkdir-devel.sha256sum] = "a5ce091cfe88494d74f60fc2677d8dd1734f06367cf76f353a0e9acea3df3307"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta+yaml-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta+yaml-devel;unpack=0"
SRC_URI[aarch64_rust-insta+yaml-devel.sha256sum] = "d62ce9ed102c09410f85ec55509120ce7d18908d805e1cdcde962bc95249a18a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-insta-devel-1.46.3-1.el10_2.noarch.rpm;name=aarch64_rust-insta-devel;unpack=0"
SRC_URI[aarch64_rust-insta-devel.sha256sum] = "2a04401ac57089069f98c4c6849fd3009dbc988f5df2002d54157398ef4e754c"

RDEPENDS:rust-insta+_cargo_insta_internal-devel = " \
 cargo \
 rust-insta+clap-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+clap-devel = " \
 cargo \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+colors-devel = " \
 cargo \
 rust-insta+console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+console-devel = " \
 cargo \
 rust-console+std-devel \
 rust-console-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+csv-devel = " \
 cargo \
 rust-csv+default-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+default-devel = " \
 cargo \
 rust-insta+colors-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+filters-devel = " \
 cargo \
 rust-insta+regex-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+glob-devel = " \
 cargo \
 rust-insta+globset-devel \
 rust-insta+walkdir-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+globset-devel = " \
 cargo \
 rust-globset+default-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+json-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+pest-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest+default-devel \
 "
RDEPENDS:rust-insta+pest_derive-devel = " \
 cargo \
 rust-insta-devel \
 rust-pest_derive+default-devel \
 "
RDEPENDS:rust-insta+redactions-devel = " \
 cargo \
 rust-insta+pest-devel \
 rust-insta+pest_derive-devel \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta+regex-devel = " \
 cargo \
 rust-insta-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-insta+ron-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-ron+default-devel \
 "
RDEPENDS:rust-insta+serde-devel = " \
 cargo \
 rust-insta-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-insta+toml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 rust-toml_writer+default-devel \
 virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ \
 virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~ \
 virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ \
 virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ \
 "
RDEPENDS:rust-insta+walkdir-devel = " \
 cargo \
 rust-insta-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-insta+yaml-devel = " \
 cargo \
 rust-insta+serde-devel \
 rust-insta-devel \
 "
RDEPENDS:rust-insta-devel = " \
 cargo \
 rust \
 rust-once_cell+default-devel \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 rust-tempfile+default-devel \
 "
