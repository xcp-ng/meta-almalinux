# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwayland"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtwayland \
 qt6-qtwayland-devel \
 qt6-qtwayland-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtwayland-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdb5d5078039312468117d2c22af27be3364dd0909828325b5557022c9114596"

URI_x86_64_v2_qt6-qtwayland = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwayland-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwayland}"
SRC_URI[x86_64_v2_qt6-qtwayland.sha256sum] = "046c2c31fa028016f5aa6b306ecadff8ba63de5c19007a61600b967c6b5e8819"

URI_x86_64_v2_qt6-qtwayland-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwayland-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwayland-devel}"
SRC_URI[x86_64_v2_qt6-qtwayland-devel.sha256sum] = "b35b295c5a978df0b75561f1ce88c89d19962f35b57648652cba884aaa9a9a6e"

URI_x86_64_v2_qt6-qtwayland-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtwayland-examples-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwayland-examples}"
SRC_URI[x86_64_v2_qt6-qtwayland-examples.sha256sum] = "e7c76028d0d51c9913bf8a5c3f3a39e6f9dff72ef56be70b3152ccce651330ba"

URI_aarch64_qt6-qtwayland = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwayland-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwayland}"
SRC_URI[aarch64_qt6-qtwayland.sha256sum] = "b817b46af6d7dc5070567cd47c2402a3ff38676941e78c124b901a58201db40c"

URI_aarch64_qt6-qtwayland-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwayland-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwayland-devel}"
SRC_URI[aarch64_qt6-qtwayland-devel.sha256sum] = "145e16a484665b7ebe4f8744cdc0760d8f6c03ac70b67903202c4604d4bbcd93"

URI_aarch64_qt6-qtwayland-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtwayland-examples-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwayland-examples}"
SRC_URI[aarch64_qt6-qtwayland-examples.sha256sum] = "77ee6fb820cc783081fa0893bccaa337f194c15008b0feeeb4b88d9552b340f8"

RDEPENDS:qt6-qtwayland = " \
 glibc \
 libglvnd-egl \
 libglvnd-opengl \
 libstdc++ \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:qt6-qtwayland-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtwayland \
 "
RDEPENDS:qt6-qtwayland-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
