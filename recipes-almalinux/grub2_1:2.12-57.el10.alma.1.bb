# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2"
PE = "1"
PV = "2.12"
PR = "57.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 grub2-common \
 grub2-efi-aa64-modules \
 grub2-efi-x64 \
 grub2-efi-x64-cdboot \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-ppc64le-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
"
PACKAGES:aarch64 = " \
 grub2-common \
 grub2-efi-aa64 \
 grub2-efi-aa64-cdboot \
 grub2-efi-aa64-modules \
 grub2-efi-x64-modules \
 grub2-pc-modules \
 grub2-ppc64le-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/grub2-2.12-57.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3722679cefe395f0c33a778bade0fcfe6496476af892334a9b062dcd1d4bc035"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-common-2.12-57.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-common;unpack=0"
SRC_URI[x86_64_v2_grub2-common.sha256sum] = "e481f383357c693d8c9ee40712cc8d31bbf2959cb462d7bd4f7aaa63af82f6c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-aa64-modules-2.12-57.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-aa64-modules;unpack=0"
SRC_URI[x86_64_v2_grub2-efi-aa64-modules.sha256sum] = "864c114dfa01a26941cf86a0578e36a55bb35315ca5227a0b588a6cac8a00fe4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-2.12-57.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64;unpack=0"
SRC_URI[x86_64_v2_grub2-efi-x64.sha256sum] = "b737b22bff8c360685427f931d15618b7cd5eab9eb9805ba67a38a3a0f379377"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-cdboot-2.12-57.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64-cdboot;unpack=0"
SRC_URI[x86_64_v2_grub2-efi-x64-cdboot.sha256sum] = "97c1d8563281b184af79c305e51e89b889bae13f5735d25d905c9f5b4ca1f6c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-modules-2.12-57.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-x64-modules;unpack=0"
SRC_URI[x86_64_v2_grub2-efi-x64-modules.sha256sum] = "6cc0ac334ead64e6f429f512fbe8297633d916425669d6bfce34c28df200717f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-2.12-57.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-pc;unpack=0"
SRC_URI[x86_64_v2_grub2-pc.sha256sum] = "a91d4ed2172e929eb68dfd7577c463d4d7f7fac9137d111d9271e5cb17311d8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-modules-2.12-57.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-pc-modules;unpack=0"
SRC_URI[x86_64_v2_grub2-pc-modules.sha256sum] = "d6886aa46ab7ba7bef5a91f8646d8d38f294266f2f608e5f19f367bd04a166c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-ppc64le-modules-2.12-57.el10.alma.1.noarch.rpm;name=x86_64_v2_grub2-ppc64le-modules;unpack=0"
SRC_URI[x86_64_v2_grub2-ppc64le-modules.sha256sum] = "b65d0818f8b86aae0b647138186da72a06f9fb5189cb0ab372dabad5a27fc29e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-2.12-57.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools;unpack=0"
SRC_URI[x86_64_v2_grub2-tools.sha256sum] = "ce74f55ac98bd94b80cd9152e7b0972ebf66d9cc1be06bf98453ee2255ae6cca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-efi-2.12-57.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-efi;unpack=0"
SRC_URI[x86_64_v2_grub2-tools-efi.sha256sum] = "ecb2f170e6ddcb779cb2072745f49f91e01b6f6d905179738a0a746e1948052c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-extra-2.12-57.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-extra;unpack=0"
SRC_URI[x86_64_v2_grub2-tools-extra.sha256sum] = "8b964cd901ee62a6c1fe30c7b823ce325c2044dc404c597bd76726281517e82b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-minimal-2.12-57.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-minimal;unpack=0"
SRC_URI[x86_64_v2_grub2-tools-minimal.sha256sum] = "be9c45c1c1b95fa7fbd3a98f90b8e1800a94015a49ae59d6f1f9f2604b767b23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-common-2.12-57.el10.alma.1.noarch.rpm;name=aarch64_grub2-common;unpack=0"
SRC_URI[aarch64_grub2-common.sha256sum] = "e481f383357c693d8c9ee40712cc8d31bbf2959cb462d7bd4f7aaa63af82f6c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-2.12-57.el10.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64;unpack=0"
SRC_URI[aarch64_grub2-efi-aa64.sha256sum] = "660faf0d01fabe0df871fffcab70d20064f2e0d3db8c817786b921c0f67ed0c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-cdboot-2.12-57.el10.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64-cdboot;unpack=0"
SRC_URI[aarch64_grub2-efi-aa64-cdboot.sha256sum] = "feb03395b3a9681d8ed0a387eb9a49e06ea89e2110a1e7260586b14c61e523ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-modules-2.12-57.el10.alma.1.noarch.rpm;name=aarch64_grub2-efi-aa64-modules;unpack=0"
SRC_URI[aarch64_grub2-efi-aa64-modules.sha256sum] = "864c114dfa01a26941cf86a0578e36a55bb35315ca5227a0b588a6cac8a00fe4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-x64-modules-2.12-57.el10.alma.1.noarch.rpm;name=aarch64_grub2-efi-x64-modules;unpack=0"
SRC_URI[aarch64_grub2-efi-x64-modules.sha256sum] = "6cc0ac334ead64e6f429f512fbe8297633d916425669d6bfce34c28df200717f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-pc-modules-2.12-57.el10.alma.1.noarch.rpm;name=aarch64_grub2-pc-modules;unpack=0"
SRC_URI[aarch64_grub2-pc-modules.sha256sum] = "d6886aa46ab7ba7bef5a91f8646d8d38f294266f2f608e5f19f367bd04a166c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-ppc64le-modules-2.12-57.el10.alma.1.noarch.rpm;name=aarch64_grub2-ppc64le-modules;unpack=0"
SRC_URI[aarch64_grub2-ppc64le-modules.sha256sum] = "b65d0818f8b86aae0b647138186da72a06f9fb5189cb0ab372dabad5a27fc29e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-2.12-57.el10.alma.1.aarch64.rpm;name=aarch64_grub2-tools;unpack=0"
SRC_URI[aarch64_grub2-tools.sha256sum] = "1e781bcd6cfbe1bf45452ee26807e9b0ee7888be9f2c3dd3b8f6c9338f067307"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-extra-2.12-57.el10.alma.1.aarch64.rpm;name=aarch64_grub2-tools-extra;unpack=0"
SRC_URI[aarch64_grub2-tools-extra.sha256sum] = "4ddc5c792746cea747a6db5bade08fcc424757559d72a31da67395ba5fff31a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-minimal-2.12-57.el10.alma.1.aarch64.rpm;name=aarch64_grub2-tools-minimal;unpack=0"
SRC_URI[aarch64_grub2-tools-minimal.sha256sum] = "d1a1099dbec00e65fe32f120148d549c682cbdf7d48c80b728b42342bfe5a51d"

RDEPENDS:grub2-common = " \
 bash \
 grep \
 util-linux-core \
 virtual/coreutils \
 "
RDEPENDS:grub2-efi-aa64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64 = " \
 bash \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-x64-cdboot = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-pc = " \
 bash \
 dracut \
 file \
 gettext-runtime \
 grub2-common \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-minimal \
 which \
 "
RDEPENDS:grub2-pc-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-ppc64le-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-tools = " \
 bash \
 device-mapper-libs \
 dracut \
 file \
 gettext-runtime \
 glibc \
 grep \
 grub2-common \
 os-prober \
 sed \
 systemd \
 xz-libs \
 "
RDEPENDS:grub2-tools-efi = " \
 device-mapper-libs \
 file \
 gettext-runtime \
 glibc \
 grub2-common \
 os-prober \
 "
RDEPENDS:grub2-tools-extra = " \
 bash \
 device-mapper-libs \
 file \
 freetype \
 gettext-runtime \
 glibc \
 grub2-common \
 grub2-tools-minimal \
 mtools \
 os-prober \
 xz-libs \
 "
RDEPENDS:grub2-tools-minimal = " \
 bash \
 device-mapper-libs \
 fuse-libs \
 gettext-runtime \
 glibc \
 grub2-common \
 xz-libs \
 "
RDEPENDS:grub2-efi-aa64 = " \
 bash \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-aa64-cdboot = " \
 grub2-common \
 "
