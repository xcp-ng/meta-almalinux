# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-kde"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 xdg-desktop-portal-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xdg-desktop-portal-kde-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "729ced11613fd719b7e66912a9cc11082fe38bcb45cddab1ccf6976692abeb97"

URI_x86_64_v2_xdg-desktop-portal-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdg-desktop-portal-kde-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal-kde}"
SRC_URI[x86_64_v2_xdg-desktop-portal-kde.sha256sum] = "49e360b6a432cc5fa9f8bf38265024dc2a6f86be812504b701b79cf44f4a16bc"

URI_aarch64_xdg-desktop-portal-kde = "${EPEL_MIRROR}/aarch64/Packages/x/xdg-desktop-portal-kde-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_xdg-desktop-portal-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal-kde}"
SRC_URI[aarch64_xdg-desktop-portal-kde.sha256sum] = "ecff1b144ed86482dc11cd6d03d7b72deb2004cad736593f2149283bada04574"

RDEPENDS:xdg-desktop-portal-kde = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kwayland \
 libstdc++ \
 libwayland-client \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 xdg-desktop-portal \
 xdg-desktop-portal-gtk \
 "
