# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-filesystem"
PV = "1.8.0"
PR = "14.el10_0"
PACKAGES = " \
 lua-filesystem \
 lua5.1-filesystem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-filesystem-1.8.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6cffacf7804d6f39214919f6ee142e77bbe316fc820a7aed9409efe39ac7660"

URI_x86_64_v2_lua-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-filesystem-1.8.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-filesystem}"
SRC_URI[x86_64_v2_lua-filesystem.sha256sum] = "2b21137e4e72e64ce9ef5433218c3e3f49101734bc31d7fb0e91c75bf38569e2"

URI_x86_64_v2_lua5.1-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua5.1-filesystem-1.8.0-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua5.1-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua5.1-filesystem}"
SRC_URI[x86_64_v2_lua5.1-filesystem.sha256sum] = "7e9e24589b2a8197be0931b28eee0a3c674f066bb4b1245e0dd534a3df461ee9"

URI_aarch64_lua-filesystem = "${EPEL_MIRROR}/aarch64/Packages/l/lua-filesystem-1.8.0-14.el10_0.aarch64.rpm;name=aarch64_lua-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-filesystem}"
SRC_URI[aarch64_lua-filesystem.sha256sum] = "9746918ada13199a38d1fa6452d67ccb6513ff6a833dccc5b77d8eb4b73ed944"

URI_aarch64_lua5.1-filesystem = "${EPEL_MIRROR}/aarch64/Packages/l/lua5.1-filesystem-1.8.0-14.el10_0.aarch64.rpm;name=aarch64_lua5.1-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua5.1-filesystem}"
SRC_URI[aarch64_lua5.1-filesystem.sha256sum] = "74ffe87f4cf2ce4cc4b9b6471ebca112d01d831c224becaa6fd665d9f3f2ec64"

RDEPENDS:lua-filesystem = " \
 glibc \
 lua-libs \
 "
RDEPENDS:lua5.1-filesystem = " \
 compat-lua-libs \
 glibc \
 "
