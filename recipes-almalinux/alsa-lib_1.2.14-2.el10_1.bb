# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-lib"
PV = "1.2.14"
PR = "2.el10_1"
PACKAGES = " \
 alsa-lib \
 alsa-lib-devel \
 alsa-ucm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-lib-1.2.14-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8fd9dd6d58f595be42c10f2c41e73fbcc8725c92da42e25f0ede7cbf581b46a"

URI_x86_64_v2_alsa-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-lib-1.2.14-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_alsa-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-lib}"
SRC_URI[x86_64_v2_alsa-lib.sha256sum] = "e7012aa9a76c20091ac40872f75cfc555012f41138516974312e921c6a4ca80a"

URI_x86_64_v2_alsa-lib-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-lib-devel-1.2.14-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_alsa-lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-lib-devel}"
SRC_URI[x86_64_v2_alsa-lib-devel.sha256sum] = "d5b5344a0ec5cfd42418e0d1ed78ebcba911b461de8458c925fd76fe6b1f42e6"

URI_x86_64_v2_alsa-ucm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-ucm-1.2.14-2.el10_1.noarch.rpm;name=x86_64_v2_alsa-ucm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-ucm}"
SRC_URI[x86_64_v2_alsa-ucm.sha256sum] = "627a70b0fee22c548dbcb533fb5e2c53aecebb0b57fc548ec36c61e647dd196f"

URI_aarch64_alsa-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-lib-1.2.14-2.el10_1.aarch64.rpm;name=aarch64_alsa-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-lib}"
SRC_URI[aarch64_alsa-lib.sha256sum] = "67157e2e4abeebc7421bc733485fe3eaa8fa92e12301de7aa3c83d4c3da08549"

URI_aarch64_alsa-lib-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-lib-devel-1.2.14-2.el10_1.aarch64.rpm;name=aarch64_alsa-lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-lib-devel}"
SRC_URI[aarch64_alsa-lib-devel.sha256sum] = "00f3006788aabde17f928a11690d7105a03934ad1be90fdbd618113abbe129d0"

URI_aarch64_alsa-ucm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-ucm-1.2.14-2.el10_1.noarch.rpm;name=aarch64_alsa-ucm;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-ucm}"
SRC_URI[aarch64_alsa-ucm.sha256sum] = "627a70b0fee22c548dbcb533fb5e2c53aecebb0b57fc548ec36c61e647dd196f"

RDEPENDS:alsa-lib = " \
 glibc \
 "
RDEPENDS:alsa-lib-devel = " \
 alsa-lib \
 alsa-lib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:alsa-ucm = " \
 alsa-lib \
 "
