# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbrown0.12"
PV = "0.12.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-hashbrown0.12+ahash-compile-time-rng-devel \
 rust-hashbrown0.12+ahash-devel \
 rust-hashbrown0.12+bumpalo-devel \
 rust-hashbrown0.12+default-devel \
 rust-hashbrown0.12+inline-more-devel \
 rust-hashbrown0.12+raw-devel \
 rust-hashbrown0.12+rayon-devel \
 rust-hashbrown0.12+serde-devel \
 rust-hashbrown0.12-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashbrown0.12-0.12.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f0d23c7a3afe39b080d8fe8be0468a648bf25c81841cb41354dd1d7caa24ac8"

URI_x86_64_v2_rust-hashbrown0.12+ahash-compile-time-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.12+ahash-compile-time-rng-devel-0.12.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.12+ahash-compile-time-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.12+ahash-compile-time-rng-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.12+ahash-compile-time-rng-devel.sha256sum] = "fc62a961f03340b64db4191fc5783af892e815e499032fea26d9f12d1ef4f046"

URI_x86_64_v2_rust-hashbrown0.12+ahash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.12+ahash-devel-0.12.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.12+ahash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.12+ahash-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.12+ahash-devel.sha256sum] = "2cf960af321d43fe3c9cfed1e5f77ee4da5240d09d189db03b99758bfb254a2b"

URI_x86_64_v2_rust-hashbrown0.12+bumpalo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.12+bumpalo-devel-0.12.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.12+bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.12+bumpalo-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.12+bumpalo-devel.sha256sum] = "b625fbbada4def0826b77c04ef543c4453928da376b432622d64fb0c4fdb23ba"

URI_x86_64_v2_rust-hashbrown0.12+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.12+default-devel-0.12.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.12+default-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.12+default-devel.sha256sum] = "95a010dde1bb931dd9f20c3af283ac5e611a72e912ba96523939c82788b02348"
RPROVIDES:rust-hashbrown0.12+default-devel:x86_64_v2 = "virtual/crate_hashbrown/default__ge_0.9.0_with_crate_hashbrown/default__lt_0.15.0~"

URI_x86_64_v2_rust-hashbrown0.12+inline-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.12+inline-more-devel-0.12.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.12+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.12+inline-more-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.12+inline-more-devel.sha256sum] = "05ac0899967295e72e58a3e279e36ded27266a87e386bdba4b2aa30ceb83e616"

URI_x86_64_v2_rust-hashbrown0.12+raw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.12+raw-devel-0.12.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.12+raw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.12+raw-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.12+raw-devel.sha256sum] = "aecb99a7c2dacd38e66b418c2745660bdb7b689b292d6252949c31d026da465e"

URI_x86_64_v2_rust-hashbrown0.12+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.12+rayon-devel-0.12.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.12+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.12+rayon-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.12+rayon-devel.sha256sum] = "910cc88e5f76a81cc46ae6edde91c59e4ebe2db7d8c24222be6128c0eaa243b6"

URI_x86_64_v2_rust-hashbrown0.12+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.12+serde-devel-0.12.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.12+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.12+serde-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.12+serde-devel.sha256sum] = "1a2fbf80034141a8d0f2529a8672ef4d66cbd6b96d6af2325f62f9436d432765"

URI_x86_64_v2_rust-hashbrown0.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown0.12-devel-0.12.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown0.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown0.12-devel}"
SRC_URI[x86_64_v2_rust-hashbrown0.12-devel.sha256sum] = "ab950f44ef8d07f419935276f7aacb6f3ab3edcbb6930deb78abcaf96234a0b0"

URI_aarch64_rust-hashbrown0.12+ahash-compile-time-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.12+ahash-compile-time-rng-devel-0.12.3-4.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.12+ahash-compile-time-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.12+ahash-compile-time-rng-devel}"
SRC_URI[aarch64_rust-hashbrown0.12+ahash-compile-time-rng-devel.sha256sum] = "2f6b50db7da8e1ef6306f37eabcdf88a906d4e1e11d3cadc77f8ed7f5b28a099"

URI_aarch64_rust-hashbrown0.12+ahash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.12+ahash-devel-0.12.3-4.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.12+ahash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.12+ahash-devel}"
SRC_URI[aarch64_rust-hashbrown0.12+ahash-devel.sha256sum] = "6803dd19163e50a04c8a5f5d3be1399aadc9c3257804576fba8e8a95c2b113a0"

URI_aarch64_rust-hashbrown0.12+bumpalo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.12+bumpalo-devel-0.12.3-4.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.12+bumpalo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.12+bumpalo-devel}"
SRC_URI[aarch64_rust-hashbrown0.12+bumpalo-devel.sha256sum] = "44f46590e3e846fe3ad3e5b1d9eb99898f5146e3cabcab03170ce532b20dbb18"

URI_aarch64_rust-hashbrown0.12+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.12+default-devel-0.12.3-4.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.12+default-devel}"
SRC_URI[aarch64_rust-hashbrown0.12+default-devel.sha256sum] = "7146376faf5037c87edb5a219d5ffb0e02355fa2e4bb3ac626fc02ac532c25ee"
RPROVIDES:rust-hashbrown0.12+default-devel:aarch64 = "virtual/crate_hashbrown/default__ge_0.9.0_with_crate_hashbrown/default__lt_0.15.0~"

URI_aarch64_rust-hashbrown0.12+inline-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.12+inline-more-devel-0.12.3-4.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.12+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.12+inline-more-devel}"
SRC_URI[aarch64_rust-hashbrown0.12+inline-more-devel.sha256sum] = "597a52424d698ee6e5cdd68e14df235c057cd9582f91a238f4c9459354645614"

URI_aarch64_rust-hashbrown0.12+raw-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.12+raw-devel-0.12.3-4.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.12+raw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.12+raw-devel}"
SRC_URI[aarch64_rust-hashbrown0.12+raw-devel.sha256sum] = "819d21536c6946f13620e8308b789769528fb23a041753552a79b61650e1e36c"

URI_aarch64_rust-hashbrown0.12+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.12+rayon-devel-0.12.3-4.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.12+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.12+rayon-devel}"
SRC_URI[aarch64_rust-hashbrown0.12+rayon-devel.sha256sum] = "e671f389a977e150c5075fb7133a3ff3cf6530c6db03bdb428aba5df6901daf9"

URI_aarch64_rust-hashbrown0.12+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.12+serde-devel-0.12.3-4.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.12+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.12+serde-devel}"
SRC_URI[aarch64_rust-hashbrown0.12+serde-devel.sha256sum] = "0938c04b65c7edb1ec554a4db518a31ad98a27fa88dc7ce6c314da68e0503d3f"

URI_aarch64_rust-hashbrown0.12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown0.12-devel-0.12.3-4.el10_0.noarch.rpm;name=aarch64_rust-hashbrown0.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown0.12-devel}"
SRC_URI[aarch64_rust-hashbrown0.12-devel.sha256sum] = "00700167821e0c4590080c8b84bd0671fe14a871bdbfafba203afe45e9480464"

RDEPENDS:rust-hashbrown0.12+ahash-compile-time-rng-devel = " \
 cargo \
 rust-ahash0.7+compile-time-rng-devel \
 rust-ahash0.7-devel \
 rust-hashbrown0.12-devel \
 "
RDEPENDS:rust-hashbrown0.12+ahash-devel = " \
 cargo \
 rust-ahash0.7-devel \
 rust-hashbrown0.12-devel \
 "
RDEPENDS:rust-hashbrown0.12+bumpalo-devel = " \
 cargo \
 rust-bumpalo+default-devel \
 rust-hashbrown0.12-devel \
 "
RDEPENDS:rust-hashbrown0.12+default-devel = " \
 cargo \
 rust-hashbrown0.12+ahash-devel \
 rust-hashbrown0.12+inline-more-devel \
 rust-hashbrown0.12-devel \
 "
RDEPENDS:rust-hashbrown0.12+inline-more-devel = " \
 cargo \
 rust-hashbrown0.12-devel \
 "
RDEPENDS:rust-hashbrown0.12+raw-devel = " \
 cargo \
 rust-hashbrown0.12-devel \
 "
RDEPENDS:rust-hashbrown0.12+rayon-devel = " \
 cargo \
 rust-hashbrown0.12-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-hashbrown0.12+serde-devel = " \
 cargo \
 rust-hashbrown0.12-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-hashbrown0.12-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_hashbrown/default__ge_0.9.0_with_crate_hashbrown/default__lt_0.15.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_hashbrown/default__ge_0.9.0_with_crate_hashbrown/default__lt_0.15.0~"
