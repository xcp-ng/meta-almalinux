# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-ronn-ng"
PV = "0.10.1"
PR = "4.el10_0"
PACKAGES = " \
 rubygem-ronn-ng \
 rubygem-ronn-ng-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-ronn-ng-0.10.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88c25eb086783bed5cd56048a4bc5fe26d863e7b36f816d46373768a771f3fee"

URI_x86_64_v2_rubygem-ronn-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-ronn-ng-0.10.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-ronn-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-ronn-ng}"
SRC_URI[x86_64_v2_rubygem-ronn-ng.sha256sum] = "cc69f58255256dfc2b6e99b328891bf870e45c4c678ab3169141abdd2f4952a2"

URI_x86_64_v2_rubygem-ronn-ng-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-ronn-ng-doc-0.10.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-ronn-ng-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-ronn-ng-doc}"
SRC_URI[x86_64_v2_rubygem-ronn-ng-doc.sha256sum] = "a3004a9bd95f849396cd6d6442daa5d42ab4da96b9fd99fe935546c2a36bea61"

URI_aarch64_rubygem-ronn-ng = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-ronn-ng-0.10.1-4.el10_0.noarch.rpm;name=aarch64_rubygem-ronn-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-ronn-ng}"
SRC_URI[aarch64_rubygem-ronn-ng.sha256sum] = "27e85c8aa1a30e8b5a527d0186dfaa5a72c5605c3a16e5f7a502cc945ba89564"

URI_aarch64_rubygem-ronn-ng-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-ronn-ng-doc-0.10.1-4.el10_0.noarch.rpm;name=aarch64_rubygem-ronn-ng-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-ronn-ng-doc}"
SRC_URI[aarch64_rubygem-ronn-ng-doc.sha256sum] = "1fdd6714297d5a1fe94020f465ef79221ce208e0b6bb82acae27658b19e655c6"

RDEPENDS:rubygem-ronn-ng = " \
 groff-base \
 ruby \
 rubygem-kramdown \
 rubygem-kramdown-parser-gfm \
 rubygem-mustache \
 rubygem-nokogiri \
 rubygems \
 "
RDEPENDS:rubygem-ronn-ng-doc = " \
 rubygem-ronn-ng \
 "
