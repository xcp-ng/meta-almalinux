# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setroubleshoot-plugins"
PV = "3.3.14"
PR = "11.el10"
PACKAGES = " \
 setroubleshoot-plugins \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/setroubleshoot-plugins-3.3.14-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "463c67006b3fb0c556b25a4e48967712e980b77c2198212dfea3e967e5ce3731"

URI_x86_64_v2_setroubleshoot-plugins = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-plugins-3.3.14-11.el10.noarch.rpm;name=x86_64_v2_setroubleshoot-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setroubleshoot-plugins}"
SRC_URI[x86_64_v2_setroubleshoot-plugins.sha256sum] = "d9b25a073ce7ccb033370de1798fcb20bf013dc7710dbd6c198aa69f92734e07"

URI_aarch64_setroubleshoot-plugins = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-plugins-3.3.14-11.el10.noarch.rpm;name=aarch64_setroubleshoot-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_setroubleshoot-plugins}"
SRC_URI[aarch64_setroubleshoot-plugins.sha256sum] = "d9b25a073ce7ccb033370de1798fcb20bf013dc7710dbd6c198aa69f92734e07"

RDEPENDS:setroubleshoot-plugins = " \
 setroubleshoot-server \
 "
