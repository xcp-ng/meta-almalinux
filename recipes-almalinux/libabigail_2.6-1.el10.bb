# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libabigail"
PV = "2.6"
PR = "1.el10"
PACKAGES = " \
 libabigail \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/libabigail-2.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "655c8c9f593ecca67e64af551699709325bb4751d7b64d23e789b08f945fbe16"

URI_x86_64_v2_libabigail = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libabigail-2.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_libabigail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libabigail}"
SRC_URI[x86_64_v2_libabigail.sha256sum] = "6e9aa3ba0014b7cfda232fea5a577388afb23c45aed109a3187755df36da54bd"

URI_aarch64_libabigail = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libabigail-2.6-1.el10.aarch64.rpm;name=aarch64_libabigail;unpack=0"
SRC_URI:append = " ${URI_aarch64_libabigail}"
SRC_URI[aarch64_libabigail.sha256sum] = "d4b3f7da041d502da3adcd4b2e2f88bac0aa4657631e371de1297b3e741b77f3"

RDEPENDS:libabigail = " \
 binutils \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 libxml2 \
 "
