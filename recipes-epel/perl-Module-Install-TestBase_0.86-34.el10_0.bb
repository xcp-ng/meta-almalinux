# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-TestBase"
PV = "0.86"
PR = "34.el10_0"
PACKAGES = " \
 perl-Module-Install-TestBase \
 perl-Module-Install-TestBase-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Install-TestBase-0.86-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2871b531f0b9cbb0bc82a0ce19c24957a12071c2e1d259d28b71c30e2ec294d9"

URI_x86_64_v2_perl-Module-Install-TestBase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-TestBase-0.86-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-TestBase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-TestBase}"
SRC_URI[x86_64_v2_perl-Module-Install-TestBase.sha256sum] = "59d278b44c116473b458ec82856b4a6659565487cc197e34c2a2ca8c37c04b97"

URI_x86_64_v2_perl-Module-Install-TestBase-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-TestBase-tests-0.86-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-TestBase-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-TestBase-tests}"
SRC_URI[x86_64_v2_perl-Module-Install-TestBase-tests.sha256sum] = "9063f6d197404d7ef62b3634a40c249133ba0cd7c20c277a8ee3fb8af6214f05"

URI_aarch64_perl-Module-Install-TestBase = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-TestBase-0.86-34.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-TestBase;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-TestBase}"
SRC_URI[aarch64_perl-Module-Install-TestBase.sha256sum] = "b77589ccfc8bb471082fb24cb39159d3f4d42c7e0d628a581bc8ae5f14ae2378"

URI_aarch64_perl-Module-Install-TestBase-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-TestBase-tests-0.86-34.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-TestBase-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-TestBase-tests}"
SRC_URI[aarch64_perl-Module-Install-TestBase-tests.sha256sum] = "d09757f03db71a0af9afff70b8c35670497cdfecd9a4b5c26153b4f9d0850c9b"

RDEPENDS:perl-Module-Install-TestBase = " \
 perl-Filter \
 perl-Module-Install \
 perl-Spiffy \
 perl-Test-Base \
 perl-Test-Simple \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Module-Install-TestBase-tests = " \
 bash \
 perl-File-Find \
 perl-Module-Install-TestBase \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 "
