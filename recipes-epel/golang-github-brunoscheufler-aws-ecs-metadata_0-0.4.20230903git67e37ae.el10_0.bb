# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-brunoscheufler-aws-ecs-metadata"
PV = "0"
PR = "0.4.20230903git67e37ae.el10_0"
PACKAGES = " \
 golang-github-brunoscheufler-aws-ecs-metadata-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-brunoscheufler-aws-ecs-metadata-0-0.4.20230903git67e37ae.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0e4f9d412e0783155056ff9b8d2d4752df67ab4a050d85fb9098e4fce6a7d37"

URI_aarch64_golang-github-brunoscheufler-aws-ecs-metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-brunoscheufler-aws-ecs-metadata-devel-0-0.4.20230903git67e37ae.el10_0.noarch.rpm;name=aarch64_golang-github-brunoscheufler-aws-ecs-metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-brunoscheufler-aws-ecs-metadata-devel}"
SRC_URI[aarch64_golang-github-brunoscheufler-aws-ecs-metadata-devel.sha256sum] = "6cf42b48ebf613086210b3f86bdc4bdbbfdcdf6a75a04240bf4c88dbffb81866"

RDEPENDS:golang-github-brunoscheufler-aws-ecs-metadata-devel = " \
 go-filesystem \
 "
