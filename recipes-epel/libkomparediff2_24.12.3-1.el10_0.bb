# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkomparediff2"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkomparediff2 \
 libkomparediff2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkomparediff2-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ea6b1154a9df279b5fa5ce2668185244d34c0686bd15ddb8a43e3e0c993f8ff"

URI_x86_64_v2_libkomparediff2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkomparediff2-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkomparediff2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkomparediff2}"
SRC_URI[x86_64_v2_libkomparediff2.sha256sum] = "74aafa299ea3051f5a95be421c03d8dc5e1753aa84aef05fdcdc454190c79144"

URI_x86_64_v2_libkomparediff2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkomparediff2-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkomparediff2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkomparediff2-devel}"
SRC_URI[x86_64_v2_libkomparediff2-devel.sha256sum] = "263897e55412f08dba04b4a290617b188d71ba5c5861d91d3c342066d5c050be"

URI_aarch64_libkomparediff2 = "${EPEL_MIRROR}/aarch64/Packages/l/libkomparediff2-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkomparediff2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkomparediff2}"
SRC_URI[aarch64_libkomparediff2.sha256sum] = "ade9609829968a4c59b2dbc0b4ebad22dbfc08afc882e191da58b762e88562c4"

URI_aarch64_libkomparediff2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkomparediff2-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkomparediff2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkomparediff2-devel}"
SRC_URI[aarch64_libkomparediff2-devel.sha256sum] = "0a5dd1b6e2f38f146d8f8b53495969df2ea8fa16da10c71a1751562b3cc66fe1"

RDEPENDS:libkomparediff2 = " \
 diffutils \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkomparediff2-devel = " \
 cmake \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kxmlgui-devel \
 libkomparediff2 \
 qt6-qtbase-devel \
 "
