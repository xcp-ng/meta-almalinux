# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zcfan"
PV = "1.4.0"
PR = "3.el10_0"
PACKAGES:x86_64_v2 = " \
 zcfan \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/z/zcfan-1.4.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e47872f50357ac70d01791479645e730391a563837a893a1b2a459b7f255b22"

URI_x86_64_v2_zcfan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zcfan-1.4.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zcfan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zcfan}"
SRC_URI[x86_64_v2_zcfan.sha256sum] = "422a90a07656728d34028b815e4cd95c68d2724ae8b6df1a7709a3c7bb9b61fc"

RDEPENDS:zcfan = " \
 bash \
 glibc \
 "
