# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GraphViz"
PV = "2.26"
PR = "5.el10_0"
PACKAGES = " \
 perl-GraphViz \
 perl-GraphViz-XML \
 perl-GraphViz-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GraphViz-2.26-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "024b733e997540e251ed1c90d88544b3e908f9d073594d573a06b1873c1f149e"

URI_x86_64_v2_perl-GraphViz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GraphViz-2.26-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GraphViz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GraphViz}"
SRC_URI[x86_64_v2_perl-GraphViz.sha256sum] = "b5fd56e7c9cc105cceefde7dbfd73154ccb3753d3494103c3496288b9ef942fe"

URI_x86_64_v2_perl-GraphViz-XML = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GraphViz-XML-2.26-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GraphViz-XML;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GraphViz-XML}"
SRC_URI[x86_64_v2_perl-GraphViz-XML.sha256sum] = "fb72e2fa4d3a594035d5989e9c350eff8ef4ba9a0cd9c797c00a9960696e89e1"

URI_x86_64_v2_perl-GraphViz-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GraphViz-tests-2.26-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GraphViz-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GraphViz-tests}"
SRC_URI[x86_64_v2_perl-GraphViz-tests.sha256sum] = "7901a0a2e027e0e290369cd0e4db71cbe4f540cb9358f9c102ccb395c34a62ce"

URI_aarch64_perl-GraphViz = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GraphViz-2.26-5.el10_0.noarch.rpm;name=aarch64_perl-GraphViz;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GraphViz}"
SRC_URI[aarch64_perl-GraphViz.sha256sum] = "958d701e1049389a28738c0623df93a4edf701dfc81d0566e133688dbe6477ed"

URI_aarch64_perl-GraphViz-XML = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GraphViz-XML-2.26-5.el10_0.noarch.rpm;name=aarch64_perl-GraphViz-XML;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GraphViz-XML}"
SRC_URI[aarch64_perl-GraphViz-XML.sha256sum] = "0ade67b355e3c3c9594ec39fabf2b2d7952836821ec4e837f088da1836dbf60e"

URI_aarch64_perl-GraphViz-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GraphViz-tests-2.26-5.el10_0.noarch.rpm;name=aarch64_perl-GraphViz-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GraphViz-tests}"
SRC_URI[aarch64_perl-GraphViz-tests.sha256sum] = "d8f934d42b6141ac8d3deb37f88d22ad0fe3e6a8cfeaff2342a36349461dd1f9"

RDEPENDS:perl-GraphViz = " \
 graphviz \
 perl-Carp \
 perl-GraphViz \
 perl-IPC-Run \
 perl-Parse-RecDescent \
 perl-Time-HiRes \
 perl-lib \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-GraphViz-XML = " \
 perl-Carp \
 perl-GraphViz \
 perl-XML-Twig \
 perl-lib \
 perl-libs \
 "
RDEPENDS:perl-GraphViz-tests = " \
 bash \
 perl-File-Which \
 perl-GraphViz \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
