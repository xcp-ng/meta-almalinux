# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpimtextedit"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kpimtextedit \
 kpimtextedit-devel \
 kpimtextedit-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kpimtextedit-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f8aeab0a248f4838ffeac39ce9de8af7339fd1c067ccfb609c31d43a1ff745f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit;unpack=0"
SRC_URI[x86_64_v2_kpimtextedit.sha256sum] = "7bbcb17047714bf978e8dfac2f4da4c031771b8fad34dabd03a4d1c66553016b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpimtextedit-devel;unpack=0"
SRC_URI[x86_64_v2_kpimtextedit-devel.sha256sum] = "53de15a59870c2cde5e755b5de92b43b2d64eabe989e510261ee96896a8a8ad2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpimtextedit-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kpimtextedit-doc;unpack=0"
SRC_URI[x86_64_v2_kpimtextedit-doc.sha256sum] = "838faf632960b1338868fb1b59640550be8085567427b00ff7caf671da99452d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kpimtextedit;unpack=0"
SRC_URI[aarch64_kpimtextedit.sha256sum] = "5bd9a34eee79e75b262a233071d2105e11529764d9d4d333e82048f323609a3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kpimtextedit-devel;unpack=0"
SRC_URI[aarch64_kpimtextedit-devel.sha256sum] = "7eb8cf0bc59415a34abbe0edc0cc8599ab1dc8c85ec6602bc419ce61db0c6a4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpimtextedit-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kpimtextedit-doc;unpack=0"
SRC_URI[aarch64_kpimtextedit-doc.sha256sum] = "111b1789207a6c4b51d8a615ff6faaf0acfa6013dbcb8ce0c9a71eecf89c0ebf"

RDEPENDS:kpimtextedit = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpimtextedit-devel = " \
 cmake-filesystem \
 kf6-ktextwidgets-devel \
 kpimtextedit \
 "
RDEPENDS:kpimtextedit-doc = " \
 "
