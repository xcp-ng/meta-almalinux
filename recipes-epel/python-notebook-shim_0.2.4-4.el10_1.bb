# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-notebook-shim"
PV = "0.2.4"
PR = "4.el10_1"
PACKAGES = " \
 python3-notebook-shim \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-notebook-shim-0.2.4-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d17581ab027968d761fad182437d80f307eb1ebbc872df08cb12edfb3b86450"

URI_x86_64_v2_python3-notebook-shim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-notebook-shim-0.2.4-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-notebook-shim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-notebook-shim}"
SRC_URI[x86_64_v2_python3-notebook-shim.sha256sum] = "f75ccc44de2bcc600e7ee732c46f7a311a612798370c579debbfb6823e8246e7"

URI_aarch64_python3-notebook-shim = "${EPEL_MIRROR}/aarch64/Packages/p/python3-notebook-shim-0.2.4-4.el10_1.noarch.rpm;name=aarch64_python3-notebook-shim;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-notebook-shim}"
SRC_URI[aarch64_python3-notebook-shim.sha256sum] = "f0acba5e6a46cadbade0864cbd2e7b170ac941555ec6563fd1892dd65dc98683"

RDEPENDS:python3-notebook-shim = " \
 python-jupyter-filesystem \
 python3 \
 python3-jupyter-server \
 "
