# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "markdownpart"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 markdownpart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/markdownpart-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c74c3be7a6c066793c1e557f884f6ad80c12b39e0da5724b550831b3830f5f8e"

URI_x86_64_v2_markdownpart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/markdownpart-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_markdownpart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_markdownpart}"
SRC_URI[x86_64_v2_markdownpart.sha256sum] = "4b4e6220d77ec0ed89e7c7670e7994733f6261deed4919dca5c335d68382a832"

URI_aarch64_markdownpart = "${EPEL_MIRROR}/aarch64/Packages/m/markdownpart-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_markdownpart;unpack=0"
SRC_URI:append = " ${URI_aarch64_markdownpart}"
SRC_URI[aarch64_markdownpart.sha256sum] = "5e9882d56bda9e77a3d664ff87e0d533a36dc5805d08149273a8f5bdbcc010b5"

RDEPENDS:markdownpart = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
