# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nordugrid-arc7"
PV = "7.2.0"
PR = "1.el10_3"
PACKAGES = " \
 nordugrid-arc7 \
 nordugrid-arc7-arc-exporter \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-archery-manage \
 nordugrid-arc7-arex \
 nordugrid-arc7-arex-lrms-contrib \
 nordugrid-arc7-client \
 nordugrid-arc7-community-rtes \
 nordugrid-arc7-datadelivery-service \
 nordugrid-arc7-devel \
 nordugrid-arc7-hed \
 nordugrid-arc7-infosys-ldap \
 nordugrid-arc7-monitor \
 nordugrid-arc7-plugins-gfal \
 nordugrid-arc7-plugins-globus \
 nordugrid-arc7-plugins-globus-common \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-internal \
 nordugrid-arc7-plugins-lcas-lcmaps \
 nordugrid-arc7-plugins-needed \
 nordugrid-arc7-plugins-python \
 nordugrid-arc7-plugins-s3 \
 nordugrid-arc7-plugins-xrootd \
 nordugrid-arc7-test-utils \
 nordugrid-arc7-wn \
 python3-arcrest \
 python3-nordugrid-arc7 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nordugrid-arc7-7.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "48989cde62d19eed20865043e494a9296da61f3992336b707f57722e45c7f2c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7.sha256sum] = "ebd41af6065b2f7be5734649d553b1d7b327daebdae168282316141587fc3e22"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arc-exporter-7.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arc-exporter.sha256sum] = "c40885c2e1a5c79eba60c4035b448c57cce2220eab908e48f1d9eba52892013a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl.sha256sum] = "1d55d1476beeeffe2cc49a615acc55bfef63467b5389913302856265411ccfee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-service-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl-service.sha256sum] = "8b6dddcf552648cdbd79f5ee2625506bd034ead0df19274f4695fba289240291"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-archery-manage-7.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-archery-manage.sha256sum] = "0f21f3a300c5171c5ae1cd3eb01c0b9f1927012e80029b6689a970f40c3a4f39"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arex;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arex.sha256sum] = "ca9b089a04f6e0a948b5c5b45ff6c2627ae2d64917b9a8f4ce4f1ce14d2b55ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-lrms-contrib-7.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "40b25bddfed3155994bad42e5d1b07489efa9303e4e2517642982ba4722f843a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-client-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-client;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-client.sha256sum] = "66b01b358ee2727639e374a2fa7f85be5fa91ab113f3f3d01447850011564e18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-community-rtes-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-community-rtes.sha256sum] = "e7b5284d8f886aadca1c609585ae212100002498fddb56f8cea4c18d709016c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-datadelivery-service-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-datadelivery-service.sha256sum] = "6133c5ef3c43bfd39b07d0442c99e6c4193ec46f0a62351eced0cb1795454331"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-devel-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-devel;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-devel.sha256sum] = "309aaef79dc62e87e586d82d2344380587a48120b5db174685c9d8a49b9896ca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-hed-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-hed;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-hed.sha256sum] = "2405c0ca2a25a098379c7e9859529c0e9ccc99027e16c2271eed5140160acd9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-infosys-ldap-7.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-infosys-ldap.sha256sum] = "a9c5694b5ad8b6bdaf82a2f108592fe6696f7cd3ebb8d837cbfefc04c960ffe7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-monitor-7.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-monitor;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-monitor.sha256sum] = "cc977eae6561e678e9399716c1e4e5bc9d51f1d60ead077e49e4efe7de1d10ac"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gfal-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gfal.sha256sum] = "ef1b06d249f626794611d778a6e010cf2c63d1227bbcab543fc285f7e7c722b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus.sha256sum] = "929f93cc5dd5a8b33fb442987719fd74ca1a7623fcb33d78e6948a792405b309"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-common-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus-common.sha256sum] = "978db8f1f8cbea5b18cad48a4f32a26ecb86cf60bd376f27e8b946e8969b9e2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gridftp-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gridftp.sha256sum] = "850ed774a047d07230c2fb366c610803b4d46a351ad39427035941abbb2dae07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-internal-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-internal.sha256sum] = "ca6c62a03c968f11056cdbc56c0c08c665382c5f7e6b1d6392a514415686826f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-lcas-lcmaps-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "28799f1bf0d46c2649477e96b368e5cf059191e944a5053310e1e9fd13d64357"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-needed-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-needed.sha256sum] = "ee8dd92e322a9c2b39c59348e9829b86b1bcdddd5e4bbd66dc9cf5067e46d2aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-python-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-python.sha256sum] = "e13ed7a53affdb7ed9d0e0403bc0d064d6166a644be2bd9db3d7e9501a7efbb4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-s3-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-s3.sha256sum] = "b017a99daf5b0729ca6b56f234915b8ebb99a1b600d58fdff0426aa75cb293ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-xrootd-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-xrootd.sha256sum] = "c2428c3e2766ef64a67439b6da46faf1dcdb5ddc70e678cd411013679d77fbe6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-test-utils-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-test-utils;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-test-utils.sha256sum] = "624af9edd120e0c1ada70f367a65cbfff786dd88d6bf2f5e69279ac639d63898"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-wn-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-wn;unpack=0"
SRC_URI[x86_64_v2_nordugrid-arc7-wn.sha256sum] = "9cfed59da79e669d78de7b901b93bbf62a50d78ad6ed8a21153ba0cd0a798f60"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-arcrest-7.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-arcrest;unpack=0"
SRC_URI[x86_64_v2_python3-arcrest.sha256sum] = "08bf8b82ca234a4c2ea1121efd016ed5450da645290ac243d37663ef2b92301a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nordugrid-arc7-7.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-nordugrid-arc7;unpack=0"
SRC_URI[x86_64_v2_python3-nordugrid-arc7.sha256sum] = "018d16b83e854f9f04af2812c477f87e1f5fdbc286364aeed5dde70493622f92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7;unpack=0"
SRC_URI[aarch64_nordugrid-arc7.sha256sum] = "87b0e4182a9f296e17729cc43265d631c3987fbfdc72a08d59bb5bac292d2f0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arc-exporter-7.2.0-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arc-exporter.sha256sum] = "0764a47d5dc7447fc7a6a708f7aa4381eb3dd37616435e340358a3aaedae57a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arcctl.sha256sum] = "17cf25818adb17656dc38f2fadc3c716fcde6cfc18079cfd23ec7cdb807e9a15"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-service-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arcctl-service.sha256sum] = "2cafe70d3f1744ac6095ba39ba7e35a19fa686aa5a36d374b505ec7414295659"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-archery-manage-7.2.0-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-archery-manage.sha256sum] = "3edd290a6be86d1da76a347a628af0a149d2f95d537f7159fb894b39f5a27838"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-arex;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arex.sha256sum] = "6e59628fac9df80c6b6e79f23087b0802223068178bb34ca4f2301a6a4a4676b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-lrms-contrib-7.2.0-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "a55fe948abfffd4f47082116eed06a420e421f85c0454829fe8ca73eff98046b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-client-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-client;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-client.sha256sum] = "0fb65134e922ba2021de361c369eb9bac55811f25c8c9f946e9a0960cb770a31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-community-rtes-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-community-rtes.sha256sum] = "0b4adfea61195250e24e3d20fa2b91f830e90fe6fb7ede8e1c521fbef4cce95c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-datadelivery-service-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-datadelivery-service.sha256sum] = "769b1fa84ac81a0f092763e8081f7f85f1393c45835d37af9704d2cd94cfe4ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-devel-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-devel;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-devel.sha256sum] = "262296b393a7b2068aad5f8242945982b1f08b730bb32c355983ed46a46078bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-hed-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-hed;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-hed.sha256sum] = "54cdf6165cce3ad07199eec81b07ca995d210bcdf78a8c9911d1047fa62c3bb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-infosys-ldap-7.2.0-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-infosys-ldap.sha256sum] = "77f2d6ba0b6c0cfc8188076e3b559f8ae9f9cb76115df337ffa36e4954e9e019"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-monitor-7.2.0-1.el10_3.noarch.rpm;name=aarch64_nordugrid-arc7-monitor;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-monitor.sha256sum] = "f5bbe38f7e8464f28c5b267e77b29031e9e99778b21fe9e3745445558cf4ebc1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gfal-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-gfal.sha256sum] = "db282eca743d148be047fc1a48aa20755f97725021f4e4dc6790b88f1595a815"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus.sha256sum] = "5ea22aaed37b83ee636e8abeace47c588f3d96281abaf05819a223c32fec7d54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-common-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus-common.sha256sum] = "57e40634f67245a07699dbfb27f3fc3efa3eab23cea8a9036f386ba885a457c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gridftp-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-gridftp.sha256sum] = "507436fb3008aaacef1c15a97b9d43604255b73a3f836d33712ba8de6fe3c9f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-internal-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-internal.sha256sum] = "520d24e70ed423f308b441c5dd1c0e603b526587e6903e96c0e71072682bbb1d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-lcas-lcmaps-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "131d7c9ccafa6caf45c0d7168c3f9cce4bdca26f1c904ee964fbda1b1bab1f3f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-needed-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-needed.sha256sum] = "8a36fd0e6f0cc0015af35fe01db6c6a682e8c1c1b9db884e197be09cb9d4cc4e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-python-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-python.sha256sum] = "c04943a9493c78a746f5b9faed0ff893e56443c5c4e4ec08b01822f85bd59132"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-s3-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-s3.sha256sum] = "29cd1e92bdd2f946c99719e42128837bc3cfdba8cf179fabef9d71dc7d416f84"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-xrootd-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-plugins-xrootd.sha256sum] = "ea4bfc80dc2d53ef1715d1edc672d7765a800065d95d481693577a2a4adc9577"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-test-utils-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-test-utils;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-test-utils.sha256sum] = "897299f6e00b7fd12472b33de325554948bb6ab1ad644eb42a9707b62b0cca7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-wn-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_nordugrid-arc7-wn;unpack=0"
SRC_URI[aarch64_nordugrid-arc7-wn.sha256sum] = "9c7aa580db79cfdd7bcab644e06d073fe97cca7bf3e60297efac28a4b6ff8994"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-arcrest-7.2.0-1.el10_3.noarch.rpm;name=aarch64_python3-arcrest;unpack=0"
SRC_URI[aarch64_python3-arcrest.sha256sum] = "ecc179a8b0b6bb12007f90d051592403a7810b7ce42de6f1992e0bbf7079fbe1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-nordugrid-arc7-7.2.0-1.el10_3.aarch64.rpm;name=aarch64_python3-nordugrid-arc7;unpack=0"
SRC_URI[aarch64_python3-nordugrid-arc7.sha256sum] = "245dc798d0b8e1083bd7251d18135cb1af41c9bb0b6f094e51f523a71921efc3"

RDEPENDS:nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 python3 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arc-exporter = " \
 python3 \
 python3-prometheus_client \
 "
RDEPENDS:nordugrid-arc7-arcctl = " \
 nordugrid-arc7 \
 python3 \
 python3-jwcrypto \
 "
RDEPENDS:nordugrid-arc7-arcctl-service = " \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 python3 \
 "
RDEPENDS:nordugrid-arc7-archery-manage = " \
 python3 \
 python3-dns \
 python3-ldap \
 "
RDEPENDS:nordugrid-arc7-arex = " \
 bash \
 findutils \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest-SHA1 \
 perl-DirHandle \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-JSON-XS \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-XML-Simple \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-vars \
 procps-ng \
 python3 \
 sqlite-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arex-lrms-contrib = " \
 bash \
 nordugrid-arc7-arex \
 perl-DBI \
 perl-Data-Dumper \
 perl-Exporter \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-XML-Simple \
 perl-libs \
 "
RDEPENDS:nordugrid-arc7-client = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-community-rtes = " \
 gnupg2 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arex \
 python3 \
 python3-dns \
 "
RDEPENDS:nordugrid-arc7-datadelivery-service = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-devel = " \
 glib2 \
 glibc \
 glibmm2.68 \
 glibmm2.68-devel \
 libgcc \
 libstdc++ \
 libxml2-devel \
 nordugrid-arc7 \
 openssl-devel \
 "
RDEPENDS:nordugrid-arc7-hed = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 systemd-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-infosys-ldap = " \
 bash \
 bdii \
 glue-schema \
 logrotate \
 nordugrid-arc7-arcctl-service \
 openldap-servers \
 policycoreutils-python-utils \
 systemd \
 "
RDEPENDS:nordugrid-arc7-monitor = " \
 nordugrid-arc7 \
 virtual/php \
 virtual/php-gd \
 virtual/php-ldap \
 "
RDEPENDS:nordugrid-arc7-plugins-gfal = " \
 gfal2 \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-globus = " \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-lcas-lcmaps \
 "
RDEPENDS:nordugrid-arc7-plugins-globus-common = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-callback \
 globus-gssapi-gsi \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-gridftp = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-ftp-client \
 globus-ftp-control \
 globus-io \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-internal = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nordugrid-arc7-arex \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-lcas-lcmaps = " \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gssapi-gsi \
 libgcc \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-plugins-needed = " \
 glib2 \
 glibc \
 glibmm2.68 \
 ldns \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-python = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3-libs \
 python3-nordugrid-arc7 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-s3 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libs3 \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-xrootd = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 xrootd-client-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-test-utils = " \
 glibc \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 "
RDEPENDS:nordugrid-arc7-wn = " \
 glibc \
 "
RDEPENDS:python3-arcrest = " \
 python3 \
 python3-cryptography \
 "
RDEPENDS:python3-nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3 \
 python3-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
