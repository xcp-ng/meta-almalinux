# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pybind11-json"
PV = "0.2.15"
PR = "1.el10_0"
PACKAGES = " \
 pybind11-json-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pybind11-json-0.2.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbfa4781dce254a5fa51156d07e45eec4243571d1518d39d8462bee848ba5ff5"

URI_x86_64_v2_pybind11-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pybind11-json-devel-0.2.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pybind11-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pybind11-json-devel}"
SRC_URI[x86_64_v2_pybind11-json-devel.sha256sum] = "2e7c5616d00b9e28d6010b2f8149095035084258d0aa41b060a68f01407bdc0d"

URI_aarch64_pybind11-json-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pybind11-json-devel-0.2.15-1.el10_0.noarch.rpm;name=aarch64_pybind11-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pybind11-json-devel}"
SRC_URI[aarch64_pybind11-json-devel.sha256sum] = "8588618c4eebe8c960a5d01b316d0d7e99ed314f12b09d24af26da0c23312e7b"

RDEPENDS:pybind11-json-devel = " \
 cmake-filesystem \
 json-devel \
 pybind11-devel \
 "
