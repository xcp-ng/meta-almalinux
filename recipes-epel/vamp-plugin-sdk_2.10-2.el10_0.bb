# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vamp-plugin-sdk"
PV = "2.10"
PR = "2.el10_0"
PACKAGES = " \
 vamp-plugin-sdk \
 vamp-plugin-sdk-devel \
 vamp-plugin-sdk-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vamp-plugin-sdk-2.10-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9acb8f63cbe4963cd113346cfe59f14d8499d8d33a67757e48b772749027c86"

URI_x86_64_v2_vamp-plugin-sdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vamp-plugin-sdk-2.10-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vamp-plugin-sdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vamp-plugin-sdk}"
SRC_URI[x86_64_v2_vamp-plugin-sdk.sha256sum] = "26594f6febb716e0198fa0d0399a07d470120c91498f6400a4e4b42cf7f0bb97"

URI_x86_64_v2_vamp-plugin-sdk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vamp-plugin-sdk-devel-2.10-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vamp-plugin-sdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vamp-plugin-sdk-devel}"
SRC_URI[x86_64_v2_vamp-plugin-sdk-devel.sha256sum] = "665a50bf07ddb17bc8d7f7d29c25f9148e70c76e2cc75df92587bc36f486d738"

URI_x86_64_v2_vamp-plugin-sdk-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vamp-plugin-sdk-static-2.10-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vamp-plugin-sdk-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vamp-plugin-sdk-static}"
SRC_URI[x86_64_v2_vamp-plugin-sdk-static.sha256sum] = "5a453195d3344b0853e32d1f75f960fd9ff2f3278d6d365c58d379e24b89ba0f"

URI_aarch64_vamp-plugin-sdk = "${EPEL_MIRROR}/aarch64/Packages/v/vamp-plugin-sdk-2.10-2.el10_0.aarch64.rpm;name=aarch64_vamp-plugin-sdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_vamp-plugin-sdk}"
SRC_URI[aarch64_vamp-plugin-sdk.sha256sum] = "4e09b7c30b72f21f30facc738ab2ce9170fa53e463e73676c042f300265eddeb"

URI_aarch64_vamp-plugin-sdk-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vamp-plugin-sdk-devel-2.10-2.el10_0.aarch64.rpm;name=aarch64_vamp-plugin-sdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vamp-plugin-sdk-devel}"
SRC_URI[aarch64_vamp-plugin-sdk-devel.sha256sum] = "ac0508920631415ba4598a7f9b1a2e75e247bc3d55fec2a99beb73ca62f407cf"

URI_aarch64_vamp-plugin-sdk-static = "${EPEL_MIRROR}/aarch64/Packages/v/vamp-plugin-sdk-static-2.10-2.el10_0.aarch64.rpm;name=aarch64_vamp-plugin-sdk-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_vamp-plugin-sdk-static}"
SRC_URI[aarch64_vamp-plugin-sdk-static.sha256sum] = "cd93ce70c80ec5585a33b613b01d16c2e0e9ad29ebe50e5369c492feff8589a1"

RDEPENDS:vamp-plugin-sdk = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:vamp-plugin-sdk-devel = " \
 glibc \
 libgcc \
 libsndfile \
 libstdc++ \
 pkgconf-pkg-config \
 vamp-plugin-sdk \
 "
RDEPENDS:vamp-plugin-sdk-static = " \
 vamp-plugin-sdk-devel \
 "
