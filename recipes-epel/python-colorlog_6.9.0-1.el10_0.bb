# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colorlog"
PV = "6.9.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-colorlog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colorlog-6.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abae8f2d719a0480104f6954495327bd166c3f05176e3b2cbe4907e48f899d93"

URI_x86_64_v2_python3-colorlog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colorlog-6.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colorlog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colorlog}"
SRC_URI[x86_64_v2_python3-colorlog.sha256sum] = "fe4fd1da5cdeaaa2225aba84216f499d784536225f8b0ff28214017a2d14a9e3"

URI_aarch64_python3-colorlog = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colorlog-6.9.0-1.el10_0.noarch.rpm;name=aarch64_python3-colorlog;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colorlog}"
SRC_URI[aarch64_python3-colorlog.sha256sum] = "4ad94bceb7b33f04fca8311762854a5e8964b76950ad27cf6cfe7d92318910c2"

RDEPENDS:python3-colorlog = " \
 python3 \
 "
