# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-ref"
PV = "0.65.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-ref+default-devel \
 rust-gix-ref+document-features-devel \
 rust-gix-ref+parallel-devel \
 rust-gix-ref+serde-devel \
 rust-gix-ref+sha1-devel \
 rust-gix-ref+sha256-devel \
 rust-gix-ref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-ref-0.65.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cacecb7e502019c5b2cf75f89974da295b96d1aa4a53b5930ebf8b153dc051ec"

URI_x86_64_v2_rust-gix-ref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+default-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+default-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+default-devel.sha256sum] = "7ec23cea2d397b654d4d4edff2b0091cfcf18b4b2fdce5a5dbc429500fc15ab8"

URI_x86_64_v2_rust-gix-ref+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+document-features-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+document-features-devel.sha256sum] = "2abcab651147902433512391ada7cf64b2c3b5bc7d329ee492a94c8ee9c5f463"

URI_x86_64_v2_rust-gix-ref+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+parallel-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+parallel-devel.sha256sum] = "c8515928096b6a34e007f7f5cbbbbc5b152630c16672d9183a0df83d397283e1"

URI_x86_64_v2_rust-gix-ref+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+serde-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+serde-devel.sha256sum] = "2320b9bf02afe0579c4324161212f2f538460f6e1c9012fc4f95e8a27c39cde0"

URI_x86_64_v2_rust-gix-ref+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+sha1-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+sha1-devel.sha256sum] = "90428c8b1cf8dc676d3cb640202fb86648afb214c085b78ae2255862b987aa33"

URI_x86_64_v2_rust-gix-ref+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref+sha256-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-ref+sha256-devel.sha256sum] = "b85290a07ced0e1cd544cb2e868a5852371dbca0c56f587ab72b5e7d7513c6b9"

URI_x86_64_v2_rust-gix-ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ref-devel-0.65.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ref-devel}"
SRC_URI[x86_64_v2_rust-gix-ref-devel.sha256sum] = "faee4ba4f72c9e9a782850a67d6aba8d4fd907b3edd927a598d694ffc65215fc"

URI_aarch64_rust-gix-ref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+default-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+default-devel}"
SRC_URI[aarch64_rust-gix-ref+default-devel.sha256sum] = "8385a04abcb98909c4874e44853ddc66b908710f203604c46e83190bc320c3af"

URI_aarch64_rust-gix-ref+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+document-features-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ref+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+document-features-devel}"
SRC_URI[aarch64_rust-gix-ref+document-features-devel.sha256sum] = "422340a3ed8c9530484738fc582c6c47db82ff61f183b57ffe98ba25f5b943c0"

URI_aarch64_rust-gix-ref+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+parallel-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ref+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+parallel-devel}"
SRC_URI[aarch64_rust-gix-ref+parallel-devel.sha256sum] = "451e9444ea86b461a81939bac61158e941762bc7630bea820b9321814c341d0a"

URI_aarch64_rust-gix-ref+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+serde-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ref+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+serde-devel}"
SRC_URI[aarch64_rust-gix-ref+serde-devel.sha256sum] = "4d9cb14ac846dccbcbe597d5db7b6923d0505dd9c27213c0690484434b543e25"

URI_aarch64_rust-gix-ref+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+sha1-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ref+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+sha1-devel}"
SRC_URI[aarch64_rust-gix-ref+sha1-devel.sha256sum] = "e3189395db848ec17a6a07cd0c98ae068ecfaa7cc9660f734dd1835d9f9f235e"

URI_aarch64_rust-gix-ref+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref+sha256-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ref+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref+sha256-devel}"
SRC_URI[aarch64_rust-gix-ref+sha256-devel.sha256sum] = "38184ac331f45b1abeb873bcf5f6de25bf963a6e48c4eb36991f99ec3a1bac65"

URI_aarch64_rust-gix-ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ref-devel-0.65.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ref-devel}"
SRC_URI[aarch64_rust-gix-ref-devel.sha256sum] = "681767409c3ab1073100498066b2f9ba55744c9b33b3cd625689bb116598266f"

RDEPENDS:rust-gix-ref+default-devel = " \
 cargo \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+parallel-devel = " \
 cargo \
 rust-gix-features+parallel-devel \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+serde-devel = " \
 cargo \
 rust-gix-actor+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-ref-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-ref+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-ref-devel \
 "
RDEPENDS:rust-gix-ref-devel = " \
 cargo \
 rust \
 rust-gix-actor+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-tempfile-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-memmap2+default-devel \
 rust-thiserror+default-devel \
 "
