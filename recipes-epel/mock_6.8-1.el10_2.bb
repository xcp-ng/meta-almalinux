# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mock"
PV = "6.8"
PR = "1.el10_2"
PACKAGES = " \
 mock \
 mock-filesystem \
 mock-lvm \
 mock-rpmautospec \
 mock-scm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mock-6.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ae477efcc51c307e05c9a172c7849a650f3408f24851dca12fe7a0c3b387297"

URI_x86_64_v2_mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock}"
SRC_URI[x86_64_v2_mock.sha256sum] = "16ef94f39dc3f0500b925425cd1bd4c5679fa7131fc0ec8056834a72b9c8f3a4"

URI_x86_64_v2_mock-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-filesystem-6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mock-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-filesystem}"
SRC_URI[x86_64_v2_mock-filesystem.sha256sum] = "3fc50463df860acd41ebed77f4736a2d8908ce9a73757e3a7dab5217a2a71e0e"

URI_x86_64_v2_mock-lvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-lvm-6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mock-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-lvm}"
SRC_URI[x86_64_v2_mock-lvm.sha256sum] = "b6a485c219635158788fdf896f43109e057a4b15bd15f3f69f21a457debbccab"

URI_x86_64_v2_mock-rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-rpmautospec-6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mock-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-rpmautospec}"
SRC_URI[x86_64_v2_mock-rpmautospec.sha256sum] = "a2d543d805d781b6df55a5ebd46656f1b34452fce98bce3afe262a90916a8dbd"

URI_x86_64_v2_mock-scm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-scm-6.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mock-scm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-scm}"
SRC_URI[x86_64_v2_mock-scm.sha256sum] = "9e66ef5d2fa0f76bbd297b8166adf2ce82c478ac61bcf23527dcff6c127e1f11"

URI_aarch64_mock = "${EPEL_MIRROR}/aarch64/Packages/m/mock-6.8-1.el10_2.noarch.rpm;name=aarch64_mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock}"
SRC_URI[aarch64_mock.sha256sum] = "ad667a223f91630a7a60228c599b22de68108dffc1c1d6a7864b65191daabba2"

URI_aarch64_mock-filesystem = "${EPEL_MIRROR}/aarch64/Packages/m/mock-filesystem-6.8-1.el10_2.noarch.rpm;name=aarch64_mock-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-filesystem}"
SRC_URI[aarch64_mock-filesystem.sha256sum] = "35ef38f17c10d2f1711a05f9c6022ffd433b862984691cacfc56f38e7c6465f7"

URI_aarch64_mock-lvm = "${EPEL_MIRROR}/aarch64/Packages/m/mock-lvm-6.8-1.el10_2.noarch.rpm;name=aarch64_mock-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-lvm}"
SRC_URI[aarch64_mock-lvm.sha256sum] = "62d4f9b63a5ef41bb6cc4f5a54fadcb5c6dfa72f20c85b488c60b835fd14fdb4"

URI_aarch64_mock-rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/m/mock-rpmautospec-6.8-1.el10_2.noarch.rpm;name=aarch64_mock-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-rpmautospec}"
SRC_URI[aarch64_mock-rpmautospec.sha256sum] = "78f31d75694d1218c66aaab9c729708e35a5e7cbe70a3961125f91181c34d64e"

URI_aarch64_mock-scm = "${EPEL_MIRROR}/aarch64/Packages/m/mock-scm-6.8-1.el10_2.noarch.rpm;name=aarch64_mock-scm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-scm}"
SRC_URI[aarch64_mock-scm.sha256sum] = "a4bf9a8524fb887ec8fbce83fd8b80bd3017c2472fc6bc9cec65bb554bdcb835"

RDEPENDS:mock = " \
 bash \
 createrepo_c \
 mock-core-configs \
 mock-filesystem \
 pigz \
 procps-ng \
 python3 \
 python3-backoff \
 python3-distro \
 python3-jinja2 \
 python3-pyroute2 \
 python3-requests \
 python3-rpm \
 python3-templated-dictionary \
 shadow-utils \
 systemd \
 systemd-container \
 tar \
 usermode \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:mock-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:mock-lvm = " \
 lvm2 \
 mock \
 python3 \
 "
RDEPENDS:mock-rpmautospec = " \
 mock \
 python3 \
 python3-rpmautospec-core \
 "
RDEPENDS:mock-scm = " \
 mock \
 python3 \
 "
