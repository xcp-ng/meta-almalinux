# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ignore"
PV = "0.4.23"
PR = "1.el10_0"
PACKAGES = " \
 rust-ignore+default-devel \
 rust-ignore+simd-accel-devel \
 rust-ignore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ignore-0.4.23-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffb6330ef57ca1ec0152756e4b4bd2b8f344c8317a7f051d933fc926cc73bf42"

URI_x86_64_v2_rust-ignore+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore+default-devel-0.4.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore+default-devel}"
SRC_URI[x86_64_v2_rust-ignore+default-devel.sha256sum] = "4619c56c4074797ded907bc42d8f419ca08cad44d73f724ba6c6b3ad4c77c4dd"

URI_x86_64_v2_rust-ignore+simd-accel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore+simd-accel-devel-0.4.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore+simd-accel-devel}"
SRC_URI[x86_64_v2_rust-ignore+simd-accel-devel.sha256sum] = "9487c572cc102c74949ba9f755b09cb8efb06a8750671698da37fd4603284a53"

URI_x86_64_v2_rust-ignore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ignore-devel-0.4.23-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ignore-devel}"
SRC_URI[x86_64_v2_rust-ignore-devel.sha256sum] = "a6c9f47014efd910d33b73ed513ecbbb6902842daf0256371d25814ba8261710"

URI_aarch64_rust-ignore+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore+default-devel-0.4.23-1.el10_0.noarch.rpm;name=aarch64_rust-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore+default-devel}"
SRC_URI[aarch64_rust-ignore+default-devel.sha256sum] = "e0be3fb173dbd602bf75e2a45ec0dda3a7d474c3c91b93d2194b6692a2ace793"

URI_aarch64_rust-ignore+simd-accel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore+simd-accel-devel-0.4.23-1.el10_0.noarch.rpm;name=aarch64_rust-ignore+simd-accel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore+simd-accel-devel}"
SRC_URI[aarch64_rust-ignore+simd-accel-devel.sha256sum] = "b87594a3f07eb014c0b718c32dd46041f755bfedb5543a2f46e3e83cbf8b135d"

URI_aarch64_rust-ignore-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ignore-devel-0.4.23-1.el10_0.noarch.rpm;name=aarch64_rust-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ignore-devel}"
SRC_URI[aarch64_rust-ignore-devel.sha256sum] = "a2992121ab1c2d36cb3151fc9884dc2ca76a4290a3b5ca3f78db57127404ca61"

RDEPENDS:rust-ignore+default-devel = " \
 cargo \
 rust-ignore-devel \
 "
RDEPENDS:rust-ignore+simd-accel-devel = " \
 cargo \
 rust-ignore-devel \
 "
RDEPENDS:rust-ignore-devel = " \
 cargo \
 rust-crossbeam-deque+default-devel \
 rust-globset+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-same-file+default-devel \
 rust-walkdir+default-devel \
 "
