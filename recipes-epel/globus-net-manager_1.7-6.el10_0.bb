# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-net-manager"
PV = "1.7"
PR = "6.el10_0"
PACKAGES = " \
 globus-net-manager \
 globus-net-manager-devel \
 globus-net-manager-doc \
 globus-xio-net-manager-driver \
 globus-xio-net-manager-driver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-net-manager-1.7-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c00722323efb30b5ae4c4a2dcd8345128df3c697d8ef04a265cab25146b141d1"

URI_x86_64_v2_globus-net-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-net-manager-1.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-net-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-net-manager}"
SRC_URI[x86_64_v2_globus-net-manager.sha256sum] = "f95aaedb1b4bdcbbd101f5506e14b476c0221a3b703d6795151b2dbae0f4594b"

URI_x86_64_v2_globus-net-manager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-net-manager-devel-1.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-net-manager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-net-manager-devel}"
SRC_URI[x86_64_v2_globus-net-manager-devel.sha256sum] = "2914163b1e58de94dc600d586977133a7808f422657e45e79ca017a3cd2317fa"

URI_x86_64_v2_globus-net-manager-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-net-manager-doc-1.7-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-net-manager-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-net-manager-doc}"
SRC_URI[x86_64_v2_globus-net-manager-doc.sha256sum] = "58751f4effb66b386f821a13de1b6f9014b776102954640abc5571b95896105c"

URI_x86_64_v2_globus-xio-net-manager-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-net-manager-driver-1.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-net-manager-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-net-manager-driver}"
SRC_URI[x86_64_v2_globus-xio-net-manager-driver.sha256sum] = "2c0929eb37dfe3aff08513519b04269879da021746b5ee679d3be5e404ad07ac"

URI_x86_64_v2_globus-xio-net-manager-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-net-manager-driver-devel-1.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-net-manager-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-net-manager-driver-devel}"
SRC_URI[x86_64_v2_globus-xio-net-manager-driver-devel.sha256sum] = "bf8dcf9b369550455cfe27e24bfd62d017eb8b6c2fe03e590b5cee13fbfc3ee7"

URI_aarch64_globus-net-manager = "${EPEL_MIRROR}/aarch64/Packages/g/globus-net-manager-1.7-6.el10_0.aarch64.rpm;name=aarch64_globus-net-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-net-manager}"
SRC_URI[aarch64_globus-net-manager.sha256sum] = "2af0ab7f16169ce7f653af236405cd27347e25d37a73df9bc9c9961746672227"

URI_aarch64_globus-net-manager-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-net-manager-devel-1.7-6.el10_0.aarch64.rpm;name=aarch64_globus-net-manager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-net-manager-devel}"
SRC_URI[aarch64_globus-net-manager-devel.sha256sum] = "0c654a75982c732966a24c261d814d5a5b72c63da91198a938e821fb129483e5"

URI_aarch64_globus-net-manager-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-net-manager-doc-1.7-6.el10_0.noarch.rpm;name=aarch64_globus-net-manager-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-net-manager-doc}"
SRC_URI[aarch64_globus-net-manager-doc.sha256sum] = "7d9a2bc7b6b9696a7b8f6741af32b5b0a6bda9ddead1452be6eaaf643d334415"

URI_aarch64_globus-xio-net-manager-driver = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-net-manager-driver-1.7-6.el10_0.aarch64.rpm;name=aarch64_globus-xio-net-manager-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-net-manager-driver}"
SRC_URI[aarch64_globus-xio-net-manager-driver.sha256sum] = "3f282f20dd11e903b77cf4a4278b8adc0f8567eccdbadcf3f8add40fa2b8edfe"

URI_aarch64_globus-xio-net-manager-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-net-manager-driver-devel-1.7-6.el10_0.aarch64.rpm;name=aarch64_globus-xio-net-manager-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-net-manager-driver-devel}"
SRC_URI[aarch64_globus-xio-net-manager-driver-devel.sha256sum] = "48cf6e5de57c08e2d2f06529df509bd4814e4e477b1f9c381dc913ec02527625"

RDEPENDS:globus-net-manager = " \
 glibc \
 globus-common \
 python3-libs \
 "
RDEPENDS:globus-net-manager-devel = " \
 globus-common-devel \
 globus-net-manager \
 globus-xio-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-net-manager-doc = " \
 "
RDEPENDS:globus-xio-net-manager-driver = " \
 glibc \
 globus-common \
 globus-net-manager \
 globus-xio \
 "
RDEPENDS:globus-xio-net-manager-driver-devel = " \
 globus-common-devel \
 globus-net-manager-devel \
 globus-xio-devel \
 globus-xio-net-manager-driver \
 pkgconf-pkg-config \
 "
