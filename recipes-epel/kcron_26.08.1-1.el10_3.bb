# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcron"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kcron \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kcron-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e060a5ba788af848755c184a6afea76c3555246de6ee72ea49d3453379181d66"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcron-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcron;unpack=0"
SRC_URI[x86_64_v2_kcron.sha256sum] = "0d48bb17f63dd70ab6a441070fbfec897988ef12b36b751df12810f79a0ac089"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcron-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kcron;unpack=0"
SRC_URI[aarch64_kcron.sha256sum] = "aaf761a58c3166a82ea301c9ac85c450453c9a6608dfe37cf5e08a30d19c365d"

RDEPENDS:kcron = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
