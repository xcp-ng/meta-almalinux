# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Lingua-Preferred"
PV = "0.2.4"
PR = "46.el10_0"
PACKAGES = " \
 perl-Lingua-Preferred \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Lingua-Preferred-0.2.4-46.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32c6eed1419c5b47ae2c07d84aac6b16e106eda5ada85d2656cc3b33ba80be87"

URI_x86_64_v2_perl-Lingua-Preferred = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lingua-Preferred-0.2.4-46.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Lingua-Preferred;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Lingua-Preferred}"
SRC_URI[x86_64_v2_perl-Lingua-Preferred.sha256sum] = "2878084c3ccdc12d8b424ce3d5668c6658c2cbff3c9a838116851f63f8c87790"

URI_aarch64_perl-Lingua-Preferred = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Lingua-Preferred-0.2.4-46.el10_0.noarch.rpm;name=aarch64_perl-Lingua-Preferred;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Lingua-Preferred}"
SRC_URI[aarch64_perl-Lingua-Preferred.sha256sum] = "104b241503e8361b1b22984227b65c4571811a57b164a7dae9329816367346d4"

RDEPENDS:perl-Lingua-Preferred = " \
 perl-AutoLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
