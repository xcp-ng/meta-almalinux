# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libappindicator"
PV = "12.10.1"
PR = "7.el10_0"
PACKAGES = " \
 libappindicator-docs \
 libappindicator-gtk3 \
 libappindicator-gtk3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libappindicator-12.10.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5cd4288ecee029082ffcf0346dc6a0d9848d03efc60e638e966fc398ceb8bd72"

URI_x86_64_v2_libappindicator-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libappindicator-docs-12.10.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libappindicator-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libappindicator-docs}"
SRC_URI[x86_64_v2_libappindicator-docs.sha256sum] = "3994e2102feb0f5ae2ed504f6f927e352ba495f017e0771f534601f9652e8b58"

URI_x86_64_v2_libappindicator-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libappindicator-gtk3-12.10.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libappindicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libappindicator-gtk3}"
SRC_URI[x86_64_v2_libappindicator-gtk3.sha256sum] = "4fc968f3cc84e039ca78c9c5d53f2a2b01b451d5e7d1853aa1c61439ed4ada77"

URI_x86_64_v2_libappindicator-gtk3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libappindicator-gtk3-devel-12.10.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libappindicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libappindicator-gtk3-devel}"
SRC_URI[x86_64_v2_libappindicator-gtk3-devel.sha256sum] = "a5a534809460dca85067588ba17b86cb4d4f5f3b568de4bac082b7b6d2c5252e"

URI_aarch64_libappindicator-docs = "${EPEL_MIRROR}/aarch64/Packages/l/libappindicator-docs-12.10.1-7.el10_0.noarch.rpm;name=aarch64_libappindicator-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libappindicator-docs}"
SRC_URI[aarch64_libappindicator-docs.sha256sum] = "a29563f677bfec44e95aa5b84f4ce1c066c68751e76504f070c37c623c5817e6"

URI_aarch64_libappindicator-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libappindicator-gtk3-12.10.1-7.el10_0.aarch64.rpm;name=aarch64_libappindicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libappindicator-gtk3}"
SRC_URI[aarch64_libappindicator-gtk3.sha256sum] = "008105ae1683f1c1793e61df4e1fa6c405ed6886a9fac40f0c008a0de3a074f1"

URI_aarch64_libappindicator-gtk3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libappindicator-gtk3-devel-12.10.1-7.el10_0.aarch64.rpm;name=aarch64_libappindicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libappindicator-gtk3-devel}"
SRC_URI[aarch64_libappindicator-gtk3-devel.sha256sum] = "02b89a32b54364757d69737f6530135bf79fbe6d196ce555e98560ac8166d0ed"

RDEPENDS:libappindicator-docs = " \
 "
RDEPENDS:libappindicator-gtk3 = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libdbusmenu \
 libdbusmenu-gtk3 \
 pango \
 "
RDEPENDS:libappindicator-gtk3-devel = " \
 dbus-glib-devel \
 gtk3-devel \
 libappindicator-gtk3 \
 libdbusmenu-devel \
 pkgconf-pkg-config \
 "
