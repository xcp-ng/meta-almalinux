# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-discover"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-discover \
 plasma-discover-flatpak \
 plasma-discover-kns \
 plasma-discover-libs \
 plasma-discover-notifier \
 plasma-discover-offline-updates \
 plasma-discover-packagekit \
 plasma-discover-snap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-discover-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "297c8d10b27e0a642869176c62a5ddb293927eb432f5c0f9556d8e5e0ff3d538"

URI_x86_64_v2_plasma-discover = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover}"
SRC_URI[x86_64_v2_plasma-discover.sha256sum] = "37c3ebd312d59700d1dfb6604db45cacd32e2ec3b91d98deea021d3c95c9cfe4"

URI_x86_64_v2_plasma-discover-flatpak = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-flatpak-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-flatpak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-flatpak}"
SRC_URI[x86_64_v2_plasma-discover-flatpak.sha256sum] = "2ef4b81ab572de347d6c1b84b1148675e4f865bdff8e7a7dfdce8a628850a39c"

URI_x86_64_v2_plasma-discover-kns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-kns-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-kns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-kns}"
SRC_URI[x86_64_v2_plasma-discover-kns.sha256sum] = "645b29b5bb82cffe737f03eb48c5166889f2b7ace887898f1214fcc7d232b69c"

URI_x86_64_v2_plasma-discover-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-libs-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-libs}"
SRC_URI[x86_64_v2_plasma-discover-libs.sha256sum] = "23e57a867235c79cee485c898f28065e3ead768ea994431d5a4fbdc5b3e71c8d"

URI_x86_64_v2_plasma-discover-notifier = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-notifier-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-notifier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-notifier}"
SRC_URI[x86_64_v2_plasma-discover-notifier.sha256sum] = "1062c5322d1192c1d871847ed4335f17a09dee6abb2177d19dd7255069874adc"

URI_x86_64_v2_plasma-discover-offline-updates = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-offline-updates-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-offline-updates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-offline-updates}"
SRC_URI[x86_64_v2_plasma-discover-offline-updates.sha256sum] = "955de02347d5c1688ace9b17e9c1f63d06265216518dca69ed1cadc9f2e1f19b"

URI_x86_64_v2_plasma-discover-packagekit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-packagekit-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-packagekit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-packagekit}"
SRC_URI[x86_64_v2_plasma-discover-packagekit.sha256sum] = "816df86da49408f2cfa3b9ffd7c4bfbe0079b11d1af6362e204b34c61846bf0d"

URI_x86_64_v2_plasma-discover-snap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-snap-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-snap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-discover-snap}"
SRC_URI[x86_64_v2_plasma-discover-snap.sha256sum] = "b3e12d014c81e2c547d57325f3e3e772b961a69d3014c2a9da2fe36fee7799bd"

URI_aarch64_plasma-discover = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-discover;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover}"
SRC_URI[aarch64_plasma-discover.sha256sum] = "4a28ba9eec7611bcf0e782dd27b4b897664c688657a53a1c76a21ed5f56a2410"

URI_aarch64_plasma-discover-flatpak = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-flatpak-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-discover-flatpak;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-flatpak}"
SRC_URI[aarch64_plasma-discover-flatpak.sha256sum] = "93fde17b83761f7c4990184c1cf689af97635dd87e18dfa9d3799d9bf53b008c"

URI_aarch64_plasma-discover-kns = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-kns-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-discover-kns;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-kns}"
SRC_URI[aarch64_plasma-discover-kns.sha256sum] = "079498aeace410f8ae8b1e3d32ed29e324544257f8cc12a27a1b22755fdb5d96"

URI_aarch64_plasma-discover-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-libs-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-discover-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-libs}"
SRC_URI[aarch64_plasma-discover-libs.sha256sum] = "73d8e0a9e1f3535341f3199261dff88565d287bcd8804b1c79c5da13a9a3ccfa"

URI_aarch64_plasma-discover-notifier = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-notifier-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-discover-notifier;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-notifier}"
SRC_URI[aarch64_plasma-discover-notifier.sha256sum] = "040e2a6c6e145f454cd863422a40e11992788a3c492da8713c5cf3cb70018212"

URI_aarch64_plasma-discover-offline-updates = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-offline-updates-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-discover-offline-updates;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-offline-updates}"
SRC_URI[aarch64_plasma-discover-offline-updates.sha256sum] = "1eda9fb309416d0f37040c95175be22beaca0ef5b0cc68d7c41dec12ccd08105"

URI_aarch64_plasma-discover-packagekit = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-packagekit-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-discover-packagekit;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-packagekit}"
SRC_URI[aarch64_plasma-discover-packagekit.sha256sum] = "733c5c97b7cd5904ff989feab44849076440f92fadd6f062eee071d581586f47"

URI_aarch64_plasma-discover-snap = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-snap-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-discover-snap;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-discover-snap}"
SRC_URI[aarch64_plasma-discover-snap.sha256sum] = "e53be27eaf45c81c89a3effed3279e19bdbd0ba70bc74addaac5aea890dff40d"

RDEPENDS:plasma-discover = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 libstdc++ \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebview \
 "
RDEPENDS:plasma-discover-flatpak = " \
 appstream-qt \
 flatpak \
 flatpak-kcm \
 flatpak-libs \
 glib2 \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 libgcc \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-kns = " \
 glibc \
 kf6-attica \
 kf6-kconfig \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-libs = " \
 appstream-qt \
 fwupd \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 libgcc \
 libstdc++ \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-discover-notifier = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-offline-updates = " \
 plasma-discover \
 "
RDEPENDS:plasma-discover-packagekit = " \
 PackageKit \
 PackageKit-Qt6 \
 appstream-qt \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kservice \
 libgcc \
 libmarkdown \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-snap = " \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 snapd \
 snapd-qt \
 "
