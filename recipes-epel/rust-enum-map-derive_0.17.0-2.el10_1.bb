# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-map-derive"
PV = "0.17.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-enum-map-derive+default-devel \
 rust-enum-map-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-map-derive-0.17.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "525c9b9d053d5814ed4595c92202e734548033c56f0bd0869edbfb5e3f8d0865"

URI_x86_64_v2_rust-enum-map-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map-derive+default-devel-0.17.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map-derive+default-devel}"
SRC_URI[x86_64_v2_rust-enum-map-derive+default-devel.sha256sum] = "5e977e7306a38fb25b8a9c3e7c4c63c0b003f50152286f07cf05c5505f712633"

URI_x86_64_v2_rust-enum-map-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-map-derive-devel-0.17.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-map-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-map-derive-devel}"
SRC_URI[x86_64_v2_rust-enum-map-derive-devel.sha256sum] = "2316f098d1bdfa3e0f7b67f162fbf6179ebb8bea45bef0735b4e9068b96cd522"

URI_aarch64_rust-enum-map-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map-derive+default-devel-0.17.0-2.el10_1.noarch.rpm;name=aarch64_rust-enum-map-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map-derive+default-devel}"
SRC_URI[aarch64_rust-enum-map-derive+default-devel.sha256sum] = "3ef1cd8091f1292e91a977e1198543900b6eef8b944663eaa5e30e971023e029"

URI_aarch64_rust-enum-map-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-map-derive-devel-0.17.0-2.el10_1.noarch.rpm;name=aarch64_rust-enum-map-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-map-derive-devel}"
SRC_URI[aarch64_rust-enum-map-derive-devel.sha256sum] = "e578ae43ce2669ff2d7cab1b894c192683235cc02e2e68a65b6a87f6ed730889"

RDEPENDS:rust-enum-map-derive+default-devel = " \
 cargo \
 rust-enum-map-derive-devel \
 "
RDEPENDS:rust-enum-map-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+derive-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2+proc-macro-devel \
 rust-syn2-devel \
 "
