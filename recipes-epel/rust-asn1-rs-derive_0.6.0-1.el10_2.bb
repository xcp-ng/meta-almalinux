# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1-rs-derive"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-asn1-rs-derive+default-devel \
 rust-asn1-rs-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-rs-derive-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c722188e1475360de98bbe2c90686b4f245ea8bcb9bea74618b397d7922a4a4c"

URI_x86_64_v2_rust-asn1-rs-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-derive+default-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-derive+default-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-derive+default-devel.sha256sum] = "497383c7d55b5a9f5db1f09a4946f8343d45020070b6c0ccd8b5ce6fbd84397b"

URI_x86_64_v2_rust-asn1-rs-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-derive-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-derive-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-derive-devel.sha256sum] = "39365b781b81e91b95b47bfcaf7d53e2bcd31e5b02e85ffd2794bdb3556ab13f"

URI_aarch64_rust-asn1-rs-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-derive+default-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-derive+default-devel}"
SRC_URI[aarch64_rust-asn1-rs-derive+default-devel.sha256sum] = "17a2493b315c0020ed7dd94f207aebea0185624c638154bd6b59093c4f651177"

URI_aarch64_rust-asn1-rs-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-derive-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-asn1-rs-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-derive-devel}"
SRC_URI[aarch64_rust-asn1-rs-derive-devel.sha256sum] = "78bea46cb65464ec1f1bb89392de6afc17d1bf9944c6ddd50e77572a978d62b6"

RDEPENDS:rust-asn1-rs-derive+default-devel = " \
 cargo \
 rust-asn1-rs-derive-devel \
 "
RDEPENDS:rust-asn1-rs-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 rust-synstructure+default-devel \
 "
