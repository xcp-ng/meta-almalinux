# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setup"
PV = "2.14.5"
PR = "7.el10"
PACKAGES = " \
 setup \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/setup-2.14.5-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01dc0e3dd1d75417d23cc4cca6d3ee5adff9446cc985d724d704b4618fb800a6"

URI_x86_64_v2_setup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/setup-2.14.5-7.el10.noarch.rpm;name=x86_64_v2_setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setup}"
SRC_URI[x86_64_v2_setup.sha256sum] = "4065c6f500ac20468530177b1a6012145c490c018a5d2812c951b0b7e919bc5b"
RPROVIDES:setup:x86_64_v2 = "virtual/group_dialout_ virtual/group_tty_"

URI_aarch64_setup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/setup-2.14.5-7.el10.noarch.rpm;name=aarch64_setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_setup}"
SRC_URI[aarch64_setup.sha256sum] = "4065c6f500ac20468530177b1a6012145c490c018a5d2812c951b0b7e919bc5b"
RPROVIDES:setup:aarch64 = "virtual/group_dialout_ virtual/group_tty_"

RDEPENDS:setup = " \
 almalinux-release \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/group_dialout_ rpm/virtual/group_tty_"

PROVIDES:append:aarch64 = " rpm/virtual/group_dialout_ rpm/virtual/group_tty_"
