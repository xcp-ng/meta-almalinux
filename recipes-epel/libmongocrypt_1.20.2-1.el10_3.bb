# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmongocrypt"
PV = "1.20.2"
PR = "1.el10_3"
PACKAGES = " \
 libmongocrypt \
 libmongocrypt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmongocrypt-1.20.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "baad01c8a00b0ce580aeff9483d0c0cc9c44bbdf8b83acc59dbe7acc960d5c47"

URI_x86_64_v2_libmongocrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-1.20.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmongocrypt}"
SRC_URI[x86_64_v2_libmongocrypt.sha256sum] = "cdbef2bbaadc40cecfce957f364d83b47d832b4661f842beafc2f5e7b6f31297"

URI_x86_64_v2_libmongocrypt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-devel-1.20.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmongocrypt-devel}"
SRC_URI[x86_64_v2_libmongocrypt-devel.sha256sum] = "de815086f67a0c45cfd234c24c4971e4f980bd04289a73496f8bd9522e1260c3"

URI_aarch64_libmongocrypt = "${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-1.20.2-1.el10_3.aarch64.rpm;name=aarch64_libmongocrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmongocrypt}"
SRC_URI[aarch64_libmongocrypt.sha256sum] = "435c40644bf1daf5b3ee8492de0ba126be8d2cd3283b23227e3e9e3b55395e06"

URI_aarch64_libmongocrypt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-devel-1.20.2-1.el10_3.aarch64.rpm;name=aarch64_libmongocrypt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmongocrypt-devel}"
SRC_URI[aarch64_libmongocrypt-devel.sha256sum] = "d52c7a2dbc64a044738afd8e316e07b7cb845ac9661d7fa110664dfdeb25e8be"

RDEPENDS:libmongocrypt = " \
 glibc \
 libbson \
 openssl-libs \
 "
RDEPENDS:libmongocrypt-devel = " \
 cmake-filesystem \
 libbson-devel \
 libmongocrypt \
 pkgconf-pkg-config \
 "
