# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mail-Message"
PV = "3.015"
PR = "1.el10_0"
PACKAGES = " \
 perl-Mail-Message \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mail-Message-3.015-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c4c9b7ca40755ad85ee1ac3030e049fc8250030e37fbfa36f43b2a7b7c73df8"

URI_x86_64_v2_perl-Mail-Message = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mail-Message-3.015-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mail-Message;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mail-Message}"
SRC_URI[x86_64_v2_perl-Mail-Message.sha256sum] = "94c4688856b58057c721b0eca6ebf57e89c5824102c75855f51fecdf32e5cd67"

URI_aarch64_perl-Mail-Message = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mail-Message-3.015-1.el10_0.noarch.rpm;name=aarch64_perl-Mail-Message;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mail-Message}"
SRC_URI[aarch64_perl-Mail-Message.sha256sum] = "e04328b7aa488949d38ed0bad40183fbc01ad5a59ac6bda99f49783a3b590169"

RDEPENDS:perl-Mail-Message = " \
 perl-Carp \
 perl-Email-Simple \
 perl-Encode \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Temp \
 perl-HTML-Formatter \
 perl-HTML-Tree \
 perl-IO \
 perl-IO-stringy \
 perl-MIME-Base64 \
 perl-MIME-Types \
 perl-MIME-tools \
 perl-Mail-Message \
 perl-Mail-Transport \
 perl-MailTools \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Test-Simple \
 perl-Text-Autoformat \
 perl-Time-HiRes \
 perl-TimeDate \
 perl-URI \
 perl-User-Identity \
 perl-base \
 perl-libnet \
 perl-libs \
 perl-overload \
 perl-vars \
 "
