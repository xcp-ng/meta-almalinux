# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-refspec"
PV = "0.28.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-refspec+default-devel \
 rust-gix-refspec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-refspec-0.28.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80996c61b06f6b0114393b99b7ceb1a6ed1f89b39f6d028acd22b182baa1251b"

URI_x86_64_v2_rust-gix-refspec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec+default-devel-0.28.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec+default-devel.sha256sum] = "792b93953488e7bfc83a2e4e4ef33a6f2ee00eadb36f01ccc93e5922abfe2d62"

URI_x86_64_v2_rust-gix-refspec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec-devel-0.28.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec-devel.sha256sum] = "f3fe08f2287d2da452223db35c4b9f17616b91ff900bd13e00367fb8d0e83623"

URI_aarch64_rust-gix-refspec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec+default-devel-0.28.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-refspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec+default-devel}"
SRC_URI[aarch64_rust-gix-refspec+default-devel.sha256sum] = "57253eab81e04c93dfbe72ae4ace453f949c7b762417af5fc2a7938f51189156"

URI_aarch64_rust-gix-refspec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec-devel-0.28.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-refspec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec-devel}"
SRC_URI[aarch64_rust-gix-refspec-devel.sha256sum] = "ff61b5d80e770437233321743bec57f85f74510d6c5e9ae1c1d8f0cafb516b22"

RDEPENDS:rust-gix-refspec+default-devel = " \
 cargo \
 rust-gix-refspec-devel \
 "
RDEPENDS:rust-gix-refspec-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-revision-devel \
 rust-gix-validate+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
