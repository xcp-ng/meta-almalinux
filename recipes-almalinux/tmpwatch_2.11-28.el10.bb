# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tmpwatch"
PV = "2.11"
PR = "28.el10"
PACKAGES = " \
 tmpwatch \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tmpwatch-2.11-28.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "488f092e429f652ef8f0f0ac8ef7718c9a99a63a2fa829a9e8ab59ba35925a8e"

URI_x86_64_v2_tmpwatch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tmpwatch-2.11-28.el10.x86_64_v2.rpm;name=x86_64_v2_tmpwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmpwatch}"
SRC_URI[x86_64_v2_tmpwatch.sha256sum] = "5e893b2464c60a98e8063257bc59d0f0b60b6a86641368e085929d6b4a6b7d16"

URI_aarch64_tmpwatch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tmpwatch-2.11-28.el10.aarch64.rpm;name=aarch64_tmpwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmpwatch}"
SRC_URI[aarch64_tmpwatch.sha256sum] = "45229cb8cbc2d90bf4b294889f380e6ec4fe8b78d6a656a5820a16cd81a4e8ab"

RDEPENDS:tmpwatch = " \
 glibc \
 psmisc \
 "
