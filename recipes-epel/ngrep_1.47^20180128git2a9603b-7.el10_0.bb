# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ngrep"
PV = "1.47^20180128git2a9603b"
PR = "7.el10_0"
PACKAGES = " \
 ngrep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ngrep-1.47^20180128git2a9603b-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a67f612e90e854c75394fe393a57272cdde01419a5ca7ee1e25cca01b3cfcd6"

URI_x86_64_v2_ngrep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ngrep-1.47^20180128git2a9603b-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ngrep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ngrep}"
SRC_URI[x86_64_v2_ngrep.sha256sum] = "0530b5c6c33fe824e7766c6bb6e074eed113aff79957187d2407b4f3ad789e00"

URI_aarch64_ngrep = "${EPEL_MIRROR}/aarch64/Packages/n/ngrep-1.47^20180128git2a9603b-7.el10_0.aarch64.rpm;name=aarch64_ngrep;unpack=0"
SRC_URI:append = " ${URI_aarch64_ngrep}"
SRC_URI[aarch64_ngrep.sha256sum] = "41f970bb9dc1f0c1ca68734e8171008de388745e9e94777b01e94cbdc5ef9331"

RDEPENDS:ngrep = " \
 glibc \
 libnet \
 libpcap \
 pcre2 \
 "
