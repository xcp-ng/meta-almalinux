# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "papi"
PV = "7.1.0"
PR = "6.el10"
PACKAGES = " \
 papi \
 papi-devel \
 papi-libs \
 papi-testsuite \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/papi-7.1.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3f2386310ff3c0feb2fb23edabd2f4b025cf535481a829bcd9d2da3453b5302"

URI_x86_64_v2_papi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papi-7.1.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_papi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papi}"
SRC_URI[x86_64_v2_papi.sha256sum] = "71f055d9c7b44d8ab149bca9e6900370bc496b3464977663689fca854bb7a16e"

URI_x86_64_v2_papi-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papi-devel-7.1.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_papi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papi-devel}"
SRC_URI[x86_64_v2_papi-devel.sha256sum] = "6c89d069f680c671742f9846cf64dd6d7db19257b3be216995fbf4f6235b3cc6"

URI_x86_64_v2_papi-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/papi-libs-7.1.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_papi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papi-libs}"
SRC_URI[x86_64_v2_papi-libs.sha256sum] = "36ce03db47a96f6a2956c355972d6ab9359d34ca9100007648dffe06739a6e2d"

URI_x86_64_v2_papi-testsuite = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/papi-testsuite-7.1.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_papi-testsuite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_papi-testsuite}"
SRC_URI[x86_64_v2_papi-testsuite.sha256sum] = "95ae08977b8fd132400e90f0e6159177c0599a4cffe6c680c32941d2b252133a"

URI_aarch64_papi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papi-7.1.0-6.el10.aarch64.rpm;name=aarch64_papi;unpack=0"
SRC_URI:append = " ${URI_aarch64_papi}"
SRC_URI[aarch64_papi.sha256sum] = "d85fd8e1e8fedf2acbbccbe667b416e6c284803dd8300c3fb9063cedbac6aebb"

URI_aarch64_papi-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papi-devel-7.1.0-6.el10.aarch64.rpm;name=aarch64_papi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_papi-devel}"
SRC_URI[aarch64_papi-devel.sha256sum] = "711e16c4950a59aaca6ba34be9f03993e5d4018b5334f3f14c5ea63772a798e4"

URI_aarch64_papi-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/papi-libs-7.1.0-6.el10.aarch64.rpm;name=aarch64_papi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_papi-libs}"
SRC_URI[aarch64_papi-libs.sha256sum] = "02f4c0e602c0f07f6cd59d7629aa3686d4a1e63200c08dc327f05b2347b87e1f"

URI_aarch64_papi-testsuite = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/papi-testsuite-7.1.0-6.el10.aarch64.rpm;name=aarch64_papi-testsuite;unpack=0"
SRC_URI:append = " ${URI_aarch64_papi-testsuite}"
SRC_URI[aarch64_papi-testsuite.sha256sum] = "81512f456132e013f92f866fd7820abcc5fa1c5bcb32ce74f93a79311e865db2"

RDEPENDS:papi = " \
 glibc \
 papi-libs \
 python3 \
 "
RDEPENDS:papi-devel = " \
 papi \
 papi-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:papi-libs = " \
 glibc \
 libpfm \
 "
RDEPENDS:papi-testsuite = " \
 bash \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 papi \
 papi-libs \
 "
