# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13"
PV = "3.13.15"
PR = "1.el10_3"
PACKAGES = " \
 python3.13 \
 python3.13-debug \
 python3.13-devel \
 python3.13-freethreading \
 python3.13-freethreading-debug \
 python3.13-idle \
 python3.13-libs \
 python3.13-test \
 python3.13-tkinter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-3.13.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f274c7f7f31759c025b1ac60451114c31534993c9dc5bcf8504706ffcf47653c"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3.13-freethreading: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)
# - python3.13-test: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3.13-freethreading: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)
# - python3.13-test: (python3.13-wheel-wheel if python3.13-setuptools-wheel < 71)

URI_x86_64_v2_python3.13 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-3.13.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13}"
SRC_URI[x86_64_v2_python3.13.sha256sum] = "eab164e70d9965ed4453362d40ce04cab20a411eddf2d0c006f944822bd7def6"

URI_x86_64_v2_python3.13-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-debug-3.13.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-debug}"
SRC_URI[x86_64_v2_python3.13-debug.sha256sum] = "e87133c8124a89c155f582a49b0441e0e40e91f8c2fc14bf15d30dd1c8d226bd"

URI_x86_64_v2_python3.13-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-devel-3.13.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-devel}"
SRC_URI[x86_64_v2_python3.13-devel.sha256sum] = "494360d4248f93657dcf9a9ec1e199d3508a626d1e284c5220b547664e07dbdc"

URI_x86_64_v2_python3.13-freethreading = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-freethreading-3.13.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-freethreading;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-freethreading}"
SRC_URI[x86_64_v2_python3.13-freethreading.sha256sum] = "8a206f7c64b6b5b278b94c32e2038a85438b8359be4c17f57c3fb180c50e104c"

URI_x86_64_v2_python3.13-freethreading-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-freethreading-debug-3.13.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-freethreading-debug}"
SRC_URI[x86_64_v2_python3.13-freethreading-debug.sha256sum] = "e8dc5fbeec2a7f381d6bae66c6b05431bb369fa4febd1a583c79cb5a68fd3aec"

URI_x86_64_v2_python3.13-idle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-idle-3.13.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-idle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-idle}"
SRC_URI[x86_64_v2_python3.13-idle.sha256sum] = "605eaa05916fd9357594a1f61be6b7f490a65a6518de820199afa1441e707fec"

URI_x86_64_v2_python3.13-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-libs-3.13.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-libs}"
SRC_URI[x86_64_v2_python3.13-libs.sha256sum] = "e95255dbb2799ae9c78d93c0e908823c937652a63625e04afe9e3115790386a9"

URI_x86_64_v2_python3.13-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-test-3.13.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-test}"
SRC_URI[x86_64_v2_python3.13-test.sha256sum] = "c28517c1ec302cdf55888f35d339832319a439ade9f7f549e94354af32cc2f03"

URI_x86_64_v2_python3.13-tkinter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-tkinter-3.13.15-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-tkinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-tkinter}"
SRC_URI[x86_64_v2_python3.13-tkinter.sha256sum] = "06dd19433b14502038138cddf63dc41712c139b586de881fdd545f4eaca0077c"

URI_aarch64_python3.13 = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-3.13.15-1.el10_3.aarch64.rpm;name=aarch64_python3.13;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13}"
SRC_URI[aarch64_python3.13.sha256sum] = "72f587c106da4a0344ac63f67c1e9f3d1884e83645259e569781b0f81c6dc23c"

URI_aarch64_python3.13-debug = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-debug-3.13.15-1.el10_3.aarch64.rpm;name=aarch64_python3.13-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-debug}"
SRC_URI[aarch64_python3.13-debug.sha256sum] = "4ceb52363875633e83999d090710879f4a4ba8e79e888945c80fc5565c5535fe"

URI_aarch64_python3.13-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-devel-3.13.15-1.el10_3.aarch64.rpm;name=aarch64_python3.13-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-devel}"
SRC_URI[aarch64_python3.13-devel.sha256sum] = "9c6ddff4f68d989be5c77820d7071b6d0544376931b29dbb666758eb84be5de5"

URI_aarch64_python3.13-freethreading = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-freethreading-3.13.15-1.el10_3.aarch64.rpm;name=aarch64_python3.13-freethreading;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-freethreading}"
SRC_URI[aarch64_python3.13-freethreading.sha256sum] = "9c976984b7cdb4dd6dc449776ad7169e850c0145d850aba2364fb9f74b495e55"

URI_aarch64_python3.13-freethreading-debug = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-freethreading-debug-3.13.15-1.el10_3.aarch64.rpm;name=aarch64_python3.13-freethreading-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-freethreading-debug}"
SRC_URI[aarch64_python3.13-freethreading-debug.sha256sum] = "3c0ee763b6dcbce6820b503c3c3b79504b4d8b8ff9e5d930877d62e0c0ec3d18"

URI_aarch64_python3.13-idle = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-idle-3.13.15-1.el10_3.aarch64.rpm;name=aarch64_python3.13-idle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-idle}"
SRC_URI[aarch64_python3.13-idle.sha256sum] = "182513030e387524bd438ef330bdd97382b20637dd0361486c3e36b813bb488a"

URI_aarch64_python3.13-libs = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-libs-3.13.15-1.el10_3.aarch64.rpm;name=aarch64_python3.13-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-libs}"
SRC_URI[aarch64_python3.13-libs.sha256sum] = "af5b1c6594bb3fc91dd42d7c4bc626b832e6526ff8bfe77ed1a6401c94d5f4ce"

URI_aarch64_python3.13-test = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-test-3.13.15-1.el10_3.aarch64.rpm;name=aarch64_python3.13-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-test}"
SRC_URI[aarch64_python3.13-test.sha256sum] = "1e7f675ae04f50786f766ab4badcd5e912f06966f59562a6556b70023383ee7d"

URI_aarch64_python3.13-tkinter = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-tkinter-3.13.15-1.el10_3.aarch64.rpm;name=aarch64_python3.13-tkinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-tkinter}"
SRC_URI[aarch64_python3.13-tkinter.sha256sum] = "f4f84acfc1c53103bfdbf004cb631be25abe2a84398a4ef0b0845e9650ec91ed"

RDEPENDS:python3.13 = " \
 glibc \
 python3.13-libs \
 "
RDEPENDS:python3.13-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.13 \
 python3.13-devel \
 python3.13-idle \
 python3.13-libs \
 python3.13-test \
 python3.13-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3-rpm-generators \
 python3-rpm-macros \
 python3.13 \
 python3.13-libs \
 "
RDEPENDS:python3.13-freethreading = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.13-pip-wheel \
 python3.13-setuptools-wheel \
 readline \
 sqlite-libs \
 tcl \
 tk \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-freethreading-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.13-freethreading \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-idle = " \
 python3.13 \
 python3.13-tkinter \
 "
RDEPENDS:python3.13-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.13-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.13-test = " \
 bash \
 glibc \
 libgcc \
 python3.13 \
 python3.13-libs \
 python3.13-setuptools-wheel \
 "
RDEPENDS:python3.13-tkinter = " \
 glibc \
 python3.13 \
 tcl \
 tk \
 "
