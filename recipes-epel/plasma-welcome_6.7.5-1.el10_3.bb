# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-welcome"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-welcome \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-welcome-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "61ac4670fb5d36da929e7222e51d600d510ad71c55de1358b1a742cb8a98ae75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-welcome-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-welcome;unpack=0"
SRC_URI[x86_64_v2_plasma-welcome.sha256sum] = "ee55db0adce4131bc79b77f0de56af5f5cb47963497e7b123955592de3e0382f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-welcome-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-welcome;unpack=0"
SRC_URI[aarch64_plasma-welcome.sha256sum] = "559cd3be7115229ce9981dca90e1624d7839230f5c765dade3cfc175f771c2bc"

RDEPENDS:plasma-welcome = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwindowsystem \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
