# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libayatana-appindicator"
PV = "0.5.94"
PR = "3.el10_1"
PACKAGES = " \
 libayatana-appindicator-gtk3 \
 libayatana-appindicator-gtk3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libayatana-appindicator-0.5.94-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec8cd8a51b6e4b29c94d79c5190f36fed0addcefcb1a35ceedfd7c7dd1a468f5"

URI_x86_64_v2_libayatana-appindicator-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-appindicator-gtk3-0.5.94-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-appindicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-appindicator-gtk3}"
SRC_URI[x86_64_v2_libayatana-appindicator-gtk3.sha256sum] = "8d14fabecaea7e6434dec998224fbfe69138d7d82df938a23396b76c8f17f828"

URI_x86_64_v2_libayatana-appindicator-gtk3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libayatana-appindicator-gtk3-devel-0.5.94-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libayatana-appindicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libayatana-appindicator-gtk3-devel}"
SRC_URI[x86_64_v2_libayatana-appindicator-gtk3-devel.sha256sum] = "8be11868e49c1fd0e4ac762b4005ced84e2b8a1524d06d1ccfa8a62e0c980cc1"

URI_aarch64_libayatana-appindicator-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-appindicator-gtk3-0.5.94-3.el10_1.aarch64.rpm;name=aarch64_libayatana-appindicator-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-appindicator-gtk3}"
SRC_URI[aarch64_libayatana-appindicator-gtk3.sha256sum] = "64761bc26d645a63363014ecdfae7a78755a76b2df57149a2da9a7fb112aee30"

URI_aarch64_libayatana-appindicator-gtk3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libayatana-appindicator-gtk3-devel-0.5.94-3.el10_1.aarch64.rpm;name=aarch64_libayatana-appindicator-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libayatana-appindicator-gtk3-devel}"
SRC_URI[aarch64_libayatana-appindicator-gtk3-devel.sha256sum] = "a7eb6a7bb4c90ae8148809ae7e55ebcc1ed1549da06569fd5fb330b43745d3b8"

RDEPENDS:libayatana-appindicator-gtk3 = " \
 glib2 \
 glibc \
 gtk3 \
 libayatana-indicator-gtk3 \
 libdbusmenu \
 libdbusmenu-gtk3 \
 libgcc \
 "
RDEPENDS:libayatana-appindicator-gtk3-devel = " \
 glib2-devel \
 gtk3-devel \
 libayatana-appindicator-gtk3 \
 libayatana-indicator-gtk3-devel \
 libdbusmenu-devel \
 pkgconf-pkg-config \
 "
