# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mimalloc"
PV = "0.1.43"
PR = "2.el10_0"
PACKAGES = " \
 rust-mimalloc+debug-devel \
 rust-mimalloc+debug_in_debug-devel \
 rust-mimalloc+default-devel \
 rust-mimalloc+extended-devel \
 rust-mimalloc+local_dynamic_tls-devel \
 rust-mimalloc+no_thp-devel \
 rust-mimalloc+override-devel \
 rust-mimalloc+secure-devel \
 rust-mimalloc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mimalloc-0.1.43-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08d01404dbdcdf6bbc01f6665934c16187cd0f9963e543a75733b616570b51cc"

URI_x86_64_v2_rust-mimalloc+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+debug-devel-0.1.43-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+debug-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+debug-devel.sha256sum] = "bc86cd6267d658200135bc97aafe9ae754b403d0f4d90a11e987aab76eb533cc"

URI_x86_64_v2_rust-mimalloc+debug_in_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+debug_in_debug-devel-0.1.43-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+debug_in_debug-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+debug_in_debug-devel.sha256sum] = "0f57d2e946c118f57b02037f7f111fc4fd84e39b552bfd86dc5dfc469261e404"

URI_x86_64_v2_rust-mimalloc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+default-devel-0.1.43-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+default-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+default-devel.sha256sum] = "7d812600c49408ebb493cfa745a0f0d8cd887c5b4d5cf775af08120b2c60a9a5"

URI_x86_64_v2_rust-mimalloc+extended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+extended-devel-0.1.43-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+extended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+extended-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+extended-devel.sha256sum] = "1674bb25759697c0fc5abb1008b1623e78a76592351e8661807f6195062c5e37"

URI_x86_64_v2_rust-mimalloc+local_dynamic_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+local_dynamic_tls-devel-0.1.43-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+local_dynamic_tls-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+local_dynamic_tls-devel.sha256sum] = "d49aa3de13690d468158ee5cd4787d35d5963d14b1cacd18e62a403a8681ad07"

URI_x86_64_v2_rust-mimalloc+no_thp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+no_thp-devel-0.1.43-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+no_thp-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+no_thp-devel.sha256sum] = "e7f6e02937ab8d10d8bddc154810e46fa2bec10abfbdcc0a6498a9869ea9fd53"

URI_x86_64_v2_rust-mimalloc+override-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+override-devel-0.1.43-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+override-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+override-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+override-devel.sha256sum] = "347bcd0743f13ed815d813c940956d1372363e352b4350601812d1e0b9561e48"

URI_x86_64_v2_rust-mimalloc+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc+secure-devel-0.1.43-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc+secure-devel}"
SRC_URI[x86_64_v2_rust-mimalloc+secure-devel.sha256sum] = "0761b19baad4432f3cbf7b1b0debb144cbedabd47a9cf9832e1bf7511ee4643e"

URI_x86_64_v2_rust-mimalloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mimalloc-devel-0.1.43-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mimalloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mimalloc-devel}"
SRC_URI[x86_64_v2_rust-mimalloc-devel.sha256sum] = "1902c0b45ede88abc6daf757b313755a98ef42cf90a086ca76f06e22d8f3ff10"

URI_aarch64_rust-mimalloc+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+debug-devel-0.1.43-2.el10_0.noarch.rpm;name=aarch64_rust-mimalloc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+debug-devel}"
SRC_URI[aarch64_rust-mimalloc+debug-devel.sha256sum] = "ec05abc4a7f25d12255431c1869c72ea374524fe94256448b390863a1cb7b1cc"

URI_aarch64_rust-mimalloc+debug_in_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+debug_in_debug-devel-0.1.43-2.el10_0.noarch.rpm;name=aarch64_rust-mimalloc+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+debug_in_debug-devel}"
SRC_URI[aarch64_rust-mimalloc+debug_in_debug-devel.sha256sum] = "47ba79b51234671e0ed40d504ec0372d970d7ddaa3fbd9934500b3e15e0da9ce"

URI_aarch64_rust-mimalloc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+default-devel-0.1.43-2.el10_0.noarch.rpm;name=aarch64_rust-mimalloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+default-devel}"
SRC_URI[aarch64_rust-mimalloc+default-devel.sha256sum] = "633ebb465c290c3ed7c566c3e946c6cbdc81b70af9c2ad63ecfd960090d500d0"

URI_aarch64_rust-mimalloc+extended-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+extended-devel-0.1.43-2.el10_0.noarch.rpm;name=aarch64_rust-mimalloc+extended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+extended-devel}"
SRC_URI[aarch64_rust-mimalloc+extended-devel.sha256sum] = "9ad290214a9c7071cb407c3e97ce960f5ca7fe154f7e10c49c935d8e4f85c3e8"

URI_aarch64_rust-mimalloc+local_dynamic_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+local_dynamic_tls-devel-0.1.43-2.el10_0.noarch.rpm;name=aarch64_rust-mimalloc+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+local_dynamic_tls-devel}"
SRC_URI[aarch64_rust-mimalloc+local_dynamic_tls-devel.sha256sum] = "9e0505b6f5fb03a83f70d48a7a1d6f2f48ee510b1cb7de9c082a2c12f2a321ce"

URI_aarch64_rust-mimalloc+no_thp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+no_thp-devel-0.1.43-2.el10_0.noarch.rpm;name=aarch64_rust-mimalloc+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+no_thp-devel}"
SRC_URI[aarch64_rust-mimalloc+no_thp-devel.sha256sum] = "e05188067d72939c9c49eea0727c8e896b1d67bce72bfa9c3a1c3a64829b10d6"

URI_aarch64_rust-mimalloc+override-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+override-devel-0.1.43-2.el10_0.noarch.rpm;name=aarch64_rust-mimalloc+override-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+override-devel}"
SRC_URI[aarch64_rust-mimalloc+override-devel.sha256sum] = "43ea4fdcdb0711776a7d3fe2192ed2a0b3ddb6b4d0c945fd623c5de74fce85fc"

URI_aarch64_rust-mimalloc+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc+secure-devel-0.1.43-2.el10_0.noarch.rpm;name=aarch64_rust-mimalloc+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc+secure-devel}"
SRC_URI[aarch64_rust-mimalloc+secure-devel.sha256sum] = "1b3ada543228433b7a34422a6d1a3b984c05522d6f96c568e506a171d45300b2"

URI_aarch64_rust-mimalloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mimalloc-devel-0.1.43-2.el10_0.noarch.rpm;name=aarch64_rust-mimalloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mimalloc-devel}"
SRC_URI[aarch64_rust-mimalloc-devel.sha256sum] = "6a24c147d75e1b3a6071b790c0da0de85fcc6e64bdbc4f3dc7cf789dfc4764b5"

RDEPENDS:rust-mimalloc+debug-devel = " \
 cargo \
 rust-libmimalloc-sys+debug-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+debug_in_debug-devel = " \
 cargo \
 rust-libmimalloc-sys+debug_in_debug-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+default-devel = " \
 cargo \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+extended-devel = " \
 cargo \
 rust-libmimalloc-sys+extended-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+local_dynamic_tls-devel = " \
 cargo \
 rust-libmimalloc-sys+local_dynamic_tls-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+no_thp-devel = " \
 cargo \
 rust-libmimalloc-sys+no_thp-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+override-devel = " \
 cargo \
 rust-libmimalloc-sys+override-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc+secure-devel = " \
 cargo \
 rust-libmimalloc-sys+secure-devel \
 rust-mimalloc-devel \
 "
RDEPENDS:rust-mimalloc-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
