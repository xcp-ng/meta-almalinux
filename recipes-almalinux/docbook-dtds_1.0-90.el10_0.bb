# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "docbook-dtds"
PV = "1.0"
PR = "90.el10_0"
PACKAGES = " \
 docbook-dtds \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/docbook-dtds-1.0-90.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04e540a6be2803b8d3e364f4119be8302c93876ffcb87a6a1cf20a0d52300142"

URI_x86_64_v2_docbook-dtds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/docbook-dtds-1.0-90.el10_0.noarch.rpm;name=x86_64_v2_docbook-dtds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docbook-dtds}"
SRC_URI[x86_64_v2_docbook-dtds.sha256sum] = "694a9738894c0e53c89dd6138bb4b6ac1bc55fcfbd9a0a8f54eb89519eda624c"

URI_aarch64_docbook-dtds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/docbook-dtds-1.0-90.el10_0.noarch.rpm;name=aarch64_docbook-dtds;unpack=0"
SRC_URI:append = " ${URI_aarch64_docbook-dtds}"
SRC_URI[aarch64_docbook-dtds.sha256sum] = "694a9738894c0e53c89dd6138bb4b6ac1bc55fcfbd9a0a8f54eb89519eda624c"

RDEPENDS:docbook-dtds = " \
 bash \
 libxml2 \
 sed \
 sgml-common \
 virtual//usr/bin/chmod \
 xml-common \
 "
