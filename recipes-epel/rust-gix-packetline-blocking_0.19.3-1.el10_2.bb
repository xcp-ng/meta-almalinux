# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-packetline-blocking"
PV = "0.19.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-packetline-blocking+async-io-devel \
 rust-gix-packetline-blocking+blocking-io-devel \
 rust-gix-packetline-blocking+default-devel \
 rust-gix-packetline-blocking+document-features-devel \
 rust-gix-packetline-blocking+serde-devel \
 rust-gix-packetline-blocking-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-packetline-blocking-0.19.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8af2c125bd4d21a6247c8d25c5f9d7e7a03953d8614196073a6df6c90679e321"

URI_x86_64_v2_rust-gix-packetline-blocking+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+async-io-devel-0.19.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+async-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+async-io-devel.sha256sum] = "891b8d30893a97f8ecef2be5cb7b8fd84d9f74cd370bd8db0607477c9b13ac2d"

URI_x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+blocking-io-devel-0.19.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel.sha256sum] = "b220c6b5814ccfdb07af99fe861e5e3e160cd965ddffef53c21d52ba37cc8fef"

URI_x86_64_v2_rust-gix-packetline-blocking+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+default-devel-0.19.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+default-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+default-devel.sha256sum] = "ad03db6e0c02c9aa668ec980d525e9a41267f2c2dc863677b6f28b298885776d"

URI_x86_64_v2_rust-gix-packetline-blocking+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+document-features-devel-0.19.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+document-features-devel.sha256sum] = "1f2dc19389a7a92ffe7554907bd62b301c89d8dab6fe2d8cec40d83295709c15"

URI_x86_64_v2_rust-gix-packetline-blocking+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+serde-devel-0.19.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+serde-devel.sha256sum] = "eb990f28f72195f04df954311afed1236d7b963810eef566ec52b32d1a0c4a93"

URI_x86_64_v2_rust-gix-packetline-blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking-devel-0.19.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking-devel.sha256sum] = "976cb54d1a09b32589c5a873726cc6c8959e09cf7ff64db040adb15f6245a625"

URI_aarch64_rust-gix-packetline-blocking+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+async-io-devel-0.19.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+async-io-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+async-io-devel.sha256sum] = "dbb4b8166694124722769e47371adfbd09c5990d57ddcc815f382b54f714bd08"

URI_aarch64_rust-gix-packetline-blocking+blocking-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+blocking-io-devel-0.19.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+blocking-io-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+blocking-io-devel.sha256sum] = "d71de9e55aa6aec9d8428e7a396bc81b99b2fb0b685e4f3fe60950b68af94c2b"

URI_aarch64_rust-gix-packetline-blocking+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+default-devel-0.19.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+default-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+default-devel.sha256sum] = "50b117764844754d1fb239f31263aabe33261b033119dfeb674e0fd301355d43"

URI_aarch64_rust-gix-packetline-blocking+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+document-features-devel-0.19.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+document-features-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+document-features-devel.sha256sum] = "de8534018973efa896eef838edadec15f80b7666ed07c0cf7fa359365c868ce4"

URI_aarch64_rust-gix-packetline-blocking+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+serde-devel-0.19.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+serde-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+serde-devel.sha256sum] = "8b2a1ef9661bfc4e2b807f39ae1c1a9dedb8d51169524bb6f31df755ae749d2d"

URI_aarch64_rust-gix-packetline-blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking-devel-0.19.3-1.el10_2.noarch.rpm;name=aarch64_rust-gix-packetline-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking-devel.sha256sum] = "6043891d20d6b74c0a0e7e6bc8737328e682762f4fca963f78a8db7bc02baf09"

RDEPENDS:rust-gix-packetline-blocking+async-io-devel = " \
 cargo \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+blocking-io-devel = " \
 cargo \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+default-devel = " \
 cargo \
 rust-gix-packetline-blocking+blocking-io-devel \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-faster-hex+serde-devel \
 rust-gix-packetline-blocking-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-packetline-blocking-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 rust-gix-trace+default-devel \
 rust-thiserror+default-devel \
 "
