# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdepim-runtime"
PE = "1"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdepim-runtime \
 kdepim-runtime-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdepim-runtime-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f84c3699520ec1b4877110bff59050d5215462b762ce4bb93383cd46a46eacfb"

URI_x86_64_v2_kdepim-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-runtime-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdepim-runtime}"
SRC_URI[x86_64_v2_kdepim-runtime.sha256sum] = "bfe5e40124ff2586285a1587b911ad69a61c380c31f74aa5e9a549c0f726aab5"

URI_x86_64_v2_kdepim-runtime-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-runtime-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-runtime-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdepim-runtime-libs}"
SRC_URI[x86_64_v2_kdepim-runtime-libs.sha256sum] = "3700f3abd861015759dc712640a6d494c56a848741876a97ef0b4c56df1042bb"

URI_aarch64_kdepim-runtime = "${EPEL_MIRROR}/aarch64/Packages/k/kdepim-runtime-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdepim-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdepim-runtime}"
SRC_URI[aarch64_kdepim-runtime.sha256sum] = "cc8affa6771a36012b94f4ea9dee683b26fa247dc278e74fdcfa67c257fca9cc"

URI_aarch64_kdepim-runtime-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kdepim-runtime-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdepim-runtime-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdepim-runtime-libs}"
SRC_URI[aarch64_kdepim-runtime-libs.sha256sum] = "cbcd42b6de66af71b8cc228899a352ca43f3eaaa1ee91ed22fe75072f409e0ba"

RDEPENDS:kdepim-runtime = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 cyrus-sasl-lib \
 glibc \
 kdepim-runtime-libs \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdav \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kidentitymanagement \
 kimap \
 kmailtransport \
 kmbox \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libkgapi \
 libstdc++ \
 pimcommon \
 qca-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtnetworkauth \
 qt6-qtspeech \
 qt6-qtwebengine \
 qtkeychain-qt6 \
 "
RDEPENDS:kdepim-runtime-libs = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdav \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 kimap \
 kldap \
 kmailtransport \
 kmbox \
 kmime \
 libgcc \
 libkgapi \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
