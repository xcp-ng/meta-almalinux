# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-novaclient"
PE = "1"
PV = "18.12.0"
PR = "1.el10_3"
PACKAGES = " \
 python-novaclient-doc \
 python3-novaclient \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-novaclient-18.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79088e52d9c08830c4baa505ce4dbbc1e85d518665b3622d9cd8e8e6df91d6ca"

URI_x86_64_v2_python-novaclient-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-novaclient-doc-18.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-novaclient-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-novaclient-doc}"
SRC_URI[x86_64_v2_python-novaclient-doc.sha256sum] = "582e459065b6f4042dbbc22c99315ffe064a50cfdad72bafcdfdc6ae89af5c52"

URI_x86_64_v2_python3-novaclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-novaclient-18.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-novaclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-novaclient}"
SRC_URI[x86_64_v2_python3-novaclient.sha256sum] = "91248a0cb39fadb6d69072405a865ed597acdd1a46b7712a8c2f5fefa00d4c67"

URI_aarch64_python-novaclient-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-novaclient-doc-18.12.0-1.el10_3.noarch.rpm;name=aarch64_python-novaclient-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-novaclient-doc}"
SRC_URI[aarch64_python-novaclient-doc.sha256sum] = "d2db655f9f7d09bfd9e48f7f3c82c42e3452f061e5da10f9c9bd3f3353874c3e"

URI_aarch64_python3-novaclient = "${EPEL_MIRROR}/aarch64/Packages/p/python3-novaclient-18.12.0-1.el10_3.noarch.rpm;name=aarch64_python3-novaclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-novaclient}"
SRC_URI[aarch64_python3-novaclient.sha256sum] = "3c673d90518d63b7b596d0af8dfc5acbb58de29851ce3be6b28b3ac210642acf"

RDEPENDS:python-novaclient-doc = " \
 "
RDEPENDS:python3-novaclient = " \
 python3 \
 python3-iso8601 \
 python3-keystoneauth1 \
 python3-oslo-i18n \
 python3-oslo-serialization \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 python3-stevedore \
 "
