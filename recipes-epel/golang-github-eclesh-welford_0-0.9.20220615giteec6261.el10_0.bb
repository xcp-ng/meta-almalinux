# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-eclesh-welford"
PV = "0"
PR = "0.9.20220615giteec6261.el10_0"
PACKAGES = " \
 golang-github-eclesh-welford-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-eclesh-welford-0-0.9.20220615giteec6261.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "894aae1c8516518d530e17f6743c4e952a5f544522255a3faae80637c92c5174"

URI_aarch64_golang-github-eclesh-welford-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-eclesh-welford-devel-0-0.9.20220615giteec6261.el10_0.noarch.rpm;name=aarch64_golang-github-eclesh-welford-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-eclesh-welford-devel}"
SRC_URI[aarch64_golang-github-eclesh-welford-devel.sha256sum] = "6f3136b5e287bd0df7b5c13bf2815a493cbf68c2cc13f65867036ea9b9bdd305"

RDEPENDS:golang-github-eclesh-welford-devel = " \
 go-filesystem \
 "
