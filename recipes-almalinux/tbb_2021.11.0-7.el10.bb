# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tbb"
PV = "2021.11.0"
PR = "7.el10"
PACKAGES = " \
 python3-tbb \
 tbb \
 tbb-bind \
 tbb-devel \
 tbb-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tbb-2021.11.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4c721e8a46c13f9e88df040082be21636142eac3c42798ca8d7cdce5c3e0df2"

URI_x86_64_v2_python3-tbb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tbb-2021.11.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tbb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tbb}"
SRC_URI[x86_64_v2_python3-tbb.sha256sum] = "384a0ef98e5987aa68dad3951e7985b974c56b7b66449b290db6bc652bd85ffb"

URI_x86_64_v2_tbb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-2021.11.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_tbb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tbb}"
SRC_URI[x86_64_v2_tbb.sha256sum] = "bcdb0c2002f1ad3bde3c90104413c6a9c2e2ba3a929fe455e0a41ff0e2c838d9"

URI_x86_64_v2_tbb-bind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-bind-2021.11.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_tbb-bind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tbb-bind}"
SRC_URI[x86_64_v2_tbb-bind.sha256sum] = "e098e0827361a830675b4c491e4c1526551da8545e87eb1935c3fc5fac92c162"

URI_x86_64_v2_tbb-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-devel-2021.11.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_tbb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tbb-devel}"
SRC_URI[x86_64_v2_tbb-devel.sha256sum] = "08c5642706e2ceaf5b565afecee3800cc5eabd1593a3fd9b39adf563d287fdea"

URI_x86_64_v2_tbb-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tbb-doc-2021.11.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_tbb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tbb-doc}"
SRC_URI[x86_64_v2_tbb-doc.sha256sum] = "46617d49fbf655fb49ffd519924a332e11ca4f05d20df708fa7c654a7c45e7f5"

URI_aarch64_python3-tbb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tbb-2021.11.0-7.el10.aarch64.rpm;name=aarch64_python3-tbb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tbb}"
SRC_URI[aarch64_python3-tbb.sha256sum] = "d4a32570d9d398022c3a3db8068a1786b08a50dddc1168341003ca6b8bddfd7d"

URI_aarch64_tbb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-2021.11.0-7.el10.aarch64.rpm;name=aarch64_tbb;unpack=0"
SRC_URI:append = " ${URI_aarch64_tbb}"
SRC_URI[aarch64_tbb.sha256sum] = "cfa4d73640db069bbd274cd0daecb8635759380867a6b5a7e2fccda89353ce0c"

URI_aarch64_tbb-bind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-bind-2021.11.0-7.el10.aarch64.rpm;name=aarch64_tbb-bind;unpack=0"
SRC_URI:append = " ${URI_aarch64_tbb-bind}"
SRC_URI[aarch64_tbb-bind.sha256sum] = "db4aeed79b488db37e1831b9e34b27043b347c15f5aaf1e7891d3b055390c116"

URI_aarch64_tbb-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-devel-2021.11.0-7.el10.aarch64.rpm;name=aarch64_tbb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tbb-devel}"
SRC_URI[aarch64_tbb-devel.sha256sum] = "73e2954b9d7593707a34a2e26b06da8dcc25dc880889b48f75d2fd171e6c15a9"

URI_aarch64_tbb-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tbb-doc-2021.11.0-7.el10.aarch64.rpm;name=aarch64_tbb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_tbb-doc}"
SRC_URI[aarch64_tbb-doc.sha256sum] = "0ce2d6a9bafb25cd8566c44324f338bf6a0e747042c21a8c62b23545a94ee457"

RDEPENDS:python3-tbb = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 tbb \
 "
RDEPENDS:tbb = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:tbb-bind = " \
 glibc \
 hwloc-libs \
 libgcc \
 libstdc++ \
 tbb \
 "
RDEPENDS:tbb-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 tbb \
 tbb-bind \
 "
RDEPENDS:tbb-doc = " \
 "
