# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdbusmenu"
PV = "16.04.0"
PR = "32.el10"
PACKAGES = " \
 libdbusmenu \
 libdbusmenu-devel \
 libdbusmenu-gtk3 \
 libdbusmenu-gtk3-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/libdbusmenu-16.04.0-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6df774db353d23722cdd61a60fbbf782ef22b3b2b347aba5b8454d0336f20c86"

URI_x86_64_v2_libdbusmenu = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdbusmenu-16.04.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_libdbusmenu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbusmenu}"
SRC_URI[x86_64_v2_libdbusmenu.sha256sum] = "6c4e458891fd53bea17d9da3002cfbdf3d8040602cf8ac167c39686b8183797c"

URI_x86_64_v2_libdbusmenu-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdbusmenu-devel-16.04.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_libdbusmenu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbusmenu-devel}"
SRC_URI[x86_64_v2_libdbusmenu-devel.sha256sum] = "c3f42787344150b41061f5979c0f38885c68abebbe4cdd1b3cba9620c18adedc"

URI_x86_64_v2_libdbusmenu-gtk3 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdbusmenu-gtk3-16.04.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_libdbusmenu-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbusmenu-gtk3}"
SRC_URI[x86_64_v2_libdbusmenu-gtk3.sha256sum] = "5198e773b00752f812f43548ece466fcc150d7125122f8a3db6cd42cff13c1ac"

URI_x86_64_v2_libdbusmenu-gtk3-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdbusmenu-gtk3-devel-16.04.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_libdbusmenu-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbusmenu-gtk3-devel}"
SRC_URI[x86_64_v2_libdbusmenu-gtk3-devel.sha256sum] = "15a468279fac7ce7fe77d29248922fc1cc2f52f1e452661b645b424f7282506a"

URI_aarch64_libdbusmenu = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdbusmenu-16.04.0-32.el10.aarch64.rpm;name=aarch64_libdbusmenu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbusmenu}"
SRC_URI[aarch64_libdbusmenu.sha256sum] = "f32f3292035994107695d6cbbdf07f1b4aa0cf0b36cefa6a122780372baf715a"

URI_aarch64_libdbusmenu-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdbusmenu-devel-16.04.0-32.el10.aarch64.rpm;name=aarch64_libdbusmenu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbusmenu-devel}"
SRC_URI[aarch64_libdbusmenu-devel.sha256sum] = "ec8499b7c39d55075c3b55ca0080975f76bb76ba9261dec7c7642f1568ad2058"

URI_aarch64_libdbusmenu-gtk3 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdbusmenu-gtk3-16.04.0-32.el10.aarch64.rpm;name=aarch64_libdbusmenu-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbusmenu-gtk3}"
SRC_URI[aarch64_libdbusmenu-gtk3.sha256sum] = "6d0150ea9493a2b26e2212684c196f7055084b48c1a6019b19d2dca5901a551d"

URI_aarch64_libdbusmenu-gtk3-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdbusmenu-gtk3-devel-16.04.0-32.el10.aarch64.rpm;name=aarch64_libdbusmenu-gtk3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbusmenu-gtk3-devel}"
SRC_URI[aarch64_libdbusmenu-gtk3-devel.sha256sum] = "fa9412d9f9a5f7c4c2b5ffcec6b6c9f7742380916fcdd3554488d1cf4b7cb4ce"

RDEPENDS:libdbusmenu = " \
 glib2 \
 glibc \
 "
RDEPENDS:libdbusmenu-devel = " \
 libdbusmenu \
 pkgconf-pkg-config \
 "
RDEPENDS:libdbusmenu-gtk3 = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libdbusmenu \
 pango \
 "
RDEPENDS:libdbusmenu-gtk3-devel = " \
 gdk-pixbuf2-devel \
 gtk3-devel \
 libdbusmenu \
 libdbusmenu-devel \
 libdbusmenu-gtk3 \
 pkgconf-pkg-config \
 "
