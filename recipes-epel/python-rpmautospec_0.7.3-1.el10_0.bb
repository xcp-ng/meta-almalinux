# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rpmautospec"
PV = "0.7.3"
PR = "1.el10_0"
PACKAGES = " \
 python3-rpmautospec \
 rpmautospec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rpmautospec-0.7.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78c3a8c80147c97e4b49d8c0acaa574b95b943231f0c67a96940055f75bb73e4"

URI_x86_64_v2_python3-rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rpmautospec-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpmautospec}"
SRC_URI[x86_64_v2_python3-rpmautospec.sha256sum] = "3fe2ce7b860317db247a372ea8d51ebcf88d570526cb65941e90d8bc78ba6a0e"

URI_x86_64_v2_rpmautospec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmautospec-0.7.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rpmautospec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmautospec}"
SRC_URI[x86_64_v2_rpmautospec.sha256sum] = "963751e7b2aa9a9468504e8b708cc81083e99a760f30368e1722ed56b80f1993"

URI_aarch64_python3-rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rpmautospec-0.7.3-1.el10_0.noarch.rpm;name=aarch64_python3-rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpmautospec}"
SRC_URI[aarch64_python3-rpmautospec.sha256sum] = "699bc36929f64827262182982decba874f81dd95caef1cd0a9488be31aa634ba"

URI_aarch64_rpmautospec = "${EPEL_MIRROR}/aarch64/Packages/r/rpmautospec-0.7.3-1.el10_0.noarch.rpm;name=aarch64_rpmautospec;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmautospec}"
SRC_URI[aarch64_rpmautospec.sha256sum] = "a5502d1753adf4d5dbadfd240978a9c0210de391e8976c834136c9cdf5629727"

RDEPENDS:python3-rpmautospec = " \
 python3 \
 python3-babel \
 python3-click \
 python3-click-plugins \
 python3-pygit2 \
 python3-rpm \
 python3-rpmautospec-core \
 "
RDEPENDS:rpmautospec = " \
 python3 \
 python3-rpmautospec \
 "
