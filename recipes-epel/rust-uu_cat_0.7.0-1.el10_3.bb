# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_cat"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_cat+default-devel \
 rust-uu_cat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_cat-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79ef765cf3428f33898342e23d14057245cab5ff8c9b8c55b3cd96170847c3dd"

URI_x86_64_v2_rust-uu_cat+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cat+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cat+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cat+default-devel}"
SRC_URI[x86_64_v2_rust-uu_cat+default-devel.sha256sum] = "1a7b63ae8cf84c3a6d1fcff82ab5247c0872bf5a7b69ad2fd8e037b545ba48de"

URI_x86_64_v2_rust-uu_cat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cat-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cat-devel}"
SRC_URI[x86_64_v2_rust-uu_cat-devel.sha256sum] = "80afaf6b16091267c5dd39ccda0904f897c4518495cc0bbfac11fefe26a2ab35"

URI_aarch64_rust-uu_cat+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cat+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_cat+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cat+default-devel}"
SRC_URI[aarch64_rust-uu_cat+default-devel.sha256sum] = "f6ddba8171f16544815c5ce168d3ac649bf24fdfb7351e88c4d3c8117aa32924"

URI_aarch64_rust-uu_cat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cat-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_cat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cat-devel}"
SRC_URI[aarch64_rust-uu_cat-devel.sha256sum] = "05b29095413859727d4593885cdce9cbdcfc8536ff73e463d4ed5fd5805047cb"

RDEPENDS:rust-uu_cat+default-devel = " \
 cargo \
 rust-uu_cat-devel \
 "
RDEPENDS:rust-uu_cat-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-memchr+default-devel \
 rust-nix0.30-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fast-inc-devel \
 rust-uucore+fs-devel \
 rust-uucore+pipes-devel \
 rust-uucore+signals-devel \
 "
