# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-ident"
PV = "1.0.26"
PR = "1.el10_3"
PACKAGES = " \
 rust-unicode-ident+default-devel \
 rust-unicode-ident-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-ident-1.0.26-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cb4608aae3484e85633ba3dcbfa71b8a21232c3e5522b92225e56e2c3e401321"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident+default-devel-1.0.26-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-ident+default-devel.sha256sum] = "67b348a8da966ad308daf09a4fae2d0025600d501b969ded9c9eebf62e1a700d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-ident-devel-1.0.26-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-ident-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-ident-devel.sha256sum] = "4417e5448546505d3a724a86b843aae3e198f911f0caf4f5363b4dc2903b621a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident+default-devel-1.0.26-1.el10_3.noarch.rpm;name=aarch64_rust-unicode-ident+default-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-ident+default-devel.sha256sum] = "f06e34499a4bd2fa0304f33920d1b16792cbee874a5a21f1e5be54fcb872522d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-ident-devel-1.0.26-1.el10_3.noarch.rpm;name=aarch64_rust-unicode-ident-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-ident-devel.sha256sum] = "323872133380db4b3c7724010860ffaf541b86e90c6d3e91100e643d45e89dd9"

RDEPENDS:rust-unicode-ident+default-devel = " \
 cargo \
 rust-unicode-ident-devel \
 "
RDEPENDS:rust-unicode-ident-devel = " \
 cargo \
 rust \
 "
