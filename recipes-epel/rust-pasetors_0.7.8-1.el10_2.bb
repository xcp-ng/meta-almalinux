# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pasetors"
PV = "0.7.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-pasetors+default-devel \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors+p384-devel \
 rust-pasetors+paserk-devel \
 rust-pasetors+rand_core-devel \
 rust-pasetors+regex-devel \
 rust-pasetors+serde-devel \
 rust-pasetors+serde_json-devel \
 rust-pasetors+sha2-devel \
 rust-pasetors+std-devel \
 rust-pasetors+time-devel \
 rust-pasetors+v2-devel \
 rust-pasetors+v3-devel \
 rust-pasetors+v4-devel \
 rust-pasetors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pasetors-0.7.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14d35f647d7f8ff419ed2d9cb7f496d73ab7696d3cdeea25a88f75fa7b5e5dc1"

URI_x86_64_v2_rust-pasetors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+default-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+default-devel}"
SRC_URI[x86_64_v2_rust-pasetors+default-devel.sha256sum] = "eff951142b2c35614ae9df12d1483b2107ccc531bf89f8703d57ea9a8e5368e1"

URI_x86_64_v2_rust-pasetors+ed25519-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+ed25519-compact-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+ed25519-compact-devel}"
SRC_URI[x86_64_v2_rust-pasetors+ed25519-compact-devel.sha256sum] = "330b580e17ebc0837ff14f0b18f0eb195705c8ec65df5015b2c73b530d3ac884"

URI_x86_64_v2_rust-pasetors+orion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+orion-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+orion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+orion-devel}"
SRC_URI[x86_64_v2_rust-pasetors+orion-devel.sha256sum] = "0a85e0bc4b4e974cc18fbd08019e7243a8f2c1db29fa9347f9d15f9b0d578f1a"

URI_x86_64_v2_rust-pasetors+p384-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+p384-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+p384-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+p384-devel}"
SRC_URI[x86_64_v2_rust-pasetors+p384-devel.sha256sum] = "b87056f159c37dd2d7819f7dd5d8a701bd9cc6e75787fe2d584a4f8f55efd095"

URI_x86_64_v2_rust-pasetors+paserk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+paserk-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+paserk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+paserk-devel}"
SRC_URI[x86_64_v2_rust-pasetors+paserk-devel.sha256sum] = "fce365dac9b055d59222839be77035dd001366c77f63f0bf502236dbeb33cbef"

URI_x86_64_v2_rust-pasetors+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+rand_core-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+rand_core-devel}"
SRC_URI[x86_64_v2_rust-pasetors+rand_core-devel.sha256sum] = "fa65fed226a269ad3f46e67ee175d3e31c7cce1dfb7e50c31a036d38dfeecc8f"

URI_x86_64_v2_rust-pasetors+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+regex-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+regex-devel}"
SRC_URI[x86_64_v2_rust-pasetors+regex-devel.sha256sum] = "4032e6f4a3830c1d616db254f73b447ddb9dbeac87bd9ca60deb4f26ca17065f"

URI_x86_64_v2_rust-pasetors+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+serde-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+serde-devel}"
SRC_URI[x86_64_v2_rust-pasetors+serde-devel.sha256sum] = "347a4bd73261ba98f59e817c9b61cbed002d8a9b378a94da239cfbe1010c3a03"

URI_x86_64_v2_rust-pasetors+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+serde_json-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+serde_json-devel}"
SRC_URI[x86_64_v2_rust-pasetors+serde_json-devel.sha256sum] = "604f812543454406b655e9286934cff5e7cd94d59f2739e66eb52f724e47222f"

URI_x86_64_v2_rust-pasetors+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+sha2-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+sha2-devel}"
SRC_URI[x86_64_v2_rust-pasetors+sha2-devel.sha256sum] = "662268948ad69ecd6e295af7350048bfd24596030d5097b0356c5c2c85fa9ec3"

URI_x86_64_v2_rust-pasetors+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+std-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+std-devel}"
SRC_URI[x86_64_v2_rust-pasetors+std-devel.sha256sum] = "d6cc5b60826950e8f2a4444438079312330e5d51d39fd583d95ce6caa0e4d31f"

URI_x86_64_v2_rust-pasetors+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+time-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+time-devel}"
SRC_URI[x86_64_v2_rust-pasetors+time-devel.sha256sum] = "a2076f6a8dbc0eecb58157bd8e7e28d6556c541e3f82dba6e1e1c2ed538bc60d"

URI_x86_64_v2_rust-pasetors+v2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v2-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v2-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v2-devel.sha256sum] = "dd2458e71bd6b2a332ee7a0c09adefbfc329d40b4ff06392c6d47b5b7551eaa1"

URI_x86_64_v2_rust-pasetors+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v3-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v3-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v3-devel.sha256sum] = "d955649fe4588d1ec20c81617861e87116e789dc92715da801a1b709002558af"

URI_x86_64_v2_rust-pasetors+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v4-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v4-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v4-devel.sha256sum] = "f8c26a8b796db524fcbded6950aedfaa707ef8e22717c15b87f94933403036b2"

URI_x86_64_v2_rust-pasetors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors-devel-0.7.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors-devel}"
SRC_URI[x86_64_v2_rust-pasetors-devel.sha256sum] = "afa5c1129b1eff868b63b1bb4313d29399902580a9b506afb24e23fc778e83b5"

URI_aarch64_rust-pasetors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+default-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+default-devel}"
SRC_URI[aarch64_rust-pasetors+default-devel.sha256sum] = "78d67465077c7f389df7b057e106a598b516cdce98c68c046b4eff84a7d31b73"

URI_aarch64_rust-pasetors+ed25519-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+ed25519-compact-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+ed25519-compact-devel}"
SRC_URI[aarch64_rust-pasetors+ed25519-compact-devel.sha256sum] = "89426743b96d39b8f579467be6992b231fa01b0dd955676791f8acb2d53d00f0"

URI_aarch64_rust-pasetors+orion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+orion-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+orion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+orion-devel}"
SRC_URI[aarch64_rust-pasetors+orion-devel.sha256sum] = "cb0346b0965b13db91f4dd5b4e2e40d0cf64eaa5f16ab61640d2e6ed6190da77"

URI_aarch64_rust-pasetors+p384-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+p384-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+p384-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+p384-devel}"
SRC_URI[aarch64_rust-pasetors+p384-devel.sha256sum] = "e89f2caa34ae8e8b77ab34fca79029cb38b1d6c39d33e1450489b870187f4161"

URI_aarch64_rust-pasetors+paserk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+paserk-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+paserk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+paserk-devel}"
SRC_URI[aarch64_rust-pasetors+paserk-devel.sha256sum] = "a0223512031060752bd39bde6e3f8ea1757523924e32edab3bcfe62ae4749c45"

URI_aarch64_rust-pasetors+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+rand_core-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+rand_core-devel}"
SRC_URI[aarch64_rust-pasetors+rand_core-devel.sha256sum] = "96ce9b2f403c1e3f523ccab61be58cf435465fbcbc70aa3f018598652263387a"

URI_aarch64_rust-pasetors+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+regex-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+regex-devel}"
SRC_URI[aarch64_rust-pasetors+regex-devel.sha256sum] = "4b387768e088a734f7568abce8bf655ee73d8987c1384e9794528595013292f1"

URI_aarch64_rust-pasetors+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+serde-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+serde-devel}"
SRC_URI[aarch64_rust-pasetors+serde-devel.sha256sum] = "8784189b57c329a1d3cb761c64d0757005d5ea1e20985329dbc947c1c6a51f5e"

URI_aarch64_rust-pasetors+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+serde_json-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+serde_json-devel}"
SRC_URI[aarch64_rust-pasetors+serde_json-devel.sha256sum] = "a3877e3977c2bba4127eba1369a10bdb8be499322ea9d6709780709e0c216807"

URI_aarch64_rust-pasetors+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+sha2-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+sha2-devel}"
SRC_URI[aarch64_rust-pasetors+sha2-devel.sha256sum] = "5c37bc260a1738bdf25935250128c3b8e278bdcebc1d4abeb491bd68c5e94e1e"

URI_aarch64_rust-pasetors+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+std-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+std-devel}"
SRC_URI[aarch64_rust-pasetors+std-devel.sha256sum] = "c1c42ba235e8d2f1f07411e323a23a335d199196393a69ca21c3d14a9ec1a928"

URI_aarch64_rust-pasetors+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+time-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+time-devel}"
SRC_URI[aarch64_rust-pasetors+time-devel.sha256sum] = "248b94ca6bb4387bb34b2ad558f0b2277d95f5995bb1dd021cda1b3313c82dfa"

URI_aarch64_rust-pasetors+v2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v2-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+v2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v2-devel}"
SRC_URI[aarch64_rust-pasetors+v2-devel.sha256sum] = "06426f3e7fdd007dbad7221592bf94574e635ebc5c6fbf61bb9e269f425224c5"

URI_aarch64_rust-pasetors+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v3-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v3-devel}"
SRC_URI[aarch64_rust-pasetors+v3-devel.sha256sum] = "6d9dde27674ae660bbf82c558e894920d8611cc802a0d273d1d90bb786592111"

URI_aarch64_rust-pasetors+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v4-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v4-devel}"
SRC_URI[aarch64_rust-pasetors+v4-devel.sha256sum] = "a588c7f1cd75074c622271b9e264f91bf5a92c61689aba9a4b164d200bb3234f"

URI_aarch64_rust-pasetors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors-devel-0.7.8-1.el10_2.noarch.rpm;name=aarch64_rust-pasetors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors-devel}"
SRC_URI[aarch64_rust-pasetors-devel.sha256sum] = "d28f2b82907bb0c8887efaf71a6ad8588d108a2288e28e4325a3351f8cb870fe"

RDEPENDS:rust-pasetors+default-devel = " \
 cargo \
 rust-pasetors+paserk-devel \
 rust-pasetors+std-devel \
 rust-pasetors+v4-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+ed25519-compact-devel = " \
 cargo \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+orion-devel = " \
 cargo \
 rust-orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+p384-devel = " \
 cargo \
 rust-p384+default-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+paserk-devel = " \
 cargo \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+rand_core-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-pasetors+regex-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-pasetors+serde-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-pasetors+serde_json-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-pasetors+sha2-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-pasetors+std-devel = " \
 cargo \
 rust-pasetors+regex-devel \
 rust-pasetors+serde_json-devel \
 rust-pasetors+time-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+time-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-pasetors+v2-devel = " \
 cargo \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+v3-devel = " \
 cargo \
 rust-pasetors+p384-devel \
 rust-pasetors+rand_core-devel \
 rust-pasetors+sha2-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+v4-devel = " \
 cargo \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors-devel = " \
 cargo \
 rust \
 rust-ct-codecs-devel \
 rust-getrandom+default-devel \
 rust-subtle-devel \
 rust-zeroize-devel \
 "
