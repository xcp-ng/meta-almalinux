# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksshaskpass"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 ksshaskpass \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksshaskpass-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0df94ff6057dc8ba8f686082c88ad4d74d0b9345785e5bbb195cd570218133e"

URI_x86_64_v2_ksshaskpass = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksshaskpass-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksshaskpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksshaskpass}"
SRC_URI[x86_64_v2_ksshaskpass.sha256sum] = "6cea7d836b8efab6be6187493dc05ef5452ec0de99002f9508b5dbcb67654f78"

URI_aarch64_ksshaskpass = "${EPEL_MIRROR}/aarch64/Packages/k/ksshaskpass-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_ksshaskpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksshaskpass}"
SRC_URI[aarch64_ksshaskpass.sha256sum] = "4bdae5f2d1f5c37dd009141564c94d83a7226d644f3a0b8f85dc16512a6af3d1"

RDEPENDS:ksshaskpass = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
