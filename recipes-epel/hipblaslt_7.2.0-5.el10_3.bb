# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipblaslt"
PV = "7.2.0"
PR = "5.el10_3"
PACKAGES:x86_64_v2 = " \
 hipblaslt \
 hipblaslt-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipblaslt-7.2.0-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba0b9bd3fbdd87d7434439288787e1f5752703a4da2b244d7d31d6bdecc8be84"

URI_x86_64_v2_hipblaslt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblaslt-7.2.0-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblaslt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblaslt}"
SRC_URI[x86_64_v2_hipblaslt.sha256sum] = "77fbf467cacb5cb181371072c06e818d1c4f16c12d66d08a05e9c865654b7459"

URI_x86_64_v2_hipblaslt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipblaslt-devel-7.2.0-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipblaslt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipblaslt-devel}"
SRC_URI[x86_64_v2_hipblaslt-devel.sha256sum] = "3ea1b653026770c35617634ce85f86cc36d9cae25e8c66c332d69523deebf8d2"

RDEPENDS:hipblaslt = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 rocm-origami \
 "
RDEPENDS:hipblaslt-devel = " \
 cmake-filesystem \
 hipblaslt \
 "
