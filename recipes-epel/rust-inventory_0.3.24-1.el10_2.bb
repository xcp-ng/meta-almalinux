# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inventory"
PV = "0.3.24"
PR = "1.el10_2"
PACKAGES = " \
 rust-inventory+default-devel \
 rust-inventory-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inventory-0.3.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7bdafa646e62218b5ec4e1b979498b849ea8d01b7ae34dc3b514fd0480e8a67"

URI_x86_64_v2_rust-inventory+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inventory+default-devel-0.3.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inventory+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inventory+default-devel}"
SRC_URI[x86_64_v2_rust-inventory+default-devel.sha256sum] = "2fddb44cf44592114620aac95a9d0cb7c05509584a49406fcc86a5bed71d25a7"

URI_x86_64_v2_rust-inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inventory-devel-0.3.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inventory-devel}"
SRC_URI[x86_64_v2_rust-inventory-devel.sha256sum] = "ec66f6d83bd15c25ff877092e3ad127760705d4980b850b10daba7cfb7a28a08"

URI_aarch64_rust-inventory+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inventory+default-devel-0.3.24-1.el10_2.noarch.rpm;name=aarch64_rust-inventory+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inventory+default-devel}"
SRC_URI[aarch64_rust-inventory+default-devel.sha256sum] = "48b3da5fb6754ebd39b21b8d964cddab81d2887ea4f27742d20b72635d229bf0"

URI_aarch64_rust-inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inventory-devel-0.3.24-1.el10_2.noarch.rpm;name=aarch64_rust-inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inventory-devel}"
SRC_URI[aarch64_rust-inventory-devel.sha256sum] = "0f421577545b3a14664cf992b591c02e499d6da485e9f60200602e0b3ea03445"

RDEPENDS:rust-inventory+default-devel = " \
 cargo \
 rust-inventory-devel \
 "
RDEPENDS:rust-inventory-devel = " \
 cargo \
 rust \
 "
