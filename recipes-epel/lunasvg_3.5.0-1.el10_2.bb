# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lunasvg"
PV = "3.5.0"
PR = "1.el10_2"
PACKAGES = " \
 lunasvg \
 lunasvg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lunasvg-3.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a44d235b90cc687c19bc46deb905c34f04d77158517883ed3a9de2a5524a69d6"

URI_x86_64_v2_lunasvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lunasvg-3.5.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lunasvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lunasvg}"
SRC_URI[x86_64_v2_lunasvg.sha256sum] = "5a3903c3aa24f16e4c0d0a45514f4bbbd0db0139346b898450890ee9cbca6449"

URI_x86_64_v2_lunasvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lunasvg-devel-3.5.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lunasvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lunasvg-devel}"
SRC_URI[x86_64_v2_lunasvg-devel.sha256sum] = "fe2da7b423116fe8be15e63615643e3b2a1a9117634f4704026351575699bda2"

URI_aarch64_lunasvg = "${EPEL_MIRROR}/aarch64/Packages/l/lunasvg-3.5.0-1.el10_2.aarch64.rpm;name=aarch64_lunasvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_lunasvg}"
SRC_URI[aarch64_lunasvg.sha256sum] = "f4863114fdce145797f961f9ca2afb4bf5c9ef08075bdf2bfedf5e055a600239"

URI_aarch64_lunasvg-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lunasvg-devel-3.5.0-1.el10_2.aarch64.rpm;name=aarch64_lunasvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lunasvg-devel}"
SRC_URI[aarch64_lunasvg-devel.sha256sum] = "e0c3192379edb5a837d7abe8432733e5bba40f81034bd79ab2955c686f2e6798"

RDEPENDS:lunasvg = " \
 glibc \
 libgcc \
 libstdc++ \
 plutovg \
 "
RDEPENDS:lunasvg-devel = " \
 cmake-filesystem \
 lunasvg \
 pkgconf-pkg-config \
 plutovg-devel \
 "
