# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmines"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmines \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmines-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49a02d83cfe97e9800e42cfb8243a3eca6d07ead6745be195ed5708661d85c7e"

URI_x86_64_v2_kmines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmines-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmines}"
SRC_URI[x86_64_v2_kmines.sha256sum] = "b058e0fd8d6aa44aca7b652f050f7e2c69e77f2c93ffb680be63a4c1e75cc6f8"

URI_aarch64_kmines = "${EPEL_MIRROR}/aarch64/Packages/k/kmines-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmines;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmines}"
SRC_URI[aarch64_kmines.sha256sum] = "186ec207343e02a9f9b25faa7ccb2e8114d70161152654bffaa8377beb217b20"

RDEPENDS:kmines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
