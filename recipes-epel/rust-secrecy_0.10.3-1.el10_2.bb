# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-secrecy"
PV = "0.10.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-secrecy+default-devel \
 rust-secrecy+serde-devel \
 rust-secrecy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-secrecy-0.10.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e99ac8c8484a6a258e995d4be22772e020abcac74400653e967068465ff77990"

URI_x86_64_v2_rust-secrecy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secrecy+default-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secrecy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secrecy+default-devel}"
SRC_URI[x86_64_v2_rust-secrecy+default-devel.sha256sum] = "d0838d7bc2f6694fe66d8fdca0eea058c67abad9de07377a8d7d424776ce34c8"

URI_x86_64_v2_rust-secrecy+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secrecy+serde-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secrecy+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secrecy+serde-devel}"
SRC_URI[x86_64_v2_rust-secrecy+serde-devel.sha256sum] = "3c13bbbc783a9d0e168212afdb9b0814fa5e404ecf1ff8c5e1a7708496863695"

URI_x86_64_v2_rust-secrecy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secrecy-devel-0.10.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secrecy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secrecy-devel}"
SRC_URI[x86_64_v2_rust-secrecy-devel.sha256sum] = "a49bb0916034c3ca3aefa42a86d94bb5bbd28bd099270a2a5c0de07acbb909b2"

URI_aarch64_rust-secrecy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secrecy+default-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-secrecy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secrecy+default-devel}"
SRC_URI[aarch64_rust-secrecy+default-devel.sha256sum] = "35753e235875a016836e951af41b57ec06d677e49c5ed3d9940ec32a17752a43"

URI_aarch64_rust-secrecy+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secrecy+serde-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-secrecy+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secrecy+serde-devel}"
SRC_URI[aarch64_rust-secrecy+serde-devel.sha256sum] = "d018642b9dd19aac6c49db46805d75910d677e53d2676055002f5aa9dbbb3503"

URI_aarch64_rust-secrecy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secrecy-devel-0.10.3-1.el10_2.noarch.rpm;name=aarch64_rust-secrecy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secrecy-devel}"
SRC_URI[aarch64_rust-secrecy-devel.sha256sum] = "441ff0c3c095c61c3814a0781cdcbf8892ad85e7a785046c4cdc6040ce0cac66"

RDEPENDS:rust-secrecy+default-devel = " \
 cargo \
 rust-secrecy-devel \
 "
RDEPENDS:rust-secrecy+serde-devel = " \
 cargo \
 rust-secrecy-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-secrecy-devel = " \
 cargo \
 rust \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
