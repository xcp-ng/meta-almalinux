# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-yaml-lint"
PV = "0.1.2"
PR = "8.el10_2"
PACKAGES = " \
 rubygem-yaml-lint \
 rubygem-yaml-lint-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-yaml-lint-0.1.2-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a57f5a74c858bd93c2ada5e92d4181b97fcc57ebab60f17c376c9d0b64721b7f"

URI_x86_64_v2_rubygem-yaml-lint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-yaml-lint-0.1.2-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-yaml-lint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-yaml-lint}"
SRC_URI[x86_64_v2_rubygem-yaml-lint.sha256sum] = "8f397e9603c8a55c27de98ae45776e1c2943790075e394a032bf20d0e201f5b8"

URI_x86_64_v2_rubygem-yaml-lint-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-yaml-lint-doc-0.1.2-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-yaml-lint-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-yaml-lint-doc}"
SRC_URI[x86_64_v2_rubygem-yaml-lint-doc.sha256sum] = "fc15d16627c92b0d038aadba8072375ba2693114d4ba014b15ed51806d8e3a9d"

URI_aarch64_rubygem-yaml-lint = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-yaml-lint-0.1.2-8.el10_2.noarch.rpm;name=aarch64_rubygem-yaml-lint;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-yaml-lint}"
SRC_URI[aarch64_rubygem-yaml-lint.sha256sum] = "4d7b07025e82d86f626e14edf31b18d84341ff8fa9f336ac35e9cc4f6453373d"

URI_aarch64_rubygem-yaml-lint-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-yaml-lint-doc-0.1.2-8.el10_2.noarch.rpm;name=aarch64_rubygem-yaml-lint-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-yaml-lint-doc}"
SRC_URI[aarch64_rubygem-yaml-lint-doc.sha256sum] = "036d86ab03cc0822debbf4a950fa07f6f49531835063927b4d1a41f1cc5d9c5e"

RDEPENDS:rubygem-yaml-lint = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-yaml-lint-doc = " \
 rubygem-yaml-lint \
 "
