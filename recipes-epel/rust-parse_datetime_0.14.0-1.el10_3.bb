# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-parse_datetime"
PV = "0.14.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-parse_datetime+default-devel \
 rust-parse_datetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-parse_datetime-0.14.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6b5a9882ef6e2ac8e857c8c4050fa5aa12bd9b989e41420a04905eb394e5e7a"

URI_x86_64_v2_rust-parse_datetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parse_datetime+default-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parse_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parse_datetime+default-devel}"
SRC_URI[x86_64_v2_rust-parse_datetime+default-devel.sha256sum] = "9f7d41db28c5c1e0e452c81ae4a0a3b21338e68784fe7559ff2cef792549b08f"

URI_x86_64_v2_rust-parse_datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-parse_datetime-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-parse_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-parse_datetime-devel}"
SRC_URI[x86_64_v2_rust-parse_datetime-devel.sha256sum] = "db19317aaa7e13d378d7e303f66d240f0b33eec8fe5468b9430f4a238006d2a6"

URI_aarch64_rust-parse_datetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parse_datetime+default-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-parse_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parse_datetime+default-devel}"
SRC_URI[aarch64_rust-parse_datetime+default-devel.sha256sum] = "0ef9ea94e4cd920c44bb1a14535b8fab759970b8841bd7e1fb983fa9e9b39d15"

URI_aarch64_rust-parse_datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-parse_datetime-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-parse_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-parse_datetime-devel}"
SRC_URI[aarch64_rust-parse_datetime-devel.sha256sum] = "7550d99eba46be18bc855718691fc4a574c9ee0cd801072e6e33cbfcfa3181bd"

RDEPENDS:rust-parse_datetime+default-devel = " \
 cargo \
 rust-parse_datetime-devel \
 "
RDEPENDS:rust-parse_datetime-devel = " \
 cargo \
 rust \
 rust-jiff+tz-system-devel \
 rust-jiff+tzdb-bundle-platform-devel \
 rust-jiff+tzdb-zoneinfo-devel \
 rust-jiff-devel \
 rust-num-traits+default-devel \
 rust-winnow0.7+default-devel \
 "
