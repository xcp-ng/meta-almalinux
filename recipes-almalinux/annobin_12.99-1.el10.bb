# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "annobin"
PV = "12.99"
PR = "1.el10"
PACKAGES = " \
 annobin-annocheck \
 annobin-docs \
 annobin-libannocheck \
 annobin-plugin-clang \
 annobin-plugin-gcc \
 annobin-plugin-llvm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/annobin-12.99-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28226bb50ba95ab22f4a38e882a6543a9f90949f6bc054a9d2441ea1e8024b15"

URI_x86_64_v2_annobin-annocheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-annocheck-12.99-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-annocheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-annocheck}"
SRC_URI[x86_64_v2_annobin-annocheck.sha256sum] = "46b24482dd2882ec1e08f261a034d841051b0397336464e378f11094fe74483e"

URI_x86_64_v2_annobin-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-docs-12.99-1.el10.noarch.rpm;name=x86_64_v2_annobin-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-docs}"
SRC_URI[x86_64_v2_annobin-docs.sha256sum] = "7fb3136858bb2ccac126e1defc1c3ab3099c6a1932593bfdb702c8ae74888a8b"

URI_x86_64_v2_annobin-libannocheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-libannocheck-12.99-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-libannocheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-libannocheck}"
SRC_URI[x86_64_v2_annobin-libannocheck.sha256sum] = "bb1e7e2b3719ebacd4cc596970673fd09e9bebcdd74b6897cc4da5add98ac913"

URI_x86_64_v2_annobin-plugin-clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-clang-12.99-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-clang}"
SRC_URI[x86_64_v2_annobin-plugin-clang.sha256sum] = "cd3a29fa4f65f30387197afe34601d51abdfe4269862c2a6c43c47383527785a"

URI_x86_64_v2_annobin-plugin-gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-gcc-12.99-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-gcc}"
SRC_URI[x86_64_v2_annobin-plugin-gcc.sha256sum] = "04257d847cfe55f31a4c6f5ca25d4f05a626ecb6ad303918366f9e13afae7613"

URI_x86_64_v2_annobin-plugin-llvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-llvm-12.99-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-llvm}"
SRC_URI[x86_64_v2_annobin-plugin-llvm.sha256sum] = "af2315a9d9affd5eacd0cdb6c9a2dd0f24ebf9fc0628ff8af8d71b0ce32e81c1"

URI_aarch64_annobin-annocheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-annocheck-12.99-1.el10.aarch64.rpm;name=aarch64_annobin-annocheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-annocheck}"
SRC_URI[aarch64_annobin-annocheck.sha256sum] = "4bb5fefabba0dd63865966f994b4362de9efcbff79083510419e65dc3b7aee69"

URI_aarch64_annobin-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-docs-12.99-1.el10.noarch.rpm;name=aarch64_annobin-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-docs}"
SRC_URI[aarch64_annobin-docs.sha256sum] = "7fb3136858bb2ccac126e1defc1c3ab3099c6a1932593bfdb702c8ae74888a8b"

URI_aarch64_annobin-libannocheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-libannocheck-12.99-1.el10.aarch64.rpm;name=aarch64_annobin-libannocheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-libannocheck}"
SRC_URI[aarch64_annobin-libannocheck.sha256sum] = "8d4a44125d21b3a06a6784ce3846eb1f9ea20d0291a2ab33f23adaaf25daa676"

URI_aarch64_annobin-plugin-clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-clang-12.99-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-clang}"
SRC_URI[aarch64_annobin-plugin-clang.sha256sum] = "2ae9381992c366277655cefd88ee8a81d23023a581c0783a5be0c802e4f63c22"

URI_aarch64_annobin-plugin-gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-gcc-12.99-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-gcc}"
SRC_URI[aarch64_annobin-plugin-gcc.sha256sum] = "0c50adaeede5bf65b1898433f7f4b4627fa69f1485735cf9fba0c7634fbbe49c"

URI_aarch64_annobin-plugin-llvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-llvm-12.99-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-llvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-llvm}"
SRC_URI[aarch64_annobin-plugin-llvm.sha256sum] = "204ad86d4bcb6c5afebdbd214b8a9ecaa1851bbd511588c220c28db4ec355818"

RDEPENDS:annobin-annocheck = " \
 annobin-docs \
 cpio \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 rpm \
 rpm-libs \
 "
RDEPENDS:annobin-docs = " \
 "
RDEPENDS:annobin-libannocheck = " \
 annobin-docs \
 glibc \
 pkgconf-pkg-config \
 "
RDEPENDS:annobin-plugin-clang = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:annobin-plugin-gcc = " \
 annobin-docs \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:annobin-plugin-llvm = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
