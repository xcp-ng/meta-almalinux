# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-test"
PV = "0.4.4"
PR = "2.el10_0"
PACKAGES = " \
 rust-tokio-test+default-devel \
 rust-tokio-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-test-0.4.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18adc80f036efaa5039a8a06264bc015a7be25e08dceb7814da6f626e3ced6b8"

URI_x86_64_v2_rust-tokio-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-test+default-devel-0.4.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-test+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-test+default-devel.sha256sum] = "5df9a74e3355936dcc07c9ad2153305c4e61913f60d1cc27d3672cc236e3521e"

URI_x86_64_v2_rust-tokio-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-test-devel-0.4.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-test-devel}"
SRC_URI[x86_64_v2_rust-tokio-test-devel.sha256sum] = "92d9a7fee961743c010f96b4186c99518be7d25eb6bdca5521f71d39f500b91f"

URI_aarch64_rust-tokio-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-test+default-devel-0.4.4-2.el10_0.noarch.rpm;name=aarch64_rust-tokio-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-test+default-devel}"
SRC_URI[aarch64_rust-tokio-test+default-devel.sha256sum] = "5566f1a6dfd3ba91e0dd8bf9cf4b3590302cffcc60046e9b21ee87c2dbac65d2"

URI_aarch64_rust-tokio-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-test-devel-0.4.4-2.el10_0.noarch.rpm;name=aarch64_rust-tokio-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-test-devel}"
SRC_URI[aarch64_rust-tokio-test-devel.sha256sum] = "3711eb9a7cbe62a1ba7d1b030a53416c8fc4b60f80efc66c9cb1c5913de20d18"

RDEPENDS:rust-tokio-test+default-devel = " \
 cargo \
 rust-tokio-test-devel \
 "
RDEPENDS:rust-tokio-test-devel = " \
 cargo \
 rust \
 rust-async-stream+default-devel \
 rust-bytes+default-devel \
 rust-futures-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+test-util-devel \
 rust-tokio+time-devel \
 rust-tokio-stream+default-devel \
 "
