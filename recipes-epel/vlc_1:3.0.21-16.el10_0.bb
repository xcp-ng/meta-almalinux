# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc"
PE = "1"
PV = "3.0.21"
PR = "16.el10_0"
PACKAGES = " \
 vlc \
 vlc-cli \
 vlc-devel \
 vlc-gui-ncurses \
 vlc-gui-qt \
 vlc-gui-skins2 \
 vlc-libs \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pulseaudio \
 vlc-plugin-rdp \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-all \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vlc-3.0.21-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c57a08f0155f8e9a1e11ebf046cb1d4294de770d8e2ddec48ff42d84d1bf5f7e"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - vlc-plugin-ffmpeg: libavcodec.so.61()(64bit)
# - vlc-plugin-ffmpeg: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - vlc-plugin-ffmpeg: libavformat.so.61()(64bit)
# - vlc-plugin-ffmpeg: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - vlc-plugin-ffmpeg: libavutil.so.59()(64bit)
# - vlc-plugin-ffmpeg: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - vlc-plugin-ffmpeg: libpostproc.so.58()(64bit)
# - vlc-plugin-ffmpeg: libpostproc.so.58(LIBPOSTPROC_58)(64bit)
# - vlc-plugin-ffmpeg: libswscale.so.8()(64bit)
# - vlc-plugin-ffmpeg: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_vlc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc}"
SRC_URI[x86_64_v2_vlc.sha256sum] = "cbe5d598c106fa30edf6d7644178329bda25f49c73a6a4faed23aedb44ab2251"

URI_x86_64_v2_vlc-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-cli-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-cli}"
SRC_URI[x86_64_v2_vlc-cli.sha256sum] = "20f4018c91670c53bd3300d7415e88d0bab059bf72ab075ef005e2e77a5e68a7"

URI_x86_64_v2_vlc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-devel-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-devel}"
SRC_URI[x86_64_v2_vlc-devel.sha256sum] = "15a530d2253e9f990d90152ccd0a53f675b3b2d18af151c7b637a1d76afe3416"

URI_x86_64_v2_vlc-gui-ncurses = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-ncurses-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-ncurses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-gui-ncurses}"
SRC_URI[x86_64_v2_vlc-gui-ncurses.sha256sum] = "ce0d250823cddac7536a608be5eb5f8b53c18297540fdd5b5d8056111d3e882b"

URI_x86_64_v2_vlc-gui-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-qt-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-gui-qt}"
SRC_URI[x86_64_v2_vlc-gui-qt.sha256sum] = "74cb0d2cd37d1a2c7dcbea3fc486ec7e9500d0d9302713722f19d722b9bdb5dd"

URI_x86_64_v2_vlc-gui-skins2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-skins2-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-skins2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-gui-skins2}"
SRC_URI[x86_64_v2_vlc-gui-skins2.sha256sum] = "70604aea8ce6dd7774e552cc85266661f232980e3b136c62d04b0d77c7c9b412"

URI_x86_64_v2_vlc-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-libs-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-libs}"
SRC_URI[x86_64_v2_vlc-libs.sha256sum] = "fd225cb088c93463c99cbc8997ae5debe6cb353a723553249ff557e1b145144d"

URI_x86_64_v2_vlc-plugin-ffmpeg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ffmpeg-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ffmpeg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-ffmpeg}"
SRC_URI[x86_64_v2_vlc-plugin-ffmpeg.sha256sum] = "c624975b8ca1729919c7a2e52209682d6d036944dc1375e3a83bf5cee661f999"

URI_x86_64_v2_vlc-plugin-fluidsynth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-fluidsynth-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-fluidsynth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-fluidsynth}"
SRC_URI[x86_64_v2_vlc-plugin-fluidsynth.sha256sum] = "d3ce1cbb1f205942615cdc259de2ec85f77f01f6fa8ac229c558b78e51fca264"

URI_x86_64_v2_vlc-plugin-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gnome-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-gnome}"
SRC_URI[x86_64_v2_vlc-plugin-gnome.sha256sum] = "509a41c54d5798f284d0b58e21f0ba59542013c8dd4d3f21d37ca389527914f4"

URI_x86_64_v2_vlc-plugin-gstreamer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gstreamer-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gstreamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-gstreamer}"
SRC_URI[x86_64_v2_vlc-plugin-gstreamer.sha256sum] = "0982f79ef5f629d67da66fa4246154bb73121b9b741f79a01577624f25f750db"

URI_x86_64_v2_vlc-plugin-ieee1394 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ieee1394-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ieee1394;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-ieee1394}"
SRC_URI[x86_64_v2_vlc-plugin-ieee1394.sha256sum] = "89960b99adc57e7c1d4666d1411838a669e74d92b7106b50cea9ed14b26c865d"

URI_x86_64_v2_vlc-plugin-jack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-jack-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-jack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-jack}"
SRC_URI[x86_64_v2_vlc-plugin-jack.sha256sum] = "8e6c03c301a491d0c7d5d3921dca84d24f4488f94924e04c82f9d17af7b8ca3c"

URI_x86_64_v2_vlc-plugin-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-kde-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-kde}"
SRC_URI[x86_64_v2_vlc-plugin-kde.sha256sum] = "82651887d3022395cb50e4d320bee7341990bf7d88f66fa424b8ee29563df6ca"

URI_x86_64_v2_vlc-plugin-lua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-lua-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-lua}"
SRC_URI[x86_64_v2_vlc-plugin-lua.sha256sum] = "53a7a52c31337e0d9e54d3af596d180df61e537f2469ccacf205007de880e804"

URI_x86_64_v2_vlc-plugin-notify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-notify-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-notify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-notify}"
SRC_URI[x86_64_v2_vlc-plugin-notify.sha256sum] = "caed9381f606b936d52a81a9a7d6bb0f9c16f783bf1db45a862b4adc29fb1aaf"

URI_x86_64_v2_vlc-plugin-pulseaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-pulseaudio-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-pulseaudio}"
SRC_URI[x86_64_v2_vlc-plugin-pulseaudio.sha256sum] = "0e1c87f0ebdf57537bfa3fe69fe306b51639fa74fc15c33b56e2e48f96421bbb"

URI_x86_64_v2_vlc-plugin-rdp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-rdp-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-rdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-rdp}"
SRC_URI[x86_64_v2_vlc-plugin-rdp.sha256sum] = "bd46bd1f281dec587c601f4ff9e0a52ce1eab8c6f3817e862ace8af9989d5c93"

URI_x86_64_v2_vlc-plugin-samba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-samba-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-samba}"
SRC_URI[x86_64_v2_vlc-plugin-samba.sha256sum] = "b700819de5285dc750c2dd478dd10dda21be5d7b25ae8f8a6f6e0ac47a38da8b"

URI_x86_64_v2_vlc-plugin-svg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-svg-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-svg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-svg}"
SRC_URI[x86_64_v2_vlc-plugin-svg.sha256sum] = "7bc73bd1fe5ec169ec733b7d2ba360103d33b6576629466d57e71ac79c1d9201"

URI_x86_64_v2_vlc-plugin-visualization = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-visualization-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-visualization;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-visualization}"
SRC_URI[x86_64_v2_vlc-plugin-visualization.sha256sum] = "cd88bc097c8b305e40735211780cf12cbb10e109d74b5548403e67849ab02f9e"

URI_x86_64_v2_vlc-plugin-vnc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-vnc-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-vnc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugin-vnc}"
SRC_URI[x86_64_v2_vlc-plugin-vnc.sha256sum] = "b8a93b117f2e83b8312914c85444bfd069b4a097ff8135b0b51fe68a3969ac78"

URI_x86_64_v2_vlc-plugins-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-all-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-all}"
SRC_URI[x86_64_v2_vlc-plugins-all.sha256sum] = "b4552fdde9c4bf8109e9ccde2dfd731f13a15a959f8db1981a969898d15331c0"

URI_x86_64_v2_vlc-plugins-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-base-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-base}"
SRC_URI[x86_64_v2_vlc-plugins-base.sha256sum] = "cbdee53cdb7e314195046fa3295d20e840823a6aa380f1fb97c5af0a874969a7"

URI_x86_64_v2_vlc-plugins-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-extra-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-extra}"
SRC_URI[x86_64_v2_vlc-plugins-extra.sha256sum] = "5f9fd891a3670d7689552aed9b3ce90b7cd96da35338210d7cf54015bccddd59"

URI_x86_64_v2_vlc-plugins-video-out = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-video-out-3.0.21-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-video-out;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vlc-plugins-video-out}"
SRC_URI[x86_64_v2_vlc-plugins-video-out.sha256sum] = "64a9d947a89092f2b9d832a042a65e2376b1013c6a8e80bc35e9db85a99e538b"

URI_aarch64_vlc = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc}"
SRC_URI[aarch64_vlc.sha256sum] = "a9b2ac897c817587d5357fdcac59cf00038fcaced4e3e49d0168b33d5fdac35b"

URI_aarch64_vlc-cli = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-cli-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-cli}"
SRC_URI[aarch64_vlc-cli.sha256sum] = "72090e4752a9480246b8dceed290c72384b6b2ae61580fb1f0c965f293d83908"

URI_aarch64_vlc-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-devel-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-devel}"
SRC_URI[aarch64_vlc-devel.sha256sum] = "0b874391aeb8eccbede8c163fc48ccff7082b5c64fdd88553d3ba36245643b6e"

URI_aarch64_vlc-gui-ncurses = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-ncurses-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-gui-ncurses;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-gui-ncurses}"
SRC_URI[aarch64_vlc-gui-ncurses.sha256sum] = "34686d78f30e2e65a3db8444cc3cea853f88023aef582762712dd47d7d71f752"

URI_aarch64_vlc-gui-qt = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-qt-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-gui-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-gui-qt}"
SRC_URI[aarch64_vlc-gui-qt.sha256sum] = "4e60a8dda9985cecebe611c14e117125c5347e5dc2c46267563afd26e492a456"

URI_aarch64_vlc-gui-skins2 = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-skins2-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-gui-skins2;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-gui-skins2}"
SRC_URI[aarch64_vlc-gui-skins2.sha256sum] = "11dcdb7dbb6bf08b83bb2664d2f99bcc38b35804837cb18b17bc9a0c1b967f62"

URI_aarch64_vlc-libs = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-libs-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-libs}"
SRC_URI[aarch64_vlc-libs.sha256sum] = "fcc83e25ef2e04839d1c31d7c906546ddcd0ac7484fdc1fdca6eaf82866e0540"

URI_aarch64_vlc-plugin-ffmpeg = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ffmpeg-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-ffmpeg;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-ffmpeg}"
SRC_URI[aarch64_vlc-plugin-ffmpeg.sha256sum] = "81c37dc0fb6940671cf8ed0f5e09d47e96184eda5409c6c59668b6747ec03837"

URI_aarch64_vlc-plugin-fluidsynth = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-fluidsynth-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-fluidsynth;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-fluidsynth}"
SRC_URI[aarch64_vlc-plugin-fluidsynth.sha256sum] = "eba2a0fd24dc2d3a5967913f01442d0e99ee1588feb1976ee8d183b9f7d87dfb"

URI_aarch64_vlc-plugin-gnome = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gnome-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-gnome}"
SRC_URI[aarch64_vlc-plugin-gnome.sha256sum] = "1db9d9ef00e6803beb33b92aabc2a2ba399e54bcf37c178688832804782f9225"

URI_aarch64_vlc-plugin-gstreamer = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gstreamer-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-gstreamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-gstreamer}"
SRC_URI[aarch64_vlc-plugin-gstreamer.sha256sum] = "46cd52f4e146b0714ea40848693394b54c175c334513925501290a48bdf31394"

URI_aarch64_vlc-plugin-ieee1394 = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ieee1394-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-ieee1394;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-ieee1394}"
SRC_URI[aarch64_vlc-plugin-ieee1394.sha256sum] = "24b374278f7c80f157feaeb88f2de6d8fc2c4b578d602655a339860201331836"

URI_aarch64_vlc-plugin-jack = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-jack-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-jack;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-jack}"
SRC_URI[aarch64_vlc-plugin-jack.sha256sum] = "440e44cd8e15042cc5b0208d2a89734708b9d969b3442e39104b9b0e9dbea0cd"

URI_aarch64_vlc-plugin-kde = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-kde-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-kde}"
SRC_URI[aarch64_vlc-plugin-kde.sha256sum] = "21936e46fc0c7d5b0c328a5bf6e6e1101026db0006742b55492afcfb7b315c8f"

URI_aarch64_vlc-plugin-lua = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-lua-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-lua}"
SRC_URI[aarch64_vlc-plugin-lua.sha256sum] = "35d57603e42fd5ad6c7bfe796715ca17caaec91fa51b07ae91c6c6b9de1c708a"

URI_aarch64_vlc-plugin-notify = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-notify-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-notify;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-notify}"
SRC_URI[aarch64_vlc-plugin-notify.sha256sum] = "638bbdfc0d635149747fe29a78c48565d75d137478e5e89dc1d4ff23b37b6acb"

URI_aarch64_vlc-plugin-pulseaudio = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-pulseaudio-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-pulseaudio}"
SRC_URI[aarch64_vlc-plugin-pulseaudio.sha256sum] = "b258ab479f26d20544b65a2932b4b2d208791f3b61c3c25b911542b53fa65817"

URI_aarch64_vlc-plugin-rdp = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-rdp-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-rdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-rdp}"
SRC_URI[aarch64_vlc-plugin-rdp.sha256sum] = "d6206a85ff9719abb57a26ba31770134fbf2c581007775c4cddbb5c4a6f6e57f"

URI_aarch64_vlc-plugin-samba = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-samba-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-samba}"
SRC_URI[aarch64_vlc-plugin-samba.sha256sum] = "4874d35cf0cf4e4eebb47c4ac716f9ec73d0513f8ba84fc29e636d3e3bf4b059"

URI_aarch64_vlc-plugin-svg = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-svg-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-svg;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-svg}"
SRC_URI[aarch64_vlc-plugin-svg.sha256sum] = "db3edb80453fe91829c4f88e8bd12b1d5f570e4f390b8bd9e1acee90c59a85e4"

URI_aarch64_vlc-plugin-visualization = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-visualization-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-visualization;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-visualization}"
SRC_URI[aarch64_vlc-plugin-visualization.sha256sum] = "f490f6675490eb94e9e318fd5e4b947c1ea7a0cf5056968b46c6a85660f4dd8c"

URI_aarch64_vlc-plugin-vnc = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-vnc-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugin-vnc;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugin-vnc}"
SRC_URI[aarch64_vlc-plugin-vnc.sha256sum] = "274b313121fd96bdc4ca301a69000b65ee040dbeb5b70f93814eed4349431600"

URI_aarch64_vlc-plugins-all = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-all-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugins-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-all}"
SRC_URI[aarch64_vlc-plugins-all.sha256sum] = "e813e9b81c14b1272e396d53a45effd96195688b8f8a093b992fabcfaef3dd80"

URI_aarch64_vlc-plugins-base = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-base-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugins-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-base}"
SRC_URI[aarch64_vlc-plugins-base.sha256sum] = "d504021ef33ffd67d98be61e94e7685da88ee2a0f96ae4a2c10c4ee0f2fd6c14"

URI_aarch64_vlc-plugins-extra = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-extra-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugins-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-extra}"
SRC_URI[aarch64_vlc-plugins-extra.sha256sum] = "bf13982f081516ee20ead31ab8be474d8f9c24f79017e42704146f5a889fff70"

URI_aarch64_vlc-plugins-video-out = "${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-video-out-3.0.21-16.el10_0.aarch64.rpm;name=aarch64_vlc-plugins-video-out;unpack=0"
SRC_URI:append = " ${URI_aarch64_vlc-plugins-video-out}"
SRC_URI[aarch64_vlc-plugins-video-out.sha256sum] = "6dd68528d074c94965b1dfc9bd2f29e16b945c0837cbd09ff71c122c817d4fec"

RDEPENDS:vlc = " \
 bash \
 hicolor-icon-theme \
 kde-filesystem \
 vlc-gui-qt \
 "
RDEPENDS:vlc-cli = " \
 bash \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-devel = " \
 pkgconf-pkg-config \
 vlc-libs \
 "
RDEPENDS:vlc-gui-ncurses = " \
 bash \
 glibc \
 ncurses-libs \
 vlc-cli \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-gui-qt = " \
 bash \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 libwayland-client \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 qt5-qtwayland \
 qt5-qtx11extras \
 vlc-cli \
 vlc-libs \
 vlc-plugin-lua \
 vlc-plugin-pipewire \
 vlc-plugin-pulseaudio \
 vlc-plugins-base \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-gui-skins2 = " \
 bash \
 freetype \
 fribidi \
 glibc \
 gnu-free-sans-fonts \
 libX11 \
 libXext \
 libXinerama \
 libXpm \
 libgcc \
 libstdc++ \
 vlc-cli \
 vlc-gui-qt \
 vlc-libs \
 "
RDEPENDS:vlc-libs = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libidn2 \
 "
RDEPENDS:vlc-plugin-ffmpeg:x86_64_v2 = " \
 glibc \
 libX11 \
 libchromaprint \
 libva \
 vlc-libs \
 vlc-plugins-base \
 vlc-plugins-video-out \
"
RDEPENDS:vlc-plugin-ffmpeg:aarch64 = " \
 glibc \
 libX11 \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libchromaprint \
 libpostproc-free \
 libswscale-free \
 libva \
 vlc-libs \
 vlc-plugins-base \
 vlc-plugins-video-out \
"
RDEPENDS:vlc-plugin-fluidsynth = " \
 fluidsynth-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gnome = " \
 glib2 \
 glibc \
 libsecret \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-ieee1394 = " \
 glibc \
 libavc1394 \
 libdc1394 \
 libgcc \
 libraw1394 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-jack = " \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-kde = " \
 dbus-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-lua = " \
 glibc \
 libgcc \
 lua-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-notify = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libnotify \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-pulseaudio = " \
 glibc \
 pulseaudio-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-rdp = " \
 freerdp2-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-samba = " \
 glibc \
 libsmbclient \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-svg = " \
 cairo \
 glib2 \
 glibc \
 librsvg2 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-visualization = " \
 glibc \
 libglvnd-glx \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-vnc = " \
 glibc \
 libvncserver \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugins-all = " \
 vlc-plugin-bittorrent \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pause-click \
 vlc-plugin-pipewire \
 vlc-plugin-pulseaudio \
 vlc-plugin-rdp \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-plugins-base = " \
 alsa-lib \
 dbus-libs \
 fdk-aac-free \
 flac-libs \
 glibc \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 liba52 \
 libdav1d \
 libgcc \
 libgcrypt \
 libgpg-error \
 libjpeg-turbo \
 libogg \
 libpng \
 libshout \
 libstdc++ \
 libtheora \
 libvorbis \
 libvpx \
 libxml2 \
 mpg123-libs \
 opus \
 speex \
 systemd-libs \
 taglib \
 twolame-libs \
 vlc-libs \
 zlib-ng-compat \
 "
RDEPENDS:vlc-plugins-extra:x86_64_v2 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 avahi-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdca \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmpeg2 \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libvpl \
 libxcb \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-extra:aarch64 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 avahi-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdca \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmpeg2 \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libxcb \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-video-out = " \
 glibc \
 libX11 \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libva \
 libwayland-client \
 libwayland-egl \
 libxcb \
 vlc-libs \
 vlc-plugins-base \
 xcb-util-keysyms \
 "
