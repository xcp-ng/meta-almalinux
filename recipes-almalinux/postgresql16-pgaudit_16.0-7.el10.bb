# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16-pgaudit"
PV = "16.0"
PR = "7.el10"
PACKAGES = " \
 pgaudit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-pgaudit-16.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acdc12af193b56454e67e1da5f2d49c484d7853345fe6cb66609123922d5566c"

URI_x86_64_v2_pgaudit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pgaudit-16.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_pgaudit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pgaudit}"
SRC_URI[x86_64_v2_pgaudit.sha256sum] = "9d36c8721f82bc06e414fdf61df1934d52ba45bbb730dadafed323de671fce43"

URI_aarch64_pgaudit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pgaudit-16.0-7.el10.aarch64.rpm;name=aarch64_pgaudit;unpack=0"
SRC_URI:append = " ${URI_aarch64_pgaudit}"
SRC_URI[aarch64_pgaudit.sha256sum] = "bb2ec1410ee65eb4e95301a815d4c2c7847a55986f01cb1f0f10f455e1e3ba57"

RDEPENDS:pgaudit = " \
 glibc \
 postgresql-server \
 "
