# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_derive"
PV = "1.0.228"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_derive+default-devel \
 rust-serde_derive+deserialize_in_place-devel \
 rust-serde_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_derive-1.0.228-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3089267eba405a2965fa934078f6631abcf47dfc52480f186039a9f810a46318"

URI_x86_64_v2_rust-serde_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive+default-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive+default-devel}"
SRC_URI[x86_64_v2_rust-serde_derive+default-devel.sha256sum] = "c5d5482c209b64d1bf5a9c8501c4d7ad110b593fc2aff7d26200022ce9d57f33"

URI_x86_64_v2_rust-serde_derive+deserialize_in_place-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive+deserialize_in_place-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive+deserialize_in_place-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive+deserialize_in_place-devel}"
SRC_URI[x86_64_v2_rust-serde_derive+deserialize_in_place-devel.sha256sum] = "55eeda0a2b4f746f92107d7fd3a35ec8a5c3a30eac80d9cbf98662d897844122"

URI_x86_64_v2_rust-serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive-devel-1.0.228-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_derive-devel}"
SRC_URI[x86_64_v2_rust-serde_derive-devel.sha256sum] = "65e2f2daf70e1ad41c0d3a2c1717ad17a983a355a551a0a8e8aac1d9adce70e4"

URI_aarch64_rust-serde_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive+default-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive+default-devel}"
SRC_URI[aarch64_rust-serde_derive+default-devel.sha256sum] = "39e3883c3d3e5b40e7375abf71fa35835ae91682ae05700ca9979a7a907dd792"

URI_aarch64_rust-serde_derive+deserialize_in_place-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive+deserialize_in_place-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_derive+deserialize_in_place-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive+deserialize_in_place-devel}"
SRC_URI[aarch64_rust-serde_derive+deserialize_in_place-devel.sha256sum] = "25304209e6525a00aad89d63ffa0f87f6705a9ea51a622e484d80a511e331c97"

URI_aarch64_rust-serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive-devel-1.0.228-1.el10_0.noarch.rpm;name=aarch64_rust-serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_derive-devel}"
SRC_URI[aarch64_rust-serde_derive-devel.sha256sum] = "676ec5046cedcf5f3f18ea4ed4e6e4723267c01ae6373d4d55c574f7badd5d0e"

RDEPENDS:rust-serde_derive+default-devel = " \
 cargo \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-serde_derive+deserialize_in_place-devel = " \
 cargo \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-serde_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
