# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zopfli"
PV = "0.8.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-zopfli+default-devel \
 rust-zopfli+gzip-devel \
 rust-zopfli+std-devel \
 rust-zopfli+zlib-devel \
 rust-zopfli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zopfli-0.8.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c2b379692f3f6992aa1173217796ca977e4eb51595a6517f9521fa007c7d5e6"

URI_x86_64_v2_rust-zopfli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+default-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+default-devel}"
SRC_URI[x86_64_v2_rust-zopfli+default-devel.sha256sum] = "be7143ad749b443dbc16d5107e3c5d5617ee873be3e1d378402d08c4a3d1a8f4"

URI_x86_64_v2_rust-zopfli+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+gzip-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+gzip-devel}"
SRC_URI[x86_64_v2_rust-zopfli+gzip-devel.sha256sum] = "8c380cbe2e73c36d25319534e4fc1c68791e96bb2dce5ac69feba0a840d6b4f3"

URI_x86_64_v2_rust-zopfli+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+std-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+std-devel}"
SRC_URI[x86_64_v2_rust-zopfli+std-devel.sha256sum] = "17e249ff744c85b17bb5fbc2c20ae17d7e83e8c0545826f44f9bb3b0545ef3a4"

URI_x86_64_v2_rust-zopfli+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+zlib-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+zlib-devel}"
SRC_URI[x86_64_v2_rust-zopfli+zlib-devel.sha256sum] = "2b7b409f55d373bcc2fa78222b8d45bbf2ca6d90e376b2ff868f2fba8ad098d0"

URI_x86_64_v2_rust-zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli-devel-0.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli-devel}"
SRC_URI[x86_64_v2_rust-zopfli-devel.sha256sum] = "cb51d7090242440da98016d2f520350957cdf625de16d817bc99b343d3e2c0b6"

URI_aarch64_rust-zopfli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+default-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-zopfli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+default-devel}"
SRC_URI[aarch64_rust-zopfli+default-devel.sha256sum] = "c68cb3e749a47b4b2f78d2195e40e1ae52c4f1317603dce0358e41b6777d3eee"

URI_aarch64_rust-zopfli+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+gzip-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-zopfli+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+gzip-devel}"
SRC_URI[aarch64_rust-zopfli+gzip-devel.sha256sum] = "75d2b36fad5654065fe106c2d46767fe40d8bfb83caa9cff4c3517d8f073a238"

URI_aarch64_rust-zopfli+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+std-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-zopfli+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+std-devel}"
SRC_URI[aarch64_rust-zopfli+std-devel.sha256sum] = "0b78acd055bb786918a97b4b906d625129ef2a39b6102bffb30fdf8ab08d212f"

URI_aarch64_rust-zopfli+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+zlib-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-zopfli+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+zlib-devel}"
SRC_URI[aarch64_rust-zopfli+zlib-devel.sha256sum] = "acdca83a0fc3a7cd3d6dce85a35b1786e27799e7fc3a98eeb571d5e94f44af75"

URI_aarch64_rust-zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli-devel-0.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli-devel}"
SRC_URI[aarch64_rust-zopfli-devel.sha256sum] = "0d6ed2702322a8b69b9de993faec88380276f42bbda8d281964af152f3724f6f"

RDEPENDS:rust-zopfli+default-devel = " \
 cargo \
 rust-zopfli+gzip-devel \
 rust-zopfli+std-devel \
 rust-zopfli+zlib-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli+gzip-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli+std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-log+default-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli+zlib-devel = " \
 cargo \
 rust-simd-adler32-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli-devel = " \
 cargo \
 rust \
 rust-bumpalo+default-devel \
 "
