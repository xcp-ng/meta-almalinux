# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiofiles"
PV = "24.1.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-aiofiles \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiofiles-24.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55e45cdc8ce5d2b87f2b1bf27833a5001be8c5aeba4889a8e101e96ca8f3c1b9"

URI_x86_64_v2_python3-aiofiles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiofiles-24.1.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiofiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiofiles}"
SRC_URI[x86_64_v2_python3-aiofiles.sha256sum] = "e88f4906f32903130c252f1d5c2aaeb1c398385e88779eed8cd9ebe0874bcc45"

URI_aarch64_python3-aiofiles = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiofiles-24.1.0-3.el10_0.noarch.rpm;name=aarch64_python3-aiofiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiofiles}"
SRC_URI[aarch64_python3-aiofiles.sha256sum] = "228e025fdea45806003dd0302a6640171e384c0b2ffa53d401a1d547a1c16433"

RDEPENDS:python3-aiofiles = " \
 python3 \
 "
