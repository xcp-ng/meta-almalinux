# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scc"
PV = "2.4.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-scc+default-devel \
 rust-scc+equivalent-devel \
 rust-scc+serde-devel \
 rust-scc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scc-2.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7308c9b5d18ee0ffa1fde19f0fc2d97d5f1231c8f8710fa1f800bb70fbe634b1"

URI_x86_64_v2_rust-scc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc+default-devel-2.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc+default-devel}"
SRC_URI[x86_64_v2_rust-scc+default-devel.sha256sum] = "5d23fd406eeb5fc5dc6969bde79a1e13044cd9f3d420f613498c9beac0ee12c0"

URI_x86_64_v2_rust-scc+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc+equivalent-devel-2.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc+equivalent-devel}"
SRC_URI[x86_64_v2_rust-scc+equivalent-devel.sha256sum] = "5327816ea1f44367fff67e23ae890f50d0d90ae647af0f128f64bfe8dec7e031"

URI_x86_64_v2_rust-scc+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc+serde-devel-2.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc+serde-devel}"
SRC_URI[x86_64_v2_rust-scc+serde-devel.sha256sum] = "76b8e7ad67ff4997ede8cf840d7ebb6fd8b874ecc215195ff8ce66be0d0c4e82"

URI_x86_64_v2_rust-scc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scc-devel-2.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scc-devel}"
SRC_URI[x86_64_v2_rust-scc-devel.sha256sum] = "7eff99e77ed9571405eba708537fcd5201076ec81d63fd7a9957cf81a78d1608"

URI_aarch64_rust-scc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc+default-devel-2.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-scc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc+default-devel}"
SRC_URI[aarch64_rust-scc+default-devel.sha256sum] = "3a6f3cee10ed0dbc8dac74440a828b98b522c4deddc7a2add542ddad6215cf77"

URI_aarch64_rust-scc+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc+equivalent-devel-2.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-scc+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc+equivalent-devel}"
SRC_URI[aarch64_rust-scc+equivalent-devel.sha256sum] = "028d5c265a52797f7ecb5f9569516fd0f838bf03ecc93d0f2834ec6892752bc1"

URI_aarch64_rust-scc+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc+serde-devel-2.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-scc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc+serde-devel}"
SRC_URI[aarch64_rust-scc+serde-devel.sha256sum] = "de07fa96f3cbfffe06dce56dc1c10084881fc52eb1e47795b557fef4134c2710"

URI_aarch64_rust-scc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scc-devel-2.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-scc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scc-devel}"
SRC_URI[aarch64_rust-scc-devel.sha256sum] = "d4d804ea7c8febce6d178c57f66f8d774e4890c80d9a087a4e4ee3dfa3d8d34f"

RDEPENDS:rust-scc+default-devel = " \
 cargo \
 rust-scc-devel \
 "
RDEPENDS:rust-scc+equivalent-devel = " \
 cargo \
 rust-equivalent+default-devel \
 rust-scc-devel \
 "
RDEPENDS:rust-scc+serde-devel = " \
 cargo \
 rust-scc-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-scc-devel = " \
 cargo \
 rust \
 rust-sdd+default-devel \
 "
