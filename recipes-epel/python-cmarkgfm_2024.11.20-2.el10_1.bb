# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cmarkgfm"
PV = "2024.11.20"
PR = "2.el10_1"
PACKAGES = " \
 python3-cmarkgfm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cmarkgfm-2024.11.20-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c13b93e4f7acd2895d697123d7418c7b896e8e0f2b6d78f1992f61fa3ffc922"

URI_x86_64_v2_python3-cmarkgfm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cmarkgfm-2024.11.20-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-cmarkgfm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cmarkgfm}"
SRC_URI[x86_64_v2_python3-cmarkgfm.sha256sum] = "a9a85f88d0d41d37836c477f89d7adf6d4a1a0b30a02b692992926b14f18eb0a"

URI_aarch64_python3-cmarkgfm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cmarkgfm-2024.11.20-2.el10_1.aarch64.rpm;name=aarch64_python3-cmarkgfm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cmarkgfm}"
SRC_URI[aarch64_python3-cmarkgfm.sha256sum] = "3f27cc0a9ed4ceffc67d83b4d67fbcbb5aefe3684e7fbd8ce6b3884bf1f274c2"

RDEPENDS:python3-cmarkgfm = " \
 glibc \
 python3 \
 python3-cffi \
 "
