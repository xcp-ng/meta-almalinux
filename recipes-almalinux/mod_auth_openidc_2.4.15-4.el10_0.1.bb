# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_auth_openidc"
PV = "2.4.15"
PR = "4.el10_0.1"
PACKAGES = " \
 mod_auth_openidc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_auth_openidc-2.4.15-4.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9ad755005303d9518244d3d686a0c54da7732864526ebf18c3c1e1cab39a55b"

URI_x86_64_v2_mod_auth_openidc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_auth_openidc-2.4.15-4.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_mod_auth_openidc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_auth_openidc}"
SRC_URI[x86_64_v2_mod_auth_openidc.sha256sum] = "b8aaef7aabac54a2722198b44f701d54361e31c8cb0b1e6389f2db32306bad12"

URI_aarch64_mod_auth_openidc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_auth_openidc-2.4.15-4.el10_0.1.aarch64.rpm;name=aarch64_mod_auth_openidc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_auth_openidc}"
SRC_URI[aarch64_mod_auth_openidc.sha256sum] = "9a38b1f907e77c6374db72d87f8511c60a7d377609bcb4afc7e048f545fc511f"

RDEPENDS:mod_auth_openidc = " \
 apr \
 apr-util \
 cjose \
 expat \
 glibc \
 httpd-core \
 jansson \
 jq \
 libxcrypt \
 openldap \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
