# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "francis"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 francis \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/francis-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf075d478e4c317f727ea2afb8450b853fac42690011cdbeb31a66b584fdc155"

URI_x86_64_v2_francis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/francis-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_francis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_francis}"
SRC_URI[x86_64_v2_francis.sha256sum] = "547a29500108a66eedbb7f10584f983b275f4f2ce8eaf259ae8ca815ef3e1e7d"

URI_aarch64_francis = "${EPEL_MIRROR}/aarch64/Packages/f/francis-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_francis;unpack=0"
SRC_URI:append = " ${URI_aarch64_francis}"
SRC_URI[aarch64_francis.sha256sum] = "d869353b35851b6d4106e87474f685708b3b615a977cf5d4c41abca31f463e4e"

RDEPENDS:francis = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
