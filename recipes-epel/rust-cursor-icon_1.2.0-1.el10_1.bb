# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursor-icon"
PV = "1.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-cursor-icon+alloc-devel \
 rust-cursor-icon+default-devel \
 rust-cursor-icon+serde-devel \
 rust-cursor-icon+std-devel \
 rust-cursor-icon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursor-icon-1.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a39eb49e16a2241c40634c19d45ce53e93f87a44f7ca73c309d494a6fc4a8d39"

URI_x86_64_v2_rust-cursor-icon+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon+alloc-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon+alloc-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon+alloc-devel.sha256sum] = "d335b596203154d3e87785804c56517b04fcca5e413644e57ec6e24ce1ba72fd"

URI_x86_64_v2_rust-cursor-icon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon+default-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon+default-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon+default-devel.sha256sum] = "3b4e0c6b326e8bd97306d659d62965f5d481b351dbd1b58a4c8263167161e258"

URI_x86_64_v2_rust-cursor-icon+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon+serde-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon+serde-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon+serde-devel.sha256sum] = "0ed162120007d21b1ee51d131287510b5dd176fa0a9e3f5a5504305654c0c4d7"

URI_x86_64_v2_rust-cursor-icon+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon+std-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon+std-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon+std-devel.sha256sum] = "a23c3315b525fa1c3a5bb08442da1c84ed5c4fed8d4d7fde44e7d6ae6dc7d30a"

URI_x86_64_v2_rust-cursor-icon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursor-icon-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursor-icon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursor-icon-devel}"
SRC_URI[x86_64_v2_rust-cursor-icon-devel.sha256sum] = "914c3b78fe1daf4d357c18b8eab1f1fc323da2d691ba0a0beaac953760a1f7ca"

URI_aarch64_rust-cursor-icon+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon+alloc-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursor-icon+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon+alloc-devel}"
SRC_URI[aarch64_rust-cursor-icon+alloc-devel.sha256sum] = "b5764e811ee31a7717d4c14b98a9c619d31a2cd8ee1d559363b28cb4dd778bb5"

URI_aarch64_rust-cursor-icon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon+default-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursor-icon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon+default-devel}"
SRC_URI[aarch64_rust-cursor-icon+default-devel.sha256sum] = "d668b099ab9105dd5e8039be4dc1ae4482e726bc2e817b1529120bc3eb4e44da"

URI_aarch64_rust-cursor-icon+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon+serde-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursor-icon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon+serde-devel}"
SRC_URI[aarch64_rust-cursor-icon+serde-devel.sha256sum] = "ac9ebb3917071aa3a30e69d7073ddd8f14fb1e1ae2bc33f349315a1e299b611c"

URI_aarch64_rust-cursor-icon+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon+std-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursor-icon+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon+std-devel}"
SRC_URI[aarch64_rust-cursor-icon+std-devel.sha256sum] = "90a506111e45d98aad833385c8ffddd3d3e09c56eff9ee9a988a1f3911432030"

URI_aarch64_rust-cursor-icon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursor-icon-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursor-icon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursor-icon-devel}"
SRC_URI[aarch64_rust-cursor-icon-devel.sha256sum] = "1b762dff88ff510f9f760f83bdc34c38a1bcc044840c01cbf87d9391c977c523"

RDEPENDS:rust-cursor-icon+alloc-devel = " \
 cargo \
 rust-cursor-icon-devel \
 "
RDEPENDS:rust-cursor-icon+default-devel = " \
 cargo \
 rust-cursor-icon+std-devel \
 rust-cursor-icon-devel \
 "
RDEPENDS:rust-cursor-icon+serde-devel = " \
 cargo \
 rust-cursor-icon-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-cursor-icon+std-devel = " \
 cargo \
 rust-cursor-icon+alloc-devel \
 rust-cursor-icon-devel \
 "
RDEPENDS:rust-cursor-icon-devel = " \
 cargo \
 rust \
 "
