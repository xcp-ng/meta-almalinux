# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openxr"
PV = "1.1.57"
PR = "1.el10_2"
PACKAGES = " \
 openxr \
 openxr-devel \
 openxr-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openxr-1.1.57-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ac9b6b93a2e909fc4de8a5e8a3e8039d685551a66c749bd7bc1a7d9bb96e0b4"

URI_x86_64_v2_openxr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-1.1.57-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openxr}"
SRC_URI[x86_64_v2_openxr.sha256sum] = "41ab8d4d66ddcd464302b6e5fcff3dc5cce60abf58a65d92541329c42f175ba8"

URI_x86_64_v2_openxr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-devel-1.1.57-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openxr-devel}"
SRC_URI[x86_64_v2_openxr-devel.sha256sum] = "b73471c381dfc599ec645de3afd64cd207c00722f2adaa4a1a3f2d60fd86bcf9"

URI_x86_64_v2_openxr-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openxr-libs-1.1.57-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openxr-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openxr-libs}"
SRC_URI[x86_64_v2_openxr-libs.sha256sum] = "80ffa403dc6a7cffafcbfe1761a20ccc2516a1a66c8a2b83f1e3eae1788fa071"

URI_aarch64_openxr = "${EPEL_MIRROR}/aarch64/Packages/o/openxr-1.1.57-1.el10_2.aarch64.rpm;name=aarch64_openxr;unpack=0"
SRC_URI:append = " ${URI_aarch64_openxr}"
SRC_URI[aarch64_openxr.sha256sum] = "ea6b5c82ca226edaed4ec232f8ee3d0c91770268dca54184048ff1196ec9a0b3"

URI_aarch64_openxr-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openxr-devel-1.1.57-1.el10_2.aarch64.rpm;name=aarch64_openxr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openxr-devel}"
SRC_URI[aarch64_openxr-devel.sha256sum] = "d7b7ea4b022500e8dab24d60974a20cb9f1f855ceb72ec538a3a2c86ec5e8d6f"

URI_aarch64_openxr-libs = "${EPEL_MIRROR}/aarch64/Packages/o/openxr-libs-1.1.57-1.el10_2.aarch64.rpm;name=aarch64_openxr-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openxr-libs}"
SRC_URI[aarch64_openxr-libs.sha256sum] = "097f9ddbaa999879c41fad8662fe5d268ff0d870f59c2c4f40fe94994f16665b"

RDEPENDS:openxr = " \
 glibc \
 libX11 \
 libXxf86vm \
 libgcc \
 libstdc++ \
 openxr-libs \
 vulkan-loader \
 "
RDEPENDS:openxr-devel = " \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 openxr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openxr-libs = " \
 glibc \
 jsoncpp \
 libgcc \
 libstdc++ \
 "
