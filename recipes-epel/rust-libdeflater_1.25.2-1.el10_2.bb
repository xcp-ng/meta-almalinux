# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libdeflater"
PV = "1.25.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-libdeflater+default-devel \
 rust-libdeflater+dynamic-devel \
 rust-libdeflater+freestanding-devel \
 rust-libdeflater+use_rust_alloc-devel \
 rust-libdeflater-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libdeflater-1.25.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecf60059d78e9c3322ec93e1dd3144d93b608fdd375058edbe3dfb17610a3138"

URI_x86_64_v2_rust-libdeflater+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+default-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+default-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+default-devel.sha256sum] = "37bfe2626dba65735ca0f43d8141f8ca0de52c565b3adbd4b81b834045f5d5f2"

URI_x86_64_v2_rust-libdeflater+dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+dynamic-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+dynamic-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+dynamic-devel.sha256sum] = "27b5bbcdd50c6914932bd16fc6afd3b255783d388b4b71bbde582dd9eaa9bc75"

URI_x86_64_v2_rust-libdeflater+freestanding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+freestanding-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+freestanding-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+freestanding-devel.sha256sum] = "8dacdc8399eb7f252a7cf01d63a97d7b44ae130c9ada06d712ef9bdc3a8e4830"

URI_x86_64_v2_rust-libdeflater+use_rust_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+use_rust_alloc-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+use_rust_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+use_rust_alloc-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+use_rust_alloc-devel.sha256sum] = "ac6d650148849240af913ce8f619b29f8dab92072637d8199736bd999998cb76"

URI_x86_64_v2_rust-libdeflater-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater-devel}"
SRC_URI[x86_64_v2_rust-libdeflater-devel.sha256sum] = "03f2907667bc05a1bb36c7d556b1c5ed5b348683bf1d9180ca003d4396abf581"

URI_aarch64_rust-libdeflater+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+default-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-libdeflater+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+default-devel}"
SRC_URI[aarch64_rust-libdeflater+default-devel.sha256sum] = "fb56c1b04996315b4199bb7360de8e32d07e74a71592fed158fd378c6fc25b30"

URI_aarch64_rust-libdeflater+dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+dynamic-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-libdeflater+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+dynamic-devel}"
SRC_URI[aarch64_rust-libdeflater+dynamic-devel.sha256sum] = "7baab5a5c0f5ab0265878d8ff8a1df9122c69132bda1898271917e74fab4ab12"

URI_aarch64_rust-libdeflater+freestanding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+freestanding-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-libdeflater+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+freestanding-devel}"
SRC_URI[aarch64_rust-libdeflater+freestanding-devel.sha256sum] = "e6765ddafe0014d7a52287495640be18c8926826d9633aad05654b065a8f26c1"

URI_aarch64_rust-libdeflater+use_rust_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+use_rust_alloc-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-libdeflater+use_rust_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+use_rust_alloc-devel}"
SRC_URI[aarch64_rust-libdeflater+use_rust_alloc-devel.sha256sum] = "7453a73cba5ce661357cf1c71b25a12e09d6ede41ccd4a50a05d93c4ac4d754a"

URI_aarch64_rust-libdeflater-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-libdeflater-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater-devel}"
SRC_URI[aarch64_rust-libdeflater-devel.sha256sum] = "cafe17032f0d25ab853a89e4fe535825a395bbbe32fbc60c38715e9fc7435b24"

RDEPENDS:rust-libdeflater+default-devel = " \
 cargo \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+dynamic-devel = " \
 cargo \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+freestanding-devel = " \
 cargo \
 rust-libdeflate-sys+freestanding-devel \
 rust-libdeflater+use_rust_alloc-devel \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+use_rust_alloc-devel = " \
 cargo \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater-devel = " \
 cargo \
 rust-libdeflate-sys+default-devel \
 "
