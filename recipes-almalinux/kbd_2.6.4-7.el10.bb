# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbd"
PV = "2.6.4"
PR = "7.el10"
PACKAGES = " \
 kbd \
 kbd-legacy \
 kbd-misc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kbd-2.6.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed225971b242dabbc6c9a679bf3ac3e54245aa1a69b7650853dcedd411b55370"

URI_x86_64_v2_kbd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kbd-2.6.4-7.el10.x86_64_v2.rpm;name=x86_64_v2_kbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbd}"
SRC_URI[x86_64_v2_kbd.sha256sum] = "3b8c3257453a8997c532d30942fcba8420dccde0aa4b837b3cf5234295ba323d"

URI_x86_64_v2_kbd-legacy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kbd-legacy-2.6.4-7.el10.noarch.rpm;name=x86_64_v2_kbd-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbd-legacy}"
SRC_URI[x86_64_v2_kbd-legacy.sha256sum] = "917c3a364af51906ed6f2cda6a8cf96fbd289db4a89fe00ebac05c891b376cc3"

URI_x86_64_v2_kbd-misc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kbd-misc-2.6.4-7.el10.noarch.rpm;name=x86_64_v2_kbd-misc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbd-misc}"
SRC_URI[x86_64_v2_kbd-misc.sha256sum] = "31fe9f6cf4d15b62d605263bd749cb1f37842b4fa3517b37b9bdbf35b855f8c3"

URI_aarch64_kbd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kbd-2.6.4-7.el10.aarch64.rpm;name=aarch64_kbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbd}"
SRC_URI[aarch64_kbd.sha256sum] = "46365de18195c61a9401292304382e70ac6aed375738f75527702c711e01aaff"

URI_aarch64_kbd-legacy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kbd-legacy-2.6.4-7.el10.noarch.rpm;name=aarch64_kbd-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbd-legacy}"
SRC_URI[aarch64_kbd-legacy.sha256sum] = "917c3a364af51906ed6f2cda6a8cf96fbd289db4a89fe00ebac05c891b376cc3"

URI_aarch64_kbd-misc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kbd-misc-2.6.4-7.el10.noarch.rpm;name=aarch64_kbd-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbd-misc}"
SRC_URI[aarch64_kbd-misc.sha256sum] = "31fe9f6cf4d15b62d605263bd749cb1f37842b4fa3517b37b9bdbf35b855f8c3"

RDEPENDS:kbd = " \
 bash \
 glibc \
 kbd-legacy \
 kbd-misc \
 pam-libs \
 "
RDEPENDS:kbd-legacy = " \
 "
RDEPENDS:kbd-misc = " \
 "
