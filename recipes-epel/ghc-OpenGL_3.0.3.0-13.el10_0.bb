# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-OpenGL"
PV = "3.0.3.0"
PR = "13.el10_0"
PACKAGES = " \
 ghc-OpenGL \
 ghc-OpenGL-devel \
 ghc-OpenGL-doc \
 ghc-OpenGL-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-OpenGL-3.0.3.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f7370f8800ba4cc52bbf01ac2ef3e08b7829fe09a2315542397b4a7cc947265"

URI_x86_64_v2_ghc-OpenGL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-OpenGL-3.0.3.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-OpenGL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-OpenGL}"
SRC_URI[x86_64_v2_ghc-OpenGL.sha256sum] = "b7417c37e3d9a698b01077b23b92d728e445805f39bb1c247840e9710a2a34c1"

URI_x86_64_v2_ghc-OpenGL-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-OpenGL-devel-3.0.3.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-OpenGL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-OpenGL-devel}"
SRC_URI[x86_64_v2_ghc-OpenGL-devel.sha256sum] = "f7b55e68957a30aba9ca4cead94900fbc83e5934e36f170fae8324eecd512938"

URI_x86_64_v2_ghc-OpenGL-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-OpenGL-doc-3.0.3.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-OpenGL-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-OpenGL-doc}"
SRC_URI[x86_64_v2_ghc-OpenGL-doc.sha256sum] = "a793e59a25c180faff020a77a84133d80025d7ba9834e9ebc63d7dd771eac213"

URI_x86_64_v2_ghc-OpenGL-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-OpenGL-prof-3.0.3.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-OpenGL-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-OpenGL-prof}"
SRC_URI[x86_64_v2_ghc-OpenGL-prof.sha256sum] = "8a294a90a2f704b6f8fd2254fdf62bebe1ab94a1b1ed73a788b3f6fca0fc16b2"

URI_aarch64_ghc-OpenGL = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-OpenGL-3.0.3.0-13.el10_0.aarch64.rpm;name=aarch64_ghc-OpenGL;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-OpenGL}"
SRC_URI[aarch64_ghc-OpenGL.sha256sum] = "611cbf9ecac90d3643b80231979859b8d62e142589b4794ab959c911c2736b97"

URI_aarch64_ghc-OpenGL-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-OpenGL-devel-3.0.3.0-13.el10_0.aarch64.rpm;name=aarch64_ghc-OpenGL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-OpenGL-devel}"
SRC_URI[aarch64_ghc-OpenGL-devel.sha256sum] = "860319ab4ce908a078366459efc642a21af967ac37fd6670a20f27248c75db62"

URI_aarch64_ghc-OpenGL-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-OpenGL-doc-3.0.3.0-13.el10_0.noarch.rpm;name=aarch64_ghc-OpenGL-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-OpenGL-doc}"
SRC_URI[aarch64_ghc-OpenGL-doc.sha256sum] = "2a2b89a7f808b948df785b46b7d092c1c8cd94072e5690ae5a9647bd439ea4d4"

URI_aarch64_ghc-OpenGL-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-OpenGL-prof-3.0.3.0-13.el10_0.aarch64.rpm;name=aarch64_ghc-OpenGL-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-OpenGL-prof}"
SRC_URI[aarch64_ghc-OpenGL-prof.sha256sum] = "5e5e2255091b947f3e54412c3fa9e48fb9583e147a0301c282b0b02950d0c0d3"

RDEPENDS:ghc-OpenGL = " \
 ghc-GLURaw \
 ghc-ObjectName \
 ghc-OpenGLRaw \
 ghc-StateVar \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-fixed \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-half \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 libglvnd-glx \
 mesa-libGLU \
 "
RDEPENDS:ghc-OpenGL-devel = " \
 ghc-GLURaw-devel \
 ghc-ObjectName-devel \
 ghc-OpenGL \
 ghc-OpenGLRaw-devel \
 ghc-StateVar-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-OpenGL-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-OpenGL-prof = " \
 ghc-GLURaw-prof \
 ghc-ObjectName-prof \
 ghc-OpenGL-devel \
 ghc-OpenGLRaw-prof \
 ghc-StateVar-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
