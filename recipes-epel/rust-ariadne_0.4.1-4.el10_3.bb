# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ariadne"
PV = "0.4.1"
PR = "4.el10_3"
PACKAGES = " \
 rust-ariadne+auto-color-devel \
 rust-ariadne+concolor-devel \
 rust-ariadne+default-devel \
 rust-ariadne-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ariadne-0.4.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8b36eb632ae7df196c22a2922224f460a9bec813c7f0639456d92f5bbb7a571"

URI_x86_64_v2_rust-ariadne+auto-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ariadne+auto-color-devel-0.4.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ariadne+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ariadne+auto-color-devel}"
SRC_URI[x86_64_v2_rust-ariadne+auto-color-devel.sha256sum] = "f152888d1cf31798842ca981841335422b9cfb9f73669a1c0d2aa7ce1e4eafa5"

URI_x86_64_v2_rust-ariadne+concolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ariadne+concolor-devel-0.4.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ariadne+concolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ariadne+concolor-devel}"
SRC_URI[x86_64_v2_rust-ariadne+concolor-devel.sha256sum] = "1a57852fd6ab5a8f98564822878e9c6ead4d88853fbb9a66d7ec7117690c487a"

URI_x86_64_v2_rust-ariadne+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ariadne+default-devel-0.4.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ariadne+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ariadne+default-devel}"
SRC_URI[x86_64_v2_rust-ariadne+default-devel.sha256sum] = "13331f880391d2bd2afa52b194891f2144e15b5ac1e5fe444d26d035f3ff6a61"

URI_x86_64_v2_rust-ariadne-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ariadne-devel-0.4.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ariadne-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ariadne-devel}"
SRC_URI[x86_64_v2_rust-ariadne-devel.sha256sum] = "59bd6ffadbc20ad53750eadd56b382441513fb39d0d0b86191aa5b513aed0aa9"

URI_aarch64_rust-ariadne+auto-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ariadne+auto-color-devel-0.4.1-4.el10_3.noarch.rpm;name=aarch64_rust-ariadne+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ariadne+auto-color-devel}"
SRC_URI[aarch64_rust-ariadne+auto-color-devel.sha256sum] = "d233beb7149135f15277d257dc49ed175f038804942a96619366702e695ab038"

URI_aarch64_rust-ariadne+concolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ariadne+concolor-devel-0.4.1-4.el10_3.noarch.rpm;name=aarch64_rust-ariadne+concolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ariadne+concolor-devel}"
SRC_URI[aarch64_rust-ariadne+concolor-devel.sha256sum] = "16ae1b925cb78c775c97ac3c40df2423bbb03d0df16519f7bc61b65cbe1827cf"

URI_aarch64_rust-ariadne+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ariadne+default-devel-0.4.1-4.el10_3.noarch.rpm;name=aarch64_rust-ariadne+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ariadne+default-devel}"
SRC_URI[aarch64_rust-ariadne+default-devel.sha256sum] = "d6f129a8161b3b87a4e66cea353a3a8fdb2c23898254059f9af448c6a4a645cf"

URI_aarch64_rust-ariadne-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ariadne-devel-0.4.1-4.el10_3.noarch.rpm;name=aarch64_rust-ariadne-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ariadne-devel}"
SRC_URI[aarch64_rust-ariadne-devel.sha256sum] = "b9b851f49ce9234d3ea7d7849f2056c066093ad93a7fbeff86bb10f93387b2a2"

RDEPENDS:rust-ariadne+auto-color-devel = " \
 cargo \
 rust-ariadne+concolor-devel \
 rust-ariadne-devel \
 rust-concolor+auto-devel \
 rust-concolor+default-devel \
 "
RDEPENDS:rust-ariadne+concolor-devel = " \
 cargo \
 rust-ariadne-devel \
 rust-concolor+default-devel \
 "
RDEPENDS:rust-ariadne+default-devel = " \
 cargo \
 rust-ariadne-devel \
 "
RDEPENDS:rust-ariadne-devel = " \
 cargo \
 rust-unicode-width0.1+default-devel \
 rust-yansi+default-devel \
 "
