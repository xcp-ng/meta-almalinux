# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktextaddons"
PV = "1.7.1"
PR = "1.el10_1"
PACKAGES = " \
 ktextaddons-common \
 ktextaddons-qt6 \
 ktextaddons-qt6-devel \
 ktextaddons-qt6-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktextaddons-1.7.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19eabb7c7e795252892ae2e6eacf47aa6a196ac6a81952b54596e329b40e7261"

URI_x86_64_v2_ktextaddons-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-common-1.7.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-common}"
SRC_URI[x86_64_v2_ktextaddons-common.sha256sum] = "6c2933e9e9c30c550ead7a31da9ce98d15efe3b51aef660fe1c46a6faba69004"

URI_x86_64_v2_ktextaddons-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-1.7.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6}"
SRC_URI[x86_64_v2_ktextaddons-qt6.sha256sum] = "05a62a37c0ba31eda3b897c4f52dff19da8998bac55119abdf6eba948a2187b9"

URI_x86_64_v2_ktextaddons-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-devel-1.7.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktextaddons-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6-devel}"
SRC_URI[x86_64_v2_ktextaddons-qt6-devel.sha256sum] = "fee0f4e1f5e2eabc81e698a6f0ca390b08d61ba522b63a9a345f6840a995d1dd"

URI_x86_64_v2_ktextaddons-qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktextaddons-qt6-doc-1.7.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ktextaddons-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktextaddons-qt6-doc}"
SRC_URI[x86_64_v2_ktextaddons-qt6-doc.sha256sum] = "6d8b4b62f2fe5da212366ae8bba3d834fc173fb498afb39069e004278be04972"

URI_aarch64_ktextaddons-common = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-common-1.7.1-1.el10_1.noarch.rpm;name=aarch64_ktextaddons-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-common}"
SRC_URI[aarch64_ktextaddons-common.sha256sum] = "53392dbd94cbda2c96414bdd5872b6d745c12fe92eede652e0c7e17b2da4c073"

URI_aarch64_ktextaddons-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-1.7.1-1.el10_1.aarch64.rpm;name=aarch64_ktextaddons-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6}"
SRC_URI[aarch64_ktextaddons-qt6.sha256sum] = "eeaffc4e965196aec853019cd0f10b5b1f42a927efbbfc00302b647ad2043702"

URI_aarch64_ktextaddons-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-devel-1.7.1-1.el10_1.aarch64.rpm;name=aarch64_ktextaddons-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6-devel}"
SRC_URI[aarch64_ktextaddons-qt6-devel.sha256sum] = "98af36d563b846090ad1ad5e914549d80fd22f60e97e9e05db1ac811e603b91e"

URI_aarch64_ktextaddons-qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ktextaddons-qt6-doc-1.7.1-1.el10_1.noarch.rpm;name=aarch64_ktextaddons-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktextaddons-qt6-doc}"
SRC_URI[aarch64_ktextaddons-qt6-doc.sha256sum] = "8ca2bc085406f0a1f73f4554a9ac906b90f99e567dc563b39a84b75bdc7d0f3b"

RDEPENDS:ktextaddons-common = " \
 "
RDEPENDS:ktextaddons-qt6 = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 kf6-syntax-highlighting \
 ktextaddons-common \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 qtkeychain-qt6 \
 "
RDEPENDS:ktextaddons-qt6-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kconfig \
 kf6-ki18n \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:ktextaddons-qt6-doc = " \
 "
