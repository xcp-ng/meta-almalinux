# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontact"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kontact \
 kontact-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontact-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1b1d3a4b320650a3fa06a0c89f386d280948047d52364597350a01e10a416d8"

URI_x86_64_v2_kontact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontact-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontact}"
SRC_URI[x86_64_v2_kontact.sha256sum] = "2993d010bf0adaaa7d3385884be6f8fb1cf6f54cc6ad1831a48d602dfd484ed0"

URI_x86_64_v2_kontact-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontact-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontact-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontact-libs}"
SRC_URI[x86_64_v2_kontact-libs.sha256sum] = "577c39fada1a60dd0e4b2e27577e270114a52349113677c3304968942742652d"

URI_aarch64_kontact = "${EPEL_MIRROR}/aarch64/Packages/k/kontact-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kontact;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontact}"
SRC_URI[aarch64_kontact.sha256sum] = "1647771857b2026b492b1e878ede28a4af57a6e4b6ada3b4790f3c297d307e37"

URI_aarch64_kontact-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kontact-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kontact-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontact-libs}"
SRC_URI[aarch64_kontact-libs.sha256sum] = "24d0ba72fb1e85eecc8662b19ff15ba200d83ce5e049f40af9bf514c8ea6ed56"

RDEPENDS:kontact = " \
 glibc \
 kaddressbook \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kxmlgui \
 kmail \
 kontact-libs \
 kontactinterface \
 korganizer \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kontact-libs = " \
 glibc \
 grantleetheme \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontact \
 kontactinterface \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
