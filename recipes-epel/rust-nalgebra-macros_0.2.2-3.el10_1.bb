# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nalgebra-macros"
PV = "0.2.2"
PR = "3.el10_1"
PACKAGES = " \
 rust-nalgebra-macros+default-devel \
 rust-nalgebra-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nalgebra-macros-0.2.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac346ec942dccbc5419cfd7ef1e1d593f8d065468820d23dd1a44871b014da76"

URI_x86_64_v2_rust-nalgebra-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra-macros+default-devel-0.2.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra-macros+default-devel}"
SRC_URI[x86_64_v2_rust-nalgebra-macros+default-devel.sha256sum] = "b5d5493700c6c0a35f611043f906e47f121f7cec840ee801f36feccf965d6a0c"

URI_x86_64_v2_rust-nalgebra-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nalgebra-macros-devel-0.2.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nalgebra-macros-devel}"
SRC_URI[x86_64_v2_rust-nalgebra-macros-devel.sha256sum] = "6e333e98509469e3cf32b21b4f8ece34bdeae8a62d8d6300f3a34e5b1f8c4904"

URI_aarch64_rust-nalgebra-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra-macros+default-devel-0.2.2-3.el10_1.noarch.rpm;name=aarch64_rust-nalgebra-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra-macros+default-devel}"
SRC_URI[aarch64_rust-nalgebra-macros+default-devel.sha256sum] = "e35a4a408e794a02fa49159f6d915bdd54640cfd0921962e9e2280fdcd328e7d"

URI_aarch64_rust-nalgebra-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nalgebra-macros-devel-0.2.2-3.el10_1.noarch.rpm;name=aarch64_rust-nalgebra-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nalgebra-macros-devel}"
SRC_URI[aarch64_rust-nalgebra-macros-devel.sha256sum] = "24bb1cb2c0a92fe96229deab18de7aa159adcb037882fdd95077c908b2114438"

RDEPENDS:rust-nalgebra-macros+default-devel = " \
 cargo \
 rust-nalgebra-macros-devel \
 "
RDEPENDS:rust-nalgebra-macros-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
