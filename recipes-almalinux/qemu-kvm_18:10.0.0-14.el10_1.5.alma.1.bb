# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qemu-kvm"
PE = "18"
PV = "10.0.0"
PR = "14.el10_1.5.alma.1"
PACKAGES:x86_64_v2 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"
PACKAGES:aarch64 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qemu-kvm-10.0.0-14.el10_1.5.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56da95187160c5d0043635909f2b3c9b5e3cbd19bb055138bfb66b9000e01154"

URI_x86_64_v2_qemu-guest-agent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-guest-agent-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-guest-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-guest-agent}"
SRC_URI[x86_64_v2_qemu-guest-agent.sha256sum] = "31b65052b3a983b532e5b11d045666d652f08c06e8878cce2cce401ab1ac9b8e"

URI_x86_64_v2_qemu-img = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-img-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-img;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-img}"
SRC_URI[x86_64_v2_qemu-img.sha256sum] = "4ced07d070cc613f8d22d68e2cf253b706227932e0b3c5b49a60ec59788635d0"

URI_x86_64_v2_qemu-kvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm}"
SRC_URI[x86_64_v2_qemu-kvm.sha256sum] = "b3b6ae58df72fb820374736176ff6ad6d8da4aceb483586c99a9231822d49060"

URI_x86_64_v2_qemu-kvm-audio-pa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-audio-pa-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-audio-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-audio-pa}"
SRC_URI[x86_64_v2_qemu-kvm-audio-pa.sha256sum] = "3fc2d4959d14980c5d7bbbfcf8d49846f91655bef7ccb6edb915a266f60f9e65"

URI_x86_64_v2_qemu-kvm-block-blkio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-blkio-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-blkio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-blkio}"
SRC_URI[x86_64_v2_qemu-kvm-block-blkio.sha256sum] = "27fb32ed843a556b443cbe7b63effb3874a84dfdcec8eb594e66f7cc5e0c516d"

URI_x86_64_v2_qemu-kvm-block-curl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-curl-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-curl}"
SRC_URI[x86_64_v2_qemu-kvm-block-curl.sha256sum] = "a9d66503e8dbb466b1e9150f4e9ba21e9ff0671b4c302e55a1fbc5dd806ab66c"

URI_x86_64_v2_qemu-kvm-block-rbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-rbd-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-rbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-block-rbd}"
SRC_URI[x86_64_v2_qemu-kvm-block-rbd.sha256sum] = "ccb45cf4a3e5da8a6d1980a712f9787bcc6374dd111ab96057a0e732be842cca"

URI_x86_64_v2_qemu-kvm-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-common-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-common}"
SRC_URI[x86_64_v2_qemu-kvm-common.sha256sum] = "dbd8726af97aa22bb58b89f6906d45c5e101d30b835d444bb130ae17694fe802"

URI_x86_64_v2_qemu-kvm-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-core-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-core}"
SRC_URI[x86_64_v2_qemu-kvm-core.sha256sum] = "1bc485b178b57d62848f7f8427a5afbbcbdfca679220388df47b5d8cf8ea6d43"

URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu.sha256sum] = "384ae41431bc4c79dcbd74cdffd64f8a7a34aca29f0d8fd00e99f10ac5499799"

URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "98b136d0bcae3c19de84c9085e341ecc84ff26790be904fdf514b884445f41f1"

URI_x86_64_v2_qemu-kvm-device-display-virtio-vga = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-vga-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-vga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-display-virtio-vga}"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-vga.sha256sum] = "ec7b556149631bb35ecce17592d818f1c550c9724431a32b31f8f2fd221d311e"

URI_x86_64_v2_qemu-kvm-device-usb-host = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-host-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-host;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-usb-host}"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-host.sha256sum] = "640c930d7394cf158ba163d0cd02845f16d5e60adbe87aba2af229f982fa610a"

URI_x86_64_v2_qemu-kvm-device-usb-redirect = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-redirect-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-device-usb-redirect}"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-redirect.sha256sum] = "840f99b37d3b8fdf1a50bd93877f43226f4500605dfcbc3316f67742ae39e329"

URI_x86_64_v2_qemu-kvm-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-docs-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-docs}"
SRC_URI[x86_64_v2_qemu-kvm-docs.sha256sum] = "e8715d1f6db61f684e0196fe7e87b792004b180f8068c2fd60ec10bd2d6d1e94"

URI_x86_64_v2_qemu-kvm-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-tools-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-tools}"
SRC_URI[x86_64_v2_qemu-kvm-tools.sha256sum] = "72f885e715f4f295bce15fc3ad8eddeb3f26bf5ec4ae27fe64383d043d9d595d"

URI_x86_64_v2_qemu-kvm-ui-egl-headless = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-egl-headless-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-egl-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-egl-headless}"
SRC_URI[x86_64_v2_qemu-kvm-ui-egl-headless.sha256sum] = "07c3581858de3e59fd4d26a74ffbc69a04c8a4f4a0bab13ec6010df9bfd1e54c"

URI_x86_64_v2_qemu-kvm-ui-opengl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-opengl-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-opengl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-opengl}"
SRC_URI[x86_64_v2_qemu-kvm-ui-opengl.sha256sum] = "3a47d03ce2344e6aad0790072ca45c5bd06f6921107ca2cf5abcf17d196fa47b"

URI_x86_64_v2_qemu-kvm-ui-spice = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-spice-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-spice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-kvm-ui-spice}"
SRC_URI[x86_64_v2_qemu-kvm-ui-spice.sha256sum] = "68857ec82f21c13fed654af34336c74661142e7d4fdead77e0ac23b07da124c3"

URI_x86_64_v2_qemu-pr-helper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-pr-helper-10.0.0-14.el10_1.5.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-pr-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qemu-pr-helper}"
SRC_URI[x86_64_v2_qemu-pr-helper.sha256sum] = "9a654cffedd47278ae4085db70e7144cf366ff4b2846c38f3c791683eee69773"

URI_aarch64_qemu-guest-agent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-guest-agent-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-guest-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-guest-agent}"
SRC_URI[aarch64_qemu-guest-agent.sha256sum] = "057242fda37723153f231fb284b8e6ff11aa86cb41c70896c98157543123fa58"

URI_aarch64_qemu-img = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-img-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-img;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-img}"
SRC_URI[aarch64_qemu-img.sha256sum] = "8fc877e9c38cabed21bbc201d1caf1e8e40d042263122a14947258e9a7b4cb60"

URI_aarch64_qemu-kvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm}"
SRC_URI[aarch64_qemu-kvm.sha256sum] = "ccb21243ce916a253c65b4d1f54d2ec715ca804e4468b3ff449aea8fc3fbf4f5"

URI_aarch64_qemu-kvm-audio-pa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-audio-pa-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-audio-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-audio-pa}"
SRC_URI[aarch64_qemu-kvm-audio-pa.sha256sum] = "43fd386be308f5b479d413e1cc7b62f719674efa19935b0702bf72e685ce2e67"

URI_aarch64_qemu-kvm-block-blkio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-blkio-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-blkio;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-blkio}"
SRC_URI[aarch64_qemu-kvm-block-blkio.sha256sum] = "4b4b70957ae163c7d8565f9d5bd11715e7d515c15654a6b9687f4532eb5fb0c1"

URI_aarch64_qemu-kvm-block-curl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-curl-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-curl}"
SRC_URI[aarch64_qemu-kvm-block-curl.sha256sum] = "2353a7805966dac8d780ea049807b488f2597f2d980034a76a6fda1bdb0a69a0"

URI_aarch64_qemu-kvm-block-rbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-rbd-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-rbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-block-rbd}"
SRC_URI[aarch64_qemu-kvm-block-rbd.sha256sum] = "df1e078ff84a97fef8f9982148a6b8cc1f888d5b520584106c03c718c853dce7"

URI_aarch64_qemu-kvm-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-common-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-common}"
SRC_URI[aarch64_qemu-kvm-common.sha256sum] = "67ba3e2724fc3428468c16cdd2ac70f54348aab29f4697b0117e87050d9debe0"

URI_aarch64_qemu-kvm-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-core-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-core}"
SRC_URI[aarch64_qemu-kvm-core.sha256sum] = "8d95ddf1ba5e73d3d1388199c19631881102145b520a19394174c4f43f9f6f69"

URI_aarch64_qemu-kvm-device-display-virtio-gpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-display-virtio-gpu}"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu.sha256sum] = "0fa2c3fc582aaa8897d6642142431ff4e166be8cf913d88bed44645bfcde6563"

URI_aarch64_qemu-kvm-device-display-virtio-gpu-pci = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-display-virtio-gpu-pci}"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "99bc1281e7e833932b2a01850f16571ae2f8366b0de7c851c826582ecc862d19"

URI_aarch64_qemu-kvm-device-usb-host = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-host-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-host;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-usb-host}"
SRC_URI[aarch64_qemu-kvm-device-usb-host.sha256sum] = "8d6f86d78d33f16c149265092227cdf704386c7b8064ed66a739528fa226c0dc"

URI_aarch64_qemu-kvm-device-usb-redirect = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-redirect-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-device-usb-redirect}"
SRC_URI[aarch64_qemu-kvm-device-usb-redirect.sha256sum] = "4a0b4d5f072be42f7ab590a97e561f56b890a15f099182803c9eb043107fab38"

URI_aarch64_qemu-kvm-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-docs-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-docs}"
SRC_URI[aarch64_qemu-kvm-docs.sha256sum] = "47b6e81177a63dc12dbc4f1ccc9a777517f94e9d9a4346a41ad063f4994e60f5"

URI_aarch64_qemu-kvm-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-tools-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-tools}"
SRC_URI[aarch64_qemu-kvm-tools.sha256sum] = "060d130a359f1f9038fba641525d975ab57e7f7ae917990d771a791fabf06545"

URI_aarch64_qemu-kvm-ui-spice = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-ui-spice-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-ui-spice;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-kvm-ui-spice}"
SRC_URI[aarch64_qemu-kvm-ui-spice.sha256sum] = "4fdd0b281c276716ac04ae04c118e5b751ccfec3c87bd607fcc890a47c2c9d51"

URI_aarch64_qemu-pr-helper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-pr-helper-10.0.0-14.el10_1.5.alma.1.aarch64.rpm;name=aarch64_qemu-pr-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_qemu-pr-helper}"
SRC_URI[aarch64_qemu-pr-helper.sha256sum] = "a6b8ddddd384723a6e8de42ceaa3a66032bde1d68cffd678e6980999bc5c0c74"

RDEPENDS:qemu-guest-agent = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 liburing \
 numactl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:qemu-img = " \
 glib2 \
 glibc \
 gnutls \
 libaio \
 libgcc \
 libselinux \
 liburing \
 libzstd \
 numactl-libs \
 zlib-ng-compat \
 "
RDEPENDS:qemu-kvm:x86_64_v2 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm:aarch64 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm-audio-pa = " \
 glibc \
 pulseaudio-libs \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-blkio = " \
 glibc \
 libblkio \
 libgcc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-curl = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-block-rbd = " \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-common:x86_64_v2 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 ipxe-roms-qemu \
 libcap-ng \
 libgcc \
 seabios-bin \
 seavgabios-bin \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-common:aarch64 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 libcap-ng \
 libgcc \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-core:x86_64_v2 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-ovmf \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-core:aarch64 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-aarch64 \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-device-display-virtio-gpu = " \
 glibc \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-display-virtio-gpu-pci = " \
 glibc \
 qemu-kvm-common \
 qemu-kvm-device-display-virtio-gpu \
 "
RDEPENDS:qemu-kvm-device-display-virtio-vga = " \
 glibc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-host = " \
 glibc \
 libusb1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-redirect = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 usbredir \
 "
RDEPENDS:qemu-kvm-docs = " \
 "
RDEPENDS:qemu-kvm-tools = " \
 glib2 \
 glibc \
 libgcc \
 libxkbcommon \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-ui-egl-headless = " \
 glibc \
 libepoxy \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 "
RDEPENDS:qemu-kvm-ui-opengl = " \
 glibc \
 libepoxy \
 libgcc \
 mesa-dri-drivers \
 mesa-libEGL \
 mesa-libGL \
 mesa-libgbm \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-ui-spice:x86_64_v2 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 spice-server \
"
RDEPENDS:qemu-kvm-ui-spice:aarch64 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 spice-server \
"
RDEPENDS:qemu-pr-helper = " \
 device-mapper-multipath-libs \
 glib2 \
 glibc \
 gnutls \
 libcap-ng \
 libgcc \
 liburing \
 numactl-libs \
 systemd-libs \
 "
