# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eglexternalplatform"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 eglexternalplatform-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/eglexternalplatform-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f5d733ec23c15721499c1804c14dea136bdacae6d1e73d3a3f7e80b71ae3d469"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eglexternalplatform-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_eglexternalplatform-devel;unpack=0"
SRC_URI[x86_64_v2_eglexternalplatform-devel.sha256sum] = "14b47a9da1fa28a4af9e6fa875eaf53b04e3d480a2cc571bf0f7cee608e5ee0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/eglexternalplatform-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_eglexternalplatform-devel;unpack=0"
SRC_URI[aarch64_eglexternalplatform-devel.sha256sum] = "d8db8fbf0d784e5032b9a3d4e39b86368bf88da5a62801c4c5e8879d4547bd17"

RDEPENDS:eglexternalplatform-devel = " \
 pkgconf-pkg-config \
 "
