# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktnef"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ktnef \
 ktnef-devel \
 ktnef-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ktnef-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8228eacfbd4bc9bbff386c8973853adff5dd917527bb5ee2619c1e27e975b110"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef;unpack=0"
SRC_URI[x86_64_v2_ktnef.sha256sum] = "32daa7cb3aa9ffd4af23132c2038d578d5f3767ea9f6459ce8fa8cb482bebf93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef-devel;unpack=0"
SRC_URI[x86_64_v2_ktnef-devel.sha256sum] = "1775927e2560a9395ae6bdb55402a5775eb9f8508cce53f0547a746fd85d333b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ktnef-doc;unpack=0"
SRC_URI[x86_64_v2_ktnef-doc.sha256sum] = "3d6a5992afd33e6c215cc2886fdb2dbb1abc0aa861a57973f05d60c8c3ef1829"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktnef-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ktnef;unpack=0"
SRC_URI[aarch64_ktnef.sha256sum] = "3293de7d8ce349f106f9d8598665d6051788a183dcb5c2c2b75702af8f0b7afe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktnef-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ktnef-devel;unpack=0"
SRC_URI[aarch64_ktnef-devel.sha256sum] = "48104b1e1d8f33b448814d36d8772b7ade58f9a901e8bfbc7c22b7294ef926b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ktnef-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_ktnef-doc;unpack=0"
SRC_URI[aarch64_ktnef-doc.sha256sum] = "99d488144414fdd5cf405fb7d1c51527bd2438b6e62dd6092867b50bbc262c05"

RDEPENDS:ktnef = " \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ktnef-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 ktnef \
 "
RDEPENDS:ktnef-doc = " \
 "
