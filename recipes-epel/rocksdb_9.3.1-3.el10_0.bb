# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocksdb"
PV = "9.3.1"
PR = "3.el10_0"
PACKAGES = " \
 rocksdb \
 rocksdb-devel \
 rocksdb-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocksdb-9.3.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b080ff137914d4bb028df6b1b49193916a977eeeb75be57170155f36ac736e4"

URI_x86_64_v2_rocksdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocksdb-9.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocksdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocksdb}"
SRC_URI[x86_64_v2_rocksdb.sha256sum] = "dbc65eeec90c9bac6f0e5143c18137287fdd9313fa18c9ea76d6955d53a57661"

URI_x86_64_v2_rocksdb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocksdb-devel-9.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocksdb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocksdb-devel}"
SRC_URI[x86_64_v2_rocksdb-devel.sha256sum] = "7ef4294e1b2bf1c02d6687ce5897ce0d88343a8ed881d5a8356aa42b8756d592"

URI_x86_64_v2_rocksdb-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocksdb-tools-9.3.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocksdb-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocksdb-tools}"
SRC_URI[x86_64_v2_rocksdb-tools.sha256sum] = "585500404a5ba1e06e799b26a48f83ab0263dd38c89db37122c2168999490448"

URI_aarch64_rocksdb = "${EPEL_MIRROR}/aarch64/Packages/r/rocksdb-9.3.1-3.el10_0.aarch64.rpm;name=aarch64_rocksdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocksdb}"
SRC_URI[aarch64_rocksdb.sha256sum] = "31f89eb2622a5e19f2483eadc442fde77d2ee9644da988c4a3dfa8bf7347a762"

URI_aarch64_rocksdb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rocksdb-devel-9.3.1-3.el10_0.aarch64.rpm;name=aarch64_rocksdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocksdb-devel}"
SRC_URI[aarch64_rocksdb-devel.sha256sum] = "1ccd9862b0102f344aab23394fe5fd195a4a064c632ea70754da99688ad580a7"

URI_aarch64_rocksdb-tools = "${EPEL_MIRROR}/aarch64/Packages/r/rocksdb-tools-9.3.1-3.el10_0.aarch64.rpm;name=aarch64_rocksdb-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_rocksdb-tools}"
SRC_URI[aarch64_rocksdb-tools.sha256sum] = "0373144956802f88e00172f089c1921be9fcf932f4f7b0f91642d147f5ba0d15"

RDEPENDS:rocksdb = " \
 bzip2-libs \
 gflags \
 glibc \
 libgcc \
 libstdc++ \
 liburing \
 libzstd \
 lz4-libs \
 snappy \
 zlib-ng-compat \
 "
RDEPENDS:rocksdb-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 rocksdb \
 "
RDEPENDS:rocksdb-tools = " \
 bzip2-libs \
 gflags \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 rocksdb \
 snappy \
 zlib-ng-compat \
 "
