# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-virt-firmware"
PV = "26.6"
PR = "1.el10"
PACKAGES = " \
 python3-virt-firmware \
 uki-direct \
 virt-sb-certs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-virt-firmware-26.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ca5fccadd7d668b6dbf36ab72a89c56eb727119ddba32cb580fc22f3f4ec6af"

URI_x86_64_v2_python3-virt-firmware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-virt-firmware-26.6-1.el10.noarch.rpm;name=x86_64_v2_python3-virt-firmware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-virt-firmware}"
SRC_URI[x86_64_v2_python3-virt-firmware.sha256sum] = "7bc1e2f2ffdf8e2408cc6ceeb1fc9b0130e2e5dc8fe2fc5ea642fa40e45a1e8c"

URI_x86_64_v2_uki-direct = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uki-direct-26.6-1.el10.noarch.rpm;name=x86_64_v2_uki-direct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uki-direct}"
SRC_URI[x86_64_v2_uki-direct.sha256sum] = "1882abb524fceed2002b708c7c78283f67e9ec6ce2bcaf87b7d1dad3c5faf70d"

URI_x86_64_v2_virt-sb-certs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-sb-certs-26.6-1.el10.noarch.rpm;name=x86_64_v2_virt-sb-certs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virt-sb-certs}"
SRC_URI[x86_64_v2_virt-sb-certs.sha256sum] = "eede797efead5fadcc5887a530dd6aad5d3928ba87183d658bde641c24a09c1b"

URI_aarch64_python3-virt-firmware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-virt-firmware-26.6-1.el10.noarch.rpm;name=aarch64_python3-virt-firmware;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-virt-firmware}"
SRC_URI[aarch64_python3-virt-firmware.sha256sum] = "7bc1e2f2ffdf8e2408cc6ceeb1fc9b0130e2e5dc8fe2fc5ea642fa40e45a1e8c"

URI_aarch64_uki-direct = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uki-direct-26.6-1.el10.noarch.rpm;name=aarch64_uki-direct;unpack=0"
SRC_URI:append = " ${URI_aarch64_uki-direct}"
SRC_URI[aarch64_uki-direct.sha256sum] = "1882abb524fceed2002b708c7c78283f67e9ec6ce2bcaf87b7d1dad3c5faf70d"

URI_aarch64_virt-sb-certs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-sb-certs-26.6-1.el10.noarch.rpm;name=aarch64_virt-sb-certs;unpack=0"
SRC_URI:append = " ${URI_aarch64_virt-sb-certs}"
SRC_URI[aarch64_virt-sb-certs.sha256sum] = "eede797efead5fadcc5887a530dd6aad5d3928ba87183d658bde641c24a09c1b"

RDEPENDS:python3-virt-firmware = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-pyyaml \
 python3-setuptools \
 virt-sb-certs \
 "
RDEPENDS:uki-direct = " \
 bash \
 python3-virt-firmware \
 "
RDEPENDS:virt-sb-certs = " \
 "
