# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-gtk3"
PV = "0.15.9"
PR = "1.el10_0"
PACKAGES = " \
 ghc-gtk3 \
 ghc-gtk3-devel \
 ghc-gtk3-doc \
 ghc-gtk3-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-gtk3-0.15.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e659caf560997e10f97151f9e18a332e878514b8f82d7960e94778a2f66aa4c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gtk3-0.15.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gtk3;unpack=0"
SRC_URI[x86_64_v2_ghc-gtk3.sha256sum] = "2aaecc75d178ea04267f92c34a08b220010b2441c8586347ea7f37c17c03c36d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gtk3-devel-0.15.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gtk3-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-gtk3-devel.sha256sum] = "e8226e47677676699da5753cc69c0480b3df2d12ae34c2c0ef5edeae2d2cf4d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gtk3-doc-0.15.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-gtk3-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-gtk3-doc.sha256sum] = "54c2214d94184bf137e82bc18942c2963c38c0027f7c05a2323ecea0c94fe76a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-gtk3-prof-0.15.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-gtk3-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-gtk3-prof.sha256sum] = "2e36adb77a0aeaa2a4b1369bccdc0cef5f0be162060d41fedf0d4906c49466bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-gtk3-0.15.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-gtk3;unpack=0"
SRC_URI[aarch64_ghc-gtk3.sha256sum] = "b1b59d3d96f471501b2a74cc822a63982891e81feff65cf0f55c9808cdf914de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-gtk3-devel-0.15.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-gtk3-devel;unpack=0"
SRC_URI[aarch64_ghc-gtk3-devel.sha256sum] = "de42052cf726bef578fd0c156ff3f07b43e904a91b4581164b4b18fed618e95d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-gtk3-doc-0.15.9-1.el10_0.noarch.rpm;name=aarch64_ghc-gtk3-doc;unpack=0"
SRC_URI[aarch64_ghc-gtk3-doc.sha256sum] = "52fb0c302f847e2b9caba4b4d42b8726540b8ee24504a23d76a1bf00642e03b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-gtk3-prof-0.15.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-gtk3-prof;unpack=0"
SRC_URI[aarch64_ghc-gtk3-prof.sha256sum] = "70fc84ee3b2788c3b338cfebd725949a3b3d1587dcaea0a85cda656f5bbc2efa"

RDEPENDS:ghc-gtk3 = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-cairo \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gio \
 ghc-glib \
 ghc-mtl \
 ghc-pango \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-utf8-string \
 glib2 \
 glibc \
 gmp \
 gtk3 \
 harfbuzz \
 libpng \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:ghc-gtk3-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cairo-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-gio-devel \
 ghc-glib-devel \
 ghc-gtk3 \
 ghc-mtl-devel \
 ghc-pango-devel \
 ghc-text-devel \
 glib2-devel \
 gtk3-devel \
 "
RDEPENDS:ghc-gtk3-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-gtk3-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cairo-prof \
 ghc-containers-prof \
 ghc-gio-prof \
 ghc-glib-prof \
 ghc-gtk3-devel \
 ghc-mtl-prof \
 ghc-pango-prof \
 ghc-text-prof \
 "
