# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulseaudio-qt"
PV = "1.8.1"
PR = "1.el10_2"
PACKAGES = " \
 pulseaudio-qt-qt6 \
 pulseaudio-qt-qt6-devel \
 pulseaudio-qt-qt6-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pulseaudio-qt-1.8.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd780d83e63cb4f7522fd7c74fd90c2bfb063912e855c2e41719d8fbae589cb2"

URI_x86_64_v2_pulseaudio-qt-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-1.8.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6.sha256sum] = "c4aae945283e4a0cd57417b88b1be383be96d8f4648e89acaf1b3f45fd603503"

URI_x86_64_v2_pulseaudio-qt-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-devel-1.8.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6-devel}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6-devel.sha256sum] = "376d999d7dd451716477de409763b76a54ea76e5b17d51a336afc02a5dd8cb32"

URI_x86_64_v2_pulseaudio-qt-qt6-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulseaudio-qt-qt6-doc-1.8.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulseaudio-qt-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulseaudio-qt-qt6-doc}"
SRC_URI[x86_64_v2_pulseaudio-qt-qt6-doc.sha256sum] = "37320ecee32a0330e49a0922e095024be7842a625bb83ca5d6f7e41c6b935eef"

URI_aarch64_pulseaudio-qt-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-1.8.1-1.el10_2.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6}"
SRC_URI[aarch64_pulseaudio-qt-qt6.sha256sum] = "f8b1104b4c24f67685cde7e4d5721b3ba1026621c351baa3d47e4c90a920c069"

URI_aarch64_pulseaudio-qt-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-devel-1.8.1-1.el10_2.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6-devel}"
SRC_URI[aarch64_pulseaudio-qt-qt6-devel.sha256sum] = "8496edec8e4089f3a017bb21770833b907e68f8985c67400a6cb1c1f966a1d83"

URI_aarch64_pulseaudio-qt-qt6-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pulseaudio-qt-qt6-doc-1.8.1-1.el10_2.aarch64.rpm;name=aarch64_pulseaudio-qt-qt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulseaudio-qt-qt6-doc}"
SRC_URI[aarch64_pulseaudio-qt-qt6-doc.sha256sum] = "b2bffc77906fd5bdf0c6eaf3850e8740b9cf1c7878c164db180584a654c12915"

RDEPENDS:pulseaudio-qt-qt6 = " \
 glibc \
 libstdc++ \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pulseaudio-qt-qt6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pulseaudio-qt-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:pulseaudio-qt-qt6-doc = " \
 "
