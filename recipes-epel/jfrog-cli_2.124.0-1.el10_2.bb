# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jfrog-cli"
PV = "2.124.0"
PR = "1.el10_2"
PACKAGES = " \
 jfrog-cli \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jfrog-cli-2.124.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7205a5387c59c254e882d88c4e9706a9ee110bafc634214b8138f08cd6954102"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jfrog-cli-2.124.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jfrog-cli;unpack=0"
SRC_URI[x86_64_v2_jfrog-cli.sha256sum] = "5b7db2da4538937a4d171e9b81742926cc0979eb6ad64612a2f335dfd03de4f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jfrog-cli-2.124.0-1.el10_2.aarch64.rpm;name=aarch64_jfrog-cli;unpack=0"
SRC_URI[aarch64_jfrog-cli.sha256sum] = "6e7eba00b1712c0ee795a86fa783f8ea242e3db4dc8468ec1666c3f5c888fb2e"

RDEPENDS:jfrog-cli = " \
 glibc \
 "
