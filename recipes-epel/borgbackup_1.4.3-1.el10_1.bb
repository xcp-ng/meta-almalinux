# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "borgbackup"
PV = "1.4.3"
PR = "1.el10_1"
PACKAGES = " \
 borgbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/borgbackup-1.4.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d5e84eb6f53643f0854d404fd51ab5f79a90e7a8a8e02acd1468ff1676dbc90"

URI_x86_64_v2_borgbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/borgbackup-1.4.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_borgbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_borgbackup}"
SRC_URI[x86_64_v2_borgbackup.sha256sum] = "790465614efd381863217ee0c23f1d7df8c595643b6d4681f1e8c0ebd733e323"

URI_aarch64_borgbackup = "${EPEL_MIRROR}/aarch64/Packages/b/borgbackup-1.4.3-1.el10_1.aarch64.rpm;name=aarch64_borgbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_borgbackup}"
SRC_URI[aarch64_borgbackup.sha256sum] = "4fe1628ce460d02c7bcc6e61dcdd6542b58a1b931d6666a9a43e4e82c6a3797e"

RDEPENDS:borgbackup = " \
 fuse \
 glibc \
 libacl \
 libzstd \
 lz4-libs \
 openssl-libs \
 python3 \
 python3-llfuse \
 python3-msgpack \
 python3-packaging \
 xxhash-libs \
 "
