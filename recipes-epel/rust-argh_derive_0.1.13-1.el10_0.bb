# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argh_derive"
PV = "0.1.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-argh_derive+default-devel \
 rust-argh_derive+help-devel \
 rust-argh_derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-argh_derive-0.1.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c64a1295272006d8a4fb7a0313f829441a2193089eef40832b8eef12ede17366"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh_derive+default-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh_derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-argh_derive+default-devel.sha256sum] = "d64891a510797d8eba8a1f0bf5e5da761c7afe923e363a8f5d69921fceecde62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh_derive+help-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh_derive+help-devel;unpack=0"
SRC_URI[x86_64_v2_rust-argh_derive+help-devel.sha256sum] = "20b76388bb51ffb8b86dc735eac513d3323bbfaa0fdba2d411c50f887db2e53f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argh_derive-devel-0.1.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argh_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-argh_derive-devel.sha256sum] = "c38933c794f6bd2e5c4cd60eaab14d38b5839fc23be9e728a76db37ee88eb71b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-argh_derive+default-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh_derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-argh_derive+default-devel.sha256sum] = "d589801e82e983dc9dc821ca16aae636ff14b8a428128e44bab4134b591af285"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-argh_derive+help-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh_derive+help-devel;unpack=0"
SRC_URI[aarch64_rust-argh_derive+help-devel.sha256sum] = "6b76503eb14d26a97f49184245f23edc3fdd1b03c9d29d17ea83f221047f0da5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-argh_derive-devel-0.1.13-1.el10_0.noarch.rpm;name=aarch64_rust-argh_derive-devel;unpack=0"
SRC_URI[aarch64_rust-argh_derive-devel.sha256sum] = "a765f3db77e73f3ba2fdad530501de336ed59ab13a23ed4ba820aded36bb89a8"

RDEPENDS:rust-argh_derive+default-devel = " \
 cargo \
 rust-argh_derive-devel \
 "
RDEPENDS:rust-argh_derive+help-devel = " \
 cargo \
 rust-argh_derive-devel \
 "
RDEPENDS:rust-argh_derive-devel = " \
 cargo \
 rust-argh_shared+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
