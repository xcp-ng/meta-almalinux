# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-build"
PV = "1.0.199"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxx-build+default-devel \
 rust-cxx-build+parallel-devel \
 rust-cxx-build-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-build-1.0.199-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72539ada8e721c831cf76f522431850c7a5a0e0735e70dd2af8ca04be787abd4"

URI_x86_64_v2_rust-cxx-build+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+default-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build+default-devel}"
SRC_URI[x86_64_v2_rust-cxx-build+default-devel.sha256sum] = "2bb2aea0a0c60d5cf28e19111ce3e9a765999d30da9d4373796048953a57891f"

URI_x86_64_v2_rust-cxx-build+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+parallel-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build+parallel-devel}"
SRC_URI[x86_64_v2_rust-cxx-build+parallel-devel.sha256sum] = "2b575cbc0b38f04cde05794c24e467d01656ad305a8aa06b8d6e15b50319e581"

URI_x86_64_v2_rust-cxx-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build-devel-1.0.199-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build-devel}"
SRC_URI[x86_64_v2_rust-cxx-build-devel.sha256sum] = "3d581ad7020935db1007ac17e6c467657bbc82506a20d64036faa6c093870bd4"

URI_aarch64_rust-cxx-build+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+default-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build+default-devel}"
SRC_URI[aarch64_rust-cxx-build+default-devel.sha256sum] = "509f9817f7bfdf23eb88e7b874fba1360f4edb973a91ba5e98c9ee421bcb13de"

URI_aarch64_rust-cxx-build+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+parallel-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build+parallel-devel}"
SRC_URI[aarch64_rust-cxx-build+parallel-devel.sha256sum] = "a5fe09c6d01544a1cde3a9c8135e1934bb7e1d8f29d646888501d23213ec1f20"

URI_aarch64_rust-cxx-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build-devel-1.0.199-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build-devel}"
SRC_URI[aarch64_rust-cxx-build-devel.sha256sum] = "abbe0f9933d2cac3e2b794c5958aef0a747bb5cc82c82a8a5cc35eef2ef0e426"

RDEPENDS:rust-cxx-build+default-devel = " \
 cargo \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build+parallel-devel = " \
 cargo \
 rust-cc+parallel-devel \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-codespan-reporting+default-devel \
 rust-indexmap+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-scratch+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
