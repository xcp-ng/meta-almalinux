# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-native-certs"
PV = "0.8.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustls-native-certs+default-devel \
 rust-rustls-native-certs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-native-certs-0.8.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d608ffd8d4362c6967f8f818b8f189683a34c78fd182e54d0a37ff32843e350"

URI_x86_64_v2_rust-rustls-native-certs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-native-certs+default-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-native-certs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-native-certs+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-native-certs+default-devel.sha256sum] = "5159387c09a923fc6b8cdd4cd0e5479e5675f8004462afd0550d46f52b223d80"

URI_x86_64_v2_rust-rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-native-certs-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-rustls-native-certs-devel.sha256sum] = "85b09c7d7305b5657b9bf8945d9c0b6b08d54cf95a44bef385e04b4441f03746"

URI_aarch64_rust-rustls-native-certs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-native-certs+default-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-native-certs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-native-certs+default-devel}"
SRC_URI[aarch64_rust-rustls-native-certs+default-devel.sha256sum] = "451aa6ae850afb8edf0dbc6903cc864e2f6764566aea175252f3167c72e1f1a2"

URI_aarch64_rust-rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-native-certs-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-native-certs-devel}"
SRC_URI[aarch64_rust-rustls-native-certs-devel.sha256sum] = "94f4eff5708cc949b2829448b6b2b242cbd8ed0f0e7084d3f007505dca7ff779"

RDEPENDS:rust-rustls-native-certs+default-devel = " \
 cargo \
 rust-rustls-native-certs-devel \
 "
RDEPENDS:rust-rustls-native-certs-devel = " \
 cargo \
 rust \
 rust-openssl-probe+default-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 "
