# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argon2"
PV = "0.5.3"
PR = "3.el10_0"
PACKAGES = " \
 rust-argon2+alloc-devel \
 rust-argon2+default-devel \
 rust-argon2+password-hash-devel \
 rust-argon2+rand-devel \
 rust-argon2+simple-devel \
 rust-argon2+std-devel \
 rust-argon2+zeroize-devel \
 rust-argon2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argon2-0.5.3-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f5a5e4602b7050b4edec732789c2d7ec174d928f10755eda46746bb1d51e6be"

URI_x86_64_v2_rust-argon2+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+alloc-devel-0.5.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+alloc-devel}"
SRC_URI[x86_64_v2_rust-argon2+alloc-devel.sha256sum] = "db005ad1fbb4fc514751bf7aaa3bb82d67b9b5737aaba9a535c0266050f00e23"

URI_x86_64_v2_rust-argon2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+default-devel-0.5.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+default-devel}"
SRC_URI[x86_64_v2_rust-argon2+default-devel.sha256sum] = "0f6139e2aca7a91dd04d8b3ece02e8d7be71d4a3a480eb9c4d2d264636bee3c6"

URI_x86_64_v2_rust-argon2+password-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+password-hash-devel-0.5.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+password-hash-devel}"
SRC_URI[x86_64_v2_rust-argon2+password-hash-devel.sha256sum] = "7138a9e48dd0e76421900eea825f7e502bb86cf8f3e683c2212f60b4087a160f"

URI_x86_64_v2_rust-argon2+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+rand-devel-0.5.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+rand-devel}"
SRC_URI[x86_64_v2_rust-argon2+rand-devel.sha256sum] = "c3fe1b11780dd1f88561a4cd24e372984418c93aa9d8ef14b56947870b311d94"

URI_x86_64_v2_rust-argon2+simple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+simple-devel-0.5.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+simple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+simple-devel}"
SRC_URI[x86_64_v2_rust-argon2+simple-devel.sha256sum] = "d1fc22faada82d0dd828d46237289705db5b5d32fee9045e0767f335023bbd4e"

URI_x86_64_v2_rust-argon2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+std-devel-0.5.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+std-devel}"
SRC_URI[x86_64_v2_rust-argon2+std-devel.sha256sum] = "bfabefd04c83ac6420d83a4084ae21b9a22bfda4026c0516249c50f019776e6e"

URI_x86_64_v2_rust-argon2+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2+zeroize-devel-0.5.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2+zeroize-devel}"
SRC_URI[x86_64_v2_rust-argon2+zeroize-devel.sha256sum] = "93ca496030d20e3752537f8a58fe27bb5f6d5fb857e5e9f253aa97815c237fa9"

URI_x86_64_v2_rust-argon2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argon2-devel-0.5.3-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argon2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argon2-devel}"
SRC_URI[x86_64_v2_rust-argon2-devel.sha256sum] = "4837aaacd7e969b6a1d9c954c46ec6964dab3e89fe2a17d0ff602517429b7ff1"

URI_aarch64_rust-argon2+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+alloc-devel-0.5.3-3.el10_0.noarch.rpm;name=aarch64_rust-argon2+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+alloc-devel}"
SRC_URI[aarch64_rust-argon2+alloc-devel.sha256sum] = "fdfe54801223298d7fa0726cf8332cca4907b7627eabc28a95bb14561ee417b8"

URI_aarch64_rust-argon2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+default-devel-0.5.3-3.el10_0.noarch.rpm;name=aarch64_rust-argon2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+default-devel}"
SRC_URI[aarch64_rust-argon2+default-devel.sha256sum] = "dca457197e58dad777efab30fb13eddc1d88e63974242792b628be2c05bc5d5c"

URI_aarch64_rust-argon2+password-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+password-hash-devel-0.5.3-3.el10_0.noarch.rpm;name=aarch64_rust-argon2+password-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+password-hash-devel}"
SRC_URI[aarch64_rust-argon2+password-hash-devel.sha256sum] = "a6747e93486462ea21c0726cc95e4378704bcd98ba1f18131baf590a8899e979"

URI_aarch64_rust-argon2+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+rand-devel-0.5.3-3.el10_0.noarch.rpm;name=aarch64_rust-argon2+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+rand-devel}"
SRC_URI[aarch64_rust-argon2+rand-devel.sha256sum] = "edf5815381f414a74bb3e525c54f2cd1dc1b6c2f1c112d576e6376c65961bf2d"

URI_aarch64_rust-argon2+simple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+simple-devel-0.5.3-3.el10_0.noarch.rpm;name=aarch64_rust-argon2+simple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+simple-devel}"
SRC_URI[aarch64_rust-argon2+simple-devel.sha256sum] = "7e1064e6a1c4dd9c9df3d43776ba0e8855d3c56ba5691e620d4a7bbcb09d959a"

URI_aarch64_rust-argon2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+std-devel-0.5.3-3.el10_0.noarch.rpm;name=aarch64_rust-argon2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+std-devel}"
SRC_URI[aarch64_rust-argon2+std-devel.sha256sum] = "638948119dbd6cd141ce9b71728f63ba296f1c9765f6e38559c6e7098b189a55"

URI_aarch64_rust-argon2+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2+zeroize-devel-0.5.3-3.el10_0.noarch.rpm;name=aarch64_rust-argon2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2+zeroize-devel}"
SRC_URI[aarch64_rust-argon2+zeroize-devel.sha256sum] = "810bfd9dcb34912dad38458eded5ed20d16b4bf846d42b92c6069316b9f76d22"

URI_aarch64_rust-argon2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argon2-devel-0.5.3-3.el10_0.noarch.rpm;name=aarch64_rust-argon2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argon2-devel}"
SRC_URI[aarch64_rust-argon2-devel.sha256sum] = "ed73d8a9fd92fd85e5b57ae87efde19c2f87300c631811875e4decbeff5f435a"

RDEPENDS:rust-argon2+alloc-devel = " \
 cargo \
 rust-argon2-devel \
 rust-password-hash+alloc-devel \
 rust-password-hash+default-devel \
 "
RDEPENDS:rust-argon2+default-devel = " \
 cargo \
 rust-argon2+alloc-devel \
 rust-argon2+password-hash-devel \
 rust-argon2+rand-devel \
 rust-argon2-devel \
 "
RDEPENDS:rust-argon2+password-hash-devel = " \
 cargo \
 rust-argon2-devel \
 rust-password-hash+default-devel \
 "
RDEPENDS:rust-argon2+rand-devel = " \
 cargo \
 rust-argon2-devel \
 rust-password-hash+default-devel \
 rust-password-hash+rand_core-devel \
 "
RDEPENDS:rust-argon2+simple-devel = " \
 cargo \
 rust-argon2+password-hash-devel \
 rust-argon2-devel \
 "
RDEPENDS:rust-argon2+std-devel = " \
 cargo \
 rust-argon2+alloc-devel \
 rust-argon2-devel \
 rust-password-hash+default-devel \
 rust-password-hash+std-devel \
 "
RDEPENDS:rust-argon2+zeroize-devel = " \
 cargo \
 rust-argon2-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-argon2-devel = " \
 cargo \
 rust \
 rust-base64ct+default-devel \
 rust-blake2-devel \
 rust-cpufeatures+default-devel \
 "
