# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "javapackages-tools-epel"
PV = "6.2.0"
PR = "12.1.el10_0"
PACKAGES = " \
 ivy-local \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/javapackages-tools-epel-6.2.0-12.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1394fd0feed27f4af40f6ff4a354315573f678fc127c78dee7b69f15d65e43ec"

URI_x86_64_v2_ivy-local = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ivy-local-6.2.0-12.1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ivy-local;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ivy-local}"
SRC_URI[x86_64_v2_ivy-local.sha256sum] = "879a2c23d7346dabba127746d791dfbe174159866343531d189cd78d732036e8"

URI_aarch64_ivy-local = "${EPEL_MIRROR}/aarch64/Packages/i/ivy-local-6.2.0-12.1.el10_0.noarch.rpm;name=aarch64_ivy-local;unpack=0"
SRC_URI:append = " ${URI_aarch64_ivy-local}"
SRC_URI[aarch64_ivy-local.sha256sum] = "b56743f97b3aff10965e30863ca685320fe0c0fde02ea511d57451ad47484b98"

RDEPENDS:ivy-local = " \
 javapackages-local-openjdk21 \
 javapackages-tools \
 "
