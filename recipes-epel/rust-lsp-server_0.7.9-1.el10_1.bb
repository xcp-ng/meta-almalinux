# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lsp-server"
PV = "0.7.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-lsp-server+default-devel \
 rust-lsp-server-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lsp-server-0.7.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3305d9bd3d677251e9ca5a1a5727b5c880ffb1eb404ac19fb652323a9ff258fc"

URI_x86_64_v2_rust-lsp-server+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lsp-server+default-devel-0.7.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lsp-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lsp-server+default-devel}"
SRC_URI[x86_64_v2_rust-lsp-server+default-devel.sha256sum] = "40a4c0c11df9bb4c86c81026abba39f277dbfdd3d3574a8f26e74b12f5dce847"

URI_x86_64_v2_rust-lsp-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lsp-server-devel-0.7.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lsp-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lsp-server-devel}"
SRC_URI[x86_64_v2_rust-lsp-server-devel.sha256sum] = "f72972dffa08db1dbcf2c4383563e79d2c15e2015cd652aee0becf1ba0dec528"

URI_aarch64_rust-lsp-server+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lsp-server+default-devel-0.7.9-1.el10_1.noarch.rpm;name=aarch64_rust-lsp-server+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lsp-server+default-devel}"
SRC_URI[aarch64_rust-lsp-server+default-devel.sha256sum] = "c0eb302b990d9899c3279af39db393d3f274d659c5b840ff73b2c0f5651856a1"

URI_aarch64_rust-lsp-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lsp-server-devel-0.7.9-1.el10_1.noarch.rpm;name=aarch64_rust-lsp-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lsp-server-devel}"
SRC_URI[aarch64_rust-lsp-server-devel.sha256sum] = "4e3890c086477e5a2f11ef91ebf150e85c196263494cce8c5b7bf170ecb4cea1"

RDEPENDS:rust-lsp-server+default-devel = " \
 cargo \
 rust-lsp-server-devel \
 "
RDEPENDS:rust-lsp-server-devel = " \
 bash \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-log+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 "
