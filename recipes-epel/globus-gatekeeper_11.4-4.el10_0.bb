# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gatekeeper"
PV = "11.4"
PR = "4.el10_0"
PACKAGES = " \
 globus-gatekeeper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gatekeeper-11.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c68d65a71ab3df655f176da990088ee1a4b17b322f53e8c585640b0dc09d36cd"

URI_x86_64_v2_globus-gatekeeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gatekeeper-11.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gatekeeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gatekeeper}"
SRC_URI[x86_64_v2_globus-gatekeeper.sha256sum] = "0d323d2dbfa00918d7aea14f4f8fce5f3227c7549774800c74bc1c077d64186d"

URI_aarch64_globus-gatekeeper = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gatekeeper-11.4-4.el10_0.aarch64.rpm;name=aarch64_globus-gatekeeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gatekeeper}"
SRC_URI[aarch64_globus-gatekeeper.sha256sum] = "44df82c5c64d4466673aea814d06a0fd8a896d7f0badea8d276f8d6cb08c69c9"

RDEPENDS:globus-gatekeeper = " \
 bash \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 logrotate \
 openssl-libs \
 systemd \
 "
