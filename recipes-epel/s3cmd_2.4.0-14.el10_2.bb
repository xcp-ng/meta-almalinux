# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s3cmd"
PV = "2.4.0"
PR = "14.el10_2"
PACKAGES = " \
 s3cmd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/s3cmd-2.4.0-14.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d6163e8c8acd1addef54f26a1e2708bef6485cc4d54b4f1b1bfc9550d565b6a"

URI_x86_64_v2_s3cmd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s3cmd-2.4.0-14.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_s3cmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s3cmd}"
SRC_URI[x86_64_v2_s3cmd.sha256sum] = "e0b59c17c5f63e5539c84cff6e263adff9f890d33055eb1250f3403fc0137070"

URI_aarch64_s3cmd = "${EPEL_MIRROR}/aarch64/Packages/s/s3cmd-2.4.0-14.el10_2.noarch.rpm;name=aarch64_s3cmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_s3cmd}"
SRC_URI[aarch64_s3cmd.sha256sum] = "c858ef1ff1f95102cacf17376e06f23094224cc3ff5685695a4388bddff4bfdd"

RDEPENDS:s3cmd = " \
 python3 \
 python3-dateutil \
 python3-file-magic \
 "
