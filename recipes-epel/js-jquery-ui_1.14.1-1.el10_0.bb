# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "js-jquery-ui"
PV = "1.14.1"
PR = "1.el10_0"
PACKAGES = " \
 js-jquery-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/js-jquery-ui-1.14.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "372944ff74be850216fd2132657c684db63f6ab02dfed36d7bceaa68818bc879"

URI_x86_64_v2_js-jquery-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/js-jquery-ui-1.14.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_js-jquery-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_js-jquery-ui}"
SRC_URI[x86_64_v2_js-jquery-ui.sha256sum] = "2235536f6b0c2f2f6206bbaddfacd1123ae49f67a64a9105c5fc0c1360fad29e"

URI_aarch64_js-jquery-ui = "${EPEL_MIRROR}/aarch64/Packages/j/js-jquery-ui-1.14.1-1.el10_0.noarch.rpm;name=aarch64_js-jquery-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_js-jquery-ui}"
SRC_URI[aarch64_js-jquery-ui.sha256sum] = "79c07906df1dbfeef5ac6473d26b454ea237259f50515d9c685bfabb13a3e059"

RDEPENDS:js-jquery-ui = " \
 js-jquery \
 web-assets-filesystem \
 "
