# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-itoa"
PV = "1.0.18"
PR = "1.el10_3"
PACKAGES = " \
 rust-itoa+default-devel \
 rust-itoa+no-panic-devel \
 rust-itoa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-itoa-1.0.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db5af6a3fedc7a400d74be7505173b9b834a57f241b3d38fc8a5455fb3bc0643"

URI_x86_64_v2_rust-itoa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa+default-devel-1.0.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa+default-devel}"
SRC_URI[x86_64_v2_rust-itoa+default-devel.sha256sum] = "f44d24fc4ec72a552c710a08cb0a47b25714728c326e16827a9a39205088f67c"

URI_x86_64_v2_rust-itoa+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa+no-panic-devel-1.0.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa+no-panic-devel}"
SRC_URI[x86_64_v2_rust-itoa+no-panic-devel.sha256sum] = "99a73a2dea35e3d6a7a321c76035875ae4d77e372675337763016eb955657214"

URI_x86_64_v2_rust-itoa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa-devel-1.0.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa-devel}"
SRC_URI[x86_64_v2_rust-itoa-devel.sha256sum] = "a08bcd64009cd4508ba1b654d0bf25af2ee4ea5c912454fbb3bc0389efb78f3c"

URI_aarch64_rust-itoa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa+default-devel-1.0.18-1.el10_3.noarch.rpm;name=aarch64_rust-itoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa+default-devel}"
SRC_URI[aarch64_rust-itoa+default-devel.sha256sum] = "2c9e47d04ba22e043c280d4d3ade6bb3696907e49e3a7def697b9ce5ec5f409c"

URI_aarch64_rust-itoa+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa+no-panic-devel-1.0.18-1.el10_3.noarch.rpm;name=aarch64_rust-itoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa+no-panic-devel}"
SRC_URI[aarch64_rust-itoa+no-panic-devel.sha256sum] = "a6c628621c66aa502fcb011bb796491bc39b51d06274a8369d47e99358ff162c"

URI_aarch64_rust-itoa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa-devel-1.0.18-1.el10_3.noarch.rpm;name=aarch64_rust-itoa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa-devel}"
SRC_URI[aarch64_rust-itoa-devel.sha256sum] = "604a0a8638903a9d475b501e1af1880f0f5c8eff45cd82592a4243e9ff614faa"

RDEPENDS:rust-itoa+default-devel = " \
 cargo \
 rust-itoa-devel \
 "
RDEPENDS:rust-itoa+no-panic-devel = " \
 cargo \
 rust-itoa-devel \
 rust-no-panic+default-devel \
 "
RDEPENDS:rust-itoa-devel = " \
 cargo \
 rust \
 "
