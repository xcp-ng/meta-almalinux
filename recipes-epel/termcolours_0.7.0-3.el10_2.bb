# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "termcolours"
PV = "0.7.0"
PR = "3.el10_2"
PACKAGES = " \
 termcolours \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/termcolours-0.7.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "889b353bb2e67aba67623ef6dc54403b41aa8fa5398a75448ce2e469dab20e79"

URI_x86_64_v2_termcolours = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/termcolours-0.7.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_termcolours;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_termcolours}"
SRC_URI[x86_64_v2_termcolours.sha256sum] = "a1f3e5ed0865bed999e0c2be97a9fa865e13a1d579da80d03713772262d76df4"

URI_aarch64_termcolours = "${EPEL_MIRROR}/aarch64/Packages/t/termcolours-0.7.0-3.el10_2.noarch.rpm;name=aarch64_termcolours;unpack=0"
SRC_URI:append = " ${URI_aarch64_termcolours}"
SRC_URI[aarch64_termcolours.sha256sum] = "22171bc958e62175c935828019c6921bbdb227265fe3fc68786101a4d190eff2"

RDEPENDS:termcolours = " \
 perl-Digest-MD5 \
 perl-Getopt-Long \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 perl-version \
 "
