# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive_core0.3"
PV = "0.3.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-cursive_core0.3+default-devel \
 rust-cursive_core0.3+doc-cfg-devel \
 rust-cursive_core0.3+toml-devel \
 rust-cursive_core0.3+unstable_scroll-devel \
 rust-cursive_core0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive_core0.3-0.3.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2659e71b8d93ffe5d342169094b45e40d0d535235722b2cba95a4792401dbc3"

URI_x86_64_v2_rust-cursive_core0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3+default-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3+default-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3+default-devel.sha256sum] = "78642d1dd6fde3ec7272c51834ea7cdf7af715d214918809b29e2d4f1413b56e"

URI_x86_64_v2_rust-cursive_core0.3+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3+doc-cfg-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3+doc-cfg-devel.sha256sum] = "e0d907f2a55951952646b7ed3204f55029b9fb335eaa30efd47304d1d694cd3a"

URI_x86_64_v2_rust-cursive_core0.3+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3+toml-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3+toml-devel.sha256sum] = "19bce2495caa5de9af1c7d2de30039bee3ec7b457d58d2f988edcdb5470af03c"

URI_x86_64_v2_rust-cursive_core0.3+unstable_scroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3+unstable_scroll-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3+unstable_scroll-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3+unstable_scroll-devel.sha256sum] = "150417332287aa783f67c26123a7c0b9caf39cfeb527b3871dfba5b86f7633bf"

URI_x86_64_v2_rust-cursive_core0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core0.3-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core0.3-devel}"
SRC_URI[x86_64_v2_rust-cursive_core0.3-devel.sha256sum] = "61be6434749b1e12249ac46835cc283e7e446f329f68a964b89d4e83830a969f"

URI_aarch64_rust-cursive_core0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3+default-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3+default-devel}"
SRC_URI[aarch64_rust-cursive_core0.3+default-devel.sha256sum] = "6bf546e2160518c14911a5f723a831a8f0ab26396c8dac5a89a58697817bd74e"

URI_aarch64_rust-cursive_core0.3+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3+doc-cfg-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core0.3+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive_core0.3+doc-cfg-devel.sha256sum] = "27fb80d3bc6b1b0495dbdf2e59d56f931177d03acc963f860397e59e11e1b3c7"

URI_aarch64_rust-cursive_core0.3+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3+toml-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core0.3+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3+toml-devel}"
SRC_URI[aarch64_rust-cursive_core0.3+toml-devel.sha256sum] = "47025bc1b93437d9fd3640f143c85df906563f0e081e17699208b2ee72a34bb1"

URI_aarch64_rust-cursive_core0.3+unstable_scroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3+unstable_scroll-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core0.3+unstable_scroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3+unstable_scroll-devel}"
SRC_URI[aarch64_rust-cursive_core0.3+unstable_scroll-devel.sha256sum] = "9688d0e1d5f67dfe89b2d38e5234edea15cd59054b2384f16625845b61bc5633"

URI_aarch64_rust-cursive_core0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core0.3-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core0.3-devel}"
SRC_URI[aarch64_rust-cursive_core0.3-devel.sha256sum] = "57c4e8a74bb5d49dfa8509f4e0e8c8ae997ba9a7d01164d5e84cfb22d7e74ed4"

RDEPENDS:rust-cursive_core0.3+default-devel = " \
 cargo \
 rust-cursive_core0.3-devel \
 "
RDEPENDS:rust-cursive_core0.3+doc-cfg-devel = " \
 cargo \
 rust-cursive_core0.3-devel \
 "
RDEPENDS:rust-cursive_core0.3+toml-devel = " \
 cargo \
 rust-cursive_core0.3-devel \
 rust-toml0.5+default-devel \
 "
RDEPENDS:rust-cursive_core0.3+unstable_scroll-devel = " \
 cargo \
 rust-cursive_core0.3-devel \
 "
RDEPENDS:rust-cursive_core0.3-devel = " \
 cargo \
 rust \
 rust-ahash+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-enum-map+default-devel \
 rust-enumset+default-devel \
 rust-lazy_static+default-devel \
 rust-log+default-devel \
 rust-num-devel \
 rust-owning_ref+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 rust-xi-unicode+default-devel \
 "
