# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lscolors"
PV = "0.20.0"
PR = "2.el10_1"
PACKAGES = " \
 lscolors \
 rust-lscolors+ansi_term-devel \
 rust-lscolors+crossterm-devel \
 rust-lscolors+default-devel \
 rust-lscolors+gnu_legacy-devel \
 rust-lscolors+nu-ansi-term-devel \
 rust-lscolors+owo-colors-devel \
 rust-lscolors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lscolors-0.20.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83ce6a5e1252c4dcf7f3e23e37aacae96cf02b0587fcd86006de6e55387625e1"

URI_x86_64_v2_lscolors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lscolors-0.20.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lscolors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lscolors}"
SRC_URI[x86_64_v2_lscolors.sha256sum] = "fa4808fda77a1ac6851ce8cf5e727af168524c155fc6e25462d413cb800ac01f"

URI_x86_64_v2_rust-lscolors+ansi_term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+ansi_term-devel-0.20.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+ansi_term-devel}"
SRC_URI[x86_64_v2_rust-lscolors+ansi_term-devel.sha256sum] = "f47fbeb4de9c47b0c143972c8848e9382120753d7a8307f42fd9d9194982700c"

URI_x86_64_v2_rust-lscolors+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+crossterm-devel-0.20.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+crossterm-devel}"
SRC_URI[x86_64_v2_rust-lscolors+crossterm-devel.sha256sum] = "b1b2b194e4b94c20e449b4be3c59ade41ce8b495c86c1bf8ed8bc4d1781d5844"

URI_x86_64_v2_rust-lscolors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+default-devel-0.20.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+default-devel}"
SRC_URI[x86_64_v2_rust-lscolors+default-devel.sha256sum] = "e44691c571865ee55208350a90c59146a366aed76fb1c2ea9385a49164ed4171"

URI_x86_64_v2_rust-lscolors+gnu_legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+gnu_legacy-devel-0.20.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+gnu_legacy-devel}"
SRC_URI[x86_64_v2_rust-lscolors+gnu_legacy-devel.sha256sum] = "96d2542c00002ee06e0316ca7da27ec156b5421cde1ba8dd3d9beafba5b28403"

URI_x86_64_v2_rust-lscolors+nu-ansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+nu-ansi-term-devel-0.20.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+nu-ansi-term-devel}"
SRC_URI[x86_64_v2_rust-lscolors+nu-ansi-term-devel.sha256sum] = "bb5d8e75e1218eeb992df5789f6ed422f5ec3aa6941ea52e2ba0ae359c42745f"

URI_x86_64_v2_rust-lscolors+owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors+owo-colors-devel-0.20.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors+owo-colors-devel}"
SRC_URI[x86_64_v2_rust-lscolors+owo-colors-devel.sha256sum] = "59f27bdf7874648cbb89f16f780103f6dfbb67333d34d9065ddf85af71cd1c25"

URI_x86_64_v2_rust-lscolors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lscolors-devel-0.20.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lscolors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lscolors-devel}"
SRC_URI[x86_64_v2_rust-lscolors-devel.sha256sum] = "0b50a7d6b6c69ecb1b35484d52520dde9b660287b1bc9f5ab78d29f62f838d26"

URI_aarch64_lscolors = "${EPEL_MIRROR}/aarch64/Packages/l/lscolors-0.20.0-2.el10_1.aarch64.rpm;name=aarch64_lscolors;unpack=0"
SRC_URI:append = " ${URI_aarch64_lscolors}"
SRC_URI[aarch64_lscolors.sha256sum] = "85f36d479fca23dbcdc5b441cfcf7fa7945170ad2d87eb19b19f1a9592c035d0"

URI_aarch64_rust-lscolors+ansi_term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+ansi_term-devel-0.20.0-2.el10_1.noarch.rpm;name=aarch64_rust-lscolors+ansi_term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+ansi_term-devel}"
SRC_URI[aarch64_rust-lscolors+ansi_term-devel.sha256sum] = "79a28d6e2083fc5121bc8344782963fffc7b228eb74506d778b2427302b6a770"

URI_aarch64_rust-lscolors+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+crossterm-devel-0.20.0-2.el10_1.noarch.rpm;name=aarch64_rust-lscolors+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+crossterm-devel}"
SRC_URI[aarch64_rust-lscolors+crossterm-devel.sha256sum] = "9d0d64c7a8446466235987dae28cd75fcfba9ef4d2b185b8fb77dea84931a1a1"

URI_aarch64_rust-lscolors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+default-devel-0.20.0-2.el10_1.noarch.rpm;name=aarch64_rust-lscolors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+default-devel}"
SRC_URI[aarch64_rust-lscolors+default-devel.sha256sum] = "9279b3c7df51d19ec780133f1b51846e4e5fdcad5cf8de1d4975a9862fd03d5f"

URI_aarch64_rust-lscolors+gnu_legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+gnu_legacy-devel-0.20.0-2.el10_1.noarch.rpm;name=aarch64_rust-lscolors+gnu_legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+gnu_legacy-devel}"
SRC_URI[aarch64_rust-lscolors+gnu_legacy-devel.sha256sum] = "8d4bbec67a66d5c28b69728415ee130217576cf9de7cadc688f1be1cadb2c198"

URI_aarch64_rust-lscolors+nu-ansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+nu-ansi-term-devel-0.20.0-2.el10_1.noarch.rpm;name=aarch64_rust-lscolors+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+nu-ansi-term-devel}"
SRC_URI[aarch64_rust-lscolors+nu-ansi-term-devel.sha256sum] = "cc705d9c4cb3cb0a5046d1d5adbb19b1d231674de20fb8ce7ca855db5cd2c6e6"

URI_aarch64_rust-lscolors+owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors+owo-colors-devel-0.20.0-2.el10_1.noarch.rpm;name=aarch64_rust-lscolors+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors+owo-colors-devel}"
SRC_URI[aarch64_rust-lscolors+owo-colors-devel.sha256sum] = "2c1c1ab12ef29e44f1ce5d6a2fd5a418687792535c30394ab3633381a1e8c59f"

URI_aarch64_rust-lscolors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lscolors-devel-0.20.0-2.el10_1.noarch.rpm;name=aarch64_rust-lscolors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lscolors-devel}"
SRC_URI[aarch64_rust-lscolors-devel.sha256sum] = "153784fb027eeda0e14c9e7694e150372ccc277098b64b5b72c2ca65255003e3"

RDEPENDS:lscolors = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-lscolors+ansi_term-devel = " \
 cargo \
 rust-ansi_term+default-devel \
 rust-lscolors-devel \
 "
RDEPENDS:rust-lscolors+crossterm-devel = " \
 cargo \
 rust-crossterm0.28+default-devel \
 rust-lscolors-devel \
 "
RDEPENDS:rust-lscolors+default-devel = " \
 cargo \
 rust-lscolors+nu-ansi-term-devel \
 rust-lscolors-devel \
 "
RDEPENDS:rust-lscolors+gnu_legacy-devel = " \
 cargo \
 rust-lscolors-devel \
 rust-nu-ansi-term+default-devel \
 rust-nu-ansi-term+gnu_legacy-devel \
 "
RDEPENDS:rust-lscolors+nu-ansi-term-devel = " \
 cargo \
 rust-lscolors-devel \
 rust-nu-ansi-term+default-devel \
 "
RDEPENDS:rust-lscolors+owo-colors-devel = " \
 cargo \
 rust-lscolors-devel \
 rust-owo-colors+default-devel \
 "
RDEPENDS:rust-lscolors-devel = " \
 cargo \
 rust \
 rust-aho-corasick+default-devel \
 "
