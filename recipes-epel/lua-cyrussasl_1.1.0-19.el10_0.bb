# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-cyrussasl"
PV = "1.1.0"
PR = "19.el10_0"
PACKAGES = " \
 lua-cyrussasl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-cyrussasl-1.1.0-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c23e64388c45fdbe01712594ca6ad0814b29818faa7a61330a8c24a9bef21e8"

URI_x86_64_v2_lua-cyrussasl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-cyrussasl-1.1.0-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-cyrussasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-cyrussasl}"
SRC_URI[x86_64_v2_lua-cyrussasl.sha256sum] = "a30735987adb1a1e695246eef95840448eaad52412edab5f4907138720bfaf3e"

URI_aarch64_lua-cyrussasl = "${EPEL_MIRROR}/aarch64/Packages/l/lua-cyrussasl-1.1.0-19.el10_0.aarch64.rpm;name=aarch64_lua-cyrussasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-cyrussasl}"
SRC_URI[aarch64_lua-cyrussasl.sha256sum] = "d614db1fab5273db3f81172f0dde5d060ae27a06f8a8f9e9870b7fbbee7eeb3b"

RDEPENDS:lua-cyrussasl = " \
 cyrus-sasl-lib \
 glibc \
 lua-libs \
 "
