# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend0.25"
PV = "0.25.1"
PR = "2.el10_2"
PACKAGES = " \
 rust-pyo3-macros-backend0.25+default-devel \
 rust-pyo3-macros-backend0.25+experimental-async-devel \
 rust-pyo3-macros-backend0.25+experimental-inspect-devel \
 rust-pyo3-macros-backend0.25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend0.25-0.25.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6828c08f7aacc39378990468cba4ddc5fc0bbfce2d4b2d23d6b772762a1a8608"

URI_x86_64_v2_rust-pyo3-macros-backend0.25+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.25+default-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.25+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.25+default-devel.sha256sum] = "81856ab0e7c9fee076992a6ea10c9774088d4a06c8d456c8f02b81b0fbecf87e"

URI_x86_64_v2_rust-pyo3-macros-backend0.25+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.25+experimental-async-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.25+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.25+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.25+experimental-async-devel.sha256sum] = "f182de85b2aaf4394f1e3e238cce1a957c70a44b2126deb7db9fab69b434c72a"

URI_x86_64_v2_rust-pyo3-macros-backend0.25+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.25+experimental-inspect-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.25+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.25+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.25+experimental-inspect-devel.sha256sum] = "2c4ceca3930fb2a0325f1dc7d7080f1667e1483c777a418337a3fd69212812e0"

URI_x86_64_v2_rust-pyo3-macros-backend0.25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.25-devel-0.25.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.25-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.25-devel.sha256sum] = "d1e10c8328b318bb6952f528a8b7f0a165504f8a0cf4ee8dfb28b4767fc92809"

URI_aarch64_rust-pyo3-macros-backend0.25+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.25+default-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.25+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.25+default-devel.sha256sum] = "088cb21652ae53ec3076c191ee3c6bde89160ff64d399ff1fb0e29a4d717beef"

URI_aarch64_rust-pyo3-macros-backend0.25+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.25+experimental-async-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.25+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.25+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.25+experimental-async-devel.sha256sum] = "dc3200af98d9ba0c05ef0fcdd56efc58ad79a967b4c8ec2a0599095e320932ef"

URI_aarch64_rust-pyo3-macros-backend0.25+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.25+experimental-inspect-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.25+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.25+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.25+experimental-inspect-devel.sha256sum] = "2fb333d49b32467fac12e9841edf1b4dc7d38fceba44d6bc531bd2d7f52923cf"

URI_aarch64_rust-pyo3-macros-backend0.25-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.25-devel-0.25.1-2.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.25-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.25-devel.sha256sum] = "4e1acfea6989c47ee7403a5cc2e063fcb4a3b63c6aebce62fe0949cd238542f1"

RDEPENDS:rust-pyo3-macros-backend0.25+default-devel = " \
 cargo \
 rust-pyo3-macros-backend0.25-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.25+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.25-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.25+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend0.25-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.25-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-pyo3-build-config0.25+default-devel \
 rust-pyo3-build-config0.25+resolve-config-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
