# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pecan"
PV = "1.8.0"
PR = "4.el10_3"
PACKAGES = " \
 python3-pecan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pecan-1.8.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ada84566c5d0d9e29b1bc8c6c056435341806cf73862f4900b4ec379e62e68a8"

URI_x86_64_v2_python3-pecan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pecan-1.8.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pecan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pecan}"
SRC_URI[x86_64_v2_python3-pecan.sha256sum] = "4e5dbe3556e21a0e5f576684038ca299d54370550ad875d4bed25b4f88e40d14"

URI_aarch64_python3-pecan = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pecan-1.8.0-4.el10_3.noarch.rpm;name=aarch64_python3-pecan;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pecan}"
SRC_URI[aarch64_python3-pecan.sha256sum] = "c64961244689d684422b45d0b966a874b44ed58d9bab65fee5491c9c0cbb1adf"

RDEPENDS:python3-pecan = " \
 python3 \
 python3-mako \
 python3-setuptools \
 python3-webob \
 "
