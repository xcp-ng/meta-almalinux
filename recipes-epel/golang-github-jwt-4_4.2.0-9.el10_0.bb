# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jwt-4"
PV = "4.2.0"
PR = "9.el10_0"
PACKAGES = " \
 golang-github-jwt-4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jwt-4-4.2.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41a3ace187333830ff78ce319a4e28cda1a089c7212ad4fd150943cd0e590e59"

URI_x86_64_v2_golang-github-jwt-4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jwt-4-devel-4.2.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jwt-4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jwt-4-devel}"
SRC_URI[x86_64_v2_golang-github-jwt-4-devel.sha256sum] = "684417fcbf0c2aa095c2f05fc2b0ac7ad4c0f4f7bc83fc04a28b25b225e1575e"

URI_aarch64_golang-github-jwt-4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jwt-4-devel-4.2.0-9.el10_0.noarch.rpm;name=aarch64_golang-github-jwt-4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jwt-4-devel}"
SRC_URI[aarch64_golang-github-jwt-4-devel.sha256sum] = "4c79636f91d2b7364ece5f85799105a69b49f2d9a78909553ced9db468554d35"

RDEPENDS:golang-github-jwt-4-devel = " \
 go-filesystem \
 "
