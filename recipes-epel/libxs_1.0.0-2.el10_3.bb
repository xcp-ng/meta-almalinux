# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxs"
PV = "1.0.0"
PR = "2.el10_3"
PACKAGES = " \
 libxs \
 libxs-devel \
 libxs-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libxs-1.0.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c611e7673f49ea036fd5ff223dd376fbdab4af44edba711d20c350b5357ebb7d"

URI_x86_64_v2_libxs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxs-1.0.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxs}"
SRC_URI[x86_64_v2_libxs.sha256sum] = "07fd2ae1e45ea838465cdcfea9e501b889c8393eb8a31649bbab193eb5729b7a"

URI_x86_64_v2_libxs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxs-devel-1.0.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxs-devel}"
SRC_URI[x86_64_v2_libxs-devel.sha256sum] = "fc15737f172759dce606abcba7e171367844b04c7423c31a47d5ed2b89b7b8c1"

URI_x86_64_v2_libxs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxs-doc-1.0.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libxs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxs-doc}"
SRC_URI[x86_64_v2_libxs-doc.sha256sum] = "b7812f75fcdfe8562394ebd7206d4e82defd97fefa682b5bde7fc6a0ab51b090"

URI_aarch64_libxs = "${EPEL_MIRROR}/aarch64/Packages/l/libxs-1.0.0-2.el10_3.aarch64.rpm;name=aarch64_libxs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxs}"
SRC_URI[aarch64_libxs.sha256sum] = "6f8e171fe42c28b6996fa97dd825741eed0236ba89652dd9849cc91c4e9685d6"

URI_aarch64_libxs-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libxs-devel-1.0.0-2.el10_3.aarch64.rpm;name=aarch64_libxs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxs-devel}"
SRC_URI[aarch64_libxs-devel.sha256sum] = "d30ca5166ca57476a5b5b40e48c013b8637bacee2232372d4458d09264bae626"

URI_aarch64_libxs-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libxs-doc-1.0.0-2.el10_3.noarch.rpm;name=aarch64_libxs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxs-doc}"
SRC_URI[aarch64_libxs-doc.sha256sum] = "af0e68969a16faccf0a53b0c6c62695a48040e80e5d5b892e4c974534926f300"

RDEPENDS:libxs:x86_64_v2 = " \
 glibc \
 libgcc \
"
RDEPENDS:libxs:aarch64 = " \
 glibc \
"
RDEPENDS:libxs-devel = " \
 cmake-filesystem \
 gcc-gfortran \
 libxs \
 pkgconf-pkg-config \
 "
RDEPENDS:libxs-doc = " \
 libxs \
 "
