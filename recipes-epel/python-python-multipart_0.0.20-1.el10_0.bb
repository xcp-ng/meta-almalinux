# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-python-multipart"
PV = "0.0.20"
PR = "1.el10_0"
PACKAGES = " \
 python3-python-multipart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-python-multipart-0.0.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd5db8373e78c6df42ab027def2809c09d9e662ac89ef0e0ba1affa8009d4da1"

URI_x86_64_v2_python3-python-multipart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-multipart-0.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-multipart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-multipart}"
SRC_URI[x86_64_v2_python3-python-multipart.sha256sum] = "147358e89a87de3f982734fc2758c6044a753f729f9ef68431e5b483233d4df3"

URI_aarch64_python3-python-multipart = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-multipart-0.0.20-1.el10_0.noarch.rpm;name=aarch64_python3-python-multipart;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-multipart}"
SRC_URI[aarch64_python3-python-multipart.sha256sum] = "c46f65521ea31d580080ddb2feabf0d2515ed1e2f1a71955886c00efb329e1a0"

RDEPENDS:python3-python-multipart = " \
 python3 \
 "
