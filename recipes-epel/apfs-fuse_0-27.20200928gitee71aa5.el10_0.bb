# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apfs-fuse"
PV = "0"
PR = "27.20200928gitee71aa5.el10_0"
PACKAGES = " \
 apfs-fuse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apfs-fuse-0-27.20200928gitee71aa5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c10f6b676b18e1a8cc81eb73cee1df09684e433504fd042362874a31eae19c25"

URI_x86_64_v2_apfs-fuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apfs-fuse-0-27.20200928gitee71aa5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apfs-fuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apfs-fuse}"
SRC_URI[x86_64_v2_apfs-fuse.sha256sum] = "810cf14d01cd64309e27e26a273c3ac0281da2d675a4700db08292da1746fe41"

URI_aarch64_apfs-fuse = "${EPEL_MIRROR}/aarch64/Packages/a/apfs-fuse-0-27.20200928gitee71aa5.el10_0.aarch64.rpm;name=aarch64_apfs-fuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_apfs-fuse}"
SRC_URI[aarch64_apfs-fuse.sha256sum] = "84ce5dc9accb2733b5dd875c2f0c79fe871b513456115a195a352029f78a0be3"

RDEPENDS:apfs-fuse = " \
 bzip2-libs \
 fuse3 \
 fuse3-libs \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
