# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-flagset"
PV = "0.4.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-flagset+default-devel \
 rust-flagset+serde-devel \
 rust-flagset+std-devel \
 rust-flagset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-flagset-0.4.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c8fbdfe754b5ef49329ba8b3b652b66dc4fe43a6f577a2f184ee1d71d315b6c"

URI_x86_64_v2_rust-flagset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flagset+default-devel-0.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flagset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flagset+default-devel}"
SRC_URI[x86_64_v2_rust-flagset+default-devel.sha256sum] = "bbbaaa446dd8d4e38b32f347da582955867b6dfe562042108ff8902e4154cb8f"

URI_x86_64_v2_rust-flagset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flagset+serde-devel-0.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flagset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flagset+serde-devel}"
SRC_URI[x86_64_v2_rust-flagset+serde-devel.sha256sum] = "62552044ad63a76956385b1926eccc67d2ad678545f733c2a81ca5b300405d04"

URI_x86_64_v2_rust-flagset+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flagset+std-devel-0.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flagset+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flagset+std-devel}"
SRC_URI[x86_64_v2_rust-flagset+std-devel.sha256sum] = "74d77c059aed34e0d56c0d4344718f9424d49a53c67d3f868fc84f33f10741e4"

URI_x86_64_v2_rust-flagset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flagset-devel-0.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flagset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flagset-devel}"
SRC_URI[x86_64_v2_rust-flagset-devel.sha256sum] = "6e3831491660bd9b0a024a710e97cb29716a3d35bfbda9149d1b7751befbb309"

URI_aarch64_rust-flagset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flagset+default-devel-0.4.7-1.el10_0.noarch.rpm;name=aarch64_rust-flagset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flagset+default-devel}"
SRC_URI[aarch64_rust-flagset+default-devel.sha256sum] = "171b9a7a40c770db2bebb614df099488024c29fd06b568a80ac54586b4d17fa0"

URI_aarch64_rust-flagset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flagset+serde-devel-0.4.7-1.el10_0.noarch.rpm;name=aarch64_rust-flagset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flagset+serde-devel}"
SRC_URI[aarch64_rust-flagset+serde-devel.sha256sum] = "fb1fa22942352d05fb8628cde527621e9cfaf88b0e9a197b17c636bc512a99dc"

URI_aarch64_rust-flagset+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flagset+std-devel-0.4.7-1.el10_0.noarch.rpm;name=aarch64_rust-flagset+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flagset+std-devel}"
SRC_URI[aarch64_rust-flagset+std-devel.sha256sum] = "12fb1000183f188db038ce8b6c0890725d9bf1384f3f5a82aa2a0de8b48018a7"

URI_aarch64_rust-flagset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flagset-devel-0.4.7-1.el10_0.noarch.rpm;name=aarch64_rust-flagset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flagset-devel}"
SRC_URI[aarch64_rust-flagset-devel.sha256sum] = "f53877099a013a309b5c6992c1a8e6313cdc4e1395743f58b20b8fe24a1808b3"

RDEPENDS:rust-flagset+default-devel = " \
 cargo \
 rust-flagset-devel \
 "
RDEPENDS:rust-flagset+serde-devel = " \
 cargo \
 rust-flagset-devel \
 rust-serde+default-devel \
 rust-serde+serde_derive-devel \
 "
RDEPENDS:rust-flagset+std-devel = " \
 cargo \
 rust-flagset-devel \
 "
RDEPENDS:rust-flagset-devel = " \
 cargo \
 rust \
 "
