# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jupyterlab_pygments"
PV = "0.3.0"
PR = "8.el10_0"
PACKAGES = " \
 python3-jupyterlab_pygments \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jupyterlab_pygments-0.3.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cf3ee819ae60cd1250dc7072fa589ee2d062e7847a3e24cfc3a0452bc96f372"

URI_x86_64_v2_python3-jupyterlab_pygments = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyterlab_pygments-0.3.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyterlab_pygments;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyterlab_pygments}"
SRC_URI[x86_64_v2_python3-jupyterlab_pygments.sha256sum] = "3fca320998158e5825e192dbb1338c9e60b79706287d1f4bc5befe4f52481269"

URI_aarch64_python3-jupyterlab_pygments = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyterlab_pygments-0.3.0-8.el10_0.noarch.rpm;name=aarch64_python3-jupyterlab_pygments;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyterlab_pygments}"
SRC_URI[aarch64_python3-jupyterlab_pygments.sha256sum] = "062a1a943df1cd9b6ea77171089ca1ce1384b8d0ceb69f7de5bb38067acd6e7d"

RDEPENDS:python3-jupyterlab_pygments = " \
 python3 \
 python3-pygments \
 "
