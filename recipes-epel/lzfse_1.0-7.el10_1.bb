# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lzfse"
PV = "1.0"
PR = "7.el10_1"
PACKAGES = " \
 lzfse \
 lzfse-devel \
 lzfse-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lzfse-1.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "83476c7f94be0b98e7e26090d0b6a5677c8923a448d1376733cbb63df9309118"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lzfse-1.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lzfse;unpack=0"
SRC_URI[x86_64_v2_lzfse.sha256sum] = "46506da5eb449d6202e47884c4ad347e38642a6a7b6e606bab934e1f704cf3c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lzfse-devel-1.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lzfse-devel;unpack=0"
SRC_URI[x86_64_v2_lzfse-devel.sha256sum] = "eedb601fe2b962acecd3686f13e67e4d99410fefb4ddb6bdab087872dec1ffc8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lzfse-libs-1.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lzfse-libs;unpack=0"
SRC_URI[x86_64_v2_lzfse-libs.sha256sum] = "98211d3cb55fd17f75b4142f204a0f2a655d6c7a739693b6b7ada3a821780ce2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lzfse-1.0-7.el10_1.aarch64.rpm;name=aarch64_lzfse;unpack=0"
SRC_URI[aarch64_lzfse.sha256sum] = "2d4ccd50ae535216bcdbde5b025b37dd8119f2e858c52993564de575843eb84a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lzfse-devel-1.0-7.el10_1.aarch64.rpm;name=aarch64_lzfse-devel;unpack=0"
SRC_URI[aarch64_lzfse-devel.sha256sum] = "1d208bbc4868a0dedc1f1b7a76a2b9730d17269eaca5333836259716cd5d9ba5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lzfse-libs-1.0-7.el10_1.aarch64.rpm;name=aarch64_lzfse-libs;unpack=0"
SRC_URI[aarch64_lzfse-libs.sha256sum] = "09852055a4c717fcc314b185daeaaea14a4316ce3b3e83bc7fdd2ae466b10d87"

RDEPENDS:lzfse = " \
 glibc \
 lzfse-libs \
 "
RDEPENDS:lzfse-devel = " \
 lzfse-libs \
 "
RDEPENDS:lzfse-libs = " \
 glibc \
 "
