# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "edac-utils"
PV = "0.18"
PR = "38.el10_0"
PACKAGES = " \
 edac-ctl \
 edac-util \
 edac-utils \
 libedac \
 libedac-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/edac-utils-0.18-38.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bbebcb84bcf6d60ea69bd71776c38921ad8f8de4b348bee1b38f4d40b8f78a9"

URI_x86_64_v2_edac-ctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/edac-ctl-0.18-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_edac-ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edac-ctl}"
SRC_URI[x86_64_v2_edac-ctl.sha256sum] = "a8895ebf9fd5c2252f8c9ad6ba6e735e342639c8b3535ef2679fa8b83c4ca615"

URI_x86_64_v2_edac-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/edac-util-0.18-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_edac-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edac-util}"
SRC_URI[x86_64_v2_edac-util.sha256sum] = "b5714b739dcdcff367a885564c9318e783201965ff905ab5d2c0a51367e9ac98"

URI_x86_64_v2_edac-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/edac-utils-0.18-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_edac-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_edac-utils}"
SRC_URI[x86_64_v2_edac-utils.sha256sum] = "6baf45436cdf5646db3a68abc316c95f46d24092aaa4267e851fad72312fa0b1"

URI_x86_64_v2_libedac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libedac-0.18-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libedac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libedac}"
SRC_URI[x86_64_v2_libedac.sha256sum] = "0d7f5353e703f80ece696119bbc049450a5df7f8c583afcfb8933a7b56624eb7"

URI_x86_64_v2_libedac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libedac-devel-0.18-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libedac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libedac-devel}"
SRC_URI[x86_64_v2_libedac-devel.sha256sum] = "42fada9c015b71b3e367d206b63b0fc44150bac02503378621fc277e4185a0f6"

URI_aarch64_edac-ctl = "${EPEL_MIRROR}/aarch64/Packages/e/edac-ctl-0.18-38.el10_0.aarch64.rpm;name=aarch64_edac-ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_edac-ctl}"
SRC_URI[aarch64_edac-ctl.sha256sum] = "3d89740980ceba4a083519d9115c4bb93f94a2fa04d1e958215c6043323a4fca"

URI_aarch64_edac-util = "${EPEL_MIRROR}/aarch64/Packages/e/edac-util-0.18-38.el10_0.aarch64.rpm;name=aarch64_edac-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_edac-util}"
SRC_URI[aarch64_edac-util.sha256sum] = "e1ff8d5a1644588e2c5709ea126b5df5c2f6cdfb65ba1911e650cf04f86bb742"

URI_aarch64_edac-utils = "${EPEL_MIRROR}/aarch64/Packages/e/edac-utils-0.18-38.el10_0.aarch64.rpm;name=aarch64_edac-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_edac-utils}"
SRC_URI[aarch64_edac-utils.sha256sum] = "022ed4797b7c16e6a21cb1ddd87e6ad095756a2cc8e61650b33b892a1f9fb63f"

URI_aarch64_libedac = "${EPEL_MIRROR}/aarch64/Packages/l/libedac-0.18-38.el10_0.aarch64.rpm;name=aarch64_libedac;unpack=0"
SRC_URI:append = " ${URI_aarch64_libedac}"
SRC_URI[aarch64_libedac.sha256sum] = "ccb6771a7a3f68f5611aec638c9fe6a8fe1c93918726e2e923406faae936284f"

URI_aarch64_libedac-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libedac-devel-0.18-38.el10_0.aarch64.rpm;name=aarch64_libedac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libedac-devel}"
SRC_URI[aarch64_libedac-devel.sha256sum] = "87fdee1e42679ce1080ecd55cd807f52207fc4d4215d38d5f8077d4185a492df"

RDEPENDS:edac-ctl = " \
 bash \
 dmidecode \
 hwdata \
 kmod \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:edac-util = " \
 glibc \
 libedac \
 "
RDEPENDS:edac-utils = " \
 edac-ctl \
 edac-util \
 libedac \
 "
RDEPENDS:libedac = " \
 glibc \
 libsysfs \
 "
RDEPENDS:libedac-devel = " \
 libedac \
 "
