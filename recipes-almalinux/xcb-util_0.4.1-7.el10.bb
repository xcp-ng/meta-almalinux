# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xcb-util"
PV = "0.4.1"
PR = "7.el10"
PACKAGES = " \
 xcb-util \
 xcb-util-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xcb-util-0.4.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e007a14c44375025299bacbf08b0dd18843e739751c6d31984f5d423604d22f7"

URI_x86_64_v2_xcb-util = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xcb-util-0.4.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util}"
SRC_URI[x86_64_v2_xcb-util.sha256sum] = "fe22dc9705029bb7bad8c91edc32e16374a219aa9efe95b25a6028c82d7c770f"

URI_x86_64_v2_xcb-util-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xcb-util-devel-0.4.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-devel}"
SRC_URI[x86_64_v2_xcb-util-devel.sha256sum] = "694160d87edcc82eddd2fcfc05cce6e65a9af4988213c271dc829c2df868f8a0"

URI_aarch64_xcb-util = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xcb-util-0.4.1-7.el10.aarch64.rpm;name=aarch64_xcb-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util}"
SRC_URI[aarch64_xcb-util.sha256sum] = "5c4891c5989b3aa57ebf93bdc93485403a0eab032d9c22bf04a774e15ed0c3f5"

URI_aarch64_xcb-util-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xcb-util-devel-0.4.1-7.el10.aarch64.rpm;name=aarch64_xcb-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-devel}"
SRC_URI[aarch64_xcb-util-devel.sha256sum] = "4be17773fefc9c0404175295bf3f43a20d0ba7384beb1294fd7eda2289ab648e"

RDEPENDS:xcb-util = " \
 glibc \
 libxcb \
 "
RDEPENDS:xcb-util-devel = " \
 libxcb-devel \
 pkgconf-pkg-config \
 xcb-util \
 "
