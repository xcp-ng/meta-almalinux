# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "madan-fonts"
PV = "2.000"
PR = "40.el10"
PACKAGES = " \
 madan-fonts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/madan-fonts-2.000-40.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b886ac0a430de32e44172e233acec0a64520ae162bbde462a935f27d168ed6a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/madan-fonts-2.000-40.el10.noarch.rpm;name=x86_64_v2_madan-fonts;unpack=0"
SRC_URI[x86_64_v2_madan-fonts.sha256sum] = "88d1924615985a413d4cf4965deac03da5a570e28602477b36676c697a0b81c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/madan-fonts-2.000-40.el10.noarch.rpm;name=aarch64_madan-fonts;unpack=0"
SRC_URI[aarch64_madan-fonts.sha256sum] = "88d1924615985a413d4cf4965deac03da5a570e28602477b36676c697a0b81c2"

RDEPENDS:madan-fonts = " \
 fonts-filesystem \
 "
