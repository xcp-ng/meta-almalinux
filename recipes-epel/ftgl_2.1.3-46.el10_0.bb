# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ftgl"
PV = "2.1.3"
PR = "46.el10_0"
PACKAGES = " \
 ftgl \
 ftgl-devel \
 ftgl-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/ftgl-2.1.3-46.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d53ea1cbbc957860005498d2e7bc70d86895bb43d1ef482e8ce3aef7b3028df5"

URI_x86_64_v2_ftgl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ftgl-2.1.3-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ftgl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ftgl}"
SRC_URI[x86_64_v2_ftgl.sha256sum] = "99078bba1375166b1dfa603a0de42c5fd5980d7a54c3e746ec7efc6477126fbb"

URI_x86_64_v2_ftgl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ftgl-devel-2.1.3-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ftgl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ftgl-devel}"
SRC_URI[x86_64_v2_ftgl-devel.sha256sum] = "90bc437ee6feac0853da8b2fcba5f724448af8dd980b122b566349b1ccaedcab"

URI_x86_64_v2_ftgl-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ftgl-docs-2.1.3-46.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ftgl-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ftgl-docs}"
SRC_URI[x86_64_v2_ftgl-docs.sha256sum] = "32a194993bf89f9aeacc4cd74d9f1bf53bda897841590d9fbed48f8d29b313bc"

URI_aarch64_ftgl = "${EPEL_MIRROR}/aarch64/Packages/f/ftgl-2.1.3-46.el10_0.aarch64.rpm;name=aarch64_ftgl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ftgl}"
SRC_URI[aarch64_ftgl.sha256sum] = "7a5ebd47e8f69b96be0b42228e66722bebb1bc5fed62fae427b715e6f198cb72"

URI_aarch64_ftgl-devel = "${EPEL_MIRROR}/aarch64/Packages/f/ftgl-devel-2.1.3-46.el10_0.aarch64.rpm;name=aarch64_ftgl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ftgl-devel}"
SRC_URI[aarch64_ftgl-devel.sha256sum] = "f69d84986f8532b2aeafda24d6aac7790092a3eb15391297c3cfe1c092a69e06"

URI_aarch64_ftgl-docs = "${EPEL_MIRROR}/aarch64/Packages/f/ftgl-docs-2.1.3-46.el10_0.aarch64.rpm;name=aarch64_ftgl-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ftgl-docs}"
SRC_URI[aarch64_ftgl-docs.sha256sum] = "a58af3d22c3a6359c4c88e962186e235e5fa6806ac9d7057d134141126a0ea66"

RDEPENDS:ftgl = " \
 freetype \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 mesa-libGLU \
 "
RDEPENDS:ftgl-devel = " \
 freetype-devel \
 ftgl \
 pkgconf-pkg-config \
 "
RDEPENDS:ftgl-docs = " \
 "
