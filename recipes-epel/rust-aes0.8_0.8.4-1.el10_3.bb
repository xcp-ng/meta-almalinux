# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aes0.8"
PV = "0.8.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-aes0.8+default-devel \
 rust-aes0.8+hazmat-devel \
 rust-aes0.8+zeroize-devel \
 rust-aes0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aes0.8-0.8.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0125660207e0a05c94731cb5a12b19d5d844a6eab366cecd45be37c6a5073c6"

URI_x86_64_v2_rust-aes0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes0.8+default-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes0.8+default-devel}"
SRC_URI[x86_64_v2_rust-aes0.8+default-devel.sha256sum] = "f4875f2d94e0585b32a2edf5dbe02f444b6f5b6731664b6cddf6351d5a12e93a"

URI_x86_64_v2_rust-aes0.8+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes0.8+hazmat-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes0.8+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes0.8+hazmat-devel}"
SRC_URI[x86_64_v2_rust-aes0.8+hazmat-devel.sha256sum] = "50451633033156836a72ba2b5b20c5990438113eaad307b08b39f1242a6690bf"

URI_x86_64_v2_rust-aes0.8+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes0.8+zeroize-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes0.8+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes0.8+zeroize-devel}"
SRC_URI[x86_64_v2_rust-aes0.8+zeroize-devel.sha256sum] = "beb392486518ceb695d4d193a9202a19420e3561738d020afa8057a8b0d1a78f"

URI_x86_64_v2_rust-aes0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes0.8-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes0.8-devel}"
SRC_URI[x86_64_v2_rust-aes0.8-devel.sha256sum] = "f8cf87d50ac580b83848698521ee547e16828ec409b4fcbd8cd3d674207cc53a"

URI_aarch64_rust-aes0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes0.8+default-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-aes0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes0.8+default-devel}"
SRC_URI[aarch64_rust-aes0.8+default-devel.sha256sum] = "696ce1ed138a39a785a4752316a4ae4b7b33dd0039a11c68303b92b8aa2c9c9f"

URI_aarch64_rust-aes0.8+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes0.8+hazmat-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-aes0.8+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes0.8+hazmat-devel}"
SRC_URI[aarch64_rust-aes0.8+hazmat-devel.sha256sum] = "c7a2ce6298fce25093a1ceaf698504a63f05008b9be157b910fb651c6c35bdee"

URI_aarch64_rust-aes0.8+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes0.8+zeroize-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-aes0.8+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes0.8+zeroize-devel}"
SRC_URI[aarch64_rust-aes0.8+zeroize-devel.sha256sum] = "3bddb2dfd3a626f7835c3661d016d93d83f45238b1400ebcd356fae847ceff36"

URI_aarch64_rust-aes0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes0.8-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-aes0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes0.8-devel}"
SRC_URI[aarch64_rust-aes0.8-devel.sha256sum] = "42f4c7c7a24ea53aad944ecbb35ca60dfadf98eacddab103f7e4b27e58692e0a"

RDEPENDS:rust-aes0.8+default-devel = " \
 cargo \
 rust-aes0.8-devel \
 "
RDEPENDS:rust-aes0.8+hazmat-devel = " \
 cargo \
 rust-aes0.8-devel \
 "
RDEPENDS:rust-aes0.8+zeroize-devel = " \
 cargo \
 rust-aes0.8-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-aes0.8-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cipher0.4+default-devel \
 rust-cpufeatures0.2+default-devel \
 "
