# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-pbs"
PV = "3.1"
PR = "20.el10_1"
PACKAGES = " \
 globus-gram-job-manager-pbs \
 globus-gram-job-manager-pbs-setup-poll \
 globus-gram-job-manager-pbs-setup-seg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-pbs-3.1-20.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d02286e7fa1922f0bfddef936ccffeefa64589829665dcade96e79ed9bcf503a"

URI_x86_64_v2_globus-gram-job-manager-pbs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-pbs-3.1-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-pbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-pbs}"
SRC_URI[x86_64_v2_globus-gram-job-manager-pbs.sha256sum] = "6c46804adc29700e245e5dc49637149c656406201816b7e3da98f8bc30b92b90"

URI_x86_64_v2_globus-gram-job-manager-pbs-setup-poll = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-pbs-setup-poll-3.1-20.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-pbs-setup-poll;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-pbs-setup-poll}"
SRC_URI[x86_64_v2_globus-gram-job-manager-pbs-setup-poll.sha256sum] = "5d5c5c6b583df4733ccd9567b18a09c6b89daa8664bb6dc8c94a9afff490c000"
RPROVIDES:globus-gram-job-manager-pbs-setup-poll:append:x86_64_v2 = " virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_1.alma_altarch"

URI_x86_64_v2_globus-gram-job-manager-pbs-setup-seg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-pbs-setup-seg-3.1-20.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-job-manager-pbs-setup-seg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-pbs-setup-seg}"
SRC_URI[x86_64_v2_globus-gram-job-manager-pbs-setup-seg.sha256sum] = "d4df244f24da586efc9894d51ca9b983d09ab1e1c272ab966d2aa3cecf0b2a53"
RPROVIDES:globus-gram-job-manager-pbs-setup-seg:append:x86_64_v2 = " virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_1.alma_altarch"

URI_aarch64_globus-gram-job-manager-pbs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-pbs-3.1-20.el10_1.aarch64.rpm;name=aarch64_globus-gram-job-manager-pbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-pbs}"
SRC_URI[aarch64_globus-gram-job-manager-pbs.sha256sum] = "cf88e6f254d82ee21c899363d7cf82108af10ed89a3afcf475153cff7cf17345"

URI_aarch64_globus-gram-job-manager-pbs-setup-poll = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-pbs-setup-poll-3.1-20.el10_1.noarch.rpm;name=aarch64_globus-gram-job-manager-pbs-setup-poll;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-pbs-setup-poll}"
SRC_URI[aarch64_globus-gram-job-manager-pbs-setup-poll.sha256sum] = "f971fe1d8f4f4073192beb940c8bd8fc4416fe363dba462201210104724d6a8f"
RPROVIDES:globus-gram-job-manager-pbs-setup-poll:append:aarch64 = " virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_1"

URI_aarch64_globus-gram-job-manager-pbs-setup-seg = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-pbs-setup-seg-3.1-20.el10_1.aarch64.rpm;name=aarch64_globus-gram-job-manager-pbs-setup-seg;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-pbs-setup-seg}"
SRC_URI[aarch64_globus-gram-job-manager-pbs-setup-seg.sha256sum] = "b85ffd965c7e60a3c3c2fc925cc9d9d711aae7d16ba2d130245e133d4a034b84"
RPROVIDES:globus-gram-job-manager-pbs-setup-seg:append:aarch64 = " virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_1"

RDEPENDS:globus-gram-job-manager-pbs:x86_64_v2 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-libs \
 virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_1.alma_altarch \
"
RDEPENDS:globus-gram-job-manager-pbs:aarch64 = " \
 globus-common \
 globus-gass-cache-program \
 globus-gatekeeper \
 globus-gram-job-manager \
 globus-gram-job-manager-scripts \
 globus-gram-protocol \
 perl-libs \
 virtual/globus-gram-job-manager-pbs-setup_eq_3.1-20.el10_1 \
"
RDEPENDS:globus-gram-job-manager-pbs-setup-poll = " \
 bash \
 globus-gram-job-manager-pbs \
 globus-gram-job-manager-scripts \
 "
RDEPENDS:globus-gram-job-manager-pbs-setup-seg = " \
 bash \
 glibc \
 globus-common \
 globus-gram-job-manager-pbs \
 globus-gram-job-manager-scripts \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-progs \
 systemd \
 "
