# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat-jakartaee-migration"
PV = "1.0.6"
PR = "1.el10"
PACKAGES = " \
 tomcat-jakartaee-migration \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat-jakartaee-migration-1.0.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e68ef1dfc1bcc043cd2b3c7205fc716b43ce41eaa21ed4c7b8c0316082ab602"

URI_x86_64_v2_tomcat-jakartaee-migration = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat-jakartaee-migration-1.0.6-1.el10.noarch.rpm;name=x86_64_v2_tomcat-jakartaee-migration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-jakartaee-migration}"
SRC_URI[x86_64_v2_tomcat-jakartaee-migration.sha256sum] = "29856fe914bc0de870f761ac4fe0c8aa4b95e15a9c04428a2121d5d054e1bc53"

URI_aarch64_tomcat-jakartaee-migration = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat-jakartaee-migration-1.0.6-1.el10.noarch.rpm;name=aarch64_tomcat-jakartaee-migration;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-jakartaee-migration}"
SRC_URI[aarch64_tomcat-jakartaee-migration.sha256sum] = "29856fe914bc0de870f761ac4fe0c8aa4b95e15a9c04428a2121d5d054e1bc53"

RDEPENDS:tomcat-jakartaee-migration = " \
 apache-commons-compress \
 apache-commons-io \
 bash \
 bcel \
 javapackages-filesystem \
 "
