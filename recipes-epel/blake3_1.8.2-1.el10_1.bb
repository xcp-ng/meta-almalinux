# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blake3"
PV = "1.8.2"
PR = "1.el10_1"
PACKAGES = " \
 blake3 \
 blake3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blake3-1.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b4cf78d8efc9cc1c2afa973c807acf6f512dc1ae9b1b66d62825236277accc6"

URI_x86_64_v2_blake3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blake3-1.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blake3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blake3}"
SRC_URI[x86_64_v2_blake3.sha256sum] = "13f4b4b1f6de59d442e64a05657517e9fd7041e9098372513382e2d5e12fd4b9"

URI_x86_64_v2_blake3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blake3-devel-1.8.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blake3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blake3-devel}"
SRC_URI[x86_64_v2_blake3-devel.sha256sum] = "d5b35317b4933538365b1a5c71a45ad3fdec05537fd24c5d9d9292640de0ec3b"

URI_aarch64_blake3 = "${EPEL_MIRROR}/aarch64/Packages/b/blake3-1.8.2-1.el10_1.aarch64.rpm;name=aarch64_blake3;unpack=0"
SRC_URI:append = " ${URI_aarch64_blake3}"
SRC_URI[aarch64_blake3.sha256sum] = "7dfa8962f8f59217ee3fe6c5c9a8ff5da91ff295b8b84f63e420bce95992408f"

URI_aarch64_blake3-devel = "${EPEL_MIRROR}/aarch64/Packages/b/blake3-devel-1.8.2-1.el10_1.aarch64.rpm;name=aarch64_blake3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_blake3-devel}"
SRC_URI[aarch64_blake3-devel.sha256sum] = "f99ebc0a23c05948e80f0740697d7bc9d7b589973d18ef2a382410ea271984e8"

RDEPENDS:blake3 = " \
 glibc \
 libstdc++ \
 tbb \
 "
RDEPENDS:blake3-devel = " \
 blake3 \
 cmake-filesystem \
 pkgconf-pkg-config \
 tbb-devel \
 "
