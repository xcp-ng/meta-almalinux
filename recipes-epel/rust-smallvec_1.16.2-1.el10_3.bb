# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smallvec"
PV = "1.16.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-smallvec+arbitrary-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-smallvec+drain_filter-devel \
 rust-smallvec+drain_keep_rest-devel \
 rust-smallvec+may_dangle-devel \
 rust-smallvec+serde-devel \
 rust-smallvec+specialization-devel \
 rust-smallvec+union-devel \
 rust-smallvec+write-devel \
 rust-smallvec-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-smallvec-1.16.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ec5a7866c58538b5120eb85c92b99d48bdeff8b22b1166f3768214377b19529d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+arbitrary-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+arbitrary-devel.sha256sum] = "6900bebf734a0c4242388f4cd5dd944b551d5b7618deaab12d005b3d9351b579"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_generics-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+const_generics-devel.sha256sum] = "f5d3536414ae168a5e140aa5d6ab2deec693754a38b92b87443d6032e29511c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+const_new-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+const_new-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+const_new-devel.sha256sum] = "1838aaf3da8be5ba9a449d8e24beff04e378e844b8ca465e497f95bb5b25aff2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+default-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+default-devel.sha256sum] = "eb167b070db0b9ad87c40edbdb0eda0bb9164ba1258683ff3a40d5a8d54168a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_filter-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+drain_filter-devel.sha256sum] = "2956933d2ea57c806d656bf6405ee88a6411ac7c779b2abe3181ea6c89dac5e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+drain_keep_rest-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+drain_keep_rest-devel.sha256sum] = "3cbbf4d250b592b0666cdc2cf53012435715c3deb9efdfeab4f7f91845ffcc23"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+may_dangle-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+may_dangle-devel.sha256sum] = "94c61342559aebbad6dfbc602154330ac5190b7e6e2e7cc9e0797901cd75d000"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+serde-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+serde-devel.sha256sum] = "a13cd6f09b22e2c75226c4e7061d2b3ec6b81e8c382d798a3d0f9c140b388653"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+specialization-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+specialization-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+specialization-devel.sha256sum] = "733e5bb29eb3de7db5b60fd5afeceeffbad2dda1f8328ca315c375bbeba06d60"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+union-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+union-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+union-devel.sha256sum] = "247e3847d504a6dacc3a5aa946d318afba0168defb4351de12ebe74b4f46fe09"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec+write-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec+write-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec+write-devel.sha256sum] = "62dad46a6bf271505727c70df8a2f7847dc6969e74a3ad848ddf8991a7f1bd0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallvec-devel-1.16.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallvec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-smallvec-devel.sha256sum] = "47cb6f02fc604ef1d904dab25933471c64b856f325fa4fc91026df5bafa8bfe5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+arbitrary-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+arbitrary-devel.sha256sum] = "6bcd6bbf96927b48bce2c8f5c04e4551b12f80759885864203bc75ac3d6d018b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_generics-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+const_generics-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+const_generics-devel.sha256sum] = "0d75be3a609d2a605cff408acfbe4496f2ce354009a591b29626a6f9f2023275"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+const_new-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+const_new-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+const_new-devel.sha256sum] = "24f2de6e314b55d86de00aeec9f64ca87b5a914c90524fffb989e1be15b2c698"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+default-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+default-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+default-devel.sha256sum] = "a37134180d766d08ec9bba63542c744d2c4e84d5da07830a7d58fb9afb3f7af9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_filter-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+drain_filter-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+drain_filter-devel.sha256sum] = "dcc7899564622951dd6d91b5c867021abecc0d6dc41abf2e0d152af965a8c6da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+drain_keep_rest-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+drain_keep_rest-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+drain_keep_rest-devel.sha256sum] = "196b0a125b15ae8892872eb840571f4d28671f50fb88ad87e050bfe9cb1747c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+may_dangle-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+may_dangle-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+may_dangle-devel.sha256sum] = "0ab0f1f0b14af673eac7aa9e05a2321e0207efca7eb150056b0ed85715d049ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+serde-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+serde-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+serde-devel.sha256sum] = "4e8a03280a8b61b80f0eb71c6204e1bfe4b28bda9b2cc46ea48d2ecae4128837"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+specialization-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+specialization-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+specialization-devel.sha256sum] = "6319dff6f2d40e1232d37fd163f7f90b2d16c6c737ceb26a91c2b1cd3cc28652"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+union-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+union-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+union-devel.sha256sum] = "bc6a73ce0546444a5a5e4e2d3fdc07e44dce551c1adda7bbf85238e10c776bc4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec+write-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec+write-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec+write-devel.sha256sum] = "e24af1e5a48f03a9ff64c43d72f6fc605a36d8c5d2b9aaffca2380d3ab27886e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-smallvec-devel-1.16.2-1.el10_3.noarch.rpm;name=aarch64_rust-smallvec-devel;unpack=0"
SRC_URI[aarch64_rust-smallvec-devel.sha256sum] = "549ce689d69ac3d956b89abd80a140da46f6b3189fd10a4d0652fde364c59164"

RDEPENDS:rust-smallvec+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_generics-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+const_new-devel = " \
 cargo \
 rust-smallvec+const_generics-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+default-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_filter-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+drain_keep_rest-devel = " \
 cargo \
 rust-smallvec+drain_filter-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+may_dangle-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+specialization-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+union-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec+write-devel = " \
 cargo \
 rust-smallvec-devel \
 "
RDEPENDS:rust-smallvec-devel = " \
 cargo \
 "
