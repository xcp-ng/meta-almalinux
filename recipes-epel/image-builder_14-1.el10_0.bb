# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "image-builder"
PV = "14"
PR = "1.el10_0"
PACKAGES = " \
 image-builder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/image-builder-14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "596f8dfee6ebf52c92a9b3a2a73b8bf2b91fef594977e8c6ca8fd8d19b43563b"

URI_x86_64_v2_image-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/image-builder-14-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_image-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_image-builder}"
SRC_URI[x86_64_v2_image-builder.sha256sum] = "fedb70cc725bc168aeafa2bd47823784787a5e8cc0e90b955ee4379615a461fd"

URI_aarch64_image-builder = "${EPEL_MIRROR}/aarch64/Packages/i/image-builder-14-1.el10_0.aarch64.rpm;name=aarch64_image-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_image-builder}"
SRC_URI[aarch64_image-builder.sha256sum] = "31c9ba08967df137c6a09d0d0c9bf74672c15ef468b06f2ea07e6d4c129a3765"

RDEPENDS:image-builder = " \
 glibc \
 gpgme \
 libxcrypt \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 "
