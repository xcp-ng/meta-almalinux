# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Email-Address"
PV = "1.913"
PR = "1.el10_0"
PACKAGES = " \
 perl-Email-Address \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Email-Address-1.913-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe0c9799efcb43b2dffcff564bf6b5d702a47a97a77f5b4e41908e6d52adbb52"

URI_x86_64_v2_perl-Email-Address = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Email-Address-1.913-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Email-Address;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Email-Address}"
SRC_URI[x86_64_v2_perl-Email-Address.sha256sum] = "ecff9ebaaeed0beca796660a310716aedd3253ca834d2f7ebad224d3af4b34fb"

URI_aarch64_perl-Email-Address = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Email-Address-1.913-1.el10_0.noarch.rpm;name=aarch64_perl-Email-Address;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Email-Address}"
SRC_URI[aarch64_perl-Email-Address.sha256sum] = "a1ed61d61aab3c506b0317bc3e3ce2ef6ebbbd97ef799df61f38dd2661d91d6e"

RDEPENDS:perl-Email-Address = " \
 perl-libs \
 perl-overload \
 "
