# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-stack"
PV = "1.8.1"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-stack-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-stack-1.8.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ff24a852d66dbf96264938f01ee62468e9ed7538429d8fdd18ac10e65f315f2"

URI_x86_64_v2_golang-github-stack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-stack-devel-1.8.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-stack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-stack-devel}"
SRC_URI[x86_64_v2_golang-github-stack-devel.sha256sum] = "7d6b73483a74bc547a56c503d81490341cd29c47d365ef368c2264680ebfff8d"

URI_aarch64_golang-github-stack-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-stack-devel-1.8.1-10.el10_0.noarch.rpm;name=aarch64_golang-github-stack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-stack-devel}"
SRC_URI[aarch64_golang-github-stack-devel.sha256sum] = "f4d7a9c62b189f390d42196ca25ef2433b6bd41d9239c535a58b52df27e97111"

RDEPENDS:golang-github-stack-devel = " \
 go-filesystem \
 "
