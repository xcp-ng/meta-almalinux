# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libijs"
PV = "0.35"
PR = "24.el10"
PACKAGES = " \
 libijs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libijs-0.35-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98fb63db5b8a036346a1fd7b3657dc0d711837e5ace1ed6ec4def6b51c5a28cf"

URI_x86_64_v2_libijs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libijs-0.35-24.el10.x86_64_v2.rpm;name=x86_64_v2_libijs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libijs}"
SRC_URI[x86_64_v2_libijs.sha256sum] = "bfe65e7d076b745768234d3966ccd5e45c2767cc13da6034ea55453b2656c49d"

URI_aarch64_libijs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libijs-0.35-24.el10.aarch64.rpm;name=aarch64_libijs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libijs}"
SRC_URI[aarch64_libijs.sha256sum] = "7122af1de06191dff3c73f3f3969f75c1d3fb23b44b5729a2735f32d70ecc743"

RDEPENDS:libijs = " \
 glibc \
 "
