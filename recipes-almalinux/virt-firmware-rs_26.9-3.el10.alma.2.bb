# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virt-firmware-rs"
PV = "26.9"
PR = "3.el10.alma.2"
PACKAGES = " \
 virt-firmware-rs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/virt-firmware-rs-26.9-3.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "35225234fb6110049f31a341453339c2857a4a98b3bdeaeef1453678756b8d0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-firmware-rs-26.9-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_virt-firmware-rs;unpack=0"
SRC_URI[x86_64_v2_virt-firmware-rs.sha256sum] = "bdf7e53837afe0950ba534755bf817c9dace28829ca88938c7769e0fff8aa4c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-firmware-rs-26.9-3.el10.alma.2.aarch64.rpm;name=aarch64_virt-firmware-rs;unpack=0"
SRC_URI[aarch64_virt-firmware-rs.sha256sum] = "1012afca209e3101c9231b82f384ab878c21c714eb4a73f272a2045c044d430f"

RDEPENDS:virt-firmware-rs = " \
 glibc \
 libgcc \
 systemd-libs \
 "
