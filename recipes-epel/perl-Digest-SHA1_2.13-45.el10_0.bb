# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Digest-SHA1"
PV = "2.13"
PR = "45.el10_0"
PACKAGES = " \
 perl-Digest-SHA1 \
 perl-Digest-SHA1-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Digest-SHA1-2.13-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "677061c8997c8b6930745e58e6c4f0eddb141e844bd0089b5add821c19c66adb"

URI_x86_64_v2_perl-Digest-SHA1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Digest-SHA1-2.13-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Digest-SHA1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Digest-SHA1}"
SRC_URI[x86_64_v2_perl-Digest-SHA1.sha256sum] = "e8f7cc845eea019370dca1f1637391fe99eae19af72815ef314eac56bee41c83"

URI_x86_64_v2_perl-Digest-SHA1-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Digest-SHA1-tests-2.13-45.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Digest-SHA1-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Digest-SHA1-tests}"
SRC_URI[x86_64_v2_perl-Digest-SHA1-tests.sha256sum] = "53b70e5dc5954f444713b79194f236fb2bbf9fde242496ce298a12c092a0f608"

URI_aarch64_perl-Digest-SHA1 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Digest-SHA1-2.13-45.el10_0.aarch64.rpm;name=aarch64_perl-Digest-SHA1;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Digest-SHA1}"
SRC_URI[aarch64_perl-Digest-SHA1.sha256sum] = "9705bfe42c205c563ceb5a9b5115e77fcbbd0b42b4b075784d5ffe971f5f0c84"

URI_aarch64_perl-Digest-SHA1-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Digest-SHA1-tests-2.13-45.el10_0.aarch64.rpm;name=aarch64_perl-Digest-SHA1-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Digest-SHA1-tests}"
SRC_URI[aarch64_perl-Digest-SHA1-tests.sha256sum] = "3fa49801e1a37918a87fdc74c1b2f7529bcf83170f2889b9a2f63a159d6b3cb9"

RDEPENDS:perl-Digest-SHA1 = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Digest-SHA1-tests = " \
 bash \
 perl-Digest-SHA1 \
 perl-Test \
 perl-Test-Harness \
 perl-interpreter \
 perl-vars \
 "
