# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrayref"
PV = "0.3.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-arrayref+default-devel \
 rust-arrayref-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrayref-0.3.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a37ce9d4bf63ae6395d2e28d9d4f8e336b24206dfdd08121990f6b3f245d3eff"

URI_x86_64_v2_rust-arrayref+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayref+default-devel-0.3.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayref+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayref+default-devel}"
SRC_URI[x86_64_v2_rust-arrayref+default-devel.sha256sum] = "005c7281f63206835afbea84b565f56fe08e16f613bb759ae17b53b595534d23"

URI_x86_64_v2_rust-arrayref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayref-devel-0.3.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayref-devel}"
SRC_URI[x86_64_v2_rust-arrayref-devel.sha256sum] = "51de37818dbea517adbeb960aa7ffbac1ac6eb5c1200793296e72c86b15d83dc"

URI_aarch64_rust-arrayref+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayref+default-devel-0.3.9-1.el10_0.noarch.rpm;name=aarch64_rust-arrayref+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayref+default-devel}"
SRC_URI[aarch64_rust-arrayref+default-devel.sha256sum] = "a771688f83067b08020bd53148cc41fa91e182bf78ed65831804655bab701f31"

URI_aarch64_rust-arrayref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayref-devel-0.3.9-1.el10_0.noarch.rpm;name=aarch64_rust-arrayref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayref-devel}"
SRC_URI[aarch64_rust-arrayref-devel.sha256sum] = "bfb4f1cb9d7dcc25fd3d052e9c3ae450852509d192c0718fd0be532c524fffbe"

RDEPENDS:rust-arrayref+default-devel = " \
 cargo \
 rust-arrayref-devel \
 "
RDEPENDS:rust-arrayref-devel = " \
 cargo \
 "
