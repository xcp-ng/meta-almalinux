# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-iso639"
PV = "0.1.4"
PR = "27.el10"
PACKAGES = " \
 python3-iso639 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-iso639-0.1.4-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c0ced74485c19ae70a6e10a694e2764d4a7865edc956f2b55c174b7a2b93a21"

URI_x86_64_v2_python3-iso639 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-iso639-0.1.4-27.el10.noarch.rpm;name=x86_64_v2_python3-iso639;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-iso639}"
SRC_URI[x86_64_v2_python3-iso639.sha256sum] = "353064852ca91b427753088149d41ce69359845d1404ac4b7b38e4383837689b"

URI_aarch64_python3-iso639 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-iso639-0.1.4-27.el10.noarch.rpm;name=aarch64_python3-iso639;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-iso639}"
SRC_URI[aarch64_python3-iso639.sha256sum] = "353064852ca91b427753088149d41ce69359845d1404ac4b7b38e4383837689b"

RDEPENDS:python3-iso639 = " \
 python3 \
 "
