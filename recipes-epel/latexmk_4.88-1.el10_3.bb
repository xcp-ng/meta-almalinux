# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "latexmk"
PV = "4.88"
PR = "1.el10_3"
PACKAGES = " \
 latexmk \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/latexmk-4.88-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dd7b02b5f81a4e51d9c67ca18b329e28c6e034d07838e13e3b8800b7fef8789c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/latexmk-4.88-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_latexmk;unpack=0"
SRC_URI[x86_64_v2_latexmk.sha256sum] = "53e718cba800155fc12841245acf06f51e0ebb8ef4c573010b7d03963b289ae2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/latexmk-4.88-1.el10_3.noarch.rpm;name=aarch64_latexmk;unpack=0"
SRC_URI[aarch64_latexmk.sha256sum] = "1f9e28bec5ada9525984b4dd1d182b7e139e26f25e912f96ffecbd7228290d33"

RDEPENDS:latexmk = " \
 ghostscript-tools-dvipdf \
 perl-Digest-MD5 \
 perl-Encode \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-FileHandle \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-Unicode-Normalize \
 perl-interpreter \
 perl-libs \
 perl-sigtrap \
 texlive-latex \
 xdg-utils \
 "
