# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scitokens-cpp"
PV = "1.1.2"
PR = "2.el10_0"
PACKAGES = " \
 scitokens-cpp \
 scitokens-cpp-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/scitokens-cpp-1.1.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "19ae15bb5ebbf00d8bcaa976306de624a75ed567c9b1af87c34c6475cbd35926"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scitokens-cpp-1.1.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scitokens-cpp;unpack=0"
SRC_URI[x86_64_v2_scitokens-cpp.sha256sum] = "c8efda9ee47f83701619d3b62fbf7fa35a5552d061821b5b54a0c3a0fbc828d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scitokens-cpp-devel-1.1.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scitokens-cpp-devel;unpack=0"
SRC_URI[x86_64_v2_scitokens-cpp-devel.sha256sum] = "d7db123a679cdfd94c32038fd64289343e5ff4109e5b0d5c1e8e3a18d349c0c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/scitokens-cpp-1.1.2-2.el10_0.aarch64.rpm;name=aarch64_scitokens-cpp;unpack=0"
SRC_URI[aarch64_scitokens-cpp.sha256sum] = "d3ef580653e572ea8c0a0c43c7f5f767f3862a0e4a642028901eb772effaac30"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/scitokens-cpp-devel-1.1.2-2.el10_0.aarch64.rpm;name=aarch64_scitokens-cpp-devel;unpack=0"
SRC_URI[aarch64_scitokens-cpp-devel.sha256sum] = "79b2c7db81e95dcbea6245ae6658fcb6e88c35141932893522dd37f81319d95e"

RDEPENDS:scitokens-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 openssl-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:scitokens-cpp-devel = " \
 scitokens-cpp \
 "
