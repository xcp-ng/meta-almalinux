# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-polling"
PV = "3.7.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-polling+default-devel \
 rust-polling-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-polling-3.7.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "590a47f6bdca713f458ccdb6f6e951ee4efea42e727505c3cd41c2368b92cc14"

URI_x86_64_v2_rust-polling+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polling+default-devel-3.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polling+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polling+default-devel}"
SRC_URI[x86_64_v2_rust-polling+default-devel.sha256sum] = "4934732e81f8c78e08be120fb2c020123d00469d005f23f37e28e41fc15452dd"

URI_x86_64_v2_rust-polling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polling-devel-3.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polling-devel}"
SRC_URI[x86_64_v2_rust-polling-devel.sha256sum] = "0557e2101fedfe1b05d003d001a60f99a72acb298a2fecde13be5f1b3999ad79"

URI_aarch64_rust-polling+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polling+default-devel-3.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-polling+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polling+default-devel}"
SRC_URI[aarch64_rust-polling+default-devel.sha256sum] = "98252bfbe4da5ea354fb7dae7a34895bd49d40b0365f5d1aee8ef86c2c16017b"

URI_aarch64_rust-polling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polling-devel-3.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-polling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polling-devel}"
SRC_URI[aarch64_rust-polling-devel.sha256sum] = "d78ed8c748a7d25346bfe3e3b375f681110f662d7af82ca54932629c72c882d8"

RDEPENDS:rust-polling+default-devel = " \
 cargo \
 rust-polling-devel \
 "
RDEPENDS:rust-polling-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix+time-devel \
 rust-rustix-devel \
 rust-tracing-devel \
 "
