# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blake3"
PV = "1.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-blake3+default-devel \
 rust-blake3+digest-devel \
 rust-blake3+mmap-devel \
 rust-blake3+neon-devel \
 rust-blake3+no_avx2-devel \
 rust-blake3+no_avx512-devel \
 rust-blake3+no_neon-devel \
 rust-blake3+no_sse2-devel \
 rust-blake3+no_sse41-devel \
 rust-blake3+prefer_intrinsics-devel \
 rust-blake3+pure-devel \
 rust-blake3+rayon-devel \
 rust-blake3+serde-devel \
 rust-blake3+std-devel \
 rust-blake3+traits-preview-devel \
 rust-blake3+zeroize-devel \
 rust-blake3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blake3-1.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8a389d5dcede814d15d4f4655f01a3eb7740e9e00a23cd019d6ac6046821cbe"

URI_x86_64_v2_rust-blake3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+default-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+default-devel}"
SRC_URI[x86_64_v2_rust-blake3+default-devel.sha256sum] = "8454767ee216c6bf799f5570f7a1b8d0bb352186501757daddd1dd1d3c09e65e"

URI_x86_64_v2_rust-blake3+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+digest-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+digest-devel}"
SRC_URI[x86_64_v2_rust-blake3+digest-devel.sha256sum] = "10fd8f67b9a27111f86316a18f1768f3b3aec08312000dd715a0ec1b3cf8b037"

URI_x86_64_v2_rust-blake3+mmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+mmap-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+mmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+mmap-devel}"
SRC_URI[x86_64_v2_rust-blake3+mmap-devel.sha256sum] = "5457a03532d32c9fdcfd09b79a374a73fd82e1fd3973a7317092b7f380e6d216"

URI_x86_64_v2_rust-blake3+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+neon-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+neon-devel}"
SRC_URI[x86_64_v2_rust-blake3+neon-devel.sha256sum] = "dbf3cb25cd6be3441ec535dbeb583ea8eb30b8ec053ebd973bed20a2736fbce4"

URI_x86_64_v2_rust-blake3+no_avx2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_avx2-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_avx2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_avx2-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_avx2-devel.sha256sum] = "0ba7981e6a2432db59d082f94b73ffc88c3bf40dea8cc9adc97126cb37613003"

URI_x86_64_v2_rust-blake3+no_avx512-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_avx512-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_avx512-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_avx512-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_avx512-devel.sha256sum] = "98a4f130bc8fcc696dedda6f23efab7fd53abf119721b07f0725eb2007905f89"

URI_x86_64_v2_rust-blake3+no_neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_neon-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_neon-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_neon-devel.sha256sum] = "3a382ce7c443e640af3597c9007dbd751eb1efcfc3ecbd9bc6211d6e4773e38a"

URI_x86_64_v2_rust-blake3+no_sse2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_sse2-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_sse2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_sse2-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_sse2-devel.sha256sum] = "dac540bb9b43719aba7c4773f0166e25d48430968771e738956a9b32d7d272bc"

URI_x86_64_v2_rust-blake3+no_sse41-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_sse41-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_sse41-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_sse41-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_sse41-devel.sha256sum] = "647beabb77f679da3ede230ce2c5d3578734017fd7d133cd4a22dbd45f504bc6"

URI_x86_64_v2_rust-blake3+prefer_intrinsics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+prefer_intrinsics-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+prefer_intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+prefer_intrinsics-devel}"
SRC_URI[x86_64_v2_rust-blake3+prefer_intrinsics-devel.sha256sum] = "9a9e8bfb9c3a11bce302435250074cede69aa5d0527bdc44d397599279a053b3"

URI_x86_64_v2_rust-blake3+pure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+pure-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+pure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+pure-devel}"
SRC_URI[x86_64_v2_rust-blake3+pure-devel.sha256sum] = "33e23cf5ed6c0f579ed3d32fa76f9f11501b6b126479d394dfb267fdbb7cabcd"

URI_x86_64_v2_rust-blake3+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+rayon-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+rayon-devel}"
SRC_URI[x86_64_v2_rust-blake3+rayon-devel.sha256sum] = "0369bd4641adcdd996a42e454dcf7a338ed998613e48628f127ac1e30af06664"

URI_x86_64_v2_rust-blake3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+serde-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+serde-devel}"
SRC_URI[x86_64_v2_rust-blake3+serde-devel.sha256sum] = "25ecd9b230bcbc9cce47e41e4bf2da64b76f6cc02c536b060e1ba6126b290613"

URI_x86_64_v2_rust-blake3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+std-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+std-devel}"
SRC_URI[x86_64_v2_rust-blake3+std-devel.sha256sum] = "be3b7c52ad01892ba8bacef8e660c06b6a2607c162e5de5877b9ff9e6f3afce6"

URI_x86_64_v2_rust-blake3+traits-preview-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+traits-preview-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+traits-preview-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+traits-preview-devel}"
SRC_URI[x86_64_v2_rust-blake3+traits-preview-devel.sha256sum] = "c4a6f7e9ae2c94f86b25f8af0879805ddde3f5d03672ca4d7a3d00d404b8b604"

URI_x86_64_v2_rust-blake3+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+zeroize-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+zeroize-devel}"
SRC_URI[x86_64_v2_rust-blake3+zeroize-devel.sha256sum] = "c87d1714384300a89cee42e5742ac8e1079a2a3fe85a8224b2f60b981c15bf29"

URI_x86_64_v2_rust-blake3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3-devel-1.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3-devel}"
SRC_URI[x86_64_v2_rust-blake3-devel.sha256sum] = "5b8a582dc3ab482c1b2a339d7a2948a67cc20892cd4b40727d8e8f5c59aba4bd"

URI_aarch64_rust-blake3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+default-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+default-devel}"
SRC_URI[aarch64_rust-blake3+default-devel.sha256sum] = "1dbe49f81fcc57535227020934dab3a2d96de838650998f292fa8943ad2308fb"

URI_aarch64_rust-blake3+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+digest-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+digest-devel}"
SRC_URI[aarch64_rust-blake3+digest-devel.sha256sum] = "453a36f14ceba3f5e776c2c9b2e1d4eb0586cd4d5c052bfcca0b38b209d80413"

URI_aarch64_rust-blake3+mmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+mmap-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+mmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+mmap-devel}"
SRC_URI[aarch64_rust-blake3+mmap-devel.sha256sum] = "395319a88a212b945b4b0d442ffbc9f41b30c9154873dacdd7ebea43db882f70"

URI_aarch64_rust-blake3+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+neon-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+neon-devel}"
SRC_URI[aarch64_rust-blake3+neon-devel.sha256sum] = "bec81370cd7733baffc306c6c648272619e44a219597393a4f395226c4d132b4"

URI_aarch64_rust-blake3+no_avx2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_avx2-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+no_avx2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_avx2-devel}"
SRC_URI[aarch64_rust-blake3+no_avx2-devel.sha256sum] = "cc8fc30fbdb7a8d2ebc3aee5faa7f4c6b12d6ada37631274c1eddcf6b9d9ab7a"

URI_aarch64_rust-blake3+no_avx512-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_avx512-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+no_avx512-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_avx512-devel}"
SRC_URI[aarch64_rust-blake3+no_avx512-devel.sha256sum] = "6d5b1f3c0532f9c3951d8077f71d26599a49177a5cbb12511db39a692aafd4be"

URI_aarch64_rust-blake3+no_neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_neon-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+no_neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_neon-devel}"
SRC_URI[aarch64_rust-blake3+no_neon-devel.sha256sum] = "2de58a331eed15831c783b02597d981b2ca4e73c22781e2f1b33acd750f4b267"

URI_aarch64_rust-blake3+no_sse2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_sse2-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+no_sse2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_sse2-devel}"
SRC_URI[aarch64_rust-blake3+no_sse2-devel.sha256sum] = "31294baf2ae837088e251f9b3479b042768c4c9e9cc904c878c6efc0aba6d8c9"

URI_aarch64_rust-blake3+no_sse41-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_sse41-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+no_sse41-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_sse41-devel}"
SRC_URI[aarch64_rust-blake3+no_sse41-devel.sha256sum] = "3a433d3828deb01f91aa7f6df5a59827d21f4e6a450a012736916234d3424d23"

URI_aarch64_rust-blake3+prefer_intrinsics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+prefer_intrinsics-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+prefer_intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+prefer_intrinsics-devel}"
SRC_URI[aarch64_rust-blake3+prefer_intrinsics-devel.sha256sum] = "abdce9fe6b1c0dbf1744b22fb328d5f9f46a740546b6ea2ddb9d55c68a9d0479"

URI_aarch64_rust-blake3+pure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+pure-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+pure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+pure-devel}"
SRC_URI[aarch64_rust-blake3+pure-devel.sha256sum] = "7fb9492519dc4198b88508cfa35892321dcfb22d7f9a9858ce4d4510b6072ef9"

URI_aarch64_rust-blake3+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+rayon-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+rayon-devel}"
SRC_URI[aarch64_rust-blake3+rayon-devel.sha256sum] = "c2654f629c54201f39d6bf7a56db7f641a28034ff8c030d74023c86f200487d6"

URI_aarch64_rust-blake3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+serde-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+serde-devel}"
SRC_URI[aarch64_rust-blake3+serde-devel.sha256sum] = "6252bdd1e13c339aa70fa2fd8f46c76bba069f65d7dc868e43b12a739e3c15b4"

URI_aarch64_rust-blake3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+std-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+std-devel}"
SRC_URI[aarch64_rust-blake3+std-devel.sha256sum] = "922ba620bb54f43efa8023cda84daa606168b1b6eb6e7c8c76df797031ac7e46"

URI_aarch64_rust-blake3+traits-preview-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+traits-preview-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+traits-preview-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+traits-preview-devel}"
SRC_URI[aarch64_rust-blake3+traits-preview-devel.sha256sum] = "c75e01d46e43dfa0a8c933ce97b90d803df93aa02facab0a65174e492b55389a"

URI_aarch64_rust-blake3+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+zeroize-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+zeroize-devel}"
SRC_URI[aarch64_rust-blake3+zeroize-devel.sha256sum] = "ec2eb80819b3c1b499161e8e38f1a243d8bc94ebfe7b80514834ad9f2ce0de8f"

URI_aarch64_rust-blake3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3-devel-1.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-blake3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3-devel}"
SRC_URI[aarch64_rust-blake3-devel.sha256sum] = "cec45511311511b6ea431b672aee327a161c035fb0c6a86561846dba0ce202f6"

RDEPENDS:rust-blake3+default-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+digest-devel = " \
 cargo \
 rust-blake3-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
RDEPENDS:rust-blake3+mmap-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 rust-memmap2+default-devel \
 "
RDEPENDS:rust-blake3+neon-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_avx2-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_avx512-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_neon-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_sse2-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_sse41-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+prefer_intrinsics-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+pure-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+rayon-devel = " \
 cargo \
 rust-blake3-devel \
 rust-rayon-core+default-devel \
 "
RDEPENDS:rust-blake3+serde-devel = " \
 cargo \
 rust-blake3-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-blake3+std-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+traits-preview-devel = " \
 cargo \
 rust-blake3-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
RDEPENDS:rust-blake3+zeroize-devel = " \
 cargo \
 rust-arrayvec+zeroize-devel \
 rust-blake3-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-blake3-devel = " \
 cargo \
 python3 \
 rust-arrayref+default-devel \
 rust-arrayvec-devel \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-constant_time_eq-devel \
 "
