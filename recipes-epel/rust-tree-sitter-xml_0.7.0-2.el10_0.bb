# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-xml"
PV = "0.7.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-xml+default-devel \
 rust-tree-sitter-xml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-xml-0.7.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a6d22af3bf1c9bdd466055f11798751691e9b5816d72f561661690613628cad"

URI_x86_64_v2_rust-tree-sitter-xml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-xml+default-devel-0.7.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-xml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-xml+default-devel.sha256sum] = "0ea95b0c22cdb19d11c45c7190fe85bc4e76299e471ca6ac3ad61e6ea0cffdb7"

URI_x86_64_v2_rust-tree-sitter-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-xml-devel-0.7.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-xml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-xml-devel.sha256sum] = "147f3eca1ce9de221cd9d8006f3d738a16f66791aab5f897a6741231b1cf58b3"

URI_aarch64_rust-tree-sitter-xml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-xml+default-devel-0.7.0-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-xml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-xml+default-devel.sha256sum] = "a1302f57654f2f2f2902d0c12dfac190128c72e492cc07688fe3058b58233f08"

URI_aarch64_rust-tree-sitter-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-xml-devel-0.7.0-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-xml-devel}"
SRC_URI[aarch64_rust-tree-sitter-xml-devel.sha256sum] = "223cde5d5716bd4faa86a6c59d7865cbcc3caaaf68b954eaee78fea1e33d27ec"

RDEPENDS:rust-tree-sitter-xml+default-devel = " \
 cargo \
 rust-tree-sitter-xml-devel \
 "
RDEPENDS:rust-tree-sitter-xml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
