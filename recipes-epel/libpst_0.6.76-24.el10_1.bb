# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpst"
PV = "0.6.76"
PR = "24.el10_1"
PACKAGES = " \
 libpst \
 libpst-devel \
 libpst-devel-doc \
 libpst-doc \
 libpst-libs \
 python3-libpst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libpst-0.6.76-24.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4d4aece72798fc261dd6f5a45ee5b557847842517d23426a35d05ffa171b7db"

URI_x86_64_v2_libpst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-0.6.76-24.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst}"
SRC_URI[x86_64_v2_libpst.sha256sum] = "7c6f8087681e4e7664e928745c97c5803d481430493bdcb4fbac861a9249c938"

URI_x86_64_v2_libpst-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-devel-0.6.76-24.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst-devel}"
SRC_URI[x86_64_v2_libpst-devel.sha256sum] = "9aa8c37edf325fcf157d037b9f70f1e684d3204b386796c58c5028d39ba29018"

URI_x86_64_v2_libpst-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-devel-doc-0.6.76-24.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst-devel-doc}"
SRC_URI[x86_64_v2_libpst-devel-doc.sha256sum] = "da8cd5788626299359ca2386e577e1e5d2051c1201114b61c4670054438ef5d6"

URI_x86_64_v2_libpst-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-doc-0.6.76-24.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst-doc}"
SRC_URI[x86_64_v2_libpst-doc.sha256sum] = "7514c47c59cff8d238ede5105d6c222d9a77267bddb6aa4613fa7e7ead8f89a6"

URI_x86_64_v2_libpst-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpst-libs-0.6.76-24.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpst-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpst-libs}"
SRC_URI[x86_64_v2_libpst-libs.sha256sum] = "4ad9c3c667f16e99618b39563b52defbe2b5ba4162eaaac07cfd2f0d48b88b5c"

URI_x86_64_v2_python3-libpst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libpst-0.6.76-24.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libpst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libpst}"
SRC_URI[x86_64_v2_python3-libpst.sha256sum] = "b7facca2b0d8d32933f797ab84a41e63c8547f63ca663f571bd407567053bafe"

URI_aarch64_libpst = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-0.6.76-24.el10_1.aarch64.rpm;name=aarch64_libpst;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst}"
SRC_URI[aarch64_libpst.sha256sum] = "cf670edfe5a1367bb1cc4f4383ef550885363b58463eb03f681469ae802fff43"

URI_aarch64_libpst-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-devel-0.6.76-24.el10_1.aarch64.rpm;name=aarch64_libpst-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst-devel}"
SRC_URI[aarch64_libpst-devel.sha256sum] = "a3f1821bb946e2cfec254bf7c16995e379dd573bd1d997521e088d902da4bb5b"

URI_aarch64_libpst-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-devel-doc-0.6.76-24.el10_1.aarch64.rpm;name=aarch64_libpst-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst-devel-doc}"
SRC_URI[aarch64_libpst-devel-doc.sha256sum] = "50789600922c473f881c16bd7c410578cfac981180f347242440cb7a0eca3880"

URI_aarch64_libpst-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-doc-0.6.76-24.el10_1.aarch64.rpm;name=aarch64_libpst-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst-doc}"
SRC_URI[aarch64_libpst-doc.sha256sum] = "36c99c39f133df23796a88ad133b4b4c9e0c47c8967b5b0bb10324b3007bf686"

URI_aarch64_libpst-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libpst-libs-0.6.76-24.el10_1.aarch64.rpm;name=aarch64_libpst-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpst-libs}"
SRC_URI[aarch64_libpst-libs.sha256sum] = "ce1ee6dd7fd3650d751a5bb1db824a75dedfa395ae73c520cad98674783c1229"

URI_aarch64_python3-libpst = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libpst-0.6.76-24.el10_1.aarch64.rpm;name=aarch64_python3-libpst;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libpst}"
SRC_URI[aarch64_python3-libpst.sha256sum] = "6bd8c90c234836eb58d805d22686c49233ff481763500523d57bbfcbcd7f2bed"

RDEPENDS:libpst = " \
 boost-python3 \
 glib2 \
 glibc \
 libgcc \
 libgsf \
 libpst-libs \
 libstdc++ \
 "
RDEPENDS:libpst-devel = " \
 libpst-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libpst-devel-doc = " \
 libpst-doc \
 "
RDEPENDS:libpst-doc = " \
 "
RDEPENDS:libpst-libs = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:python3-libpst = " \
 boost-python3 \
 glibc \
 libgcc \
 libpst-libs \
 libstdc++ \
 python3 \
 zlib-ng-compat \
 "
