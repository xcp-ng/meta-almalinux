# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-queue"
PV = "0.3.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue+default-devel \
 rust-crossbeam-queue+nightly-devel \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-queue-0.3.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cc045acca394a0cc3041a958df0e64c01848ce456f21674bd54ead9fe5e6c8e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+alloc-devel-0.3.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue+alloc-devel.sha256sum] = "b3bff3bb75bdec970972b0032e329970f50958ca50629e20a5295b55a58595a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+default-devel-0.3.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue+default-devel.sha256sum] = "e53c69219f0d28c3986cda6c20749731a6dbc64cbb1b89a78f4155d95e0cfb51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+nightly-devel-0.3.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue+nightly-devel.sha256sum] = "c5654f490744b60c0f102b1db6037c60ed876a181721c346d513783178006a87"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+std-devel-0.3.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue+std-devel.sha256sum] = "04c060042c84cc39de8c3c9f5825a0a1245242a6bbf29b04d0f9971f595d030e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue-devel-0.3.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-queue-devel.sha256sum] = "e4d35ebe4571f95af776de4beecdf92e44ce374be630936ecd3ae56c34db8a11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+alloc-devel-0.3.14-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue+alloc-devel.sha256sum] = "2afb269d0b97afb4e697cb152e540d741d35ab1ad51a6aaab14ef312943325f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+default-devel-0.3.14-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue+default-devel.sha256sum] = "f428dc554915399779e66ea524e0462e1ffef68f68f0901a7754e054888380a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+nightly-devel-0.3.14-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue+nightly-devel.sha256sum] = "5d63a2bb9680874d216e1c30539cdc8c74abbb7f87355ac6b4bdcf3a43f0477c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+std-devel-0.3.14-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue+std-devel.sha256sum] = "28a072444f8407c606b222af61c8a2449efdbe98dab9a46687f73d12591cab3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue-devel-0.3.14-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-queue-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-queue-devel.sha256sum] = "dda6848d743f86b0df83c14e528a5f46e077b66b9d602035a759e0e3495e7ae1"

RDEPENDS:rust-crossbeam-queue+alloc-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+default-devel = " \
 cargo \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+nightly-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-queue+std-devel = " \
 cargo \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-queue-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
