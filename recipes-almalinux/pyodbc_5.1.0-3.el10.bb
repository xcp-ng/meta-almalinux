# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyodbc"
PV = "5.1.0"
PR = "3.el10"
PACKAGES = " \
 python3-pyodbc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pyodbc-5.1.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "495734fa396b25ab5dc4b2e7baabb271f2d2123e5078f0f6705842cd5a52bed3"

URI_x86_64_v2_python3-pyodbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyodbc-5.1.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyodbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyodbc}"
SRC_URI[x86_64_v2_python3-pyodbc.sha256sum] = "c43de53a5f1fecca9507c4791f96688c02917fdd7a3b9076a41a721c68025b46"

URI_aarch64_python3-pyodbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyodbc-5.1.0-3.el10.aarch64.rpm;name=aarch64_python3-pyodbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyodbc}"
SRC_URI[aarch64_python3-pyodbc.sha256sum] = "5c9826bef0e922f005de72eadfcea66fadaa3a3fd2e4b8b116255849e1005ceb"

RDEPENDS:python3-pyodbc = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 unixODBC \
 "
