# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gv"
PV = "3.7.4"
PR = "33.el10_0"
PACKAGES = " \
 gv \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gv-3.7.4-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dba8e214e4a37b8049c9dc7de6d5c00a926a5e41ceb2de9c5dbb38cb30a8da74"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gv-3.7.4-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gv;unpack=0"
SRC_URI[x86_64_v2_gv.sha256sum] = "8fdc45d40ac26073057078de22d28d6cdda1c408839f9e8ef4d57a5f5ae2b78b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gv-3.7.4-33.el10_0.aarch64.rpm;name=aarch64_gv;unpack=0"
SRC_URI[aarch64_gv.sha256sum] = "7a4e21d0efa666667bc4b5c5507ba81eebed1f9f91b89a482fdca010d59cc0f4"

RDEPENDS:gv = " \
 Xaw3d \
 ghostscript \
 glibc \
 libX11 \
 libXinerama \
 libXmu \
 libXt \
 perl-interpreter \
 "
