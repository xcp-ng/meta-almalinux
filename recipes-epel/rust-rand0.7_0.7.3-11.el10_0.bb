# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand0.7"
PV = "0.7.3"
PR = "11.el10_0"
PACKAGES = " \
 rust-rand0.7+alloc-devel \
 rust-rand0.7+default-devel \
 rust-rand0.7+getrandom-devel \
 rust-rand0.7+getrandom_package-devel \
 rust-rand0.7+libc-devel \
 rust-rand0.7+log-devel \
 rust-rand0.7+rand_pcg-devel \
 rust-rand0.7+serde1-devel \
 rust-rand0.7+small_rng-devel \
 rust-rand0.7+std-devel \
 rust-rand0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand0.7-0.7.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f883b2f7709459e567b51aa715231ad430085a5c90cde888b8bf705144979a86"

URI_x86_64_v2_rust-rand0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+alloc-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+alloc-devel.sha256sum] = "474977acd8fad99ea7f482f04e847a7a6ddfa62f526265ffb8a65e5425f445c2"

URI_x86_64_v2_rust-rand0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+default-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+default-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+default-devel.sha256sum] = "018bf27001d85e1bbb3092a5ddc33fd388a055af584d88c27133dee36428d967"
RPROVIDES:rust-rand0.7+default-devel:append:x86_64_v2 = " virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

URI_x86_64_v2_rust-rand0.7+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+getrandom-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+getrandom-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+getrandom-devel.sha256sum] = "97327fdc7f2d00dcd108f6733db9a3165f6096aad11f3a3eb0944342795cf6e9"

URI_x86_64_v2_rust-rand0.7+getrandom_package-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+getrandom_package-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+getrandom_package-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+getrandom_package-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+getrandom_package-devel.sha256sum] = "7c742ffd3190c4c8010b888af552ff3e038484c5a70affd9944055c66c0b6750"

URI_x86_64_v2_rust-rand0.7+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+libc-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+libc-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+libc-devel.sha256sum] = "86e729c726796d6d301e907658fdbff47e21e932200a78b901769e070691c70d"

URI_x86_64_v2_rust-rand0.7+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+log-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+log-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+log-devel.sha256sum] = "df776c7fce760854cf4d19ccd9a20bd4ea3e23805647b24c6462ef9c25511e5b"

URI_x86_64_v2_rust-rand0.7+rand_pcg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+rand_pcg-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+rand_pcg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+rand_pcg-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+rand_pcg-devel.sha256sum] = "ecab71d6cc2683a40000dbdc3c6de64f7a797aa3066994268a7d3796e4812af7"

URI_x86_64_v2_rust-rand0.7+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+serde1-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+serde1-devel.sha256sum] = "dd8f68e90a26aab7a550a0305a6dfdb6522ea8b5c947b9ddf7659f692726f6b6"

URI_x86_64_v2_rust-rand0.7+small_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+small_rng-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+small_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+small_rng-devel.sha256sum] = "f4ac3d6ddf01ad0852fcb8c1ffe48b8034206c5e36042d39df30bdf20733d694"

URI_x86_64_v2_rust-rand0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7+std-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7+std-devel}"
SRC_URI[x86_64_v2_rust-rand0.7+std-devel.sha256sum] = "702807e17c99c4389da25a3f666607e896dd3bd2f8c763febf8435315bf24de2"

URI_x86_64_v2_rust-rand0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.7-devel-0.7.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.7-devel}"
SRC_URI[x86_64_v2_rust-rand0.7-devel.sha256sum] = "25dc5d52cd90dc60587bc1187d7b692d559b804bf46352c2978183c645eebc69"

URI_aarch64_rust-rand0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+alloc-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+alloc-devel}"
SRC_URI[aarch64_rust-rand0.7+alloc-devel.sha256sum] = "396cd1947814b86660c9606c0bacbdac5341189ce319d178e59e332c2248838f"

URI_aarch64_rust-rand0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+default-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+default-devel}"
SRC_URI[aarch64_rust-rand0.7+default-devel.sha256sum] = "1ad045ee2b05a557bf1050a48048d1e8a19506f3b8740e41b9b777f6e5606e28"
RPROVIDES:rust-rand0.7+default-devel:append:aarch64 = " virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

URI_aarch64_rust-rand0.7+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+getrandom-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+getrandom-devel}"
SRC_URI[aarch64_rust-rand0.7+getrandom-devel.sha256sum] = "d0872343e0f688963c0bed1d47e319895411240eef9cfcd4d2d5d42bb9fa546a"

URI_aarch64_rust-rand0.7+getrandom_package-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+getrandom_package-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+getrandom_package-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+getrandom_package-devel}"
SRC_URI[aarch64_rust-rand0.7+getrandom_package-devel.sha256sum] = "d872a4f7a642eefd8d93bb2543a59904ad630e3aca1b393b9238a97ba698faf9"

URI_aarch64_rust-rand0.7+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+libc-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+libc-devel}"
SRC_URI[aarch64_rust-rand0.7+libc-devel.sha256sum] = "e92d2e1d207efa79ffd86e3c8fa2acb283de5f14612a084f67530442a0962b0f"

URI_aarch64_rust-rand0.7+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+log-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+log-devel}"
SRC_URI[aarch64_rust-rand0.7+log-devel.sha256sum] = "50942f679812d96232a41dd3080dcaa2315229234b91c5d6f5a65fb29466767d"

URI_aarch64_rust-rand0.7+rand_pcg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+rand_pcg-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+rand_pcg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+rand_pcg-devel}"
SRC_URI[aarch64_rust-rand0.7+rand_pcg-devel.sha256sum] = "1636fe8e7ca502b163a4a6047c7e3a4911ab2469eaa862db639598562bc99edb"

URI_aarch64_rust-rand0.7+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+serde1-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+serde1-devel}"
SRC_URI[aarch64_rust-rand0.7+serde1-devel.sha256sum] = "513bb2374647d58c7ff47fa5360c3d59f780a7ce888c1e73934ea38093ae8fbc"

URI_aarch64_rust-rand0.7+small_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+small_rng-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+small_rng-devel}"
SRC_URI[aarch64_rust-rand0.7+small_rng-devel.sha256sum] = "87cdc6bd11ca7ccc0c660dd26e2a52baba8a1ab7e63866ce82aa8380b91dae8e"

URI_aarch64_rust-rand0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7+std-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7+std-devel}"
SRC_URI[aarch64_rust-rand0.7+std-devel.sha256sum] = "e3d6ffc872c267bdbeb50a69c86fdcfd7aec98ad05c48f329dc28bd6cac37b1d"

URI_aarch64_rust-rand0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.7-devel-0.7.3-11.el10_0.noarch.rpm;name=aarch64_rust-rand0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.7-devel}"
SRC_URI[aarch64_rust-rand0.7-devel.sha256sum] = "c8cbbde77faee86a786e2502d5d2c449c521a83089c08300f73e0328df06d8b9"

RDEPENDS:rust-rand0.7+alloc-devel = " \
 cargo \
 rust-rand0.7-devel \
 rust-rand_core0.5+alloc-devel \
 "
RDEPENDS:rust-rand0.7+default-devel = " \
 cargo \
 rust-rand0.7+std-devel \
 rust-rand0.7-devel \
 "
RDEPENDS:rust-rand0.7+getrandom-devel = " \
 cargo \
 rust-rand0.7+getrandom_package-devel \
 rust-rand0.7-devel \
 rust-rand_core0.5+getrandom-devel \
 "
RDEPENDS:rust-rand0.7+getrandom_package-devel = " \
 cargo \
 rust-getrandom0.1+default-devel \
 rust-rand0.7-devel \
 "
RDEPENDS:rust-rand0.7+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rand0.7-devel \
 "
RDEPENDS:rust-rand0.7+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-rand0.7-devel \
 "
RDEPENDS:rust-rand0.7+rand_pcg-devel = " \
 cargo \
 rust-rand0.7-devel \
 rust-rand_pcg0.2+default-devel \
 "
RDEPENDS:rust-rand0.7+serde1-devel = " \
 cargo \
 rust-rand0.7-devel \
 "
RDEPENDS:rust-rand0.7+small_rng-devel = " \
 cargo \
 rust-rand0.7+rand_pcg-devel \
 rust-rand0.7-devel \
 "
RDEPENDS:rust-rand0.7+std-devel = " \
 cargo \
 rust-rand0.7+alloc-devel \
 rust-rand0.7+getrandom-devel \
 rust-rand0.7+libc-devel \
 rust-rand0.7-devel \
 rust-rand_chacha0.2+std-devel \
 rust-rand_core0.5+std-devel \
 "
RDEPENDS:rust-rand0.7-devel = " \
 cargo \
 rust-rand_chacha0.2-devel \
 rust-rand_core0.5+default-devel \
 "
