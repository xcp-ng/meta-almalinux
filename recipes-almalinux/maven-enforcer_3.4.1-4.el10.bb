# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-enforcer"
PV = "3.4.1"
PR = "4.el10"
PACKAGES = " \
 maven-enforcer \
 maven-enforcer-api \
 maven-enforcer-extension \
 maven-enforcer-javadoc \
 maven-enforcer-plugin \
 maven-enforcer-rules \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-enforcer-3.4.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b009197ebe679736ac67d6b3ede69c79829cd2d6d341f63fd16177a159e78a59"

URI_x86_64_v2_maven-enforcer = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-enforcer-3.4.1-4.el10.noarch.rpm;name=x86_64_v2_maven-enforcer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-enforcer}"
SRC_URI[x86_64_v2_maven-enforcer.sha256sum] = "eb4164f5b73a57318a064a9362e7608e285aa914d2dd5274b1fdc46526122570"

URI_x86_64_v2_maven-enforcer-api = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-enforcer-api-3.4.1-4.el10.noarch.rpm;name=x86_64_v2_maven-enforcer-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-enforcer-api}"
SRC_URI[x86_64_v2_maven-enforcer-api.sha256sum] = "2a7e5aae22c24b0db9566885ca4f068adfb7dfde6925ddf8cb02f9ec3f8b771c"

URI_x86_64_v2_maven-enforcer-extension = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-enforcer-extension-3.4.1-4.el10.noarch.rpm;name=x86_64_v2_maven-enforcer-extension;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-enforcer-extension}"
SRC_URI[x86_64_v2_maven-enforcer-extension.sha256sum] = "de8e3563bde63b24d4e2942c2cea3875738ad1320aba6200fd770ebda2817062"

URI_x86_64_v2_maven-enforcer-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-enforcer-javadoc-3.4.1-4.el10.noarch.rpm;name=x86_64_v2_maven-enforcer-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-enforcer-javadoc}"
SRC_URI[x86_64_v2_maven-enforcer-javadoc.sha256sum] = "3091d606ca060c0441f70d2d054e11a04f066df25b9bf78b0a171f08fa829b1b"

URI_x86_64_v2_maven-enforcer-plugin = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-enforcer-plugin-3.4.1-4.el10.noarch.rpm;name=x86_64_v2_maven-enforcer-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-enforcer-plugin}"
SRC_URI[x86_64_v2_maven-enforcer-plugin.sha256sum] = "1e67115eb683c9fab041c04311ee88984561dde406891de3494112363c8d74b3"

URI_x86_64_v2_maven-enforcer-rules = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-enforcer-rules-3.4.1-4.el10.noarch.rpm;name=x86_64_v2_maven-enforcer-rules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-enforcer-rules}"
SRC_URI[x86_64_v2_maven-enforcer-rules.sha256sum] = "6a25cd194b46be4cb042d6a493c870deea4355a75bc76432951e51a69ebcdb72"

URI_aarch64_maven-enforcer = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-enforcer-3.4.1-4.el10.noarch.rpm;name=aarch64_maven-enforcer;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-enforcer}"
SRC_URI[aarch64_maven-enforcer.sha256sum] = "eb4164f5b73a57318a064a9362e7608e285aa914d2dd5274b1fdc46526122570"

URI_aarch64_maven-enforcer-api = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-enforcer-api-3.4.1-4.el10.noarch.rpm;name=aarch64_maven-enforcer-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-enforcer-api}"
SRC_URI[aarch64_maven-enforcer-api.sha256sum] = "2a7e5aae22c24b0db9566885ca4f068adfb7dfde6925ddf8cb02f9ec3f8b771c"

URI_aarch64_maven-enforcer-extension = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-enforcer-extension-3.4.1-4.el10.noarch.rpm;name=aarch64_maven-enforcer-extension;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-enforcer-extension}"
SRC_URI[aarch64_maven-enforcer-extension.sha256sum] = "de8e3563bde63b24d4e2942c2cea3875738ad1320aba6200fd770ebda2817062"

URI_aarch64_maven-enforcer-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-enforcer-javadoc-3.4.1-4.el10.noarch.rpm;name=aarch64_maven-enforcer-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-enforcer-javadoc}"
SRC_URI[aarch64_maven-enforcer-javadoc.sha256sum] = "3091d606ca060c0441f70d2d054e11a04f066df25b9bf78b0a171f08fa829b1b"

URI_aarch64_maven-enforcer-plugin = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-enforcer-plugin-3.4.1-4.el10.noarch.rpm;name=aarch64_maven-enforcer-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-enforcer-plugin}"
SRC_URI[aarch64_maven-enforcer-plugin.sha256sum] = "1e67115eb683c9fab041c04311ee88984561dde406891de3494112363c8d74b3"

URI_aarch64_maven-enforcer-rules = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-enforcer-rules-3.4.1-4.el10.noarch.rpm;name=aarch64_maven-enforcer-rules;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-enforcer-rules}"
SRC_URI[aarch64_maven-enforcer-rules.sha256sum] = "6a25cd194b46be4cb042d6a493c870deea4355a75bc76432951e51a69ebcdb72"

RDEPENDS:maven-enforcer = " \
 javapackages-filesystem \
 maven-parent \
 "
RDEPENDS:maven-enforcer-api = " \
 javapackages-filesystem \
 "
RDEPENDS:maven-enforcer-extension = " \
 javapackages-filesystem \
 "
RDEPENDS:maven-enforcer-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:maven-enforcer-plugin = " \
 jakarta-annotations \
 javapackages-filesystem \
 maven-enforcer-api \
 maven-enforcer-rules \
 "
RDEPENDS:maven-enforcer-rules = " \
 apache-commons-codec \
 apache-commons-io \
 apache-commons-lang3 \
 javapackages-filesystem \
 maven-enforcer-api \
 maven-resolver \
 plexus-utils \
 "
