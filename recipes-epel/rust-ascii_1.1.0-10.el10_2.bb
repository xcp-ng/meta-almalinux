# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ascii"
PV = "1.1.0"
PR = "10.el10_2"
PACKAGES = " \
 rust-ascii+alloc-devel \
 rust-ascii+default-devel \
 rust-ascii+serde-devel \
 rust-ascii+serde_test-devel \
 rust-ascii+std-devel \
 rust-ascii-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ascii-1.1.0-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51fdd040f2db11e14c55bccc8d2e18ec3a826a5ab70731425cef88ea1119e3ac"

URI_x86_64_v2_rust-ascii+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ascii+alloc-devel-1.1.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ascii+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ascii+alloc-devel}"
SRC_URI[x86_64_v2_rust-ascii+alloc-devel.sha256sum] = "645e09e0e951c09becbd606b8505e7db4b9dd2a1b3b5c48ead266819248d41e1"

URI_x86_64_v2_rust-ascii+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ascii+default-devel-1.1.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ascii+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ascii+default-devel}"
SRC_URI[x86_64_v2_rust-ascii+default-devel.sha256sum] = "2936481e02498744731d03d3494516a4ea0457cea9fc8715adc669f2ee4890d3"

URI_x86_64_v2_rust-ascii+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ascii+serde-devel-1.1.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ascii+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ascii+serde-devel}"
SRC_URI[x86_64_v2_rust-ascii+serde-devel.sha256sum] = "a255c36312021eaf0d121e4d14991edf37f67d186a88d9b221a8f2fbfed8e874"

URI_x86_64_v2_rust-ascii+serde_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ascii+serde_test-devel-1.1.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ascii+serde_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ascii+serde_test-devel}"
SRC_URI[x86_64_v2_rust-ascii+serde_test-devel.sha256sum] = "3db9325fb90ec2476bea49f1687918d0ba7315310cd8153d4edcdff0fa36fb0c"

URI_x86_64_v2_rust-ascii+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ascii+std-devel-1.1.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ascii+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ascii+std-devel}"
SRC_URI[x86_64_v2_rust-ascii+std-devel.sha256sum] = "2a47ba594630ee6fbad5adb3874f327764403c7ee300fdbfe1e9ff259e3ddba5"

URI_x86_64_v2_rust-ascii-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ascii-devel-1.1.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ascii-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ascii-devel}"
SRC_URI[x86_64_v2_rust-ascii-devel.sha256sum] = "38a6c27434338c8c9e8bf5f5b9d15a068ee5a25e2ec97e0f59026a2b6332ae52"

URI_aarch64_rust-ascii+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ascii+alloc-devel-1.1.0-10.el10_2.noarch.rpm;name=aarch64_rust-ascii+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ascii+alloc-devel}"
SRC_URI[aarch64_rust-ascii+alloc-devel.sha256sum] = "3904190459751ceb838faf4fd6db1430c6718e9ecbadf8c5e55225f790b0e080"

URI_aarch64_rust-ascii+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ascii+default-devel-1.1.0-10.el10_2.noarch.rpm;name=aarch64_rust-ascii+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ascii+default-devel}"
SRC_URI[aarch64_rust-ascii+default-devel.sha256sum] = "a26814d9c626c2d7e3df09254c5d0248889109a7f5ff6bd4b857a485b80f8357"

URI_aarch64_rust-ascii+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ascii+serde-devel-1.1.0-10.el10_2.noarch.rpm;name=aarch64_rust-ascii+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ascii+serde-devel}"
SRC_URI[aarch64_rust-ascii+serde-devel.sha256sum] = "460f768edd1dd455ce6037551f2b85ae62c2b1e994dcff65756e8cc432e02f9c"

URI_aarch64_rust-ascii+serde_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ascii+serde_test-devel-1.1.0-10.el10_2.noarch.rpm;name=aarch64_rust-ascii+serde_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ascii+serde_test-devel}"
SRC_URI[aarch64_rust-ascii+serde_test-devel.sha256sum] = "70605da9e4eadb56a92dec7f7cd783f99962c899583ba48218adcb93207f72b4"

URI_aarch64_rust-ascii+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ascii+std-devel-1.1.0-10.el10_2.noarch.rpm;name=aarch64_rust-ascii+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ascii+std-devel}"
SRC_URI[aarch64_rust-ascii+std-devel.sha256sum] = "72bfa19eb43b07291b1e05e63efca71a0b22757dcaba7a368efd499522743d1a"

URI_aarch64_rust-ascii-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ascii-devel-1.1.0-10.el10_2.noarch.rpm;name=aarch64_rust-ascii-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ascii-devel}"
SRC_URI[aarch64_rust-ascii-devel.sha256sum] = "ef8d9ba1a1f953cecf85429fbf8f1446183bba7b244d606d7e81dfcaa2064baa"

RDEPENDS:rust-ascii+alloc-devel = " \
 cargo \
 rust-ascii-devel \
 "
RDEPENDS:rust-ascii+default-devel = " \
 cargo \
 rust-ascii+std-devel \
 rust-ascii-devel \
 "
RDEPENDS:rust-ascii+serde-devel = " \
 cargo \
 rust-ascii-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-ascii+serde_test-devel = " \
 cargo \
 rust-ascii-devel \
 rust-serde_test+default-devel \
 "
RDEPENDS:rust-ascii+std-devel = " \
 cargo \
 rust-ascii+alloc-devel \
 rust-ascii-devel \
 "
RDEPENDS:rust-ascii-devel = " \
 cargo \
 "
