# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "picosat"
PV = "965"
PR = "28.el10_2"
PACKAGES = " \
 picosat \
 picosat-R \
 picosat-devel \
 picosat-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/picosat-965-28.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0750ff671d1c2ef059d928b68ebb0440027863827de29801b91f591e4930d53"

URI_x86_64_v2_picosat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picosat-965-28.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picosat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picosat}"
SRC_URI[x86_64_v2_picosat.sha256sum] = "b796ef68ca224586e01941989ad218bacd2ae4d0b1ae29b7e1bffe7d29541123"

URI_x86_64_v2_picosat-R = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picosat-R-965-28.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picosat-R;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picosat-R}"
SRC_URI[x86_64_v2_picosat-R.sha256sum] = "5a63be3f00daf5f14d7e5f5d652463f11d4fc9295b457e482984b0f66d43fb2b"

URI_x86_64_v2_picosat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picosat-devel-965-28.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picosat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picosat-devel}"
SRC_URI[x86_64_v2_picosat-devel.sha256sum] = "ee803588c8f7598ffe24522b37d634c2ed8ffd42955be88bb22da4ef955340b1"

URI_x86_64_v2_picosat-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picosat-libs-965-28.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picosat-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_picosat-libs}"
SRC_URI[x86_64_v2_picosat-libs.sha256sum] = "e7223f837843fa68b7ecbb6a2675c407c4e41de43e69759b0decd24bac675605"

URI_aarch64_picosat = "${EPEL_MIRROR}/aarch64/Packages/p/picosat-965-28.el10_2.aarch64.rpm;name=aarch64_picosat;unpack=0"
SRC_URI:append = " ${URI_aarch64_picosat}"
SRC_URI[aarch64_picosat.sha256sum] = "bd6e93c6e30de106166ad56440197cdd1afdc4bb4a764b8d017df1ff3db950b5"

URI_aarch64_picosat-R = "${EPEL_MIRROR}/aarch64/Packages/p/picosat-R-965-28.el10_2.aarch64.rpm;name=aarch64_picosat-R;unpack=0"
SRC_URI:append = " ${URI_aarch64_picosat-R}"
SRC_URI[aarch64_picosat-R.sha256sum] = "65518bb9a25a225e61e743c31398ed0b402f9275efa7209ca16eb83aaf9e6ea9"

URI_aarch64_picosat-devel = "${EPEL_MIRROR}/aarch64/Packages/p/picosat-devel-965-28.el10_2.aarch64.rpm;name=aarch64_picosat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_picosat-devel}"
SRC_URI[aarch64_picosat-devel.sha256sum] = "c454ec3c1fbad406cdf12f41d82fffd2ebfff204adc5ecfb546af2cabb815456"

URI_aarch64_picosat-libs = "${EPEL_MIRROR}/aarch64/Packages/p/picosat-libs-965-28.el10_2.aarch64.rpm;name=aarch64_picosat-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_picosat-libs}"
SRC_URI[aarch64_picosat-libs.sha256sum] = "88e59abf4d3bc2c4105bec9ec23f4268bbfa068e1f84f217f88331d7e363ecb4"

RDEPENDS:picosat = " \
 bzip2 \
 glibc \
 gzip \
 picosat-libs \
 "
RDEPENDS:picosat-R = " \
 R-core \
 glibc \
 "
RDEPENDS:picosat-devel = " \
 picosat-R \
 picosat-libs \
 "
RDEPENDS:picosat-libs = " \
 glibc \
 "
