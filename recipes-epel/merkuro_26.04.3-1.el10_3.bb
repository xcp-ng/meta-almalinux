# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "merkuro"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 merkuro \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/merkuro-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "069c37e5b714ebf62ea5369119644edb7338da28b6e7a586cce85ac884a0cc9a"

URI_x86_64_v2_merkuro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/merkuro-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_merkuro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_merkuro}"
SRC_URI[x86_64_v2_merkuro.sha256sum] = "80e77a9918bdb2f6a9f7d6c4ad63d00bbe3063222ad376fe2d314a397ddad7ef"

URI_aarch64_merkuro = "${EPEL_MIRROR}/aarch64/Packages/m/merkuro-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_merkuro;unpack=0"
SRC_URI:append = " ${URI_aarch64_merkuro}"
SRC_URI[aarch64_merkuro.sha256sum] = "81b58b2fed0637bd97abca45c06b70d421c1ec3bbbd1e5e483a4216baad29f78"

RDEPENDS:merkuro = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgme2pp \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kidentitymanagement \
 kmailtransport \
 kmbox \
 kmime \
 libgcc \
 libkdepim \
 libkleo \
 libplasma \
 libstdc++ \
 mailcommon \
 messagelib \
 mimetreeparser \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
