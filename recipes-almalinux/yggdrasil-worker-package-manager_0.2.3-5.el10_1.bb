# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yggdrasil-worker-package-manager"
PV = "0.2.3"
PR = "5.el10_1"
PACKAGES = " \
 yggdrasil-worker-package-manager \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yggdrasil-worker-package-manager-0.2.3-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "421093208c9cc35b4e1e1e519658cc9b465413c29aaff4234840415f289333b8"

URI_x86_64_v2_yggdrasil-worker-package-manager = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yggdrasil-worker-package-manager-0.2.3-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_yggdrasil-worker-package-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil-worker-package-manager}"
SRC_URI[x86_64_v2_yggdrasil-worker-package-manager.sha256sum] = "9711ab87905ff3199234f134b120f45030ea6b96ec8bda8882e4fd481a132135"

URI_aarch64_yggdrasil-worker-package-manager = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yggdrasil-worker-package-manager-0.2.3-5.el10_1.aarch64.rpm;name=aarch64_yggdrasil-worker-package-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil-worker-package-manager}"
SRC_URI[aarch64_yggdrasil-worker-package-manager.sha256sum] = "3e84aaf54ad912a4462b74377f547f875adf6fb2675a4c881aae0f47a3ec5fff"

RDEPENDS:yggdrasil-worker-package-manager = " \
 bash \
 glibc \
 "
