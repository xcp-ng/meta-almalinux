# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vifm"
PV = "0.14.3"
PR = "1.el10_1"
PACKAGES = " \
 vifm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vifm-0.14.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b0b2177c308430a49f6df7e3c8f64c18ea99121a4f74e4439b61a5b3e53c9d9d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vifm-0.14.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vifm;unpack=0"
SRC_URI[x86_64_v2_vifm.sha256sum] = "93d98b3a42c04403cf37b01d394b78fe896a7bdb62b1d8906ef5beab1b219205"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vifm-0.14.3-1.el10_1.aarch64.rpm;name=aarch64_vifm;unpack=0"
SRC_URI[aarch64_vifm.sha256sum] = "8d3afc4aafd4293b29b781601ff098c162ecc8fef4225c6623a230bb456e4cfc"

RDEPENDS:vifm = " \
 bash \
 file-libs \
 glibc \
 hicolor-icon-theme \
 ncurses-libs \
 perl-interpreter \
 perl-libs \
 "
