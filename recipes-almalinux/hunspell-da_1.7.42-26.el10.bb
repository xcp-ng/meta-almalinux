# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-da"
PV = "1.7.42"
PR = "26.el10"
PACKAGES = " \
 hunspell-da \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-da-1.7.42-26.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d160ee57f9b2213198fabce896df50100c8fb2f02133d8d95e5fa04e41a7152"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-da-1.7.42-26.el10.noarch.rpm;name=x86_64_v2_hunspell-da;unpack=0"
SRC_URI[x86_64_v2_hunspell-da.sha256sum] = "76a4cdd63010ca07074c28525bc7808e31e08140dc0f4ee89983cad4450d8433"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-da-1.7.42-26.el10.noarch.rpm;name=aarch64_hunspell-da;unpack=0"
SRC_URI[aarch64_hunspell-da.sha256sum] = "76a4cdd63010ca07074c28525bc7808e31e08140dc0f4ee89983cad4450d8433"

RDEPENDS:hunspell-da = " \
 hunspell-filesystem \
 "
