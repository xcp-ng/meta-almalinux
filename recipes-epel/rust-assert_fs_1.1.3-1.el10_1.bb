# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_fs"
PV = "1.1.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-assert_fs+color-auto-devel \
 rust-assert_fs+color-devel \
 rust-assert_fs+default-devel \
 rust-assert_fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_fs-1.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adc87bc5e626e87d897439899cd9aa8d8202d86025479d251ae84c7093ccc121"

URI_x86_64_v2_rust-assert_fs+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+color-auto-devel-1.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+color-auto-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+color-auto-devel.sha256sum] = "e906e969abbe41aae2479b0bc2bbe4502d79c06e5a7b3a91a05473704cb7423c"

URI_x86_64_v2_rust-assert_fs+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+color-devel-1.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+color-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+color-devel.sha256sum] = "2376abf86e88bad78fb04d9a5d53f529e2bd6bcf66fa16e58a8b33d813038454"

URI_x86_64_v2_rust-assert_fs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs+default-devel-1.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs+default-devel}"
SRC_URI[x86_64_v2_rust-assert_fs+default-devel.sha256sum] = "b2b714c44c8148efae47b12e7d33dde4046b836b6d61dc979b7aa433ac669833"

URI_x86_64_v2_rust-assert_fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_fs-devel-1.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_fs-devel}"
SRC_URI[x86_64_v2_rust-assert_fs-devel.sha256sum] = "4a4fb74146917421415be90e46be6c85240dd12c939939c6213d29743738fdf7"

URI_aarch64_rust-assert_fs+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+color-auto-devel-1.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-assert_fs+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+color-auto-devel}"
SRC_URI[aarch64_rust-assert_fs+color-auto-devel.sha256sum] = "4ac65d1dd672be5667e4f1830e2264d05eb716e76e8586e7c9a8a2238397a2f3"

URI_aarch64_rust-assert_fs+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+color-devel-1.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-assert_fs+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+color-devel}"
SRC_URI[aarch64_rust-assert_fs+color-devel.sha256sum] = "43a6d4036295ff769cf1d1559aa7601914b8473b2ff03521745e5f556e999698"

URI_aarch64_rust-assert_fs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs+default-devel-1.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-assert_fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs+default-devel}"
SRC_URI[aarch64_rust-assert_fs+default-devel.sha256sum] = "a594c795fb48ca0e4fe3cab07f21d4d0d864ab9da7b045abc8a685ab16e4b3b9"

URI_aarch64_rust-assert_fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_fs-devel-1.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-assert_fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_fs-devel}"
SRC_URI[aarch64_rust-assert_fs-devel.sha256sum] = "2efa041379f23b922566e86960376562c1080fbc47570be1c7675366b7897339"

RDEPENDS:rust-assert_fs+color-auto-devel = " \
 cargo \
 rust-assert_fs+color-devel \
 rust-assert_fs-devel \
 "
RDEPENDS:rust-assert_fs+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-assert_fs-devel \
 rust-predicates+color-devel \
 "
RDEPENDS:rust-assert_fs+default-devel = " \
 cargo \
 rust-assert_fs-devel \
 "
RDEPENDS:rust-assert_fs-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-doc-comment+default-devel \
 rust-globwalk+default-devel \
 rust-predicates+diff-devel \
 rust-predicates-core+default-devel \
 rust-predicates-devel \
 rust-predicates-tree+default-devel \
 rust-tempfile+default-devel \
 "
