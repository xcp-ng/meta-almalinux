# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kguiaddons"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kguiaddons \
 kf6-kguiaddons-devel \
 kf6-kguiaddons-doc \
 kf6-kguiaddons-html \
 python3-kf6-kguiaddons \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kguiaddons-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "263ca04e8f6bf13d79548839bcd27b2cafa863f1514e28fae075f1966c86bfd9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons;unpack=0"
SRC_URI[x86_64_v2_kf6-kguiaddons.sha256sum] = "a9375c3b6331b0d8301b0c956681804dee3541b234261c49ec37d562e92f0285"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kguiaddons-devel.sha256sum] = "b680b1b5e8edd53e521b0554adbb4dc7719aa2107f9e2eb0032d64483c93a656"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kguiaddons-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kguiaddons-doc.sha256sum] = "b2ededcda207ef73ea76934e801bfc218693a268727ff88e500d6cfdceafae9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kguiaddons-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kguiaddons-html.sha256sum] = "ef7a4da240921ed3b8235697a2414ff77260f4f35128ec1942c51536e8b6d9ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kguiaddons-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kguiaddons;unpack=0"
SRC_URI[x86_64_v2_python3-kf6-kguiaddons.sha256sum] = "2e5c91d231358edb2f9cc4de22c0d45c8eb259ea44fd3dcdd06452acd0dd506b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kguiaddons;unpack=0"
SRC_URI[aarch64_kf6-kguiaddons.sha256sum] = "2ee508ae6441c44eadae7ef8101dce28ad3d4cde593ea01e2cc8cf8a89ef5124"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kguiaddons-devel;unpack=0"
SRC_URI[aarch64_kf6-kguiaddons-devel.sha256sum] = "9c512b82845e90067e39639aa919cc3e1f72a6c975fdb64b7fd471b1deff0d3b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kguiaddons-doc;unpack=0"
SRC_URI[aarch64_kf6-kguiaddons-doc.sha256sum] = "b6aa92e0516e02e61b4427f72da692a842b9fbcf98f82f7bbcfb5bed18db8775"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kguiaddons-html;unpack=0"
SRC_URI[aarch64_kf6-kguiaddons-html.sha256sum] = "4ac9b425b938574102f1fe8f8c193cc185c11d696475c2d59b1813cf5685b90d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kguiaddons-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kguiaddons;unpack=0"
SRC_URI[aarch64_python3-kf6-kguiaddons.sha256sum] = "a15dcf6b33f83bd9b9b6844cd7ab93164fdf6bbcbcfa63a3634bc3540474323e"

RDEPENDS:kf6-kguiaddons = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kguiaddons-devel = " \
 cmake-filesystem \
 kf6-kguiaddons \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kguiaddons-doc = " \
 "
RDEPENDS:kf6-kguiaddons-html = " \
 "
RDEPENDS:python3-kf6-kguiaddons = " \
 glibc \
 kf6-kguiaddons \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
