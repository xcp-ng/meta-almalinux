# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg_aliases"
PV = "0.2.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-cfg_aliases+default-devel \
 rust-cfg_aliases-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg_aliases-0.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00f81f1939cdd09bc3c3afdbfc338b6fadfe63e6b04bd7c7f2467e30c268dcdb"

URI_x86_64_v2_rust-cfg_aliases+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg_aliases+default-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg_aliases+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg_aliases+default-devel}"
SRC_URI[x86_64_v2_rust-cfg_aliases+default-devel.sha256sum] = "ace285126fea321c84e2fe5ffdcb54316a52ef88f5532429a8cb359d70bd3dfd"

URI_x86_64_v2_rust-cfg_aliases-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg_aliases-devel-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg_aliases-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg_aliases-devel}"
SRC_URI[x86_64_v2_rust-cfg_aliases-devel.sha256sum] = "d1be7c9336e3a71f975d2b140c12a3f6805a70f2c67ab01a093eea1e47cc6e9d"

URI_aarch64_rust-cfg_aliases+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg_aliases+default-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-cfg_aliases+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg_aliases+default-devel}"
SRC_URI[aarch64_rust-cfg_aliases+default-devel.sha256sum] = "9c753484ea1774b2be889298ab08a7eab2a9e42aae4ae624f1a3e4365538aaa0"

URI_aarch64_rust-cfg_aliases-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg_aliases-devel-0.2.2-1.el10_3.noarch.rpm;name=aarch64_rust-cfg_aliases-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg_aliases-devel}"
SRC_URI[aarch64_rust-cfg_aliases-devel.sha256sum] = "743a60dfcb19b4b76aa5e23b80cb223131feba6837c79eb36a9969ac1f554693"

RDEPENDS:rust-cfg_aliases+default-devel = " \
 cargo \
 rust-cfg_aliases-devel \
 "
RDEPENDS:rust-cfg_aliases-devel = " \
 cargo \
 "
