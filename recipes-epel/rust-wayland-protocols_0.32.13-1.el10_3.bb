# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-protocols"
PV = "0.32.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-protocols+server-devel \
 rust-wayland-protocols+staging-devel \
 rust-wayland-protocols+unstable-devel \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-protocols-0.32.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3fb37003b18897539a7152d95ab3ca77713e157a39fd5b1a64ff53a2b788cde1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+client-devel-0.32.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-protocols+client-devel.sha256sum] = "24bfc0b1a9cbc1b03e220ea8f106a66a72889b7575b8d8aa44c8811c6c259ab1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+default-devel-0.32.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-protocols+default-devel.sha256sum] = "22e8bd074899094efa903c5c67ead71c06ba50ce6e373185b9e401fdda99f2f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+server-devel-0.32.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-protocols+server-devel.sha256sum] = "be89500074c902c76f2e57532465068994c848ea6d49dd5b0fd2031fefd9f557"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+staging-devel-0.32.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-protocols+staging-devel.sha256sum] = "24066c7bbf855fc91d140e7f672e454ee686219b3e0f2a841818e6382ebb7e5e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+unstable-devel-0.32.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-protocols+unstable-devel.sha256sum] = "4dcc6b1adc83f37f85c622f7f0fc468db003c43f11d778e1a6d6ccd576161892"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-client-devel-0.32.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-client-devel.sha256sum] = "86cdf38c10dad02f18f7fb4b64c7f90b557f0cea27a12e3a08b7158f321d2792"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-server-devel-0.32.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-server-devel.sha256sum] = "5ec409c2c8dc4462e3f3d56f627064bea548588306cefe84a99d53b70233b964"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-devel-0.32.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-devel;unpack=0"
SRC_URI[x86_64_v2_rust-wayland-protocols-devel.sha256sum] = "bb44ef4e46089c88126fb3fe8aa0dd847f87295cfe2205493cca20d92758eaae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+client-devel-0.32.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-protocols+client-devel.sha256sum] = "6026c6dbe1c6681b2def35195bd60e6d102da182f5ef6048682007b56de3c183"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+default-devel-0.32.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-protocols+default-devel.sha256sum] = "ccfccd8de35de342fe9403b28957955497b0936e85a498163c3332edee5b6b56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+server-devel-0.32.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-protocols+server-devel.sha256sum] = "ff19134b0118ed5b796a6731dd1268e69fa17239aaefb818bc51801158c8d8cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+staging-devel-0.32.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-protocols+staging-devel.sha256sum] = "48484e7d18885abfd7203b58da7fc9d5573c9d56b148bed0068a684c69c6eb8f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+unstable-devel-0.32.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-protocols+unstable-devel.sha256sum] = "6f2dda5f8f28311bdbb9dff5c85d713903945b88af353bcfeb42375c2e62d0e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-client-devel-0.32.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-protocols+wayland-client-devel.sha256sum] = "24e4ad78afa15332e0064d737369fb69b2ad9cdeb6f3033e19df998b750d927c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-server-devel-0.32.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-protocols+wayland-server-devel.sha256sum] = "3eab651bbc85ce46a8a301ebab23ed42455ba626badc6e6197960f5bbe3513c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-devel-0.32.13-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols-devel;unpack=0"
SRC_URI[aarch64_rust-wayland-protocols-devel.sha256sum] = "9f21403c3d0786c9b8f635dc8710de9943a58cc8fc338e62ce5875129d75877c"

RDEPENDS:rust-wayland-protocols+client-devel = " \
 cargo \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+default-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+server-devel = " \
 cargo \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+staging-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+unstable-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-client-devel = " \
 cargo \
 rust-wayland-client+default-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-server-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 rust-wayland-server+default-devel \
 "
RDEPENDS:rust-wayland-protocols-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
