# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cap-std"
PV = "4.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-cap-std+camino-devel \
 rust-cap-std+default-devel \
 rust-cap-std+fs_utf8-devel \
 rust-cap-std-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cap-std-4.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1c8c0f9499056e1a94909b4f338926cd40d65c072db27de5d617c93a9753be4a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cap-std+camino-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cap-std+camino-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cap-std+camino-devel.sha256sum] = "55f66c350ccb4578f871ac9a25d08c0b91e070e9ca7fc1321c9f0200841c432b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cap-std+default-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cap-std+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cap-std+default-devel.sha256sum] = "ad29fa3152a1946cc0d5ba41984f0fecab414442d2a6d04eef80160ecd566d11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cap-std+fs_utf8-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cap-std+fs_utf8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cap-std+fs_utf8-devel.sha256sum] = "21a11fc9254245aeaa830739d4e5f100f6a2367e3ad0d77aa6f7a6ca247bf8d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cap-std-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cap-std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cap-std-devel.sha256sum] = "0191c4b04e5060e54be875277a7e94c5159215a607e9473f07f8dc52e6c9a1d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cap-std+camino-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-cap-std+camino-devel;unpack=0"
SRC_URI[aarch64_rust-cap-std+camino-devel.sha256sum] = "33b38c4e2979011a345fea0c21e462d3d09212689b1b3b904f19102a0468808e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cap-std+default-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-cap-std+default-devel;unpack=0"
SRC_URI[aarch64_rust-cap-std+default-devel.sha256sum] = "772cb2575f3b6f3a5c25d35f4451a340ba31c2c1a39fa987bce1a262de53ef82"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cap-std+fs_utf8-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-cap-std+fs_utf8-devel;unpack=0"
SRC_URI[aarch64_rust-cap-std+fs_utf8-devel.sha256sum] = "2661b03bb1e1eb009c21d065c7515da575068acfc7a27890973823ca2001164b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cap-std-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-cap-std-devel;unpack=0"
SRC_URI[aarch64_rust-cap-std-devel.sha256sum] = "6d885d7a4175a5e135f73e28e963af70b05cc4205de6e375c36869443792a55f"

RDEPENDS:rust-cap-std+camino-devel = " \
 cargo \
 rust-camino+default-devel \
 rust-cap-std-devel \
 "
RDEPENDS:rust-cap-std+default-devel = " \
 cargo \
 rust-cap-std-devel \
 "
RDEPENDS:rust-cap-std+fs_utf8-devel = " \
 cargo \
 rust-cap-std+camino-devel \
 rust-cap-std-devel \
 "
RDEPENDS:rust-cap-std-devel = " \
 cargo \
 rust-cap-primitives+default-devel \
 rust-io-extras+default-devel \
 rust-io-lifetimes-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 "
