# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing"
PV = "0.1.43"
PR = "1.el10_1"
PACKAGES = " \
 rust-tracing+async-await-devel \
 rust-tracing+attributes-devel \
 rust-tracing+default-devel \
 rust-tracing+log-always-devel \
 rust-tracing+log-devel \
 rust-tracing+max_level_debug-devel \
 rust-tracing+max_level_error-devel \
 rust-tracing+max_level_info-devel \
 rust-tracing+max_level_off-devel \
 rust-tracing+max_level_trace-devel \
 rust-tracing+max_level_warn-devel \
 rust-tracing+release_max_level_debug-devel \
 rust-tracing+release_max_level_error-devel \
 rust-tracing+release_max_level_info-devel \
 rust-tracing+release_max_level_off-devel \
 rust-tracing+release_max_level_trace-devel \
 rust-tracing+release_max_level_warn-devel \
 rust-tracing+std-devel \
 rust-tracing+tracing-attributes-devel \
 rust-tracing-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-0.1.43-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "299e6fe1743dbe2e6b7f9afdaf7c2118b01e851f0ff146e280c5f94059dd776e"

URI_x86_64_v2_rust-tracing+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+async-await-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+async-await-devel}"
SRC_URI[x86_64_v2_rust-tracing+async-await-devel.sha256sum] = "ad3d73aeb533a2819f95b8e3761ade1b76c20de7c081693af35c071255bb6d3a"

URI_x86_64_v2_rust-tracing+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+attributes-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing+attributes-devel.sha256sum] = "92f8ef91ce0e7ea58f670f74f865498666e07fafd507d585791a15205bd947d5"

URI_x86_64_v2_rust-tracing+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+default-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+default-devel}"
SRC_URI[x86_64_v2_rust-tracing+default-devel.sha256sum] = "15b409278b0cb59b7785d97a742ff5ae56d7458d4effff8377b372a041266000"

URI_x86_64_v2_rust-tracing+log-always-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+log-always-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+log-always-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+log-always-devel}"
SRC_URI[x86_64_v2_rust-tracing+log-always-devel.sha256sum] = "f849339dd93522fb0305d3778b25f70204b96fbf71289186bcac49a16806c112"

URI_x86_64_v2_rust-tracing+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+log-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+log-devel}"
SRC_URI[x86_64_v2_rust-tracing+log-devel.sha256sum] = "ac9853c86794267ead0b3a9735ae018fd4e0322d9a72dcaa318cb3d23e2de3a8"

URI_x86_64_v2_rust-tracing+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_debug-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_debug-devel.sha256sum] = "020b75387d7439dced4e3a63b471da5959639e67a09a475c46d0be20a5e16a5b"

URI_x86_64_v2_rust-tracing+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_error-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_error-devel.sha256sum] = "ceeb8b4ffe4f9ede15652ce63163eef45640045dc3792d3a0180d0c0a734fe90"

URI_x86_64_v2_rust-tracing+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_info-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_info-devel.sha256sum] = "651726a36fd4238ff523f6e14fc3865edee5c9b35114e4b5adb6732ccbc41ded"

URI_x86_64_v2_rust-tracing+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_off-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_off-devel.sha256sum] = "0832d33a9c6b2ca75d65669e9a4211ce4afce2ce7ebb12b4f243c0409a46609a"

URI_x86_64_v2_rust-tracing+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_trace-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_trace-devel.sha256sum] = "5d45a2c97132ebce60990bed6dd201294342cda9abc2b907099d31b3cdf691ab"

URI_x86_64_v2_rust-tracing+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_warn-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_warn-devel.sha256sum] = "6a855439ce3de202727dc428de36c68a16b36d5e83b4b6596716a28c5e42bc05"

URI_x86_64_v2_rust-tracing+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_debug-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_debug-devel.sha256sum] = "404b575dce255e3439303c8697a3befdc44811e5b9de9fb3e53e875d15fa5585"

URI_x86_64_v2_rust-tracing+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_error-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_error-devel.sha256sum] = "ad2693101999117a76fa9772cd3d8722c24ff95718a645a8c6b2f6327f9b5b0c"

URI_x86_64_v2_rust-tracing+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_info-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_info-devel.sha256sum] = "5b5fa88e371196a9022ae7382fd6d5e43d3253ca4f7b6f862af0fc07ce0105ab"

URI_x86_64_v2_rust-tracing+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_off-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_off-devel.sha256sum] = "111c9c787f3e9de4dec1d1d202157b8630b49e0303ca7f34343ba7649312bd51"

URI_x86_64_v2_rust-tracing+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_trace-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_trace-devel.sha256sum] = "01c97dae9ad8be39e02b21ed5aa44fc7192a36053013d94e79a02157e30d7e22"

URI_x86_64_v2_rust-tracing+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_warn-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_warn-devel.sha256sum] = "695a174063782d824ff8c3a9f7f7a01852f1ccfa38e1dc971ef70663ed6ac1b8"

URI_x86_64_v2_rust-tracing+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+std-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+std-devel}"
SRC_URI[x86_64_v2_rust-tracing+std-devel.sha256sum] = "dc1518d19ba33131fdc8b736ade3ed8c48f1f45faef6dcf97fbd33677493c52d"

URI_x86_64_v2_rust-tracing+tracing-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+tracing-attributes-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+tracing-attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing+tracing-attributes-devel.sha256sum] = "6fc94684464b03375131de5c9a0b519e5d9e77e182ae8cf36f1dd06e6e79d376"

URI_x86_64_v2_rust-tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-devel-0.1.43-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-devel}"
SRC_URI[x86_64_v2_rust-tracing-devel.sha256sum] = "548ec620ed6e4673ddcf315e9a10ec722f149164fe4b66faf5dbd1c976dae9f7"

URI_aarch64_rust-tracing+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+async-await-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+async-await-devel}"
SRC_URI[aarch64_rust-tracing+async-await-devel.sha256sum] = "d98aa032e81c3c7a162796c65eadadba9410ecf8750e64328c0e38089c181230"

URI_aarch64_rust-tracing+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+attributes-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+attributes-devel}"
SRC_URI[aarch64_rust-tracing+attributes-devel.sha256sum] = "5a30b52403cedc83068b748ee1c3b988f8c0c4b21606d9eb19411a8a9ba061a8"

URI_aarch64_rust-tracing+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+default-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+default-devel}"
SRC_URI[aarch64_rust-tracing+default-devel.sha256sum] = "8d8aa61c197fff5ef57781dd3b5ae10eaed737bc695a8be52f4d46fe07c1c5ec"

URI_aarch64_rust-tracing+log-always-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+log-always-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+log-always-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+log-always-devel}"
SRC_URI[aarch64_rust-tracing+log-always-devel.sha256sum] = "6974e985da4640a4609d1d7a664adaefb19f1d27ae957399b3ce5eaf50eea985"

URI_aarch64_rust-tracing+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+log-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+log-devel}"
SRC_URI[aarch64_rust-tracing+log-devel.sha256sum] = "c043e6d35fa8a88ffc35d83b4cda88cd7a4cdc41b34b5202571848b2a295f81f"

URI_aarch64_rust-tracing+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_debug-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_debug-devel}"
SRC_URI[aarch64_rust-tracing+max_level_debug-devel.sha256sum] = "60c16494a2ffad53ca0df1b01af59652bff33eba202663829ff29bfb63877a5a"

URI_aarch64_rust-tracing+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_error-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_error-devel}"
SRC_URI[aarch64_rust-tracing+max_level_error-devel.sha256sum] = "b9fc84ca7154fa757156c21a24037b4114b2ebc8b533bcaa93cbd9e0e471ea64"

URI_aarch64_rust-tracing+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_info-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_info-devel}"
SRC_URI[aarch64_rust-tracing+max_level_info-devel.sha256sum] = "9cb25ed7a213dffa716cbcdfaeb78b2c212e06d4c8712de074080d06a1f28f71"

URI_aarch64_rust-tracing+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_off-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_off-devel}"
SRC_URI[aarch64_rust-tracing+max_level_off-devel.sha256sum] = "15d91875a555c527b01fbae05419167b8a76eeef7a2c31b761e79f5bffeac2d0"

URI_aarch64_rust-tracing+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_trace-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_trace-devel}"
SRC_URI[aarch64_rust-tracing+max_level_trace-devel.sha256sum] = "618a0001c9db7f67dfa7e0ec18a39a16e87774e0b28d68753f7b6086bbacbc6e"

URI_aarch64_rust-tracing+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_warn-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_warn-devel}"
SRC_URI[aarch64_rust-tracing+max_level_warn-devel.sha256sum] = "899ce26f7bb072cdbbf348341158889ab5d4cd4c51b9170c6069489706694449"

URI_aarch64_rust-tracing+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_debug-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_debug-devel.sha256sum] = "891251ad6eaf16b1a05ab0516ff309337e9e841e3b3db942e6fc4bedee66b590"

URI_aarch64_rust-tracing+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_error-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_error-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_error-devel.sha256sum] = "dfa3bedd879930fc0372315387137f3ad25efe7f143977f4c7dd9a2a26066e94"

URI_aarch64_rust-tracing+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_info-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_info-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_info-devel.sha256sum] = "858e6f7368ae78c86aec6defe813418a112fc9211467c713a1a7643600df687f"

URI_aarch64_rust-tracing+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_off-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_off-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_off-devel.sha256sum] = "84e605c4bf1a7fa34a5b2f053c1504cab9562657e760af53ce571d08895f9089"

URI_aarch64_rust-tracing+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_trace-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_trace-devel.sha256sum] = "24ca5096f1eadf8f025f1ccd532d69c6ea1fbecdd634f563fa73d7cda3d2e566"

URI_aarch64_rust-tracing+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_warn-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_warn-devel.sha256sum] = "d5c7fbb352f4df8405a333ec0c00a24c4543ee3757f7aa9e712e48b0dfec1992"

URI_aarch64_rust-tracing+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+std-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+std-devel}"
SRC_URI[aarch64_rust-tracing+std-devel.sha256sum] = "90948f0f6927182ee345f50c4366b0bdd19b660e282ac6b741f5db2396601119"

URI_aarch64_rust-tracing+tracing-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+tracing-attributes-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing+tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+tracing-attributes-devel}"
SRC_URI[aarch64_rust-tracing+tracing-attributes-devel.sha256sum] = "5b995939e5df7dbf10677b68d129e063af00ebd07a2319debf60003f3bbc8058"

URI_aarch64_rust-tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-devel-0.1.43-1.el10_1.noarch.rpm;name=aarch64_rust-tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-devel}"
SRC_URI[aarch64_rust-tracing-devel.sha256sum] = "a5e5984747cc5d3e9136a0e7eab3d5b9da35c77f22563a12ce230fef6f68193b"

RDEPENDS:rust-tracing+async-await-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+attributes-devel = " \
 cargo \
 rust-tracing+tracing-attributes-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+default-devel = " \
 cargo \
 rust-tracing+attributes-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+log-always-devel = " \
 cargo \
 rust-tracing+log-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_debug-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_error-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_info-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_off-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_trace-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_warn-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_debug-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_error-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_info-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_off-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_trace-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_warn-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+std-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+tracing-attributes-devel = " \
 cargo \
 rust-tracing-attributes+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 rust-tracing-core-devel \
 "
