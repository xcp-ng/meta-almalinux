# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-ignore"
PV = "0.21.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-ignore+default-devel \
 rust-gix-ignore+document-features-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-ignore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-ignore-0.21.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f972ac7a7f0d22d7aaad866b2d1b534da667297c1c2d195ca92827ac9de9461"

URI_x86_64_v2_rust-gix-ignore+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+default-devel-0.21.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore+default-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore+default-devel.sha256sum] = "2cfd263383746f2209f370a6f662db830fa59f663f872b3ac56f13062ca9b883"

URI_x86_64_v2_rust-gix-ignore+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+document-features-devel-0.21.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore+document-features-devel.sha256sum] = "e8b3b21ebdbac8e4b68c7644c1b58f819693cc5b77de80467dcbbcc52c70ccfb"

URI_x86_64_v2_rust-gix-ignore+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+serde-devel-0.21.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore+serde-devel.sha256sum] = "fbd7ead52dca8cf77c9098b7e8f49c895e43b6fcc3c327416974e2b3b6641d6a"

URI_x86_64_v2_rust-gix-ignore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore-devel-0.21.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore-devel.sha256sum] = "fbc5ad7694e8c30face6b8509b978894e24a7593b29fc1e60a997a88adec7afd"

URI_aarch64_rust-gix-ignore+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+default-devel-0.21.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore+default-devel}"
SRC_URI[aarch64_rust-gix-ignore+default-devel.sha256sum] = "327f2fe35f4a501ed45912bb77178732953052cf6f478816451f4c9e79f0ddcf"

URI_aarch64_rust-gix-ignore+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+document-features-devel-0.21.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ignore+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore+document-features-devel}"
SRC_URI[aarch64_rust-gix-ignore+document-features-devel.sha256sum] = "3175e9d254c5a88ff46357876168c078cdcb3d118667aa8720247df34f6baaab"

URI_aarch64_rust-gix-ignore+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+serde-devel-0.21.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ignore+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore+serde-devel}"
SRC_URI[aarch64_rust-gix-ignore+serde-devel.sha256sum] = "b9fef9b44ed9724c82a896f6ac8d4543997f75a3971fe5a26be577729c19f2e4"

URI_aarch64_rust-gix-ignore-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore-devel-0.21.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore-devel}"
SRC_URI[aarch64_rust-gix-ignore-devel.sha256sum] = "5d27e793f89692b3b4e8f3270a75de75d5a476aa1fda3de32a82724edcac3920"

RDEPENDS:rust-gix-ignore+default-devel = " \
 cargo \
 rust-gix-ignore-devel \
 "
RDEPENDS:rust-gix-ignore+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-ignore-devel \
 "
RDEPENDS:rust-gix-ignore+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-glob+serde-devel \
 rust-gix-ignore-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-ignore-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-trace+default-devel \
 rust-unicode-bom+default-devel \
 "
