# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ouroboros"
PV = "0.18.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-ouroboros+default-devel \
 rust-ouroboros+std-devel \
 rust-ouroboros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ouroboros-0.18.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "261d0aaf9c4a91fc17819a185f12efe5c7dad927a58957b2ea5f3100438ed982"

URI_x86_64_v2_rust-ouroboros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros+default-devel-0.18.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros+default-devel}"
SRC_URI[x86_64_v2_rust-ouroboros+default-devel.sha256sum] = "01490229bed766be313183c0e931ed530bcfd5964d9c69c266e45493fcc2934e"

URI_x86_64_v2_rust-ouroboros+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros+std-devel-0.18.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros+std-devel}"
SRC_URI[x86_64_v2_rust-ouroboros+std-devel.sha256sum] = "a9d94fde9f3fd89c7783d1e4291e49330e4534dbc5e34f4ba7ecd8c3e07e9275"

URI_x86_64_v2_rust-ouroboros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ouroboros-devel-0.18.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ouroboros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ouroboros-devel}"
SRC_URI[x86_64_v2_rust-ouroboros-devel.sha256sum] = "28d06eb726b025f6c19c1510c1dd9aa3bbb15fb6237f60b586c20c5d54f67d6a"

URI_aarch64_rust-ouroboros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros+default-devel-0.18.5-1.el10_0.noarch.rpm;name=aarch64_rust-ouroboros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros+default-devel}"
SRC_URI[aarch64_rust-ouroboros+default-devel.sha256sum] = "ca4834d62a450bd43afdefbd8a0ff3cb0a6cb2bf3c75a6da940e8759d9a8d1b9"

URI_aarch64_rust-ouroboros+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros+std-devel-0.18.5-1.el10_0.noarch.rpm;name=aarch64_rust-ouroboros+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros+std-devel}"
SRC_URI[aarch64_rust-ouroboros+std-devel.sha256sum] = "7d97a470fa08cb5fff627115af67418c63637a1f0bc36bec9d5b4168e4afa130"

URI_aarch64_rust-ouroboros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ouroboros-devel-0.18.5-1.el10_0.noarch.rpm;name=aarch64_rust-ouroboros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ouroboros-devel}"
SRC_URI[aarch64_rust-ouroboros-devel.sha256sum] = "ad18765b4c29d61fdf983bd96846f6845cc4dd072cde8d664a242c3b4f86242c"

RDEPENDS:rust-ouroboros+default-devel = " \
 cargo \
 rust-ouroboros+std-devel \
 rust-ouroboros-devel \
 "
RDEPENDS:rust-ouroboros+std-devel = " \
 cargo \
 rust-ouroboros-devel \
 rust-ouroboros_macro+std-devel \
 "
RDEPENDS:rust-ouroboros-devel = " \
 cargo \
 rust-aliasable+default-devel \
 rust-ouroboros_macro+default-devel \
 rust-static_assertions+default-devel \
 "
