# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cap-primitives"
PV = "4.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-cap-primitives+arbitrary-devel \
 rust-cap-primitives+default-devel \
 rust-cap-primitives-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cap-primitives-4.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e0057555be851575d55c25dfeedf5dc013e306580ef3bf6dc5e72497301706f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cap-primitives+arbitrary-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cap-primitives+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cap-primitives+arbitrary-devel.sha256sum] = "bf306223d66e358d76933f78e78e9f962eb9a413d8d0c8492a4ec230271b1446"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cap-primitives+default-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cap-primitives+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cap-primitives+default-devel.sha256sum] = "9579a085f02925e344335b0d463a3dc869efe2641a8c12c52069c976db163037"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cap-primitives-devel-4.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cap-primitives-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cap-primitives-devel.sha256sum] = "0655fa0f16d862a68a169e00828fb65c976366967e54b2c3cd3ce65a24d991df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cap-primitives+arbitrary-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-cap-primitives+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-cap-primitives+arbitrary-devel.sha256sum] = "4484b87100a5c210a63d50442b4c102f135d1593668f1c59e140ab5d41cd7109"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cap-primitives+default-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-cap-primitives+default-devel;unpack=0"
SRC_URI[aarch64_rust-cap-primitives+default-devel.sha256sum] = "2487aca27501e5c0fc8b2ffb48241d8c37e6698666eb50ecce862f11faf5601d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cap-primitives-devel-4.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-cap-primitives-devel;unpack=0"
SRC_URI[aarch64_rust-cap-primitives-devel.sha256sum] = "12b4d78f32d64610610154a4089451cd1eb677ca7f0669295afa0a6081cd2fb8"

RDEPENDS:rust-cap-primitives+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-cap-primitives-devel \
 "
RDEPENDS:rust-cap-primitives+default-devel = " \
 cargo \
 rust-cap-primitives-devel \
 "
RDEPENDS:rust-cap-primitives-devel = " \
 cargo \
 rust-ambient-authority+default-devel \
 rust-fs-set-times+default-devel \
 rust-io-extras+default-devel \
 rust-io-lifetimes-devel \
 rust-ipnet+default-devel \
 rust-maybe-owned+default-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+process-devel \
 rust-rustix+termios-devel \
 rust-rustix+time-devel \
 rust-rustix-linux-procfs+default-devel \
 "
