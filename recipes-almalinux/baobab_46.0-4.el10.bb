# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baobab"
PV = "46.0"
PR = "4.el10"
PACKAGES = " \
 baobab \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/baobab-46.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b8357c8a0bf04d216be28fd154c19094e12ee48bc4adfd2075f02f3886763a0c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/baobab-46.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_baobab;unpack=0"
SRC_URI[x86_64_v2_baobab.sha256sum] = "b86fca69ed16704bf90ecaa2f04c27215920522bf7da5c6a9bbd4bfe0a307b65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/baobab-46.0-4.el10.aarch64.rpm;name=aarch64_baobab;unpack=0"
SRC_URI[aarch64_baobab.sha256sum] = "b6263c1e6845d1c5fa4dad936147513967f0a2f8d7f73a20a92b7aacac2ad8b7"

RDEPENDS:baobab = " \
 cairo \
 glib2 \
 glibc \
 gtk4 \
 libadwaita \
 pango \
 "
