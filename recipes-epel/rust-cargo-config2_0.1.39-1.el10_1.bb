# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-config2"
PV = "0.1.39"
PR = "1.el10_1"
PACKAGES = " \
 rust-cargo-config2+default-devel \
 rust-cargo-config2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-config2-0.1.39-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02f7a09f9c2d245d0f3f5a66e92c0b01e68e598ee75af76bd9d9806489c4f7ef"

URI_x86_64_v2_rust-cargo-config2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-config2+default-devel-0.1.39-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-config2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-config2+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-config2+default-devel.sha256sum] = "e45899882b2e2da47527becdaf4337887b756ccfdcb94354e2d83ce86ed99896"

URI_x86_64_v2_rust-cargo-config2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-config2-devel-0.1.39-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-config2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-config2-devel}"
SRC_URI[x86_64_v2_rust-cargo-config2-devel.sha256sum] = "3c4c57ce8697e21123daa96c79f081a416c08bea396ca1fe78f7f5a14c802bb7"

URI_aarch64_rust-cargo-config2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-config2+default-devel-0.1.39-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-config2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-config2+default-devel}"
SRC_URI[aarch64_rust-cargo-config2+default-devel.sha256sum] = "57be92a38c08cde22a792ad3db4aaff64e760d9dc23f5488b8effb0dc567d253"

URI_aarch64_rust-cargo-config2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-config2-devel-0.1.39-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-config2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-config2-devel}"
SRC_URI[aarch64_rust-cargo-config2-devel.sha256sum] = "bc662d5e5745d13f28878cb85238a749bf776bc198490cb36e61dc2aafc778fc"

RDEPENDS:rust-cargo-config2+default-devel = " \
 cargo \
 rust-cargo-config2-devel \
 "
RDEPENDS:rust-cargo-config2-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-toml+parse-devel \
 rust-toml+serde-devel \
 rust-toml-devel \
 "
