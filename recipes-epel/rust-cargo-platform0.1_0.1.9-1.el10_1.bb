# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-platform0.1"
PV = "0.1.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-cargo-platform0.1+default-devel \
 rust-cargo-platform0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-platform0.1-0.1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4b89e327d6b4f1f8875fda509c3f7a7f30b04eeb5144ff64f41fdc5a1aa8b43"

URI_x86_64_v2_rust-cargo-platform0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-platform0.1+default-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-platform0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-platform0.1+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-platform0.1+default-devel.sha256sum] = "4722068d1f89fd61c8b976922d41c470dd0d38f780072fbd15d84d60e7d90117"

URI_x86_64_v2_rust-cargo-platform0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-platform0.1-devel-0.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-platform0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-platform0.1-devel}"
SRC_URI[x86_64_v2_rust-cargo-platform0.1-devel.sha256sum] = "0eba312ca4bd1d97f8a13f5f4d96493d45a4d71d3c8a27b48b2ebf9ab64850ad"

URI_aarch64_rust-cargo-platform0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-platform0.1+default-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-platform0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-platform0.1+default-devel}"
SRC_URI[aarch64_rust-cargo-platform0.1+default-devel.sha256sum] = "0fca9f6ac303b88ea13bc185a00852057d5bc24166c46a031d7734849e8a57d3"

URI_aarch64_rust-cargo-platform0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-platform0.1-devel-0.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-platform0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-platform0.1-devel}"
SRC_URI[aarch64_rust-cargo-platform0.1-devel.sha256sum] = "03078f2741c3149fbcffb443fc659eb5eab5f63cb623629bfb4eccf9d384c383"

RDEPENDS:rust-cargo-platform0.1+default-devel = " \
 cargo \
 rust-cargo-platform0.1-devel \
 "
RDEPENDS:rust-cargo-platform0.1-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 "
