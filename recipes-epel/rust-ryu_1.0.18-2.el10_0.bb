# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ryu"
PV = "1.0.18"
PR = "2.el10_0"
PACKAGES = " \
 rust-ryu+default-devel \
 rust-ryu+no-panic-devel \
 rust-ryu+small-devel \
 rust-ryu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ryu-1.0.18-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5205686284f6183036e1cd3868a6566cf08e3a387e2b749c1df2eaf9f0534b1e"

URI_x86_64_v2_rust-ryu+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+default-devel-1.0.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+default-devel}"
SRC_URI[x86_64_v2_rust-ryu+default-devel.sha256sum] = "499300a98e5ce14d87b9b98630b78b403a1815045ad51a449bd42444e5139bb5"

URI_x86_64_v2_rust-ryu+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+no-panic-devel-1.0.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+no-panic-devel}"
SRC_URI[x86_64_v2_rust-ryu+no-panic-devel.sha256sum] = "ef9c81d08b1f5348f976627706b677ccce4fb698411dbf191442e67f64a93c52"

URI_x86_64_v2_rust-ryu+small-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+small-devel-1.0.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+small-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+small-devel}"
SRC_URI[x86_64_v2_rust-ryu+small-devel.sha256sum] = "8aac13bf4aa7934ffc824cff234e40334c212c72bbb2d510dbcf63c89553e6e7"

URI_x86_64_v2_rust-ryu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu-devel-1.0.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu-devel}"
SRC_URI[x86_64_v2_rust-ryu-devel.sha256sum] = "fa1f0b383470a9abcb18148b57276d683607b332ae90d6ec69d7cd3792fd0187"

URI_aarch64_rust-ryu+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+default-devel-1.0.18-2.el10_0.noarch.rpm;name=aarch64_rust-ryu+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+default-devel}"
SRC_URI[aarch64_rust-ryu+default-devel.sha256sum] = "4af5fe297f3e4e501a864313a96dabd2853688dee1a5c083997c99803be6263a"

URI_aarch64_rust-ryu+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+no-panic-devel-1.0.18-2.el10_0.noarch.rpm;name=aarch64_rust-ryu+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+no-panic-devel}"
SRC_URI[aarch64_rust-ryu+no-panic-devel.sha256sum] = "56d3aab3059caa5f05338ec2519a48079f0ee9fe747cefc131d6e884e417f242"

URI_aarch64_rust-ryu+small-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+small-devel-1.0.18-2.el10_0.noarch.rpm;name=aarch64_rust-ryu+small-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+small-devel}"
SRC_URI[aarch64_rust-ryu+small-devel.sha256sum] = "b5c49ae561e5a228ea577d412614f6289867bb17fdc8d67b871678443f0e5222"

URI_aarch64_rust-ryu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu-devel-1.0.18-2.el10_0.noarch.rpm;name=aarch64_rust-ryu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu-devel}"
SRC_URI[aarch64_rust-ryu-devel.sha256sum] = "4907cddfa7a797dab78fe04ed0886d3182d3a3f9a5bead65b707b62ab8b2c124"

RDEPENDS:rust-ryu+default-devel = " \
 cargo \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu+no-panic-devel = " \
 cargo \
 rust-no-panic+default-devel \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu+small-devel = " \
 cargo \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu-devel = " \
 cargo \
 rust \
 "
