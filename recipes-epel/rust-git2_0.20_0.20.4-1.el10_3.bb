# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-git2_0.20"
PV = "0.20.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-git2_0.20+default-devel \
 rust-git2_0.20+https-devel \
 rust-git2_0.20+openssl-probe-devel \
 rust-git2_0.20+openssl-sys-devel \
 rust-git2_0.20+ssh-devel \
 rust-git2_0.20+unstable-devel \
 rust-git2_0.20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-git2_0.20-0.20.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bf68da8f3667fe3288b2ebd3dbccc3d8ed2e4a9aaa941d26218d0fc6b23cff0"

URI_x86_64_v2_rust-git2_0.20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.20+default-devel-0.20.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.20+default-devel}"
SRC_URI[x86_64_v2_rust-git2_0.20+default-devel.sha256sum] = "1247be4ddb28f8c0bb75cda1c83f19606775c4bb4aa09336520b8778c6840cf8"

URI_x86_64_v2_rust-git2_0.20+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.20+https-devel-0.20.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.20+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.20+https-devel}"
SRC_URI[x86_64_v2_rust-git2_0.20+https-devel.sha256sum] = "d72bca3de9bd686b8ecc9711d376aaccc630fffff47dedf6f1a0a7a42919c20d"

URI_x86_64_v2_rust-git2_0.20+openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.20+openssl-probe-devel-0.20.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.20+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.20+openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-git2_0.20+openssl-probe-devel.sha256sum] = "4fd6d27bd2e7b5392069d836a06769966dddce549d929646784678d95ca06b89"

URI_x86_64_v2_rust-git2_0.20+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.20+openssl-sys-devel-0.20.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.20+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.20+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-git2_0.20+openssl-sys-devel.sha256sum] = "85085cb3555ec918fa65085624cce91003d861c214a7fa764e16e55c9f70ee9d"

URI_x86_64_v2_rust-git2_0.20+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.20+ssh-devel-0.20.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.20+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.20+ssh-devel}"
SRC_URI[x86_64_v2_rust-git2_0.20+ssh-devel.sha256sum] = "0220ab353574e066708a60f8bb5fb4a7198e698e9d65305986aae6a67d70e442"

URI_x86_64_v2_rust-git2_0.20+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.20+unstable-devel-0.20.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.20+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.20+unstable-devel}"
SRC_URI[x86_64_v2_rust-git2_0.20+unstable-devel.sha256sum] = "fe38478fca4d2f8244b93d35dce1a0085481e0ec4e53f7d893c68c11478184b5"

URI_x86_64_v2_rust-git2_0.20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-git2_0.20-devel-0.20.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-git2_0.20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-git2_0.20-devel}"
SRC_URI[x86_64_v2_rust-git2_0.20-devel.sha256sum] = "4de91b904c3e5a217ae2777c1080b5aaa56d8821aceff9950d863bb6c0a2a740"

URI_aarch64_rust-git2_0.20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.20+default-devel-0.20.4-1.el10_3.noarch.rpm;name=aarch64_rust-git2_0.20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.20+default-devel}"
SRC_URI[aarch64_rust-git2_0.20+default-devel.sha256sum] = "b8c7b9e60c12c9247f2c2ecb6d1a2ea51194c78eae09fa81ba6609c69a7c2a2b"

URI_aarch64_rust-git2_0.20+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.20+https-devel-0.20.4-1.el10_3.noarch.rpm;name=aarch64_rust-git2_0.20+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.20+https-devel}"
SRC_URI[aarch64_rust-git2_0.20+https-devel.sha256sum] = "ed3ceba958cf0e72e1b32dda0a75bcd64472a78e2fac6f1f6dd894df935ed7c5"

URI_aarch64_rust-git2_0.20+openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.20+openssl-probe-devel-0.20.4-1.el10_3.noarch.rpm;name=aarch64_rust-git2_0.20+openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.20+openssl-probe-devel}"
SRC_URI[aarch64_rust-git2_0.20+openssl-probe-devel.sha256sum] = "815ff7d1eb006a16c54ef1d06b1fa65e0fb542d70e8f2fbd1d62ca26a5ae75ff"

URI_aarch64_rust-git2_0.20+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.20+openssl-sys-devel-0.20.4-1.el10_3.noarch.rpm;name=aarch64_rust-git2_0.20+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.20+openssl-sys-devel}"
SRC_URI[aarch64_rust-git2_0.20+openssl-sys-devel.sha256sum] = "b5b24a6e5272f2aa10029e5c5babe1f6184b2a516361ebbda839543104628bc2"

URI_aarch64_rust-git2_0.20+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.20+ssh-devel-0.20.4-1.el10_3.noarch.rpm;name=aarch64_rust-git2_0.20+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.20+ssh-devel}"
SRC_URI[aarch64_rust-git2_0.20+ssh-devel.sha256sum] = "caaba695380c787f223cd140284dd0733c5bf0ef2d35aa3ed1e1f3469004c129"

URI_aarch64_rust-git2_0.20+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.20+unstable-devel-0.20.4-1.el10_3.noarch.rpm;name=aarch64_rust-git2_0.20+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.20+unstable-devel}"
SRC_URI[aarch64_rust-git2_0.20+unstable-devel.sha256sum] = "3c8f2a74217c08561074192a6b9bee77adc062232b521b9b9873f64f43d102a8"

URI_aarch64_rust-git2_0.20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-git2_0.20-devel-0.20.4-1.el10_3.noarch.rpm;name=aarch64_rust-git2_0.20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-git2_0.20-devel}"
SRC_URI[aarch64_rust-git2_0.20-devel.sha256sum] = "6ef14f7678f30d743f0f2ce3293aab37a0376c1a219bf7bbb9719f897f033aac"

RDEPENDS:rust-git2_0.20+default-devel = " \
 cargo \
 rust-git2_0.20+https-devel \
 rust-git2_0.20+ssh-devel \
 rust-git2_0.20-devel \
 "
RDEPENDS:rust-git2_0.20+https-devel = " \
 cargo \
 rust-git2_0.20+openssl-probe-devel \
 rust-git2_0.20+openssl-sys-devel \
 rust-git2_0.20-devel \
 rust-libgit2-sys+https-devel \
 "
RDEPENDS:rust-git2_0.20+openssl-probe-devel = " \
 cargo \
 rust-git2_0.20-devel \
 rust-openssl-probe0.1+default-devel \
 "
RDEPENDS:rust-git2_0.20+openssl-sys-devel = " \
 cargo \
 rust-git2_0.20-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-git2_0.20+ssh-devel = " \
 cargo \
 rust-git2_0.20-devel \
 rust-libgit2-sys+ssh-devel \
 "
RDEPENDS:rust-git2_0.20+unstable-devel = " \
 cargo \
 rust-git2_0.20-devel \
 "
RDEPENDS:rust-git2_0.20-devel = " \
 bash \
 cargo \
 rust-bitflags+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-log+default-devel \
 rust-url+default-devel \
 "
