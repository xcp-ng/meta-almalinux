# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-openvpn"
PE = "1"
PV = "1.12.5"
PR = "1.el10_2"
PACKAGES = " \
 NetworkManager-openvpn \
 NetworkManager-openvpn-gnome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-openvpn-1.12.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d0d620b8e233cad1c32d179dceba65d054ad4e9a6a22bd9df06a1d4105bdd4d"

URI_x86_64_v2_NetworkManager-openvpn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-openvpn-1.12.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-openvpn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-openvpn}"
SRC_URI[x86_64_v2_NetworkManager-openvpn.sha256sum] = "491e948d2a3050bca011fdee27c11ff4422e52409c4f21a1af5bb1aceba4bdb8"

URI_x86_64_v2_NetworkManager-openvpn-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-openvpn-gnome-1.12.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-openvpn-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-openvpn-gnome}"
SRC_URI[x86_64_v2_NetworkManager-openvpn-gnome.sha256sum] = "a039ed7f00bb65bb97a128b28bdc2513ec0fa56d6d38fd93a2c64b5b29f03945"

URI_aarch64_NetworkManager-openvpn = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-openvpn-1.12.5-1.el10_2.aarch64.rpm;name=aarch64_NetworkManager-openvpn;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-openvpn}"
SRC_URI[aarch64_NetworkManager-openvpn.sha256sum] = "39a294a81f19b09fc42d62415e3c6d44141d670ef9b0f2796c272c10aa0fdf02"

URI_aarch64_NetworkManager-openvpn-gnome = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-openvpn-gnome-1.12.5-1.el10_2.aarch64.rpm;name=aarch64_NetworkManager-openvpn-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-openvpn-gnome}"
SRC_URI[aarch64_NetworkManager-openvpn-gnome.sha256sum] = "a4584b141c3fab32e67cf0d02733edef6f2e8dbc9ef5f29759bab10a4bd28d6c"

RDEPENDS:NetworkManager-openvpn = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 dbus \
 glib2 \
 glibc \
 libgcc \
 openvpn \
 shadow-utils \
 "
RDEPENDS:NetworkManager-openvpn-gnome = " \
 NetworkManager-libnm \
 NetworkManager-openvpn \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 pango \
 shared-mime-info \
 vulkan-loader \
 "
