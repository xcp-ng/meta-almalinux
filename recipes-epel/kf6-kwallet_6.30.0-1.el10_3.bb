# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwallet"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kwallet \
 kf6-kwallet-devel \
 kf6-kwallet-doc \
 kf6-kwallet-html \
 kf6-kwallet-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kwallet-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0978a3bbba38f5990ef382f6e768cc5d3c9f0f78a29f4078c5e5b5441c5a8e3a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet;unpack=0"
SRC_URI[x86_64_v2_kf6-kwallet.sha256sum] = "abb268dea8c25f94230e8ec69fb29ff3a7ca027fd3e38e4858aa5f52567ee6a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kwallet-devel.sha256sum] = "2b7154b62464a7a107e97176892de891370b1afe82720b6d4079e6de1fe37ab1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwallet-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kwallet-doc.sha256sum] = "36a7e142d1447f52f8b1114620a12644e494d958a185fc5a620607b8ef31d94a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwallet-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kwallet-html.sha256sum] = "de1cb6766f06717bd14635933f007c3b04bb84c006fbfd014e005b6b1a2d3a30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-libs-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-libs;unpack=0"
SRC_URI[x86_64_v2_kf6-kwallet-libs.sha256sum] = "eea5fc0d6794d1f1c0228ecd03fc3d91ad3a9a886e05a5404101b388dff5c066"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwallet;unpack=0"
SRC_URI[aarch64_kf6-kwallet.sha256sum] = "9b82ae63b8184df00d4598e67f904b5afa76bff68ce7c69fce143a16ed727235"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwallet-devel;unpack=0"
SRC_URI[aarch64_kf6-kwallet-devel.sha256sum] = "0ec1bbcdb2687dc3e606dd4251dbfc06cc5f638de542a0a840d2388598a7e2a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwallet-doc;unpack=0"
SRC_URI[aarch64_kf6-kwallet-doc.sha256sum] = "cf014d8a178f9457072f3ca4ccf26f8676fcf571ed5d2872d07cd0dde8603d4a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwallet-html;unpack=0"
SRC_URI[aarch64_kf6-kwallet-html.sha256sum] = "7ea2f0c03c26145bd7ed220760a5cfbb112048968817e288d863ed248f8b8278"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-libs-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwallet-libs;unpack=0"
SRC_URI[aarch64_kf6-kwallet-libs.sha256sum] = "1b05b4044a4d5806455236c060fcf769577a000d387eb5a239f1d6447ca981ee"

RDEPENDS:kf6-kwallet = " \
 glib2 \
 glibc \
 gpgme2pp \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libgcc \
 libsecret \
 libstdc++ \
 pinentry-gnome3 \
 qca-qt6 \
 qca-qt6-ossl \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwallet-devel = " \
 cmake-filesystem \
 kf6-kwallet-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwallet-doc = " \
 "
RDEPENDS:kf6-kwallet-html = " \
 "
RDEPENDS:kf6-kwallet-libs = " \
 glibc \
 gpgme2pp \
 kf6-kconfig \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet \
 kf6-kwidgetsaddons \
 libgcrypt \
 libstdc++ \
 qt6-qtbase \
 "
