# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-email-validator"
PV = "2.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-email-validator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-email-validator-2.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc61ccd95fb03a028eabbf6e77411722772de843f66bd1c0d98d794cb9aaebf4"

URI_x86_64_v2_python3-email-validator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-email-validator-2.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-email-validator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-email-validator}"
SRC_URI[x86_64_v2_python3-email-validator.sha256sum] = "a89462096db5caa47a3d04ffbb3ebbccc41b86c51fa79cc129012b262b6a3a71"

URI_aarch64_python3-email-validator = "${EPEL_MIRROR}/aarch64/Packages/p/python3-email-validator-2.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-email-validator;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-email-validator}"
SRC_URI[aarch64_python3-email-validator.sha256sum] = "97d26f8931520dfd1305d1be405c5e4cc2770cd7f0e3f0e519402b99234e5ac1"

RDEPENDS:python3-email-validator = " \
 python3 \
 python3-dns \
 python3-idna \
 "
