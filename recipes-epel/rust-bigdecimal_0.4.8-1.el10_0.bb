# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bigdecimal"
PV = "0.4.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-bigdecimal+default-devel \
 rust-bigdecimal+serde-devel \
 rust-bigdecimal+serde-json-devel \
 rust-bigdecimal+serde_json-devel \
 rust-bigdecimal+std-devel \
 rust-bigdecimal+string-only-devel \
 rust-bigdecimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bigdecimal-0.4.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e16dff88a656403dc7a3144c9fac64bf98bf3ae90ab64ac8843c48e88621b1bb"

URI_x86_64_v2_rust-bigdecimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+default-devel-0.4.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+default-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+default-devel.sha256sum] = "d20f6dffdfb165421fc31483788f0b081329781398446dcc6eaeb05758794864"

URI_x86_64_v2_rust-bigdecimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde-devel-0.4.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde-devel.sha256sum] = "111f7ea3c74dbe357ad33da48689b759def2870b26f58610b181465a31705fe6"

URI_x86_64_v2_rust-bigdecimal+serde-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde-json-devel-0.4.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde-json-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde-json-devel.sha256sum] = "c01bb568e572541c8b605d513e7eacff6418a61a87afcafa0de0790f1a441ba8"

URI_x86_64_v2_rust-bigdecimal+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+serde_json-devel-0.4.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+serde_json-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+serde_json-devel.sha256sum] = "4a9d65768e787020e071ae467f2da932f0edc597d281f7374a9cfc7a12257c07"

URI_x86_64_v2_rust-bigdecimal+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+std-devel-0.4.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+std-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+std-devel.sha256sum] = "e9bbc594ae066175fbb661bb85930d898fb14f5690548c8836087f4e6fc1269a"

URI_x86_64_v2_rust-bigdecimal+string-only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal+string-only-devel-0.4.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal+string-only-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal+string-only-devel.sha256sum] = "8aecda4e04be7f9a743695be9ea1f07a79d45b090b01e108fa9b775e218256c5"

URI_x86_64_v2_rust-bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bigdecimal-devel-0.4.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-bigdecimal-devel.sha256sum] = "bf9f0fde72bada1ec2ac72a48e4e62f08d20f4f3f4331c576df8da04d984cb58"

URI_aarch64_rust-bigdecimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+default-devel-0.4.8-1.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+default-devel}"
SRC_URI[aarch64_rust-bigdecimal+default-devel.sha256sum] = "90171e158affb6fa2f77b4268067ea95ca5c1240dd4e9a97c6a550955a9fba78"

URI_aarch64_rust-bigdecimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde-devel-0.4.8-1.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde-devel.sha256sum] = "b634e65ffa633ee3422bf79d3c610c1e03468a1cb89c619087a79ab8a6b733c0"

URI_aarch64_rust-bigdecimal+serde-json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde-json-devel-0.4.8-1.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal+serde-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde-json-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde-json-devel.sha256sum] = "6e4d83fcdfcecceac3ad8d659598a099bca62edc8583bdccac05a77aba468cea"

URI_aarch64_rust-bigdecimal+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+serde_json-devel-0.4.8-1.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+serde_json-devel}"
SRC_URI[aarch64_rust-bigdecimal+serde_json-devel.sha256sum] = "a510f8590cd7b5b8e459e3d4e15bb0c1b224e7f1cdfef3cd8e3ec2d6a717eaa8"

URI_aarch64_rust-bigdecimal+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+std-devel-0.4.8-1.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+std-devel}"
SRC_URI[aarch64_rust-bigdecimal+std-devel.sha256sum] = "2eef15096ec5aa535a30cf1511ff197ddfbfe0f5dc4f7649f53ceade830f27c6"

URI_aarch64_rust-bigdecimal+string-only-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal+string-only-devel-0.4.8-1.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal+string-only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal+string-only-devel}"
SRC_URI[aarch64_rust-bigdecimal+string-only-devel.sha256sum] = "0b5ec7060a483629e88ce8b0b18623642876c4c2f2f1d408c79dbe5b7c8ad64b"

URI_aarch64_rust-bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bigdecimal-devel-0.4.8-1.el10_0.noarch.rpm;name=aarch64_rust-bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bigdecimal-devel}"
SRC_URI[aarch64_rust-bigdecimal-devel.sha256sum] = "1b399b918633b2b3ca69a2336b9883236b414978f5c2770799931621d440f8a8"

RDEPENDS:rust-bigdecimal+default-devel = " \
 cargo \
 rust-bigdecimal+std-devel \
 rust-bigdecimal-devel \
 "
RDEPENDS:rust-bigdecimal+serde-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bigdecimal+serde-json-devel = " \
 cargo \
 rust-bigdecimal+serde_json-devel \
 rust-bigdecimal-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bigdecimal+serde_json-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-serde_json+alloc-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-bigdecimal+std-devel = " \
 cargo \
 rust-bigdecimal-devel \
 rust-num-bigint+std-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-bigdecimal+string-only-devel = " \
 cargo \
 rust-bigdecimal-devel \
 "
RDEPENDS:rust-bigdecimal-devel = " \
 cargo \
 rust-autocfg+default-devel \
 rust-libm+default-devel \
 rust-num-bigint-devel \
 rust-num-integer-devel \
 rust-num-traits-devel \
 "
