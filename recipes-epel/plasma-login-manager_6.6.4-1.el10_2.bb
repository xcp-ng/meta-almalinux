# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-login-manager"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kcm-plasmalogin \
 plasma-login-manager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-login-manager-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca57d6f0188d5e4f8a3c418856bbd0713ca0b996c9a7cb2c3de5e09b21a17882"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - plasma-login-manager: kde-settings-plasma

URI_x86_64_v2_kcm-plasmalogin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcm-plasmalogin-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcm-plasmalogin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcm-plasmalogin}"
SRC_URI[x86_64_v2_kcm-plasmalogin.sha256sum] = "9e9f0d4d490f9f33a51deb84fdf366cdfc4b629b8fc553d1a9c16f6fa279fcbc"

URI_x86_64_v2_plasma-login-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-login-manager-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-login-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-login-manager}"
SRC_URI[x86_64_v2_plasma-login-manager.sha256sum] = "b7d994f9fc40ab14bbf93a1aa5437bf811f406c55f013319d6f44ca41b3be6fe"

URI_aarch64_kcm-plasmalogin = "${EPEL_MIRROR}/aarch64/Packages/k/kcm-plasmalogin-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kcm-plasmalogin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcm-plasmalogin}"
SRC_URI[aarch64_kcm-plasmalogin.sha256sum] = "bbf39f0fd978c9cdce19d216345677c22f203dc9d922fb91e443ba4ea6c2aa18"

URI_aarch64_plasma-login-manager = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-login-manager-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-login-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-login-manager}"
SRC_URI[aarch64_plasma-login-manager.sha256sum] = "4095b64eae6fd5f134ced7b18a40885caa871b5eb33a3c475dabc2124b103f52"

RDEPENDS:kcm-plasmalogin = " \
 dbus-common \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kpackage \
 kf6-kservice \
 libstdc++ \
 plasma-login-manager \
 plasma-systemsettings \
 polkit \
 qt6-filesystem \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-login-manager:x86_64_v2 = " \
 bash \
 glibc \
 kcm-plasmalogin \
 kf6-filesystem \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kimageformats \
 kf6-kpackage \
 kf6-kwindowsystem \
 kwin \
 layer-shell-qt \
 libXau \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 pam-libs \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 shadow-utils \
 systemd \
 systemd-libs \
"
RDEPENDS:plasma-login-manager:aarch64 = " \
 bash \
 glibc \
 kcm-plasmalogin \
 kde-settings-plasma \
 kf6-filesystem \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kimageformats \
 kf6-kpackage \
 kf6-kwindowsystem \
 kwin \
 layer-shell-qt \
 libXau \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 pam-libs \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 shadow-utils \
 systemd \
 systemd-libs \
"
