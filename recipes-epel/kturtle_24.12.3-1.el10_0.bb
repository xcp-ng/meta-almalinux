# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kturtle"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kturtle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kturtle-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5103302818d3a2b1784f433a134603f98b55d4d1a38bc2feae2a4a2b4230f36a"

URI_x86_64_v2_kturtle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kturtle-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kturtle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kturtle}"
SRC_URI[x86_64_v2_kturtle.sha256sum] = "b7b710d3cb92697fa19a67b80ab713e909b70e754cd1b646f59a4dbb528d5a67"

URI_aarch64_kturtle = "${EPEL_MIRROR}/aarch64/Packages/k/kturtle-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kturtle;unpack=0"
SRC_URI:append = " ${URI_aarch64_kturtle}"
SRC_URI[aarch64_kturtle.sha256sum] = "a744b7851e8bc326f11f7faf4dbfc5aea2fd9091e5d66f209f1155702fc03f3a"

RDEPENDS:kturtle = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
