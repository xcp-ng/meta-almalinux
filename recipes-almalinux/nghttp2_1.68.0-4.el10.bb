# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nghttp2"
PV = "1.68.0"
PR = "4.el10"
PACKAGES = " \
 libnghttp2 \
 libnghttp2-devel \
 nghttp2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nghttp2-1.68.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86e61fc0680258ff5af921f0022dd8a5018dd9aebb05e2c7e4ad64fb1be890fe"

URI_x86_64_v2_libnghttp2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnghttp2-1.68.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_libnghttp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnghttp2}"
SRC_URI[x86_64_v2_libnghttp2.sha256sum] = "e919d6d442aaec548088ffd0b9dcd32b631f7ed3f75d48a04410fa57a285965a"

URI_x86_64_v2_libnghttp2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnghttp2-devel-1.68.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_libnghttp2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnghttp2-devel}"
SRC_URI[x86_64_v2_libnghttp2-devel.sha256sum] = "802418f6094d87179cd1df48db430919068a04d09ac7aea67a769a09408f235a"

URI_x86_64_v2_nghttp2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nghttp2-1.68.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_nghttp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nghttp2}"
SRC_URI[x86_64_v2_nghttp2.sha256sum] = "e6ddae3a7ba23e7f7e4d30ebb220497047d3650545ebf5258396cb2d1bd36648"

URI_aarch64_libnghttp2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnghttp2-1.68.0-4.el10.aarch64.rpm;name=aarch64_libnghttp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnghttp2}"
SRC_URI[aarch64_libnghttp2.sha256sum] = "7f93b235745e5bd68f044550674b3aab4ff796648cbd9902ef8715c40787958f"

URI_aarch64_libnghttp2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnghttp2-devel-1.68.0-4.el10.aarch64.rpm;name=aarch64_libnghttp2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnghttp2-devel}"
SRC_URI[aarch64_libnghttp2-devel.sha256sum] = "3d9348b9447fc04ec3c2909a46f646b8c1b299613bf9af341c21c20b33cdc602"

URI_aarch64_nghttp2 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nghttp2-1.68.0-4.el10.aarch64.rpm;name=aarch64_nghttp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_nghttp2}"
SRC_URI[aarch64_nghttp2.sha256sum] = "7e48ddeec3cc792cffe8adb69955d19cb665604a92bcf20dbc7098176bdcbbc9"

RDEPENDS:libnghttp2 = " \
 glibc \
 "
RDEPENDS:libnghttp2-devel = " \
 libnghttp2 \
 pkgconf-pkg-config \
 "
RDEPENDS:nghttp2 = " \
 bash \
 c-ares \
 glibc \
 libev \
 libgcc \
 libnghttp2 \
 libstdc++ \
 libxml2 \
 openssl-libs \
 systemd \
 zlib-ng-compat \
 "
