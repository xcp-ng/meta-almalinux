# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-newtype-uuid"
PV = "1.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-newtype-uuid+alloc-devel \
 rust-newtype-uuid+default-devel \
 rust-newtype-uuid+proptest1-devel \
 rust-newtype-uuid+schemars08-devel \
 rust-newtype-uuid+serde-devel \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid+v4-devel \
 rust-newtype-uuid+v7-devel \
 rust-newtype-uuid-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-newtype-uuid-1.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9b1eb510e9df796164205ce3744466b52bdd99add30180d6aff42520d4b22d08"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+alloc-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+alloc-devel.sha256sum] = "0a998248f1619f2941ccb94fcbac2c41ab986b67c8e772e9bb7fa4a796b5ea65"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+default-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+default-devel.sha256sum] = "12a66c83f038382e44a4f0ec6acf0a0b5930e53d5d0dffc30262514a64e5d582"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+proptest1-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+proptest1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+proptest1-devel.sha256sum] = "4dd6f96c863bfc45961b61c659c7fd10427ce6430513c7668f66c634c28b8ee8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+schemars08-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+schemars08-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+schemars08-devel.sha256sum] = "05209096a3672f886924d57cc2d432bc027b25c546116b925bb7cf736906c306"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+serde-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+serde-devel.sha256sum] = "a3001190deb963c1fc3c8006b010b9aa801d559b43e9a2712d8a7d9fc1fd7a07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+std-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+std-devel.sha256sum] = "c4f94eff252afc8c540e7bd46f2d0e4818e9a1869bd675977af6783d58761a9d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+v4-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+v4-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+v4-devel.sha256sum] = "548b6033ddf652655b9293491e87e2abcf8983db5ef26c596df5cad7f581c6cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid+v7-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid+v7-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid+v7-devel.sha256sum] = "0a0455aaef1c455cca6fbb075cdd1ea46b6d34d9855909f7669587fe1553e281"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-newtype-uuid-devel-1.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-newtype-uuid-devel;unpack=0"
SRC_URI[x86_64_v2_rust-newtype-uuid-devel.sha256sum] = "7310848491e6a554a60ce47278c5908d462f4c1e53ef64921b1da77d14f81bef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+alloc-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-newtype-uuid+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+alloc-devel.sha256sum] = "1ece665178f0604ad1884886ccc95b03a013f78f54b011b536b8300a62dde0e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+default-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-newtype-uuid+default-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+default-devel.sha256sum] = "ec4713f8d2558c34dd199a3ecd1a24850ad97cd935aaa1ecd2b7cdff3c950470"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+proptest1-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-newtype-uuid+proptest1-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+proptest1-devel.sha256sum] = "169b94410fe24f86a5ff93e978978fa6a9d7ccbe8693a5d27b97e34b0a6af8b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+schemars08-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-newtype-uuid+schemars08-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+schemars08-devel.sha256sum] = "e3c5e6f3a1a8dad0b1a651a3e7eaa714b5b01cb0d3d61ae582afbeaa3e6bd9ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+serde-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-newtype-uuid+serde-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+serde-devel.sha256sum] = "1883cfae89b66c2759a7bbd23ba98fca5373637d19ed5da6e6b72b50bec30685"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+std-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-newtype-uuid+std-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+std-devel.sha256sum] = "f120d328e055b6882cce746190f933c7a27fbc630518fe97361a642a5b504ff3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+v4-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-newtype-uuid+v4-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+v4-devel.sha256sum] = "b0e8f6bcc55f7ef52d6acefb30980786924539cbfb34a9e344ae7a45ebdfe376"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid+v7-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-newtype-uuid+v7-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid+v7-devel.sha256sum] = "f2511f5ba634cac31709b8e38c67c39f715bb19bb0bd19e2eeba23e7435a3d79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-newtype-uuid-devel-1.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-newtype-uuid-devel;unpack=0"
SRC_URI[aarch64_rust-newtype-uuid-devel.sha256sum] = "c886477c7cb95da3ec4ae750184a588511c8e247ce73ef9206554d71392a3f0b"

RDEPENDS:rust-newtype-uuid+alloc-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 "
RDEPENDS:rust-newtype-uuid+default-devel = " \
 cargo \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-newtype-uuid+proptest1-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-proptest+std-devel \
 rust-proptest-devel \
 "
RDEPENDS:rust-newtype-uuid+schemars08-devel = " \
 cargo \
 rust-newtype-uuid+std-devel \
 rust-newtype-uuid-devel \
 rust-schemars0.8+default-devel \
 rust-schemars0.8+uuid1-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-newtype-uuid+serde-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-uuid+serde-devel \
 "
RDEPENDS:rust-newtype-uuid+std-devel = " \
 cargo \
 rust-newtype-uuid+alloc-devel \
 rust-newtype-uuid-devel \
 rust-uuid+std-devel \
 "
RDEPENDS:rust-newtype-uuid+v4-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-uuid+v4-devel \
 "
RDEPENDS:rust-newtype-uuid+v7-devel = " \
 cargo \
 rust-newtype-uuid-devel \
 rust-uuid+v7-devel \
 "
RDEPENDS:rust-newtype-uuid-devel = " \
 cargo \
 rust \
 rust-uuid-devel \
 "
