# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blake3"
PV = "1.8.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-blake3+default-devel \
 rust-blake3+digest-devel \
 rust-blake3+mmap-devel \
 rust-blake3+neon-devel \
 rust-blake3+no_avx2-devel \
 rust-blake3+no_avx512-devel \
 rust-blake3+no_neon-devel \
 rust-blake3+no_sse2-devel \
 rust-blake3+no_sse41-devel \
 rust-blake3+prefer_intrinsics-devel \
 rust-blake3+pure-devel \
 rust-blake3+rayon-devel \
 rust-blake3+serde-devel \
 rust-blake3+std-devel \
 rust-blake3+traits-preview-devel \
 rust-blake3+zeroize-devel \
 rust-blake3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blake3-1.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac63856540be62172a6f62a7ed8d45016910a205ff0ff5a44c76f364e9351fbf"

URI_x86_64_v2_rust-blake3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+default-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+default-devel}"
SRC_URI[x86_64_v2_rust-blake3+default-devel.sha256sum] = "764ebe6711a991acb234bb6c34cbbc5aadb6de3f22bf160e20c9c8018a63c28d"

URI_x86_64_v2_rust-blake3+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+digest-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+digest-devel}"
SRC_URI[x86_64_v2_rust-blake3+digest-devel.sha256sum] = "20d31bb565c807c99e6f5c02cff1fd9d7aab55256dafc75e80b6a1758a034f6e"

URI_x86_64_v2_rust-blake3+mmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+mmap-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+mmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+mmap-devel}"
SRC_URI[x86_64_v2_rust-blake3+mmap-devel.sha256sum] = "db745242cd7ad6bfd945cae0b7cef0cba89931079859cee6d099332bd07dbff3"

URI_x86_64_v2_rust-blake3+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+neon-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+neon-devel}"
SRC_URI[x86_64_v2_rust-blake3+neon-devel.sha256sum] = "2734ec3d9ba2d9ce845b1cc6bc5aa96e2e2e0405c6035c3ef07128a15fb11d83"

URI_x86_64_v2_rust-blake3+no_avx2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_avx2-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_avx2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_avx2-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_avx2-devel.sha256sum] = "aca8e422eeeed7a5c95a521d2db6d8a32662742a9dc0f9592d55fc5b34cb8d83"

URI_x86_64_v2_rust-blake3+no_avx512-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_avx512-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_avx512-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_avx512-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_avx512-devel.sha256sum] = "e9f91d5209c2aabc969e06ecbbe3da9d796b91caa2af8f5525ddd7f09860d9e2"

URI_x86_64_v2_rust-blake3+no_neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_neon-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_neon-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_neon-devel.sha256sum] = "ff81d21c942f68e4ff432ae147f7cfa289401242282fd7c60c7f31dc5a68e3f3"

URI_x86_64_v2_rust-blake3+no_sse2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_sse2-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_sse2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_sse2-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_sse2-devel.sha256sum] = "e6ceacd268fe8e5e10e7266e4353ba30002e40fddf7f2a3836636d9d79bddee2"

URI_x86_64_v2_rust-blake3+no_sse41-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+no_sse41-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+no_sse41-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+no_sse41-devel}"
SRC_URI[x86_64_v2_rust-blake3+no_sse41-devel.sha256sum] = "b8dd45c9b4fd892bd3d7a1d05d7dd83ac3eadc267a424704d24baf5de383fbf1"

URI_x86_64_v2_rust-blake3+prefer_intrinsics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+prefer_intrinsics-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+prefer_intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+prefer_intrinsics-devel}"
SRC_URI[x86_64_v2_rust-blake3+prefer_intrinsics-devel.sha256sum] = "0f8e211f3b19883a440940a7c85616942cc00ec684010c68f1c5bf71429c87b8"

URI_x86_64_v2_rust-blake3+pure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+pure-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+pure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+pure-devel}"
SRC_URI[x86_64_v2_rust-blake3+pure-devel.sha256sum] = "e2f24bd3fd38a042a6ab652ad8ca17077b96798049cfb154c4091211bdcc181f"

URI_x86_64_v2_rust-blake3+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+rayon-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+rayon-devel}"
SRC_URI[x86_64_v2_rust-blake3+rayon-devel.sha256sum] = "7740dc6af09ccdfa06ad98a4f56a68324b6a7cd76b348e61c1c9fd49e19ab3e2"

URI_x86_64_v2_rust-blake3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+serde-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+serde-devel}"
SRC_URI[x86_64_v2_rust-blake3+serde-devel.sha256sum] = "c374e5bdc14b5ed1dd6b7c053512062b0fd31f6c3bcb0f9e69f4eed13bc50b33"

URI_x86_64_v2_rust-blake3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+std-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+std-devel}"
SRC_URI[x86_64_v2_rust-blake3+std-devel.sha256sum] = "25024fc151d28e5d73eed20ab91453e654d61821952e82109f3ff587392b1a60"

URI_x86_64_v2_rust-blake3+traits-preview-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+traits-preview-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+traits-preview-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+traits-preview-devel}"
SRC_URI[x86_64_v2_rust-blake3+traits-preview-devel.sha256sum] = "7df6ba12775f9a90401eeef13a50117e57d06c479991ca06e778423fd9e3a2cb"

URI_x86_64_v2_rust-blake3+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+zeroize-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3+zeroize-devel}"
SRC_URI[x86_64_v2_rust-blake3+zeroize-devel.sha256sum] = "b70a10724659177ffa5c17dd6f719a7a7c34f7a01a813b4ef4ba778c01d7638e"

URI_x86_64_v2_rust-blake3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3-devel-1.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blake3-devel}"
SRC_URI[x86_64_v2_rust-blake3-devel.sha256sum] = "d806732fd852df9a41dfe26cd90fd3958d58440fa395025b40197fbb91695f94"

URI_aarch64_rust-blake3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+default-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+default-devel}"
SRC_URI[aarch64_rust-blake3+default-devel.sha256sum] = "27ed3d3665197e88be579fb838a2405a96521857abd36f0b7a17f3fbbae99af7"

URI_aarch64_rust-blake3+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+digest-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+digest-devel}"
SRC_URI[aarch64_rust-blake3+digest-devel.sha256sum] = "82ecbe60d15f1393427a9247127fa01d2f8ae21e4e77f33c34835761a00aeb32"

URI_aarch64_rust-blake3+mmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+mmap-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+mmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+mmap-devel}"
SRC_URI[aarch64_rust-blake3+mmap-devel.sha256sum] = "b4c03790a86dbf6c2801b83e7dc30982c82520ed2f426a9ff9763dfdfb290299"

URI_aarch64_rust-blake3+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+neon-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+neon-devel}"
SRC_URI[aarch64_rust-blake3+neon-devel.sha256sum] = "589ea3f9ce6130ea55baa2b704cedd4527efcc9c83fe5e3a1bbb1871ed45af0e"

URI_aarch64_rust-blake3+no_avx2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_avx2-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+no_avx2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_avx2-devel}"
SRC_URI[aarch64_rust-blake3+no_avx2-devel.sha256sum] = "98ee167567ba231bb9874f4c15202a9d48f3e3c6484fcd0c726fcd5f2a5ef668"

URI_aarch64_rust-blake3+no_avx512-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_avx512-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+no_avx512-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_avx512-devel}"
SRC_URI[aarch64_rust-blake3+no_avx512-devel.sha256sum] = "767851af64d6ed8b350d9b49ab7b10c086745666b1f49333df02e889a0b4c30c"

URI_aarch64_rust-blake3+no_neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_neon-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+no_neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_neon-devel}"
SRC_URI[aarch64_rust-blake3+no_neon-devel.sha256sum] = "3b55a2defefcc8a96ab03d984cb7269b71e7bc5fb72ea161c8a7f95f64344dd0"

URI_aarch64_rust-blake3+no_sse2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_sse2-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+no_sse2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_sse2-devel}"
SRC_URI[aarch64_rust-blake3+no_sse2-devel.sha256sum] = "5967939671468b2bc44a2def0be1c0a1b53d6f9ff99b4442ae8d684f248ec232"

URI_aarch64_rust-blake3+no_sse41-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+no_sse41-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+no_sse41-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+no_sse41-devel}"
SRC_URI[aarch64_rust-blake3+no_sse41-devel.sha256sum] = "3b934e3a9caaa08ef0ce333854c838b6fdc38e7fedcc7c2bc0502c9a3148a1f1"

URI_aarch64_rust-blake3+prefer_intrinsics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+prefer_intrinsics-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+prefer_intrinsics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+prefer_intrinsics-devel}"
SRC_URI[aarch64_rust-blake3+prefer_intrinsics-devel.sha256sum] = "a6a0a1ea45d701ff34dfc4ba7aeefb5f2cce8d04204b5139f7a9ba37cd06ad04"

URI_aarch64_rust-blake3+pure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+pure-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+pure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+pure-devel}"
SRC_URI[aarch64_rust-blake3+pure-devel.sha256sum] = "38193f4245723ca09a11733b1243c01c775692650f50152984e4c354367072df"

URI_aarch64_rust-blake3+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+rayon-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+rayon-devel}"
SRC_URI[aarch64_rust-blake3+rayon-devel.sha256sum] = "db2e0cadc2ae1a6ad9f30fb1f18282fc700ffed884ca7721a1cacb8bfb88b5b2"

URI_aarch64_rust-blake3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+serde-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+serde-devel}"
SRC_URI[aarch64_rust-blake3+serde-devel.sha256sum] = "cf98adde23e59d6059b9f8bef784eb7a0a972f8ad1c6d44129eb9c5eb6fe2a7c"

URI_aarch64_rust-blake3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+std-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+std-devel}"
SRC_URI[aarch64_rust-blake3+std-devel.sha256sum] = "5529897ff25c4977b0a5bc5b916e0873b420a0664c9931b2dcddca57886bd2b5"

URI_aarch64_rust-blake3+traits-preview-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+traits-preview-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+traits-preview-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+traits-preview-devel}"
SRC_URI[aarch64_rust-blake3+traits-preview-devel.sha256sum] = "3540b051ebd7f46f73504ff628c6ca253687cbbc2138a82e5c8bc6e31260de23"

URI_aarch64_rust-blake3+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+zeroize-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3+zeroize-devel}"
SRC_URI[aarch64_rust-blake3+zeroize-devel.sha256sum] = "a05e1e82b251e022f02565a518ea41aa083b7967d7082e263483a377f8aef0c8"

URI_aarch64_rust-blake3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3-devel-1.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-blake3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blake3-devel}"
SRC_URI[aarch64_rust-blake3-devel.sha256sum] = "1215d1cd38b69dd24e9c31a312cf3095f1a1efd329041101bcfd53fc48763aff"

RDEPENDS:rust-blake3+default-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+digest-devel = " \
 cargo \
 rust-blake3-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
RDEPENDS:rust-blake3+mmap-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 rust-memmap2+default-devel \
 "
RDEPENDS:rust-blake3+neon-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_avx2-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_avx512-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_neon-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_sse2-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+no_sse41-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+prefer_intrinsics-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+pure-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+rayon-devel = " \
 cargo \
 rust-blake3-devel \
 rust-rayon-core+default-devel \
 "
RDEPENDS:rust-blake3+serde-devel = " \
 cargo \
 rust-blake3-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-blake3+std-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+traits-preview-devel = " \
 cargo \
 rust-blake3-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 "
RDEPENDS:rust-blake3+zeroize-devel = " \
 cargo \
 rust-arrayvec+zeroize-devel \
 rust-blake3-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-blake3-devel = " \
 cargo \
 python3 \
 rust-arrayref+default-devel \
 rust-arrayvec-devel \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-constant_time_eq-devel \
 "
