# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-mime"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 akonadi-mime \
 akonadi-mime-devel \
 akonadi-mime-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-mime-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c18b6207cb50c08ed82dd30293f54147d6c4033e7562d65c0d0479f21ca7519e"

URI_x86_64_v2_akonadi-mime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime}"
SRC_URI[x86_64_v2_akonadi-mime.sha256sum] = "1a9d0829944f4ee48ed1efa483f00673c212fe591a6ea105942effcf7ebe136d"

URI_x86_64_v2_akonadi-mime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-mime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime-devel}"
SRC_URI[x86_64_v2_akonadi-mime-devel.sha256sum] = "9457feebfaff54f818b70abc74474717d65e1b1d42bdcf766657cb2cd842cc2a"

URI_x86_64_v2_akonadi-mime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-mime-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-mime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-mime-doc}"
SRC_URI[x86_64_v2_akonadi-mime-doc.sha256sum] = "07feed0d1f6bf1c7844b3c2ea8951ce548c97073f3b0be382382d4f6eee5ac88"

URI_aarch64_akonadi-mime = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-mime;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime}"
SRC_URI[aarch64_akonadi-mime.sha256sum] = "a218852d4ba9ae92fa6092e220137396d3387c2070947e3286ec185c23ddab0d"

URI_aarch64_akonadi-mime-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-mime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime-devel}"
SRC_URI[aarch64_akonadi-mime-devel.sha256sum] = "44b6b5f3dd9cc4f72ea34bbb0da7c71237b460b31d842ea10ff946b73486de4b"

URI_aarch64_akonadi-mime-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-mime-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_akonadi-mime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-mime-doc}"
SRC_URI[aarch64_akonadi-mime-doc.sha256sum] = "bba5b48dac9b8a96db1a64e669d29e826e9afc9d28fa5c711405e214633ecf33"

RDEPENDS:akonadi-mime = " \
 akonadi-server \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:akonadi-mime-devel = " \
 akonadi-mime \
 akonadi-server-devel \
 cmake-filesystem \
 "
RDEPENDS:akonadi-mime-doc = " \
 "
