# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nptyping"
PV = "2.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-nptyping \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-nptyping-2.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "60205a86fc93e0d80a82fb17b139960eb325286f04cbad1fdfec1546bf46e0f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nptyping-2.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-nptyping;unpack=0"
SRC_URI[x86_64_v2_python3-nptyping.sha256sum] = "405da1859afaba71ab84cd160b08546eb9c59ac6d6b274d696d02490f87a4b80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-nptyping-2.5.0-1.el10_0.noarch.rpm;name=aarch64_python3-nptyping;unpack=0"
SRC_URI[aarch64_python3-nptyping.sha256sum] = "aa970d101bcd72cd44fc57e507c6fb989938289000391c92d251c6110aa69416"

RDEPENDS:python3-nptyping = " \
 python3 \
 python3-numpy \
 "
