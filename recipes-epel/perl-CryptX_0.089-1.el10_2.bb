# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CryptX"
PV = "0.089"
PR = "1.el10_2"
PACKAGES = " \
 perl-CryptX \
 perl-CryptX-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CryptX-0.089-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c84ac81ae9b173e215865ddbb2765f53db3b319ae5fcab3dc045b2172176b388"

URI_x86_64_v2_perl-CryptX = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CryptX-0.089-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-CryptX;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CryptX}"
SRC_URI[x86_64_v2_perl-CryptX.sha256sum] = "189778d1359b2d915fc0cf33e8cb5095425212cc3463b7064ca5ffc0b454866c"

URI_x86_64_v2_perl-CryptX-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CryptX-tests-0.089-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CryptX-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CryptX-tests}"
SRC_URI[x86_64_v2_perl-CryptX-tests.sha256sum] = "b4d6d70e033b3d379f7f915c041f1d13cd6d77493216193361c2d4c879e9a72c"

URI_aarch64_perl-CryptX = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CryptX-0.089-1.el10_2.aarch64.rpm;name=aarch64_perl-CryptX;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CryptX}"
SRC_URI[aarch64_perl-CryptX.sha256sum] = "598eb4d417e67b72674c4bced9be26838e5e6ff49ca5c69504a946c91df0a2ba"

URI_aarch64_perl-CryptX-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CryptX-tests-0.089-1.el10_2.noarch.rpm;name=aarch64_perl-CryptX-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CryptX-tests}"
SRC_URI[aarch64_perl-CryptX-tests.sha256sum] = "9277946b574cabd3ce8a45c38eaa634cc251fde16c53c06b7cc1da286c543652"

RDEPENDS:perl-CryptX = " \
 glibc \
 perl-Carp \
 perl-CryptX \
 perl-Exporter \
 perl-Time-HiRes \
 perl-base \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-CryptX-tests = " \
 bash \
 perl-CryptX \
 perl-Data-Dumper \
 perl-File-Find \
 perl-IO \
 perl-JSON \
 perl-Math-BigInt \
 perl-Math-Complex \
 perl-POSIX \
 perl-Storable \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 perl-overload \
 virtual/coreutils \
 "
