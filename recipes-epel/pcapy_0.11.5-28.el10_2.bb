# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcapy"
PV = "0.11.5"
PR = "28.el10_2"
PACKAGES = " \
 python3-pcapy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pcapy-0.11.5-28.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d0fc32865503e3da6f1c276d721c80fb4f4bb75a42968c2bc809725c4ecc44a"

URI_x86_64_v2_python3-pcapy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pcapy-0.11.5-28.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pcapy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pcapy}"
SRC_URI[x86_64_v2_python3-pcapy.sha256sum] = "aef4f7eadadd22027fc05d5acf3441b5c6434dd2e09cd3a3401577e9afc1d395"

URI_aarch64_python3-pcapy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pcapy-0.11.5-28.el10_2.aarch64.rpm;name=aarch64_python3-pcapy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pcapy}"
SRC_URI[aarch64_python3-pcapy.sha256sum] = "8d49f4e163ac0aac2c4d0f5f6d75baa9ab000c29b2ce2591cf2b40c71996af98"

RDEPENDS:python3-pcapy = " \
 glibc \
 libgcc \
 libpcap \
 libstdc++ \
 python3 \
 "
