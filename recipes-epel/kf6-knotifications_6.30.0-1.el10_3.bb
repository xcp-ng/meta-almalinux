# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knotifications"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-knotifications \
 kf6-knotifications-devel \
 kf6-knotifications-doc \
 kf6-knotifications-html \
 python3-kf6-knotifications \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-knotifications-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c652ab79ad262f2ec14dd72993d9da5c75d5dc88020e141164ced67e3027408a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications;unpack=0"
SRC_URI[x86_64_v2_kf6-knotifications.sha256sum] = "b110a22817f7f09fe1e765a33bdb2d86e30e97f554af1f3f665fd6a086095ebe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knotifications-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-knotifications-devel.sha256sum] = "2fc459f698ab34f1a1979c53e02cb2039dc6ff2eb83f7f5410311567018e95ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifications-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-knotifications-doc.sha256sum] = "ae9e4dfd35e3b5d2e5410ae9eedf70d0e8e13ac4380350d2918450cd03ea1c5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knotifications-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knotifications-html;unpack=0"
SRC_URI[x86_64_v2_kf6-knotifications-html.sha256sum] = "8f4b6796830d7ab4b5f8e8d164bc499985a1cc049c69a26e0d21a5250fa1397e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-knotifications-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-knotifications;unpack=0"
SRC_URI[x86_64_v2_python3-kf6-knotifications.sha256sum] = "a7d750514db64f6b9b71d627d12255f36f586f64aa55e79780bbf3267b152399"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knotifications;unpack=0"
SRC_URI[aarch64_kf6-knotifications.sha256sum] = "4bb710be1158e01ff8a556aff77e0a78499fd1eab7d7381caa82fe4bca06487b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-knotifications-devel;unpack=0"
SRC_URI[aarch64_kf6-knotifications-devel.sha256sum] = "0d995b893a4bb36812bb540deacc26b3f68eee846c9f24f9e0dc56c5b73c47a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knotifications-doc;unpack=0"
SRC_URI[aarch64_kf6-knotifications-doc.sha256sum] = "cd5a7cba41fd5b8422cce034b4c960ce4b6ef95725f98be372fb798d88854941"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-knotifications-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-knotifications-html;unpack=0"
SRC_URI[aarch64_kf6-knotifications-html.sha256sum] = "00c8906ea3feef4f12a3f9198a5903496277d6b7f5ac3039ea3d24635d955421"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-knotifications-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-knotifications;unpack=0"
SRC_URI[aarch64_python3-kf6-knotifications.sha256sum] = "d3c161e27decbf0dcee58c0a0822dee64a381a723b785ba4edc720d47717b44c"

RDEPENDS:kf6-knotifications = " \
 glibc \
 kf6-kconfig \
 libcanberra \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knotifications-devel = " \
 cmake-filesystem \
 kf6-knotifications \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-knotifications-doc = " \
 "
RDEPENDS:kf6-knotifications-html = " \
 "
RDEPENDS:python3-kf6-knotifications = " \
 glibc \
 kf6-knotifications \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
