# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_mangen"
PV = "0.2.33"
PR = "1.el10_2"
PACKAGES = " \
 rust-clap_mangen+debug-devel \
 rust-clap_mangen+default-devel \
 rust-clap_mangen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_mangen-0.2.33-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de38eb729b045147897004fea9354e068791d929f3c389c8e4577de4a98509ba"

URI_x86_64_v2_rust-clap_mangen+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen+debug-devel-0.2.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen+debug-devel.sha256sum] = "cb8eced25620e8741c637bbd5f953bfac1aece4872897e579ae237cf1f5a2472"

URI_x86_64_v2_rust-clap_mangen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen+default-devel-0.2.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen+default-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen+default-devel.sha256sum] = "42508c85774a1503d4dd6c557869f2034c3dbb3a108f37a76767fa07e03bd31c"

URI_x86_64_v2_rust-clap_mangen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_mangen-devel-0.2.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_mangen-devel}"
SRC_URI[x86_64_v2_rust-clap_mangen-devel.sha256sum] = "229b5ba707a5eb09bb97dae8fc1d2c50ef37b80aa30d1b626aad228ca9c3aa02"

URI_aarch64_rust-clap_mangen+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen+debug-devel-0.2.33-1.el10_2.noarch.rpm;name=aarch64_rust-clap_mangen+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen+debug-devel}"
SRC_URI[aarch64_rust-clap_mangen+debug-devel.sha256sum] = "0aa6ba323b9dff5018cf68bbde4b6bc0392313e284245d7fdcf41499d1ad8d24"

URI_aarch64_rust-clap_mangen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen+default-devel-0.2.33-1.el10_2.noarch.rpm;name=aarch64_rust-clap_mangen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen+default-devel}"
SRC_URI[aarch64_rust-clap_mangen+default-devel.sha256sum] = "efdd0913bffc03e2204607dd700fed36693a058a932552ab1e0ea1dc0ca08385"

URI_aarch64_rust-clap_mangen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_mangen-devel-0.2.33-1.el10_2.noarch.rpm;name=aarch64_rust-clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_mangen-devel}"
SRC_URI[aarch64_rust-clap_mangen-devel.sha256sum] = "db6863d706f9957a7468fbb2dc1fada08b517b22919671f194be853262a17ed1"

RDEPENDS:rust-clap_mangen+debug-devel = " \
 cargo \
 rust-clap+debug-devel \
 rust-clap_mangen-devel \
 "
RDEPENDS:rust-clap_mangen+default-devel = " \
 cargo \
 rust-clap_mangen-devel \
 "
RDEPENDS:rust-clap_mangen-devel = " \
 cargo \
 rust \
 rust-clap+env-devel \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-roff+default-devel \
 "
