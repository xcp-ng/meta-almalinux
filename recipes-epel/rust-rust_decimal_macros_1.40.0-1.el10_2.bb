# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust_decimal_macros"
PV = "1.40.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rust_decimal_macros+default-devel \
 rust-rust_decimal_macros+reexportable-devel \
 rust-rust_decimal_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust_decimal_macros-1.40.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6d98fffc200452d4d8cd18ae720bff804efd399c0abc5d3a554292b4cb7015a"

URI_x86_64_v2_rust-rust_decimal_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros+default-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal_macros+default-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal_macros+default-devel.sha256sum] = "d0da0b8dd69661818bed66a662ffadfa33678392130273e19759afaeb2f2c144"

URI_x86_64_v2_rust-rust_decimal_macros+reexportable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros+reexportable-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros+reexportable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal_macros+reexportable-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal_macros+reexportable-devel.sha256sum] = "302a93967fdc3648d93f635de8f1ae112803610e147adbad726dd280f4ccb305"

URI_x86_64_v2_rust-rust_decimal_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros-devel-1.40.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal_macros-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal_macros-devel.sha256sum] = "21cb540afb48576e51dcacef4ed86698c29a7654fcda3dc1885559edf7d048aa"

URI_aarch64_rust-rust_decimal_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros+default-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal_macros+default-devel}"
SRC_URI[aarch64_rust-rust_decimal_macros+default-devel.sha256sum] = "e7db38ec238db63fab65e9e94af6a776557cadfce50ebeb1fce8d404ba650e0a"

URI_aarch64_rust-rust_decimal_macros+reexportable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros+reexportable-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal_macros+reexportable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal_macros+reexportable-devel}"
SRC_URI[aarch64_rust-rust_decimal_macros+reexportable-devel.sha256sum] = "451208fd183bcb3bd4e0af68bbebd8e2bd16b157f12402640628a70de02e5fa6"

URI_aarch64_rust-rust_decimal_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros-devel-1.40.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust_decimal_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal_macros-devel}"
SRC_URI[aarch64_rust-rust_decimal_macros-devel.sha256sum] = "206436c8d3bb442d75b112525d84b0c417ae0d70f64584e07511305cd22efe90"

RDEPENDS:rust-rust_decimal_macros+default-devel = " \
 cargo \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal_macros+reexportable-devel = " \
 cargo \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal_macros-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
