# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vkroots"
PV = "0^20260507gitee76e62"
PR = "2.el10_3"
PACKAGES = " \
 vkroots-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vkroots-0^20260507gitee76e62-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1978787c2f0c6b723cde7f15d5157e1b1b07be2c55a9ddf68289226c60c5f254"

URI_x86_64_v2_vkroots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vkroots-devel-0^20260507gitee76e62-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_vkroots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vkroots-devel}"
SRC_URI[x86_64_v2_vkroots-devel.sha256sum] = "a9771469d9776212e66c01325711b94e85d01d43db95a939e681839fa9e7b30d"

URI_aarch64_vkroots-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vkroots-devel-0^20260507gitee76e62-2.el10_3.noarch.rpm;name=aarch64_vkroots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vkroots-devel}"
SRC_URI[aarch64_vkroots-devel.sha256sum] = "8dbff9dcea438fd8a0a91ef170c510224f54d5b52e03d8ce51791e9d40eb75c1"

RDEPENDS:vkroots-devel = " \
 pkgconf-pkg-config \
 "
