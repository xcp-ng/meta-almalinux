# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-notification"
PV = "0.3.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-notification \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-notification-0.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a58ee1e8ce0d11fd0d1fa64aa0df6bcf96cec5df6f0725b5b27fa8ab86f31db8"

URI_x86_64_v2_python3-colcon-notification = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-notification-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-notification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-notification}"
SRC_URI[x86_64_v2_python3-colcon-notification.sha256sum] = "81131d9efff573c6bb07a3c071c80dbbf86cc17490677de1fe2682489b8d75da"

URI_aarch64_python3-colcon-notification = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-notification-0.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-notification;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-notification}"
SRC_URI[aarch64_python3-colcon-notification.sha256sum] = "21581e7c57f7de09e101c27688a57f1de8d1a06551e71e12d6a8556e0099c055"

RDEPENDS:python3-colcon-notification = " \
 python3 \
 python3-colcon-core \
 python3-notify2 \
 "
