# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-fancyindex"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 nginx-mod-fancyindex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-fancyindex-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8065ebaca113aa396d9d44897d261ffdfc879bfbbcfc1d2523261e867cff501a"

URI_x86_64_v2_nginx-mod-fancyindex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-fancyindex-0.6.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-fancyindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-fancyindex}"
SRC_URI[x86_64_v2_nginx-mod-fancyindex.sha256sum] = "cf57f00ae8be301bb2690d9df58bada60395763126391bed1e5d03caac3470f4"

URI_aarch64_nginx-mod-fancyindex = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-fancyindex-0.6.0-1.el10_2.aarch64.rpm;name=aarch64_nginx-mod-fancyindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-fancyindex}"
SRC_URI[aarch64_nginx-mod-fancyindex.sha256sum] = "37aa4129e4393f2851dc9098b76ec3fce032a996f5896e858e6d11c9862eb581"

RDEPENDS:nginx-mod-fancyindex = " \
 glibc \
 nginx \
 "
