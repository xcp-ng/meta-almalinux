# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcalc"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kcalc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcalc-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1241fb315dddae88a2df695e3e1c75e8001fe7c7fbce03eebc241a057dc405db"

URI_x86_64_v2_kcalc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcalc-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcalc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcalc}"
SRC_URI[x86_64_v2_kcalc.sha256sum] = "8eaa3440104410eeccccd6076cb5e5b8b48e28bd4e866bf7c0ba9eb956ca2bf5"

URI_aarch64_kcalc = "${EPEL_MIRROR}/aarch64/Packages/k/kcalc-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kcalc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcalc}"
SRC_URI[aarch64_kcalc.sha256sum] = "3dcb5bf2f4f8fd8de8297a63578252c44c566b36a00bf212b96eae2413bfbacc"

RDEPENDS:kcalc = " \
 glibc \
 gmp \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 mpfr \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
