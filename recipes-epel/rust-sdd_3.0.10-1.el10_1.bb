# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sdd"
PV = "3.0.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-sdd+default-devel \
 rust-sdd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sdd-3.0.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03a118aeb3d1612abb5ade977fae1a4cfc9f04f4e9a6e57c993312930408ec44"

URI_x86_64_v2_rust-sdd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sdd+default-devel-3.0.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sdd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sdd+default-devel}"
SRC_URI[x86_64_v2_rust-sdd+default-devel.sha256sum] = "d5ac1388b28f99a417acadcc30bae745fe2560911d8b1d00fdf5c3807d71f710"

URI_x86_64_v2_rust-sdd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sdd-devel-3.0.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sdd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sdd-devel}"
SRC_URI[x86_64_v2_rust-sdd-devel.sha256sum] = "bf2b54b85e3c34b1997f39319d64b58e9414ba2405ae7bcd62036fbf4051231e"

URI_aarch64_rust-sdd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sdd+default-devel-3.0.10-1.el10_1.noarch.rpm;name=aarch64_rust-sdd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sdd+default-devel}"
SRC_URI[aarch64_rust-sdd+default-devel.sha256sum] = "a171018d98f3487f2bcdc7ba30a25258d697317b4f5ad047b0d61a019bf66154"

URI_aarch64_rust-sdd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sdd-devel-3.0.10-1.el10_1.noarch.rpm;name=aarch64_rust-sdd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sdd-devel}"
SRC_URI[aarch64_rust-sdd-devel.sha256sum] = "fcbea570126b11d9e130f2cf4f14a58531ad4996c83a6c35e2d5776cb76e7bfe"

RDEPENDS:rust-sdd+default-devel = " \
 cargo \
 rust-sdd-devel \
 "
RDEPENDS:rust-sdd-devel = " \
 cargo \
 rust \
 "
