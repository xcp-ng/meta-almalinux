# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-z85"
PV = "3.0.6"
PR = "3.el10_3"
PACKAGES = " \
 rust-z85+default-devel \
 rust-z85-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-z85-3.0.6-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87a9471a1c2d016510436b960937f1934eeeacb153d2134af0608b56c6f5fbba"

URI_x86_64_v2_rust-z85+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-z85+default-devel-3.0.6-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-z85+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-z85+default-devel}"
SRC_URI[x86_64_v2_rust-z85+default-devel.sha256sum] = "f072b7a9b7095d3937e3c9c5cdf12a0b36005eced41a17dad072b6a9d6fae8b3"

URI_x86_64_v2_rust-z85-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-z85-devel-3.0.6-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-z85-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-z85-devel}"
SRC_URI[x86_64_v2_rust-z85-devel.sha256sum] = "d5fc05a65b8ca045f6030f5a1c45ec6588a5161a3e042ccc0e4fad806ce03b7b"

URI_aarch64_rust-z85+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-z85+default-devel-3.0.6-3.el10_3.noarch.rpm;name=aarch64_rust-z85+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-z85+default-devel}"
SRC_URI[aarch64_rust-z85+default-devel.sha256sum] = "e5acbbb9b02821790d8b0994ad7f014d4abfc74d00e319f31b4cf8ed2fb598c0"

URI_aarch64_rust-z85-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-z85-devel-3.0.6-3.el10_3.noarch.rpm;name=aarch64_rust-z85-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-z85-devel}"
SRC_URI[aarch64_rust-z85-devel.sha256sum] = "9417cc2fc7b8e11d185772a0401fc8234513b209dc254a5e254338de7e1b3d28"

RDEPENDS:rust-z85+default-devel = " \
 cargo \
 rust-z85-devel \
 "
RDEPENDS:rust-z85-devel = " \
 cargo \
 "
