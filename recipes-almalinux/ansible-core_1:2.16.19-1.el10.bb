# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-core"
PE = "1"
PV = "2.16.19"
PR = "1.el10"
PACKAGES = " \
 ansible-core \
 ansible-test \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-core-2.16.19-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57db481b7e60b3658f6447b9e491bbdc4d953c6c3ed36b2e029606cbd7dba2e5"

URI_x86_64_v2_ansible-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-core-2.16.19-1.el10.noarch.rpm;name=x86_64_v2_ansible-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-core}"
SRC_URI[x86_64_v2_ansible-core.sha256sum] = "c0b6ae0687efc44a308ae3c9783b9320838a5850f5ac9cec06ad48e8fb5a466c"

URI_x86_64_v2_ansible-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-test-2.16.19-1.el10.noarch.rpm;name=x86_64_v2_ansible-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-test}"
SRC_URI[x86_64_v2_ansible-test.sha256sum] = "3fabf15e9a9d78e3a2b8b2ce5d8dab63196794b6b00a42efa533d402a5aec2d6"

URI_aarch64_ansible-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-core-2.16.19-1.el10.noarch.rpm;name=aarch64_ansible-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-core}"
SRC_URI[aarch64_ansible-core.sha256sum] = "c0b6ae0687efc44a308ae3c9783b9320838a5850f5ac9cec06ad48e8fb5a466c"

URI_aarch64_ansible-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-test-2.16.19-1.el10.noarch.rpm;name=aarch64_ansible-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-test}"
SRC_URI[aarch64_ansible-test.sha256sum] = "3fabf15e9a9d78e3a2b8b2ce5d8dab63196794b6b00a42efa533d402a5aec2d6"

RDEPENDS:ansible-core = " \
 git-core \
 python3 \
 python3-cryptography \
 python3-jinja2 \
 python3-packaging \
 python3-pyyaml \
 python3-resolvelib \
 "
RDEPENDS:ansible-test = " \
 ansible-core \
 python3 \
 "
