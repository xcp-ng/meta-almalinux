# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-netaddr"
PV = "1.3.0"
PR = "2.el10"
PACKAGES = " \
 python3-netaddr \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-netaddr-1.3.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "057d7ec8b9e5f9dd76c17f48e4bd64e2c06afd6987370ea2e4b48589f627d2c6"

URI_x86_64_v2_python3-netaddr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-netaddr-1.3.0-2.el10.noarch.rpm;name=x86_64_v2_python3-netaddr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-netaddr}"
SRC_URI[x86_64_v2_python3-netaddr.sha256sum] = "74f2aabece98c3712462c6edaf887c779716173750e683d2c016e0da8aa2ea0e"

URI_aarch64_python3-netaddr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-netaddr-1.3.0-2.el10.noarch.rpm;name=aarch64_python3-netaddr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-netaddr}"
SRC_URI[aarch64_python3-netaddr.sha256sum] = "74f2aabece98c3712462c6edaf887c779716173750e683d2c016e0da8aa2ea0e"

RDEPENDS:python3-netaddr = " \
 python3 \
 "
