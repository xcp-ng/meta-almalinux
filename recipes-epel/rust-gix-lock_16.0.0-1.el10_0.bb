# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-lock"
PV = "16.0.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-lock+default-devel \
 rust-gix-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-lock-16.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "636a5a6e04e481c0e918e5761f6f37f7944e6d838bcb85697c350b278d9504c6"

URI_x86_64_v2_rust-gix-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-lock+default-devel-16.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-lock+default-devel}"
SRC_URI[x86_64_v2_rust-gix-lock+default-devel.sha256sum] = "679dbae2ba921d5629a6b9671964245f0bb57701813aa861e1eecd748cb2afd8"

URI_x86_64_v2_rust-gix-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-lock-devel-16.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-lock-devel}"
SRC_URI[x86_64_v2_rust-gix-lock-devel.sha256sum] = "31311ca77bfb631b9bb6d6149788684f457e2422aaad0b9499cf2fc4b125d384"

URI_aarch64_rust-gix-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-lock+default-devel-16.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-lock+default-devel}"
SRC_URI[aarch64_rust-gix-lock+default-devel.sha256sum] = "7a340aedceef0f59ec133f1806e5395eedfb248166ecf9b356dcb98629f2a8df"

URI_aarch64_rust-gix-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-lock-devel-16.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-lock-devel}"
SRC_URI[aarch64_rust-gix-lock-devel.sha256sum] = "0fd3697831034e720aa153003fb919867b098d0bd5d840170026a248895f3ea2"

RDEPENDS:rust-gix-lock+default-devel = " \
 cargo \
 rust-gix-lock-devel \
 "
RDEPENDS:rust-gix-lock-devel = " \
 cargo \
 rust \
 rust-gix-tempfile-devel \
 rust-gix-utils-devel \
 rust-thiserror+default-devel \
 "
