# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "epel-release"
PV = "10"
PR = "6.el10_0"
PACKAGES = " \
 epel-release \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/epel-release-10-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7d7cd153b23cd8018c626aca8892a228ba22c4f8edabfc32e8dbced25e6a355"

URI_aarch64_epel-release = "${EPEL_MIRROR}/aarch64/Packages/e/epel-release-10-6.el10_0.noarch.rpm;name=aarch64_epel-release;unpack=0"
SRC_URI:append = " ${URI_aarch64_epel-release}"
SRC_URI[aarch64_epel-release.sha256sum] = "e8604c7e4580cf88a5d7d34473398424f27cd8f67938c685adc54385b9edeb8b"

RDEPENDS:epel-release = " \
 almalinux-release \
 bash \
 "
