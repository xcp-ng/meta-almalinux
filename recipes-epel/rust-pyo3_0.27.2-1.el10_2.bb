# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3"
PV = "0.27.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3+abi3-devel \
 rust-pyo3+abi3-py310-devel \
 rust-pyo3+abi3-py311-devel \
 rust-pyo3+abi3-py312-devel \
 rust-pyo3+abi3-py313-devel \
 rust-pyo3+abi3-py314-devel \
 rust-pyo3+abi3-py37-devel \
 rust-pyo3+abi3-py38-devel \
 rust-pyo3+abi3-py39-devel \
 rust-pyo3+anyhow-devel \
 rust-pyo3+arc_lock-devel \
 rust-pyo3+auto-initialize-devel \
 rust-pyo3+bigdecimal-devel \
 rust-pyo3+bytes-devel \
 rust-pyo3+chrono-devel \
 rust-pyo3+chrono-local-devel \
 rust-pyo3+chrono-tz-devel \
 rust-pyo3+default-devel \
 rust-pyo3+either-devel \
 rust-pyo3+experimental-async-devel \
 rust-pyo3+experimental-inspect-devel \
 rust-pyo3+extension-module-devel \
 rust-pyo3+eyre-devel \
 rust-pyo3+full-devel \
 rust-pyo3+hashbrown-devel \
 rust-pyo3+indexmap-devel \
 rust-pyo3+indoc-devel \
 rust-pyo3+inventory-devel \
 rust-pyo3+jiff-02-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3+macros-devel \
 rust-pyo3+multiple-pymethods-devel \
 rust-pyo3+nightly-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3+num-complex-devel \
 rust-pyo3+num-rational-devel \
 rust-pyo3+ordered-float-devel \
 rust-pyo3+parking_lot-devel \
 rust-pyo3+py-clone-devel \
 rust-pyo3+pyo3-macros-devel \
 rust-pyo3+rust_decimal-devel \
 rust-pyo3+serde-devel \
 rust-pyo3+smallvec-devel \
 rust-pyo3+time-devel \
 rust-pyo3+unindent-devel \
 rust-pyo3+uuid-devel \
 rust-pyo3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-0.27.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f236ae8369f81753d00780eaca87717a768220ab63518dfed785372bf8c52093"

URI_x86_64_v2_rust-pyo3+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-devel.sha256sum] = "886b52d8474601e5e106d1263dfd381d283ac15a28fe5a9c7c8ba0f1674bede7"

URI_x86_64_v2_rust-pyo3+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py310-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py310-devel.sha256sum] = "d22c2848309c457624b9286e8776c033a3c6f94bd5546247698c5dda96c0063d"

URI_x86_64_v2_rust-pyo3+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py311-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py311-devel.sha256sum] = "bd463ef5edd08b05ab455f276f319c6cfd35cc858e0effd9008107c0e0f3efdc"

URI_x86_64_v2_rust-pyo3+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py312-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py312-devel.sha256sum] = "aba968e15d7a654d0cc4c9219cea2424297f6289c25818a428c44945192434a4"

URI_x86_64_v2_rust-pyo3+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py313-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py313-devel.sha256sum] = "e298a1dc22bc02e37c5117d2be0cbd3877251e29f4c75dfa2a39b8a1f347b1eb"

URI_x86_64_v2_rust-pyo3+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py314-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py314-devel.sha256sum] = "572bad24e9b8b71bb4f5f9594462b50475923b1f040cd468a6ed6b6d85c8a761"

URI_x86_64_v2_rust-pyo3+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py37-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py37-devel.sha256sum] = "e163ae55fe04531eabd938400cae9083198c030dd7b060f49e30a09f8dc06316"

URI_x86_64_v2_rust-pyo3+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py38-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py38-devel.sha256sum] = "50413f44dc983dabf46c798c740e3d194fb746594912caa25d93a3ef1c3ac349"

URI_x86_64_v2_rust-pyo3+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py39-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py39-devel.sha256sum] = "f3fdfc06880598e05c11a49e02f57b52214544d0d4fd93f9098f5fb61ec8b4f5"

URI_x86_64_v2_rust-pyo3+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+anyhow-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3+anyhow-devel.sha256sum] = "b2ec4ea0d0adbe2b64fdd3213c7d57704bf481e0c5bd33a630dcd08afb33431b"

URI_x86_64_v2_rust-pyo3+arc_lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+arc_lock-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+arc_lock-devel}"
SRC_URI[x86_64_v2_rust-pyo3+arc_lock-devel.sha256sum] = "a89fc4f373accf03976fefb40eb66819ab25a496b767889d98477158ebd558bf"

URI_x86_64_v2_rust-pyo3+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+auto-initialize-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3+auto-initialize-devel.sha256sum] = "5984bfa21172946c80e0e4c1b454dd9cc006aa425d22d6d3e8e5925dc41e52cc"

URI_x86_64_v2_rust-pyo3+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+bigdecimal-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3+bigdecimal-devel.sha256sum] = "8bde5399e3fff80254e54a585cdca51a69f3426f49dfc467d102c12fcacc7e61"

URI_x86_64_v2_rust-pyo3+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+bytes-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+bytes-devel}"
SRC_URI[x86_64_v2_rust-pyo3+bytes-devel.sha256sum] = "cc41693e5ce974cabacd18b019abe4a2f9e12b29f06fc3cc1d243ab5787c110f"

URI_x86_64_v2_rust-pyo3+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-devel.sha256sum] = "4c1a7bf6a4f52c1b2a40fd323f214a53e4e08deafc6408de710621c5ea87f80a"

URI_x86_64_v2_rust-pyo3+chrono-local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-local-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-local-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-local-devel.sha256sum] = "67be09390dd3828b7c0dfebb73584d505afd5fef2911c7a4a3bfbee2cb157164"

URI_x86_64_v2_rust-pyo3+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-tz-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-tz-devel.sha256sum] = "b77d9c1b440f332d14d2f3e251c6f35709030065aa1ebffe72e766dea3ce9bcd"

URI_x86_64_v2_rust-pyo3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+default-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3+default-devel.sha256sum] = "930556a15d513acfd8bdddcaa6c5ca22a53d6febb69bc835ff484fe85c765de4"

URI_x86_64_v2_rust-pyo3+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+either-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3+either-devel.sha256sum] = "4c1b2add07fc4f16ab690fdb36a3c4fddb386f2476b36fc48deb14604ba72adb"

URI_x86_64_v2_rust-pyo3+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+experimental-async-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3+experimental-async-devel.sha256sum] = "41fa83879b875aa0acbdcdc286e4e44344a8ce0ea12f39439edcddf81066e573"

URI_x86_64_v2_rust-pyo3+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+experimental-inspect-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3+experimental-inspect-devel.sha256sum] = "775e201ba1447abb51df49092f995400de6f1c6d88ba56cb9c51f9847ccb3b4b"

URI_x86_64_v2_rust-pyo3+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+extension-module-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3+extension-module-devel.sha256sum] = "de1660cee2888b7b13966997aaa8670750f1dc6b55578a2e75b71a807ead6311"

URI_x86_64_v2_rust-pyo3+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+eyre-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3+eyre-devel.sha256sum] = "d4bd24eb6e1a0dbb520d3d1b96333e71d0e5e7687c5bab510cc99b41e87987ed"

URI_x86_64_v2_rust-pyo3+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+full-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3+full-devel.sha256sum] = "6dee2f6df3856674a50d9b420054dc4322c83efaedb16a342759b24795a5f664"

URI_x86_64_v2_rust-pyo3+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+hashbrown-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3+hashbrown-devel.sha256sum] = "f7ce5047493dcf6e90bde978626e4d19a9141de63881a83bd04acaba10d8139d"

URI_x86_64_v2_rust-pyo3+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+indexmap-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3+indexmap-devel.sha256sum] = "9c8161bd48fd2ea734ee36c5a5f8a6e2cf4d654c797edd340fc4571fdf795706"

URI_x86_64_v2_rust-pyo3+indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+indoc-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+indoc-devel}"
SRC_URI[x86_64_v2_rust-pyo3+indoc-devel.sha256sum] = "daf8e319add98483dcfca76743390fb109dc62c3a5e124b4af4cd4992c634573"

URI_x86_64_v2_rust-pyo3+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+inventory-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3+inventory-devel.sha256sum] = "b94f57773e7f6b202c34d3532396c38751815ce9f2132c1e56c6aad3880c4797"

URI_x86_64_v2_rust-pyo3+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+jiff-02-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-pyo3+jiff-02-devel.sha256sum] = "4b43c8b8b810dd4682ffb9615702eea418d800c31f12c88b447a597e3b23e8ed"

URI_x86_64_v2_rust-pyo3+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+lock_api-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+lock_api-devel}"
SRC_URI[x86_64_v2_rust-pyo3+lock_api-devel.sha256sum] = "b08ada48465c8c5b04eb2acf6c30630e342e375e756504e6cba588a24f8a7ef9"

URI_x86_64_v2_rust-pyo3+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+macros-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3+macros-devel.sha256sum] = "949cb574b67ae1e5134115c4779694cf2bd3f820fa5727779ab90a59b179325b"

URI_x86_64_v2_rust-pyo3+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+multiple-pymethods-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3+multiple-pymethods-devel.sha256sum] = "27b11f99c1f0a9f1a314ce34b807016d2dc37a6d08e9579069ca318b2c99ba4f"

URI_x86_64_v2_rust-pyo3+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+nightly-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3+nightly-devel.sha256sum] = "2f03ce89753449d9121f5abb89860f07bd2589ae2de7588706f90b8198abb0ef"

URI_x86_64_v2_rust-pyo3+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-bigint-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-bigint-devel.sha256sum] = "57fa54b4d639281b938484d8f8459ed523b242dfb7ef7153837599c16e215f2f"

URI_x86_64_v2_rust-pyo3+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-complex-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-complex-devel.sha256sum] = "e14ca31bd474c3d851ded9f86ea34e902261e28e67d4cca17f9e6965674d434f"

URI_x86_64_v2_rust-pyo3+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-rational-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-rational-devel.sha256sum] = "05f2151ceb773d93db7588434e778e0b308513dc77958e2614171aead559e606"

URI_x86_64_v2_rust-pyo3+ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+ordered-float-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+ordered-float-devel}"
SRC_URI[x86_64_v2_rust-pyo3+ordered-float-devel.sha256sum] = "f51c2af7f46dd151435c95ca72b2a2e180d19dee2850ba2740fede15345fa3d3"

URI_x86_64_v2_rust-pyo3+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+parking_lot-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-pyo3+parking_lot-devel.sha256sum] = "d3f516ff64de3ffc392367b981463eed96e0dbeeaa54989208bc8b9d9bc820bb"

URI_x86_64_v2_rust-pyo3+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+py-clone-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3+py-clone-devel.sha256sum] = "5c20e22d5819da403e4e459a28e012975a6ec02bde36eb86b1579e72317686de"

URI_x86_64_v2_rust-pyo3+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+pyo3-macros-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3+pyo3-macros-devel.sha256sum] = "e1a971aa8f2b52fe1c5a83167f2b2071ab5bb0ab0bb2c0164443c1c86ffe3316"

URI_x86_64_v2_rust-pyo3+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+rust_decimal-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3+rust_decimal-devel.sha256sum] = "0a88ac875b8ebc36158a04abd98fc4f8f097dd81927532985d6acd1c131688b7"

URI_x86_64_v2_rust-pyo3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+serde-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3+serde-devel.sha256sum] = "76816d326f713062988c8cca28b618bc75f52cecbdb2c367f1b7d295ce0a3770"

URI_x86_64_v2_rust-pyo3+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+smallvec-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3+smallvec-devel.sha256sum] = "099a0d02f3a2973e49f35505f976dbb26a8e1e6f9af621bcc826a6ca461aa4e3"

URI_x86_64_v2_rust-pyo3+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+time-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+time-devel}"
SRC_URI[x86_64_v2_rust-pyo3+time-devel.sha256sum] = "7025a478f1d2943905b5fe6574b58c27bec2c1f45755e6fe4fc8e1180e9550cb"

URI_x86_64_v2_rust-pyo3+unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+unindent-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+unindent-devel}"
SRC_URI[x86_64_v2_rust-pyo3+unindent-devel.sha256sum] = "9ad02580e31a2c04d901c4a527bdb7bdcf2a230553d331ca94ef1cabeea3bbd1"

URI_x86_64_v2_rust-pyo3+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+uuid-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+uuid-devel}"
SRC_URI[x86_64_v2_rust-pyo3+uuid-devel.sha256sum] = "765b6e032f7fffa9a1514dc41e811485541763913653d3329ca08c58aaef7784"

URI_x86_64_v2_rust-pyo3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-devel-0.27.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-devel.sha256sum] = "69f0432e9b802f35349dfc2119af9e7926ee177662f9d53e693611341964fe8c"

URI_aarch64_rust-pyo3+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-devel.sha256sum] = "0ea7141d8d6821fa1ed43cdc5e19ca1786bcb91e30bef7fda3bd79706cb9e085"

URI_aarch64_rust-pyo3+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py310-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py310-devel.sha256sum] = "793f86f10e11d3a114b6db62ccafc2fc7dd62b0c4ea0f3cdece32832393b66b4"

URI_aarch64_rust-pyo3+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py311-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py311-devel.sha256sum] = "c789981c4f53aab0df9399b916c99bc328bd82e2db1077af67a9e10e9a3d4cff"

URI_aarch64_rust-pyo3+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py312-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py312-devel.sha256sum] = "be8b513564b8c297607067dc3f0dea5a362cc50247d122f4cf16134167efdc76"

URI_aarch64_rust-pyo3+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py313-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py313-devel.sha256sum] = "14a8724480a09a5b624d9030f8be3bac3c956119f0a55c3deb1a228bec67e4f3"

URI_aarch64_rust-pyo3+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py314-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py314-devel.sha256sum] = "fe7702eb0c3ba5f4862c58d16132b550adc25810cf7e76f5818360f520a455c1"

URI_aarch64_rust-pyo3+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py37-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py37-devel.sha256sum] = "9f7d6f19038d2cb2c27ef2fead825a2757c3d32db300dd320cd5dbcbd54c54f5"

URI_aarch64_rust-pyo3+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py38-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py38-devel.sha256sum] = "a8a5dcab11fd0cee93445705d352989e472b86113204130b47351bd9f2518c42"

URI_aarch64_rust-pyo3+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py39-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py39-devel.sha256sum] = "4432af3a45bef3d07607e319bcbc01635ec23716d962602b307648d52bce4a9c"

URI_aarch64_rust-pyo3+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+anyhow-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3+anyhow-devel.sha256sum] = "eb4842cad879e30e1517a42e8a642b1c9805aaf43d2c1daa1fcdf55aa633fa95"

URI_aarch64_rust-pyo3+arc_lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+arc_lock-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+arc_lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+arc_lock-devel}"
SRC_URI[aarch64_rust-pyo3+arc_lock-devel.sha256sum] = "e3f6ff8a319fcd96521d56f44d454ee2bc96b930691dd22909b20118efaca16c"

URI_aarch64_rust-pyo3+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+auto-initialize-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3+auto-initialize-devel.sha256sum] = "73ddf6aa0e2718663bae0a910250ebd95fe463687fc1519dbcd3537ce16b2b15"

URI_aarch64_rust-pyo3+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+bigdecimal-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+bigdecimal-devel}"
SRC_URI[aarch64_rust-pyo3+bigdecimal-devel.sha256sum] = "e5385fdd713ddec9eec9860b98be603bb7f09251d4c4e5575863a575aed4d93c"

URI_aarch64_rust-pyo3+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+bytes-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+bytes-devel}"
SRC_URI[aarch64_rust-pyo3+bytes-devel.sha256sum] = "d4a4454f9b95360c9d8adccd206890f19d65abf42eb4d752e32c5829745a87d1"

URI_aarch64_rust-pyo3+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-devel.sha256sum] = "a6a6275466d27ee1f0b42d539bb7ba125a8b6f630a2cafbb170db36e04f7a927"

URI_aarch64_rust-pyo3+chrono-local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-local-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+chrono-local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-local-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-local-devel.sha256sum] = "2514fa3a208c2e503433b118203666c5922213ae7160ccf3542dadf0e1b21af5"

URI_aarch64_rust-pyo3+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-tz-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-tz-devel.sha256sum] = "b96b007567c747b59697eb0baa8820c2b0701422e0de32454f0f34af22a381cc"

URI_aarch64_rust-pyo3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+default-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+default-devel}"
SRC_URI[aarch64_rust-pyo3+default-devel.sha256sum] = "3eaa8c7783b74c9a9c6715a4cd57b4afb809eb4a8d5e62392e09798ef3e06eb6"

URI_aarch64_rust-pyo3+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+either-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+either-devel}"
SRC_URI[aarch64_rust-pyo3+either-devel.sha256sum] = "756f9c701fd1a0692c8473e20e1b49b458f1ebc5bdf1773ed9d4feab5050ea2a"

URI_aarch64_rust-pyo3+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+experimental-async-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3+experimental-async-devel.sha256sum] = "95bd45219fde48a9cbdb471b374c59cd932f4b3c52a220504320ed804ef96f07"

URI_aarch64_rust-pyo3+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+experimental-inspect-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3+experimental-inspect-devel.sha256sum] = "cc90547bf7ccb59bcbf4f887f7e1a1849ddf8a5f06652d4bab6f133d18bc4e32"

URI_aarch64_rust-pyo3+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+extension-module-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3+extension-module-devel.sha256sum] = "de2fc497d713ac2a070cd7eaf0485ef8b4b759b7068f60b273cb793c59f580f1"

URI_aarch64_rust-pyo3+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+eyre-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+eyre-devel}"
SRC_URI[aarch64_rust-pyo3+eyre-devel.sha256sum] = "26a303b1e8e091b1e0e2d98b863281dc0cd9cd8cab5ebadcdf928ea48d8fe6fb"

URI_aarch64_rust-pyo3+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+full-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+full-devel}"
SRC_URI[aarch64_rust-pyo3+full-devel.sha256sum] = "b4f3e94467604e00b98d5dd4d4de18cab9ef6ccdfe3bc88d53807d0fc4bb54d4"

URI_aarch64_rust-pyo3+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+hashbrown-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3+hashbrown-devel.sha256sum] = "4468d19acdf1badb8d1a87d200d6d994620f7d2e86e3af62db4177a957051055"

URI_aarch64_rust-pyo3+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+indexmap-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3+indexmap-devel.sha256sum] = "d39bd3249f5d3ec121ab763f4bee7ad1569201673923690d75a4e6804a48b211"

URI_aarch64_rust-pyo3+indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+indoc-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+indoc-devel}"
SRC_URI[aarch64_rust-pyo3+indoc-devel.sha256sum] = "cb0f4ab0017b745beebbd78b9548bda627bb380e7fc9f8d72d9cb00f5da21507"

URI_aarch64_rust-pyo3+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+inventory-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+inventory-devel}"
SRC_URI[aarch64_rust-pyo3+inventory-devel.sha256sum] = "feb009a0cc0ed968e16c0eec3b13e2e84d991d5c9436b7568ba0283fb6f8baa0"

URI_aarch64_rust-pyo3+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+jiff-02-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+jiff-02-devel}"
SRC_URI[aarch64_rust-pyo3+jiff-02-devel.sha256sum] = "8e1e481011ba85c193cb557069f3ab5726f2d8e26179726cbf21df315ed5470e"

URI_aarch64_rust-pyo3+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+lock_api-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+lock_api-devel}"
SRC_URI[aarch64_rust-pyo3+lock_api-devel.sha256sum] = "5892f11c93c728e81ca0f2a0d63c624493419593f214ba03fa7dff32525f23e6"

URI_aarch64_rust-pyo3+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+macros-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+macros-devel}"
SRC_URI[aarch64_rust-pyo3+macros-devel.sha256sum] = "1a0df4b37c8db72941cea31d0317dda7855588dcda929adda42a4861523ffc76"

URI_aarch64_rust-pyo3+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+multiple-pymethods-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3+multiple-pymethods-devel.sha256sum] = "5c2fc8f4f159edb04e2ecbc87e9ec3602544552cabf3b74cce8112783c5a8421"

URI_aarch64_rust-pyo3+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+nightly-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+nightly-devel}"
SRC_URI[aarch64_rust-pyo3+nightly-devel.sha256sum] = "da52393a2e040c3fddc6352ba0152a0e06fb84834d6fec320039043a5b988461"

URI_aarch64_rust-pyo3+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-bigint-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3+num-bigint-devel.sha256sum] = "900494791a54bf0dd9be227967352e09ae5ad6f0ebb02b3434f9c46a22bffa8b"

URI_aarch64_rust-pyo3+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-complex-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3+num-complex-devel.sha256sum] = "ec65cc092815c31bd162823089c13d4987b4ef5bc427d012d34617059785beb5"

URI_aarch64_rust-pyo3+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-rational-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3+num-rational-devel.sha256sum] = "97ef327ca8fb89f5baefb5a8a2718024c5326e0079e0720d2750d0076365a119"

URI_aarch64_rust-pyo3+ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+ordered-float-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+ordered-float-devel}"
SRC_URI[aarch64_rust-pyo3+ordered-float-devel.sha256sum] = "997aa94fb24443bd40550b4524e04293bfb31318825edb28d970219a8db70263"

URI_aarch64_rust-pyo3+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+parking_lot-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+parking_lot-devel}"
SRC_URI[aarch64_rust-pyo3+parking_lot-devel.sha256sum] = "0ccaa93f96e09726e45cbcc79ffd22b776dcd512fbf775ea8a1b244be07b03b0"

URI_aarch64_rust-pyo3+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+py-clone-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3+py-clone-devel.sha256sum] = "cfa85611efffb34d181db790b428ac5809ff1960cb943cff65a5b54e00ca7052"

URI_aarch64_rust-pyo3+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+pyo3-macros-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3+pyo3-macros-devel.sha256sum] = "91d8b2041cb6a2a8f906a990b7a98879dbc4eb5e7a924f085ca206caa0221760"

URI_aarch64_rust-pyo3+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+rust_decimal-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3+rust_decimal-devel.sha256sum] = "1771c4e802b595f706ee94a44d8798aaf1ec2c9c409618af91ecee6013625341"

URI_aarch64_rust-pyo3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+serde-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+serde-devel}"
SRC_URI[aarch64_rust-pyo3+serde-devel.sha256sum] = "ef56ec6bd81e91febf8c0a6556e0cfec410c9e43f28d3fb18cc706c9d7d0740a"

URI_aarch64_rust-pyo3+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+smallvec-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3+smallvec-devel.sha256sum] = "287bbe715c641b1d61056ccf0d49e8a558f96346d38366f5c300af222df17b49"

URI_aarch64_rust-pyo3+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+time-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+time-devel}"
SRC_URI[aarch64_rust-pyo3+time-devel.sha256sum] = "715d9802eaaa25ddf04063c3c801c92ab0e1ad8e664a7fdc74d70403e9d00d11"

URI_aarch64_rust-pyo3+unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+unindent-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+unindent-devel}"
SRC_URI[aarch64_rust-pyo3+unindent-devel.sha256sum] = "af42690f002be5912bf7b7750d42aeea8b69331f1c9a6cb080b7f00a0f6d217e"

URI_aarch64_rust-pyo3+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+uuid-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+uuid-devel}"
SRC_URI[aarch64_rust-pyo3+uuid-devel.sha256sum] = "53f589d9ba6dfaa6d69a404e7fcaa28f2430b3fe93a6e0e3874d9901dac06f44"

URI_aarch64_rust-pyo3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-devel-0.27.2-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-devel}"
SRC_URI[aarch64_rust-pyo3-devel.sha256sum] = "29700762e57b35d04c39cc881a569428c523c4879e6d752ba920b175b887b5a8"

RDEPENDS:rust-pyo3+abi3-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-devel \
 "
RDEPENDS:rust-pyo3+abi3-py310-devel = " \
 cargo \
 rust-pyo3+abi3-py311-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py310-devel \
 "
RDEPENDS:rust-pyo3+abi3-py311-devel = " \
 cargo \
 rust-pyo3+abi3-py312-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py311-devel \
 "
RDEPENDS:rust-pyo3+abi3-py312-devel = " \
 cargo \
 rust-pyo3+abi3-py313-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py312-devel \
 "
RDEPENDS:rust-pyo3+abi3-py313-devel = " \
 cargo \
 rust-pyo3+abi3-py314-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py313-devel \
 "
RDEPENDS:rust-pyo3+abi3-py314-devel = " \
 cargo \
 rust-pyo3+abi3-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py314-devel \
 "
RDEPENDS:rust-pyo3+abi3-py37-devel = " \
 cargo \
 rust-pyo3+abi3-py38-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py37-devel \
 "
RDEPENDS:rust-pyo3+abi3-py38-devel = " \
 cargo \
 rust-pyo3+abi3-py39-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py38-devel \
 "
RDEPENDS:rust-pyo3+abi3-py39-devel = " \
 cargo \
 rust-pyo3+abi3-py310-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py39-devel \
 "
RDEPENDS:rust-pyo3+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+arc_lock-devel = " \
 cargo \
 rust-lock_api+arc_lock-devel \
 rust-lock_api+default-devel \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+default-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+auto-initialize-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+bigdecimal-devel = " \
 cargo \
 rust-bigdecimal+default-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-local-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+default-devel = " \
 cargo \
 rust-pyo3+macros-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+experimental-async-devel = " \
 cargo \
 rust-pyo3+macros-devel \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-async-devel \
 "
RDEPENDS:rust-pyo3+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-inspect-devel \
 "
RDEPENDS:rust-pyo3+extension-module-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-ffi+extension-module-devel \
 "
RDEPENDS:rust-pyo3+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+full-devel = " \
 cargo \
 rust-pyo3+anyhow-devel \
 rust-pyo3+arc_lock-devel \
 rust-pyo3+bigdecimal-devel \
 rust-pyo3+bytes-devel \
 rust-pyo3+chrono-devel \
 rust-pyo3+chrono-local-devel \
 rust-pyo3+chrono-tz-devel \
 rust-pyo3+either-devel \
 rust-pyo3+experimental-async-devel \
 rust-pyo3+experimental-inspect-devel \
 rust-pyo3+eyre-devel \
 rust-pyo3+hashbrown-devel \
 rust-pyo3+indexmap-devel \
 rust-pyo3+jiff-02-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3+macros-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3+num-complex-devel \
 rust-pyo3+num-rational-devel \
 rust-pyo3+ordered-float-devel \
 rust-pyo3+parking_lot-devel \
 rust-pyo3+py-clone-devel \
 rust-pyo3+rust_decimal-devel \
 rust-pyo3+serde-devel \
 rust-pyo3+smallvec-devel \
 rust-pyo3+time-devel \
 rust-pyo3+uuid-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+hashbrown-devel = " \
 cargo \
 rust-pyo3-devel \
 virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~ \
 "
RDEPENDS:rust-pyo3+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+indoc-devel = " \
 cargo \
 rust-indoc+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+macros-devel = " \
 cargo \
 rust-pyo3+indoc-devel \
 rust-pyo3+pyo3-macros-devel \
 rust-pyo3+unindent-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3+inventory-devel \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+multiple-pymethods-devel \
 "
RDEPENDS:rust-pyo3+nightly-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-num-traits+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+ordered-float-devel = " \
 cargo \
 rust-ordered-float-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-pyo3+lock_api-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+py-clone-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 "
RDEPENDS:rust-pyo3+rust_decimal-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3+serde-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3+smallvec-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3+time-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-time-devel \
 "
RDEPENDS:rust-pyo3+unindent-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-unindent+default-devel \
 "
RDEPENDS:rust-pyo3+uuid-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-pyo3-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-memoffset+default-devel \
 rust-once_cell+default-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-pyo3-ffi+default-devel \
 "
