# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dpkg"
PV = "1.22.20"
PR = "1.el10_0"
PACKAGES = " \
 dpkg \
 dpkg-dev \
 dpkg-devel \
 dpkg-perl \
 dselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dpkg-1.22.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e801fda670b9476bc10174278f5cce29771199669271c189480f2d48abeb09e"

URI_x86_64_v2_dpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-1.22.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg}"
SRC_URI[x86_64_v2_dpkg.sha256sum] = "769b422f73ab698330c5e8f5e1c91e7e4b9496d790012a4c82ddd1a1435c7ca6"

URI_x86_64_v2_dpkg-dev = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-dev-1.22.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dpkg-dev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-dev}"
SRC_URI[x86_64_v2_dpkg-dev.sha256sum] = "c36a1f11b1eeecd9ffb29b97c3440373a8cc444c96f8a03dbf1064fddca59e26"

URI_x86_64_v2_dpkg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-devel-1.22.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dpkg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-devel}"
SRC_URI[x86_64_v2_dpkg-devel.sha256sum] = "843b9eaeabe5fa2bf775f324af75e221436d5ea604360cf25d5c6bd1ce33e54d"

URI_x86_64_v2_dpkg-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dpkg-perl-1.22.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dpkg-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dpkg-perl}"
SRC_URI[x86_64_v2_dpkg-perl.sha256sum] = "14a7458503aa9a37175e7103cb5d101d2afe27a6cd62a5417119ce4aea3ee2c8"

URI_x86_64_v2_dselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dselect-1.22.20-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dselect}"
SRC_URI[x86_64_v2_dselect.sha256sum] = "19e7712f504d7c026e1958ff899443bf26ac8e0c56fa5a161f74aafc9ffe4e4b"

URI_aarch64_dpkg = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-1.22.20-1.el10_0.aarch64.rpm;name=aarch64_dpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg}"
SRC_URI[aarch64_dpkg.sha256sum] = "dbd10521f72633b1b00660ea94176fb66655dab99f7820c9e27006f1532db977"

URI_aarch64_dpkg-dev = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-dev-1.22.20-1.el10_0.noarch.rpm;name=aarch64_dpkg-dev;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-dev}"
SRC_URI[aarch64_dpkg-dev.sha256sum] = "42ce7a0fd247b613a7d753dc096696e012443cf14c2cafc414665438b8f19346"

URI_aarch64_dpkg-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-devel-1.22.20-1.el10_0.aarch64.rpm;name=aarch64_dpkg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-devel}"
SRC_URI[aarch64_dpkg-devel.sha256sum] = "01face8bc100efbe0fcd9e64ea5bef12d3ea1fa6a6cbedc9717e21119f853ef8"

URI_aarch64_dpkg-perl = "${EPEL_MIRROR}/aarch64/Packages/d/dpkg-perl-1.22.20-1.el10_0.noarch.rpm;name=aarch64_dpkg-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_dpkg-perl}"
SRC_URI[aarch64_dpkg-perl.sha256sum] = "40b10968c2afaf37bda689529954b1efac496003f5c98ec87f24414d66744979"

URI_aarch64_dselect = "${EPEL_MIRROR}/aarch64/Packages/d/dselect-1.22.20-1.el10_0.aarch64.rpm;name=aarch64_dselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_dselect}"
SRC_URI[aarch64_dselect.sha256sum] = "bf807ca40cf2f0fa7e56339e1030a7ab6755180c824a3c79451319e696096cb3"

RDEPENDS:dpkg = " \
 bash \
 bzip2-libs \
 glibc \
 libmd \
 libselinux \
 libzstd \
 tar \
 xz-libs \
 zlib-ng \
 "
RDEPENDS:dpkg-dev = " \
 binutils \
 bzip2 \
 dpkg-perl \
 gcc \
 make \
 patch \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-interpreter \
 perl-libs \
 xz \
 xz-lzma-compat \
 zstd \
 "
RDEPENDS:dpkg-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:dpkg-perl = " \
 dpkg \
 dpkg-perl \
 perl-Carp \
 perl-Digest \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Digest-SHA1 \
 perl-Errno \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-IO \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Tie \
 perl-Time-HiRes \
 perl-Time-Piece \
 perl-TimeDate \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-parent \
 "
RDEPENDS:dselect = " \
 bash \
 dpkg \
 dselect \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-interpreter \
 perl-libs \
 "
