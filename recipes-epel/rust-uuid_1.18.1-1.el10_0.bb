# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uuid"
PV = "1.18.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-uuid+arbitrary-devel \
 rust-uuid+atomic-devel \
 rust-uuid+bytemuck-devel \
 rust-uuid+default-devel \
 rust-uuid+fast-rng-devel \
 rust-uuid+md5-devel \
 rust-uuid+rng-devel \
 rust-uuid+rng-getrandom-devel \
 rust-uuid+rng-rand-devel \
 rust-uuid+serde-devel \
 rust-uuid+sha1-devel \
 rust-uuid+slog-devel \
 rust-uuid+std-devel \
 rust-uuid+v1-devel \
 rust-uuid+v3-devel \
 rust-uuid+v4-devel \
 rust-uuid+v5-devel \
 rust-uuid+v6-devel \
 rust-uuid+v7-devel \
 rust-uuid+v8-devel \
 rust-uuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uuid-1.18.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42e06da35fb30207193b4fc1408a03362b43c97d62f61eff6e7b841e1a0aad13"

URI_x86_64_v2_rust-uuid+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+arbitrary-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-uuid+arbitrary-devel.sha256sum] = "1135eee7e6e7c533b09bb14e7d1aa304bd2bfb69366839b8bde55254eec46495"

URI_x86_64_v2_rust-uuid+atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+atomic-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+atomic-devel}"
SRC_URI[x86_64_v2_rust-uuid+atomic-devel.sha256sum] = "da41e7ccd49a1a90d71a91320910b2736ea4baa8c6fecb6a99b5e1398790bd63"

URI_x86_64_v2_rust-uuid+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+bytemuck-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-uuid+bytemuck-devel.sha256sum] = "5fbc66d81bd3e554578df691963907c124498104fd751d0721edfdf1718a8d13"

URI_x86_64_v2_rust-uuid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+default-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+default-devel}"
SRC_URI[x86_64_v2_rust-uuid+default-devel.sha256sum] = "be3492b4780c86cb2fe1a708acb11360f92a9af7b86d7ca8e4d5878d83cbf9a3"

URI_x86_64_v2_rust-uuid+fast-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+fast-rng-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+fast-rng-devel}"
SRC_URI[x86_64_v2_rust-uuid+fast-rng-devel.sha256sum] = "6a35a0a2f795c8f7c0aa501d4258bdb9522e05b513163f19c0d4894e001a8cb2"

URI_x86_64_v2_rust-uuid+md5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+md5-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+md5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+md5-devel}"
SRC_URI[x86_64_v2_rust-uuid+md5-devel.sha256sum] = "8fa5c939880ff3e7b8a4cb9dce50565ca9b5598fa04573ac00311af8c0f0b43a"

URI_x86_64_v2_rust-uuid+rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-devel.sha256sum] = "8566957bab345e28a7b5e130270e0348903555d4d019d22e29b4acd12e8b79d5"

URI_x86_64_v2_rust-uuid+rng-getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-getrandom-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-getrandom-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-getrandom-devel.sha256sum] = "6733d34df0ab76892f038022eb743c62f13bff5157671ccb18386ef4b3a56b64"

URI_x86_64_v2_rust-uuid+rng-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-rand-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-rand-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-rand-devel.sha256sum] = "dc346c8af7067fd6fa37fc264e1a07ce9f6a8d0f267e79dc6b85a3753b8a6578"

URI_x86_64_v2_rust-uuid+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+serde-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+serde-devel}"
SRC_URI[x86_64_v2_rust-uuid+serde-devel.sha256sum] = "9ae3d39bb4d9dd41eb88d115a1abba47d4732967ddc8ff50469c99fee393098d"

URI_x86_64_v2_rust-uuid+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+sha1-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+sha1-devel}"
SRC_URI[x86_64_v2_rust-uuid+sha1-devel.sha256sum] = "db79b672443923f3d763774b61430f69f2e1707006332652195a5cdfb84069d9"

URI_x86_64_v2_rust-uuid+slog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+slog-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+slog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+slog-devel}"
SRC_URI[x86_64_v2_rust-uuid+slog-devel.sha256sum] = "c7a872b1314bbca0a61d77ad44c134fdd346873e052326b0ebf6a3a40204ebb8"

URI_x86_64_v2_rust-uuid+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+std-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+std-devel}"
SRC_URI[x86_64_v2_rust-uuid+std-devel.sha256sum] = "caf3a3d2c01bee24c8ca17ee44117e8f29aeb21743febf081449fea65e254012"

URI_x86_64_v2_rust-uuid+v1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v1-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v1-devel}"
SRC_URI[x86_64_v2_rust-uuid+v1-devel.sha256sum] = "8b38963fb655bc46b67da23bc43648cf003f444d2b23d50f96b49fd3b7abd3f7"

URI_x86_64_v2_rust-uuid+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v3-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v3-devel}"
SRC_URI[x86_64_v2_rust-uuid+v3-devel.sha256sum] = "1b0274a1186c31c371464b48f53396d6bdb5b9a4fb198c8663e504d6fb9b2a07"

URI_x86_64_v2_rust-uuid+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v4-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v4-devel}"
SRC_URI[x86_64_v2_rust-uuid+v4-devel.sha256sum] = "b53847c884099947edea421681b42dc99091a06388eb4a58fcbce915f61a098a"

URI_x86_64_v2_rust-uuid+v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v5-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v5-devel}"
SRC_URI[x86_64_v2_rust-uuid+v5-devel.sha256sum] = "074e57095a0cf5d97bc2a2655a22185b231a2d5731d17709abbd2bd64bef7943"

URI_x86_64_v2_rust-uuid+v6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v6-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v6-devel}"
SRC_URI[x86_64_v2_rust-uuid+v6-devel.sha256sum] = "7d52005165737ff69d67f6090e3744964bf9090046127d4d9beba7bd671f9a54"

URI_x86_64_v2_rust-uuid+v7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v7-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v7-devel}"
SRC_URI[x86_64_v2_rust-uuid+v7-devel.sha256sum] = "841dbcf3c4d23c0735f41b73e43169529c93cc4a24e556bdb240598dcda2d632"

URI_x86_64_v2_rust-uuid+v8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v8-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v8-devel}"
SRC_URI[x86_64_v2_rust-uuid+v8-devel.sha256sum] = "90ec2eb352154a69870397a34ea7ab6b6c9458be9ae8971363f8847735792444"

URI_x86_64_v2_rust-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid-devel-1.18.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid-devel}"
SRC_URI[x86_64_v2_rust-uuid-devel.sha256sum] = "539b88312e18c77d74b429e2ef16f435e51f9e10a347d256b66e2378f130a1b1"

URI_aarch64_rust-uuid+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+arbitrary-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+arbitrary-devel}"
SRC_URI[aarch64_rust-uuid+arbitrary-devel.sha256sum] = "7477e413b5f560a80108e82565eb64089b06ea1ab49d320ff78e53bb796d09c2"

URI_aarch64_rust-uuid+atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+atomic-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+atomic-devel}"
SRC_URI[aarch64_rust-uuid+atomic-devel.sha256sum] = "83d1d055445a9bc7757de4e43f79b1875dacaf1b63fdf2e68518c1a64460a004"

URI_aarch64_rust-uuid+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+bytemuck-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+bytemuck-devel}"
SRC_URI[aarch64_rust-uuid+bytemuck-devel.sha256sum] = "2ab0d63aff0fb5530877a497725ccf9729ad5c3ae4a39cd3ba029837c23a6d75"

URI_aarch64_rust-uuid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+default-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+default-devel}"
SRC_URI[aarch64_rust-uuid+default-devel.sha256sum] = "3c303e33f0cdb76924e6e364bb29a47b7d306eb86cc50fac021798078cce0879"

URI_aarch64_rust-uuid+fast-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+fast-rng-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+fast-rng-devel}"
SRC_URI[aarch64_rust-uuid+fast-rng-devel.sha256sum] = "77d1cb4e1eb6130799486bff697fbb23e42a0023876d65c5cef8cbe83d1d0c08"

URI_aarch64_rust-uuid+md5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+md5-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+md5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+md5-devel}"
SRC_URI[aarch64_rust-uuid+md5-devel.sha256sum] = "cf8e68045819efc3274a77eb5558110d1cbffa53ec1efa565704197a1dda6710"

URI_aarch64_rust-uuid+rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-devel}"
SRC_URI[aarch64_rust-uuid+rng-devel.sha256sum] = "49d7498eb5de88ee3b3cc558c7d23b9f332a70709adb3b1d3005fdb015da4630"

URI_aarch64_rust-uuid+rng-getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-getrandom-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-getrandom-devel}"
SRC_URI[aarch64_rust-uuid+rng-getrandom-devel.sha256sum] = "d53f2143c24e2b4654e82b924e949184c3f1dd545a535b038a1039d4cf4ae997"

URI_aarch64_rust-uuid+rng-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-rand-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-rand-devel}"
SRC_URI[aarch64_rust-uuid+rng-rand-devel.sha256sum] = "626ee2251f6de5a4316edfef69144fc4a7ca6304e3efd945dc53de52f80d556d"

URI_aarch64_rust-uuid+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+serde-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+serde-devel}"
SRC_URI[aarch64_rust-uuid+serde-devel.sha256sum] = "994e74b0f0806caefa6af7085c061e6aa76e03b63875c384674a22b6ae8aa278"

URI_aarch64_rust-uuid+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+sha1-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+sha1-devel}"
SRC_URI[aarch64_rust-uuid+sha1-devel.sha256sum] = "c4f1601bfa738bd3b99f4de73e341a0c5f7eb2db1cfd7941218b9aa1dbda4685"

URI_aarch64_rust-uuid+slog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+slog-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+slog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+slog-devel}"
SRC_URI[aarch64_rust-uuid+slog-devel.sha256sum] = "20c852a6d52f0677016cfe4b7eabfd418b6c6ee1d938f16c7caf096540be7d90"

URI_aarch64_rust-uuid+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+std-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+std-devel}"
SRC_URI[aarch64_rust-uuid+std-devel.sha256sum] = "e35914c4dc0dc340ba8b02e928aff711f332c703965c5c2e82d90fa6c7fcf847"

URI_aarch64_rust-uuid+v1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v1-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+v1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v1-devel}"
SRC_URI[aarch64_rust-uuid+v1-devel.sha256sum] = "81bf5b8b5ae68ea7013e2a082e0d4ee61fa32723d6f9504da88ee1346f2e1925"

URI_aarch64_rust-uuid+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v3-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v3-devel}"
SRC_URI[aarch64_rust-uuid+v3-devel.sha256sum] = "7de033566b2ec55053493b1b977f565c032cfffa28d4501b263fe193fc8c0a28"

URI_aarch64_rust-uuid+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v4-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v4-devel}"
SRC_URI[aarch64_rust-uuid+v4-devel.sha256sum] = "7e51ba1166eb8c908888b1864551834529439c7a14eaaaac88d4f8e6588d6b81"

URI_aarch64_rust-uuid+v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v5-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v5-devel}"
SRC_URI[aarch64_rust-uuid+v5-devel.sha256sum] = "f32753724edc24e569c3e2997d46d2552d95747578ddd036d651d3eb866c5852"

URI_aarch64_rust-uuid+v6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v6-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+v6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v6-devel}"
SRC_URI[aarch64_rust-uuid+v6-devel.sha256sum] = "bb2922bad3aa8e5464d24203c5b6a657dcf0cc4125b6b52c6fb4dcc8e0c8bcf0"

URI_aarch64_rust-uuid+v7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v7-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v7-devel}"
SRC_URI[aarch64_rust-uuid+v7-devel.sha256sum] = "edb208295bf917eb2e5a96802b01f49b9212fe92b39bda04412c437b8bb974bd"

URI_aarch64_rust-uuid+v8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v8-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid+v8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v8-devel}"
SRC_URI[aarch64_rust-uuid+v8-devel.sha256sum] = "394b1666feaf66318e2055d281da0c4565872abeb0021d43be863d694eaacbf9"

URI_aarch64_rust-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid-devel-1.18.1-1.el10_0.noarch.rpm;name=aarch64_rust-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid-devel}"
SRC_URI[aarch64_rust-uuid-devel.sha256sum] = "59d732483d11c95183c4cbc380853b5ad641abb1fb16661f67f1a871cb82462a"

RDEPENDS:rust-uuid+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+atomic-devel = " \
 cargo \
 rust-atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+default-devel = " \
 cargo \
 rust-uuid+std-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+fast-rng-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+md5-devel = " \
 cargo \
 rust-md-5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-rand-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+sha1-devel = " \
 cargo \
 rust-sha1_smol-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+slog-devel = " \
 cargo \
 rust-slog+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+std-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v1-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v3-devel = " \
 cargo \
 rust-uuid+md5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v4-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v5-devel = " \
 cargo \
 rust-uuid+sha1-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v6-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v7-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v8-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid-devel = " \
 cargo \
 rust \
 "
