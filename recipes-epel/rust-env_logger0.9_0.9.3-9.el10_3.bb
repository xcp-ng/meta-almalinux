# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger0.9"
PV = "0.9.3"
PR = "9.el10_3"
PACKAGES = " \
 rust-env_logger0.9+atty-devel \
 rust-env_logger0.9+default-devel \
 rust-env_logger0.9+humantime-devel \
 rust-env_logger0.9+regex-devel \
 rust-env_logger0.9+termcolor-devel \
 rust-env_logger0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger0.9-0.9.3-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75ee25a6fa58bcd80e11971451c7b16589900d513273177f44a86740e656c99a"

URI_x86_64_v2_rust-env_logger0.9+atty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+atty-devel-0.9.3-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+atty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+atty-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+atty-devel.sha256sum] = "6fb7501476411970224dad715d2a40106dded9b8bbac6ac923554a118c70e445"

URI_x86_64_v2_rust-env_logger0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+default-devel-0.9.3-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+default-devel.sha256sum] = "948c610bb91f0b9fa3ad61f0468903e57b54ad20a82cc3fce8114d1c4aa218b7"

URI_x86_64_v2_rust-env_logger0.9+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+humantime-devel-0.9.3-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+humantime-devel.sha256sum] = "0fcf0fa277e402401ca82d0bfc4ab7fea7a4989449f05160f4d569503ba68302"

URI_x86_64_v2_rust-env_logger0.9+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+regex-devel-0.9.3-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+regex-devel.sha256sum] = "290107901c0e3d186d3ff4ebc912a8415373e2ea507cd90ef5fc35c994a0b041"

URI_x86_64_v2_rust-env_logger0.9+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9+termcolor-devel-0.9.3-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9+termcolor-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9+termcolor-devel.sha256sum] = "bee5db801e6a311700a9693462965ed8c89ad4f458e2c24521f0d7a36a1a4402"

URI_x86_64_v2_rust-env_logger0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.9-devel-0.9.3-9.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.9-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.9-devel.sha256sum] = "16212fa5d809874ff2754ef5c95087d7c274a70a3ee115aaf32394c3301ecfc0"
RPROVIDES:rust-env_logger0.9-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger0.9+atty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+atty-devel-0.9.3-9.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.9+atty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+atty-devel}"
SRC_URI[aarch64_rust-env_logger0.9+atty-devel.sha256sum] = "457da4b9e7c0b8156657da8260e7d5d13dc1405cadf4d3f547b22392431e69ef"

URI_aarch64_rust-env_logger0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+default-devel-0.9.3-9.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+default-devel}"
SRC_URI[aarch64_rust-env_logger0.9+default-devel.sha256sum] = "be510379ce15fda28ce78379ff09e24673306f03acb22096ab9e80dfbbe5fa4a"

URI_aarch64_rust-env_logger0.9+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+humantime-devel-0.9.3-9.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.9+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+humantime-devel}"
SRC_URI[aarch64_rust-env_logger0.9+humantime-devel.sha256sum] = "2e98c62e8061d889d4ee0b1f97d482866562ccf90e8e0fde570c71c53ebd93a0"

URI_aarch64_rust-env_logger0.9+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+regex-devel-0.9.3-9.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.9+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+regex-devel}"
SRC_URI[aarch64_rust-env_logger0.9+regex-devel.sha256sum] = "aefc7f3928273bdc53178593887ca06bf72d4d12a7745779cc7ed19ecd914406"

URI_aarch64_rust-env_logger0.9+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9+termcolor-devel-0.9.3-9.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.9+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9+termcolor-devel}"
SRC_URI[aarch64_rust-env_logger0.9+termcolor-devel.sha256sum] = "52ea88b73c982c2f61371ec591e5c4733b0359a2075cb8ae30104ec9752606ac"

URI_aarch64_rust-env_logger0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.9-devel-0.9.3-9.el10_3.noarch.rpm;name=aarch64_rust-env_logger0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.9-devel}"
SRC_URI[aarch64_rust-env_logger0.9-devel.sha256sum] = "cbc2d7471cfa5a6d53b57ea326a4886e4ac2296b655a826a82867c47dadde6a5"
RPROVIDES:rust-env_logger0.9-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger0.9+atty-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 "
RDEPENDS:rust-env_logger0.9+default-devel = " \
 cargo \
 rust-env_logger0.9+atty-devel \
 rust-env_logger0.9+humantime-devel \
 rust-env_logger0.9+regex-devel \
 rust-env_logger0.9+termcolor-devel \
 rust-env_logger0.9-devel \
 "
RDEPENDS:rust-env_logger0.9+humantime-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-humantime+default-devel \
 "
RDEPENDS:rust-env_logger0.9+regex-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_logger0.9+termcolor-devel = " \
 cargo \
 rust-env_logger0.9-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-env_logger0.9-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
