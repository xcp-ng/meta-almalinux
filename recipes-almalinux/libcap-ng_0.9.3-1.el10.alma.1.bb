# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcap-ng"
PV = "0.9.3"
PR = "1.el10.alma.1"
PACKAGES = " \
 libcap-ng \
 libcap-ng-devel \
 libcap-ng-python3 \
 libcap-ng-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcap-ng-0.9.3-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee547de06d201e4d735eb83876b16a4e00ab66a9cd55c1ff8e206bdb3f1da370"

URI_x86_64_v2_libcap-ng = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-ng-0.9.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libcap-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-ng}"
SRC_URI[x86_64_v2_libcap-ng.sha256sum] = "2c0d77d20e80b6cd47a64f78faacd3841c240109e3efca1d5e9d68fed71ab1bb"

URI_x86_64_v2_libcap-ng-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-ng-devel-0.9.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libcap-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-ng-devel}"
SRC_URI[x86_64_v2_libcap-ng-devel.sha256sum] = "49c23daf0de8a20ef1b63a76d1495ee81ca695ca2faa613232ad1da213cb56a5"

URI_x86_64_v2_libcap-ng-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-ng-python3-0.9.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libcap-ng-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-ng-python3}"
SRC_URI[x86_64_v2_libcap-ng-python3.sha256sum] = "2f753ad5e66d48dbdffe51070530a4ffe3056b1673fd07864481dbb36a8c2cd3"

URI_x86_64_v2_libcap-ng-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-ng-utils-0.9.3-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libcap-ng-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-ng-utils}"
SRC_URI[x86_64_v2_libcap-ng-utils.sha256sum] = "6e76d82254730899f6a59ed449ce40142a814c544009d9c438fd05c776af04ba"

URI_aarch64_libcap-ng = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcap-ng-0.9.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libcap-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-ng}"
SRC_URI[aarch64_libcap-ng.sha256sum] = "1558f39c0f63168c3903175e60e9242939edc1697eeb261a6367be183d5b4740"

URI_aarch64_libcap-ng-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcap-ng-devel-0.9.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libcap-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-ng-devel}"
SRC_URI[aarch64_libcap-ng-devel.sha256sum] = "9a57ecbf105ecac020c1ebd0291235fdf9443fae6e379fb2837a6bf585ccf73b"

URI_aarch64_libcap-ng-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcap-ng-python3-0.9.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libcap-ng-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-ng-python3}"
SRC_URI[aarch64_libcap-ng-python3.sha256sum] = "838b87b98832f304e87e5c92e70d96aaab773608992826d850511a483f61e958"

URI_aarch64_libcap-ng-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcap-ng-utils-0.9.3-1.el10.alma.1.aarch64.rpm;name=aarch64_libcap-ng-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-ng-utils}"
SRC_URI[aarch64_libcap-ng-utils.sha256sum] = "5e731daa7d1f6024efccf2b81706710e7db1dff19e311068e46998a56501e9fd"

RDEPENDS:libcap-ng = " \
 glibc \
 "
RDEPENDS:libcap-ng-devel = " \
 kernel-headers \
 libcap-ng \
 pkgconf-pkg-config \
 "
RDEPENDS:libcap-ng-python3 = " \
 glibc \
 libcap-ng \
 python3 \
 "
RDEPENDS:libcap-ng-utils = " \
 audit-libs \
 glibc \
 libbpf \
 libcap-ng \
 "
