# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-rust-orchard"
PV = "0.16.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-rust-orchard+default-devel \
 rust-tree-sitter-rust-orchard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-rust-orchard-0.16.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bec7355118abe3f277431b12abfda1158ff4ebca8e231d0d87a6d2d930467aea"

URI_x86_64_v2_rust-tree-sitter-rust-orchard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-rust-orchard+default-devel-0.16.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-rust-orchard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-rust-orchard+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-rust-orchard+default-devel.sha256sum] = "56ae94f47bc145cdc1015cf4375ac5cc54eeca046e0e9b8f4b23f6dd6b828b13"

URI_x86_64_v2_rust-tree-sitter-rust-orchard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-rust-orchard-devel-0.16.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-rust-orchard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-rust-orchard-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-rust-orchard-devel.sha256sum] = "2e1f2e4b80a9bba6b5d546a21310b6b4b7682b52069a162052a199c70beb5d11"

URI_aarch64_rust-tree-sitter-rust-orchard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-rust-orchard+default-devel-0.16.7-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-rust-orchard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-rust-orchard+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-rust-orchard+default-devel.sha256sum] = "75372cd5160dee3107dba1e1c18e78daba54367b195a84e94256d20def768338"

URI_aarch64_rust-tree-sitter-rust-orchard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-rust-orchard-devel-0.16.7-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-rust-orchard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-rust-orchard-devel}"
SRC_URI[aarch64_rust-tree-sitter-rust-orchard-devel.sha256sum] = "8ba6322c23ffbe04767a3842477eacdccfa898277cb273365bc3b63268289494"

RDEPENDS:rust-tree-sitter-rust-orchard+default-devel = " \
 cargo \
 rust-tree-sitter-rust-orchard-devel \
 "
RDEPENDS:rust-tree-sitter-rust-orchard-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
