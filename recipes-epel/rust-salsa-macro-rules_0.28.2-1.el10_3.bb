# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-salsa-macro-rules"
PV = "0.28.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-salsa-macro-rules+accumulator-devel \
 rust-salsa-macro-rules+default-devel \
 rust-salsa-macro-rules-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-salsa-macro-rules-0.28.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6550308dadfc7537706ff742e0745e87668bb7db9e6342bb4e6ab5394397b394"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa-macro-rules+accumulator-devel-0.28.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa-macro-rules+accumulator-devel;unpack=0"
SRC_URI[x86_64_v2_rust-salsa-macro-rules+accumulator-devel.sha256sum] = "d64dcd5a8039fdb359386cb6a6f60e7a74210a47720125504d73dd33f90f048e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa-macro-rules+default-devel-0.28.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa-macro-rules+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-salsa-macro-rules+default-devel.sha256sum] = "d17accc66d416337259e98588740d5c8f99919199a016a4e30229e770868e0f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa-macro-rules-devel-0.28.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa-macro-rules-devel;unpack=0"
SRC_URI[x86_64_v2_rust-salsa-macro-rules-devel.sha256sum] = "fbab3fd4b026def5fc2d97f916e3f34ea7d10bc696d18ea91a84f5a3606e0ba1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa-macro-rules+accumulator-devel-0.28.2-1.el10_3.noarch.rpm;name=aarch64_rust-salsa-macro-rules+accumulator-devel;unpack=0"
SRC_URI[aarch64_rust-salsa-macro-rules+accumulator-devel.sha256sum] = "b7cd0808c6c18068d0eb2ded41d51f5fb8e29225182d5a0131f267aae54b4dcf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa-macro-rules+default-devel-0.28.2-1.el10_3.noarch.rpm;name=aarch64_rust-salsa-macro-rules+default-devel;unpack=0"
SRC_URI[aarch64_rust-salsa-macro-rules+default-devel.sha256sum] = "7235f3bc9d8ab70d4889172eaea67860d8ee28904a75079bc8f7cbb950cfaf4c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa-macro-rules-devel-0.28.2-1.el10_3.noarch.rpm;name=aarch64_rust-salsa-macro-rules-devel;unpack=0"
SRC_URI[aarch64_rust-salsa-macro-rules-devel.sha256sum] = "36d99cce050e082d903413a5041217e30679cd73d92f128b33a47d1445736848"

RDEPENDS:rust-salsa-macro-rules+accumulator-devel = " \
 cargo \
 rust-salsa-macro-rules-devel \
 "
RDEPENDS:rust-salsa-macro-rules+default-devel = " \
 cargo \
 rust-salsa-macro-rules-devel \
 "
RDEPENDS:rust-salsa-macro-rules-devel = " \
 cargo \
 rust \
 "
