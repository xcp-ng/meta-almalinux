# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config"
PV = "0.25.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-build-config+abi3-devel \
 rust-pyo3-build-config+abi3-py310-devel \
 rust-pyo3-build-config+abi3-py311-devel \
 rust-pyo3-build-config+abi3-py312-devel \
 rust-pyo3-build-config+abi3-py313-devel \
 rust-pyo3-build-config+abi3-py314-devel \
 rust-pyo3-build-config+abi3-py37-devel \
 rust-pyo3-build-config+abi3-py38-devel \
 rust-pyo3-build-config+abi3-py39-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+extension-module-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-pyo3-build-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config-0.25.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "975f9833fc47719a4bc972f2a0085aa9abc852904c1e14222197234b7729f0f9"

URI_x86_64_v2_rust-pyo3-build-config+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-devel.sha256sum] = "6ec607c9c9be4c0ec97f0345a5446596fb986a77d6721428b5662a0a693fdabf"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py310-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py310-devel.sha256sum] = "dab71a4e971c9a51cc10cb84a58b01ee8ae5d902332618068025ac640f04abbe"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py311-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py311-devel.sha256sum] = "627801a66b689580b46d65f0b75e405e033fdbc11abeb944433878ba238fd3c7"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py312-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py312-devel.sha256sum] = "730733f957ca2c371f4796eb05cfb25ecbb5015e64ed82513ef94da2cf5144d2"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py313-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py313-devel.sha256sum] = "b0139a956db65a89f16dcf9ef6229a343068084e62f332dcc688237455e8a22a"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py314-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py314-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py314-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py314-devel.sha256sum] = "7e6c6419c6f48aa72b6798625733f7172b2805a0c4b976054afb5e349b91deb8"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py37-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py37-devel.sha256sum] = "7001f1da25c4be70c5b31d1501216e332147019fd6b704ea33232bc8615a4641"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py38-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py38-devel.sha256sum] = "6b63045c78a6b453dc511fb5fd1559db326aff674888d4ad66375f37147427c0"

URI_x86_64_v2_rust-pyo3-build-config+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+abi3-py39-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+abi3-py39-devel.sha256sum] = "f2c21c5a957ce6836184a90299d9ec86e743a256d48f79bc7309d636dc34148a"

URI_x86_64_v2_rust-pyo3-build-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+default-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+default-devel.sha256sum] = "fe097d64e173ed212c1cfd845bbb1cf9b2aadb912b76f0806c8706ba81fe7a42"

URI_x86_64_v2_rust-pyo3-build-config+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+extension-module-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+extension-module-devel.sha256sum] = "5bc578ebd6e632a3ae4fe62f71430c65342cddfa19125f542f00d817cf8b221b"

URI_x86_64_v2_rust-pyo3-build-config+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config+resolve-config-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config+resolve-config-devel.sha256sum] = "69fd99ce77284fa82b85993f50e19768a72619875e0b311482b9f4579d9e8324"

URI_x86_64_v2_rust-pyo3-build-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config-devel-0.25.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config-devel.sha256sum] = "0ccd7b81d6d88d0c9fc9cf5d0d3be5d329b3a3417d2627aeed73c402aa5a036a"

URI_aarch64_rust-pyo3-build-config+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-devel.sha256sum] = "10d0395b33823a97d671b1fa05bc7c8e1fb3a32a3dfcf3b142f25255a58eed81"

URI_aarch64_rust-pyo3-build-config+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py310-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py310-devel.sha256sum] = "a7c22d6443b5087b13a4071bff2432c06c6396c6e0d8730cde409565f6aa3806"

URI_aarch64_rust-pyo3-build-config+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py311-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py311-devel.sha256sum] = "d3379d329855bd078dbd9f75e79b893f099727bede3a8e05b62495ddcaacd08f"

URI_aarch64_rust-pyo3-build-config+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py312-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py312-devel.sha256sum] = "c4282280de25755bc20662232fa75c7fd3cbda2eec5e24f46e13cdba50fd2e6e"

URI_aarch64_rust-pyo3-build-config+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py313-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py313-devel.sha256sum] = "ebb1cc2631a3f6aadaeea7155c4240e943b7613c1c93213766d33777d865530d"

URI_aarch64_rust-pyo3-build-config+abi3-py314-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py314-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py314-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py314-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py314-devel.sha256sum] = "0a506748379236c41b157ab4267e4011f3079ad95ba2cf31af329501b351605d"

URI_aarch64_rust-pyo3-build-config+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py37-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py37-devel.sha256sum] = "147afb5c6a5eb6265f7e53201b685ac656af3ca5d895b32fdb8d26af1dfc465f"

URI_aarch64_rust-pyo3-build-config+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py38-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py38-devel.sha256sum] = "73d63aa73a016d78be4ae62b16d3b49fd9ff99524d001492706ab055ea51f054"

URI_aarch64_rust-pyo3-build-config+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+abi3-py39-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+abi3-py39-devel.sha256sum] = "a90ed8e2171472fd4b906c4e0e5c62d83d013947266963b60fef618ce652612e"

URI_aarch64_rust-pyo3-build-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+default-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+default-devel.sha256sum] = "0a37419c6986c1609043cba3255bd30b505cd405da9cb49597849a03e3c33e55"

URI_aarch64_rust-pyo3-build-config+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+extension-module-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+extension-module-devel.sha256sum] = "a2789560922bc13a4a615e137527b0ec2a9e8d56024c0122811e94d73dd28257"

URI_aarch64_rust-pyo3-build-config+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config+resolve-config-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config+resolve-config-devel.sha256sum] = "8be49e02073bec7c855ddb0d33386751ad4be09bc54296d92eeddce555d39613"

URI_aarch64_rust-pyo3-build-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config-devel-0.25.1-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-build-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config-devel.sha256sum] = "425a6c7cb49ed3fbc22720ce84b0ef40efa700b467c1381b980f0e95466e3ac3"

RDEPENDS:rust-pyo3-build-config+abi3-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py311-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py312-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py313-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py313-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py314-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py314-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py38-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py39-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config+abi3-py310-devel \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+default-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config-devel \
 "
RDEPENDS:rust-pyo3-build-config-devel = " \
 cargo \
 python3 \
 rust \
 rust-once_cell+default-devel \
 rust-target-lexicon+default-devel \
 "
