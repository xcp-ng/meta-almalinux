# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ascii-canvas"
PV = "4.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-ascii-canvas+default-devel \
 rust-ascii-canvas-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ascii-canvas-4.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86d7b63b38c1f753a4bb2e795b5673af0c8812a2332030ab92e2dbce561cbc93"

URI_x86_64_v2_rust-ascii-canvas+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ascii-canvas+default-devel-4.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ascii-canvas+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ascii-canvas+default-devel}"
SRC_URI[x86_64_v2_rust-ascii-canvas+default-devel.sha256sum] = "cba14c23c4428125f0a2d4b47bb777fa4bb12bd2837c0b8e0a48a5a9a976bfe6"

URI_x86_64_v2_rust-ascii-canvas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ascii-canvas-devel-4.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ascii-canvas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ascii-canvas-devel}"
SRC_URI[x86_64_v2_rust-ascii-canvas-devel.sha256sum] = "5d51947ad2a1def614291857656888080282fbf5c23eb65c68c53def46e14bac"

URI_aarch64_rust-ascii-canvas+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ascii-canvas+default-devel-4.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-ascii-canvas+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ascii-canvas+default-devel}"
SRC_URI[aarch64_rust-ascii-canvas+default-devel.sha256sum] = "b56262eac25419a5f8007641e26a8c527516a21311682672af997b30f49950d8"

URI_aarch64_rust-ascii-canvas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ascii-canvas-devel-4.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-ascii-canvas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ascii-canvas-devel}"
SRC_URI[aarch64_rust-ascii-canvas-devel.sha256sum] = "75b9e2ce66e351b32dcdae8cbaff07e8c4ad5f61aecd704f5e1892f638f1f68f"

RDEPENDS:rust-ascii-canvas+default-devel = " \
 cargo \
 rust-ascii-canvas-devel \
 "
RDEPENDS:rust-ascii-canvas-devel = " \
 cargo \
 rust \
 rust-term+default-devel \
 "
