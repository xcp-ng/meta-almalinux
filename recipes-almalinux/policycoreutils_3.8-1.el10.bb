# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "policycoreutils"
PV = "3.8"
PR = "1.el10"
PACKAGES = " \
 policycoreutils \
 policycoreutils-dbus \
 policycoreutils-devel \
 policycoreutils-gui \
 policycoreutils-newrole \
 policycoreutils-python-utils \
 policycoreutils-restorecond \
 policycoreutils-sandbox \
 python3-policycoreutils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/policycoreutils-3.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2152ee99700e607041d48ec9d72d92ab1e6ca84062e061b726cb3965b22c8655"

URI_x86_64_v2_policycoreutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/policycoreutils-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils}"
SRC_URI[x86_64_v2_policycoreutils.sha256sum] = "8c878688a575e3de24c8dee9c8d64e37ea8572ac62d1abd6388de113f99ed347"

URI_x86_64_v2_policycoreutils-dbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-dbus-3.8-1.el10.noarch.rpm;name=x86_64_v2_policycoreutils-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-dbus}"
SRC_URI[x86_64_v2_policycoreutils-dbus.sha256sum] = "6c83f8ca4ab8bf4ef64882ce2728dd4745d6636f8f5a57db28ca7c3663047888"

URI_x86_64_v2_policycoreutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-devel-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-devel}"
SRC_URI[x86_64_v2_policycoreutils-devel.sha256sum] = "13f121572f2444805c05249fb8b0cd4dce5663c7212dd8c498d716fc4a2504a4"

URI_x86_64_v2_policycoreutils-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-gui-3.8-1.el10.noarch.rpm;name=x86_64_v2_policycoreutils-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-gui}"
SRC_URI[x86_64_v2_policycoreutils-gui.sha256sum] = "9368d2e458907de14501898c8c06dc9e6eb2834075b4c8abd61369a27e1236ba"

URI_x86_64_v2_policycoreutils-newrole = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/policycoreutils-newrole-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-newrole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-newrole}"
SRC_URI[x86_64_v2_policycoreutils-newrole.sha256sum] = "4e49e1d89c7115ffdd96388da2ab14967e828bb5af8e4c17301c8b12f7dd1353"

URI_x86_64_v2_policycoreutils-python-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-python-utils-3.8-1.el10.noarch.rpm;name=x86_64_v2_policycoreutils-python-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-python-utils}"
SRC_URI[x86_64_v2_policycoreutils-python-utils.sha256sum] = "e1dc6d7fae25024f068a9f0989bfb16b13093f5820640be8b1e4b542fad7b0ba"

URI_x86_64_v2_policycoreutils-restorecond = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/policycoreutils-restorecond-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-restorecond;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-restorecond}"
SRC_URI[x86_64_v2_policycoreutils-restorecond.sha256sum] = "89cc0553081211cdb921306a152d902edd6136cda016f80c2e6c57df23a0e057"

URI_x86_64_v2_policycoreutils-sandbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/policycoreutils-sandbox-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_policycoreutils-sandbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_policycoreutils-sandbox}"
SRC_URI[x86_64_v2_policycoreutils-sandbox.sha256sum] = "20848fa972e6af8588d6de2be611c8e0e82fe94777f63b0b629f161163ca74b3"

URI_x86_64_v2_python3-policycoreutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-policycoreutils-3.8-1.el10.noarch.rpm;name=x86_64_v2_python3-policycoreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-policycoreutils}"
SRC_URI[x86_64_v2_python3-policycoreutils.sha256sum] = "edaec2ae8d1cdf15aec40f1f3f1132e1390e6e61de969b8329c29301d584be8d"

URI_aarch64_policycoreutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/policycoreutils-3.8-1.el10.aarch64.rpm;name=aarch64_policycoreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils}"
SRC_URI[aarch64_policycoreutils.sha256sum] = "46aac1ef0da0e79c707faa41af5f6b35e97f2156c21c8be2775fa09ed0934c58"

URI_aarch64_policycoreutils-dbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-dbus-3.8-1.el10.noarch.rpm;name=aarch64_policycoreutils-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-dbus}"
SRC_URI[aarch64_policycoreutils-dbus.sha256sum] = "6c83f8ca4ab8bf4ef64882ce2728dd4745d6636f8f5a57db28ca7c3663047888"

URI_aarch64_policycoreutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-devel-3.8-1.el10.aarch64.rpm;name=aarch64_policycoreutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-devel}"
SRC_URI[aarch64_policycoreutils-devel.sha256sum] = "4999232b66485fb3804776c3aac78ddab9c8c53dad8d2d0e989e734975df64ba"

URI_aarch64_policycoreutils-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-gui-3.8-1.el10.noarch.rpm;name=aarch64_policycoreutils-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-gui}"
SRC_URI[aarch64_policycoreutils-gui.sha256sum] = "9368d2e458907de14501898c8c06dc9e6eb2834075b4c8abd61369a27e1236ba"

URI_aarch64_policycoreutils-newrole = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/policycoreutils-newrole-3.8-1.el10.aarch64.rpm;name=aarch64_policycoreutils-newrole;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-newrole}"
SRC_URI[aarch64_policycoreutils-newrole.sha256sum] = "6ecc4c44f37956c4337311ca1cf7ebe157bade75819e0a9b84848d5a2f2c05b7"

URI_aarch64_policycoreutils-python-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-python-utils-3.8-1.el10.noarch.rpm;name=aarch64_policycoreutils-python-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-python-utils}"
SRC_URI[aarch64_policycoreutils-python-utils.sha256sum] = "e1dc6d7fae25024f068a9f0989bfb16b13093f5820640be8b1e4b542fad7b0ba"

URI_aarch64_policycoreutils-restorecond = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/policycoreutils-restorecond-3.8-1.el10.aarch64.rpm;name=aarch64_policycoreutils-restorecond;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-restorecond}"
SRC_URI[aarch64_policycoreutils-restorecond.sha256sum] = "8af24476d2335493bfd11b501db3f758021c24805bee10830801cc7966286c11"

URI_aarch64_policycoreutils-sandbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/policycoreutils-sandbox-3.8-1.el10.aarch64.rpm;name=aarch64_policycoreutils-sandbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_policycoreutils-sandbox}"
SRC_URI[aarch64_policycoreutils-sandbox.sha256sum] = "c62ebb249cf5b97943ff75f25f08971e0f4e2aa857bd5b022ede0f13a339be24"

URI_aarch64_python3-policycoreutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-policycoreutils-3.8-1.el10.noarch.rpm;name=aarch64_python3-policycoreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-policycoreutils}"
SRC_URI[aarch64_python3-policycoreutils.sha256sum] = "edaec2ae8d1cdf15aec40f1f3f1132e1390e6e61de969b8329c29301d584be8d"

RDEPENDS:policycoreutils = " \
 audit-libs \
 bash \
 diffutils \
 gawk \
 glibc \
 grep \
 libselinux \
 libselinux-utils \
 libsemanage \
 libsepol \
 rpm \
 sed \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:policycoreutils-dbus = " \
 polkit \
 python3 \
 python3-gobject-base \
 python3-policycoreutils \
 "
RDEPENDS:policycoreutils-devel = " \
 glibc \
 libselinux \
 make \
 policycoreutils-python-utils \
 python3 \
 python3-dnf \
 selinux-policy-devel \
 "
RDEPENDS:policycoreutils-gui = " \
 bash \
 gtk3 \
 policycoreutils-dbus \
 policycoreutils-devel \
 python3 \
 python3-gobject \
 python3-policycoreutils \
 "
RDEPENDS:policycoreutils-newrole = " \
 audit-libs \
 glibc \
 libcap-ng \
 libselinux \
 pam-libs \
 policycoreutils \
 "
RDEPENDS:policycoreutils-python-utils = " \
 python3 \
 python3-policycoreutils \
 "
RDEPENDS:policycoreutils-restorecond = " \
 bash \
 glib2 \
 glibc \
 libselinux \
 "
RDEPENDS:policycoreutils-sandbox = " \
 bash \
 glibc \
 libcap-ng \
 libselinux \
 python3 \
 python3-policycoreutils \
 rsync \
 "
RDEPENDS:python3-policycoreutils = " \
 checkpolicy \
 policycoreutils \
 python3 \
 python3-audit \
 python3-distro \
 python3-libselinux \
 python3-libsemanage \
 python3-setools \
 "
