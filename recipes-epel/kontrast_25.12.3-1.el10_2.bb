# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontrast"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kontrast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontrast-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4920b5459786659b9ad31b9d69eac2036498107082dd331377408a7eedbecd75"

URI_x86_64_v2_kontrast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontrast-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontrast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontrast}"
SRC_URI[x86_64_v2_kontrast.sha256sum] = "de21bcbd0cb7dd501f00f956d32c7be4bdfb557c3318d585e05b5b0b06e10a53"

URI_aarch64_kontrast = "${EPEL_MIRROR}/aarch64/Packages/k/kontrast-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kontrast;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontrast}"
SRC_URI[aarch64_kontrast.sha256sum] = "bf2180ab17dad05e7aabf1e0ac16b2bbbd8b323b3cb69d83eeeefa395527d908"

RDEPENDS:kontrast = " \
 futuresql-qt6 \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
