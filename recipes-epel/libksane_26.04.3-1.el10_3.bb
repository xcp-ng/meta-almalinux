# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksane"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libksane \
 libksane-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksane-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "452d77424a123a4b238a14f86d640afda3bff35e85c717c2970f06930d30c892"

URI_x86_64_v2_libksane = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksane}"
SRC_URI[x86_64_v2_libksane.sha256sum] = "adf5609b12d91f6bc61c55cdb4795053e1f1d44063c9322e02fd40479d1090da"

URI_x86_64_v2_libksane-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksane-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksane-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksane-devel}"
SRC_URI[x86_64_v2_libksane-devel.sha256sum] = "b496d1485ae06f4271046e6d2db2e5f4bab91f727689b78d4bb4b8a83622b741"

URI_aarch64_libksane = "${EPEL_MIRROR}/aarch64/Packages/l/libksane-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libksane;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksane}"
SRC_URI[aarch64_libksane.sha256sum] = "ce7de8f532fe474e13496279c7d2d3de4fcef6fc08f220f9cbb7c33aa64d2868"

URI_aarch64_libksane-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksane-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libksane-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksane-devel}"
SRC_URI[aarch64_libksane-devel.sha256sum] = "eb8417911dabbfd84b4114982f1375005d2658b060738877c8f0ae93af32684a"

RDEPENDS:libksane = " \
 glibc \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 ksanecore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libksane-devel = " \
 cmake-filesystem \
 libksane \
 qt6-qtbase-devel \
 "
