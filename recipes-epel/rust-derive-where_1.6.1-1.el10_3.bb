# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive-where"
PV = "1.6.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-derive-where+default-devel \
 rust-derive-where+nightly-devel \
 rust-derive-where+safe-devel \
 rust-derive-where+serde-devel \
 rust-derive-where+zeroize-devel \
 rust-derive-where+zeroize-on-drop-devel \
 rust-derive-where-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive-where-1.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55f0922f811ba5e07dff38de19c90c2d8247540e2b2ce78d5eeeacb201358109"

URI_x86_64_v2_rust-derive-where+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+default-devel-1.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+default-devel}"
SRC_URI[x86_64_v2_rust-derive-where+default-devel.sha256sum] = "423bc06ba5ef5f431bf91f44a15aedd50738109ccf45cecd32786edce747b9be"

URI_x86_64_v2_rust-derive-where+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+nightly-devel-1.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+nightly-devel}"
SRC_URI[x86_64_v2_rust-derive-where+nightly-devel.sha256sum] = "613fac709d2da11698e4c44a8f79ccb91ea81553d8dd284df9d62b44c457cd31"

URI_x86_64_v2_rust-derive-where+safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+safe-devel-1.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+safe-devel}"
SRC_URI[x86_64_v2_rust-derive-where+safe-devel.sha256sum] = "1659ea2672a3ccef1749926c26e30a94d79968f6cbd87f01ab9c81c6189af402"

URI_x86_64_v2_rust-derive-where+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+serde-devel-1.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+serde-devel}"
SRC_URI[x86_64_v2_rust-derive-where+serde-devel.sha256sum] = "b86db6f269acab4404fb86f120e41ffda7b1e710ba40ad9d14a925fccde4e0f1"

URI_x86_64_v2_rust-derive-where+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-devel-1.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+zeroize-devel}"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-devel.sha256sum] = "1ac5fea1298a2bef70db0f5d88e3166a646d1f58ea2cf0750b6cdb2468bf7bfd"

URI_x86_64_v2_rust-derive-where+zeroize-on-drop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-on-drop-devel-1.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+zeroize-on-drop-devel}"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "25ca5590a6b4c4166bdcc82b0d699070dcaa78331e32b00b655363dcf62cc61b"

URI_x86_64_v2_rust-derive-where-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where-devel-1.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where-devel}"
SRC_URI[x86_64_v2_rust-derive-where-devel.sha256sum] = "cdd58b0567168f818d30dd0ba13c6338fc796648ca6c3b2d8d6d469ede08dca3"

URI_aarch64_rust-derive-where+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+default-devel-1.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+default-devel}"
SRC_URI[aarch64_rust-derive-where+default-devel.sha256sum] = "cceaae7c85bd39389c26a3e8e1d52c1ed2f5205cc7c1e668f9367d6d1c7b23c6"

URI_aarch64_rust-derive-where+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+nightly-devel-1.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+nightly-devel}"
SRC_URI[aarch64_rust-derive-where+nightly-devel.sha256sum] = "289e8060342ac3242ffe44fa8e11fb2215549e8c66ae8de4d26b29530e802e66"

URI_aarch64_rust-derive-where+safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+safe-devel-1.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+safe-devel}"
SRC_URI[aarch64_rust-derive-where+safe-devel.sha256sum] = "90a05e2a9e47b830f62de7b4b3ebdbd474f0ae29a295877699e9215bc5f3e2f5"

URI_aarch64_rust-derive-where+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+serde-devel-1.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+serde-devel}"
SRC_URI[aarch64_rust-derive-where+serde-devel.sha256sum] = "af889245992a94857083ae754e8e0a600e193eb5b37aea6bf8fc9970955929db"

URI_aarch64_rust-derive-where+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-devel-1.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+zeroize-devel}"
SRC_URI[aarch64_rust-derive-where+zeroize-devel.sha256sum] = "d769472e174cfc36ebc01af4a6cde3a66b552f613d68014e8b9e2bf4dea082bc"

URI_aarch64_rust-derive-where+zeroize-on-drop-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-on-drop-devel-1.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+zeroize-on-drop-devel}"
SRC_URI[aarch64_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "fbf9051e192f11ed1f0432fc70b5e623959a6e7dba8fbbd513d446b97945aeb1"

URI_aarch64_rust-derive-where-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where-devel-1.6.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive-where-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where-devel}"
SRC_URI[aarch64_rust-derive-where-devel.sha256sum] = "d74512a2f3b4599297d1f8f26ce21eb68c8f5b9f6870d6c551009773f4744c9b"

RDEPENDS:rust-derive-where+default-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+nightly-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+safe-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+serde-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-on-drop-devel = " \
 cargo \
 rust-derive-where+zeroize-devel \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+derive-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2-devel \
 "
