# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xio-rate-driver"
PV = "2.1"
PR = "11.el10_0"
PACKAGES = " \
 globus-xio-rate-driver \
 globus-xio-rate-driver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-xio-rate-driver-2.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2487f68e3a00d420c1545de37ac0aa222c6de75a66df8ba637f93b609646430"

URI_x86_64_v2_globus-xio-rate-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-rate-driver-2.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-rate-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-rate-driver}"
SRC_URI[x86_64_v2_globus-xio-rate-driver.sha256sum] = "ce497f78a75c4daeed583346225aab737e0df27195da5b7fb525eba10486054d"

URI_x86_64_v2_globus-xio-rate-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-rate-driver-devel-2.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-rate-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-rate-driver-devel}"
SRC_URI[x86_64_v2_globus-xio-rate-driver-devel.sha256sum] = "9d2511a84bedef700168b4e1be43589d48908c35d06806e857db0030b2c9548e"

URI_aarch64_globus-xio-rate-driver = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-rate-driver-2.1-11.el10_0.aarch64.rpm;name=aarch64_globus-xio-rate-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-rate-driver}"
SRC_URI[aarch64_globus-xio-rate-driver.sha256sum] = "3b0c534b4c7515454c4625a330faef5afd0b9ce08dab7dfefe866aa6834cb25f"

URI_aarch64_globus-xio-rate-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-rate-driver-devel-2.1-11.el10_0.aarch64.rpm;name=aarch64_globus-xio-rate-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-rate-driver-devel}"
SRC_URI[aarch64_globus-xio-rate-driver-devel.sha256sum] = "9554cd70ca6a5e42b007a97b58f46495783f33f0cb1c94f866652d4ea73e724f"

RDEPENDS:globus-xio-rate-driver = " \
 glibc \
 globus-common \
 globus-xio \
 "
RDEPENDS:globus-xio-rate-driver-devel = " \
 globus-common-devel \
 globus-xio-devel \
 globus-xio-rate-driver \
 pkgconf-pkg-config \
 "
