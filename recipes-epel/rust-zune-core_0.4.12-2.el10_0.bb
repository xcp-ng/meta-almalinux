# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-core"
PV = "0.4.12"
PR = "2.el10_0"
PACKAGES = " \
 rust-zune-core+default-devel \
 rust-zune-core+log-devel \
 rust-zune-core+serde-devel \
 rust-zune-core+std-devel \
 rust-zune-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-core-0.4.12-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ca5bbff242a6fe4b77e9da74be1299ba81f4169c9c5b2a61c001d6650e6d72c"

URI_x86_64_v2_rust-zune-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+default-devel-0.4.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+default-devel}"
SRC_URI[x86_64_v2_rust-zune-core+default-devel.sha256sum] = "ddb672211b4fa0ebcc777bf7dbcc12f37e787849ff5a49d565c32326a0ce8b7c"

URI_x86_64_v2_rust-zune-core+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+log-devel-0.4.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+log-devel}"
SRC_URI[x86_64_v2_rust-zune-core+log-devel.sha256sum] = "10504332393f3bf88677ec23f9c8d3a9f40553025e7076251b8332edd938b43c"

URI_x86_64_v2_rust-zune-core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+serde-devel-0.4.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+serde-devel}"
SRC_URI[x86_64_v2_rust-zune-core+serde-devel.sha256sum] = "83382ba48c8f53672cbc96473ac7d7bc86fbf656ec3b481c70ee88fcc97ab0a1"

URI_x86_64_v2_rust-zune-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core+std-devel-0.4.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core+std-devel}"
SRC_URI[x86_64_v2_rust-zune-core+std-devel.sha256sum] = "f63d3607e239f593c7036fe6740cebbbec0ee080b8bd8808f11f6e0a97865347"

URI_x86_64_v2_rust-zune-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-core-devel-0.4.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-core-devel}"
SRC_URI[x86_64_v2_rust-zune-core-devel.sha256sum] = "deb7c579f4b0b41d0a43863ea544140ca755b3e25befdbac516905f7468191a6"

URI_aarch64_rust-zune-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+default-devel-0.4.12-2.el10_0.noarch.rpm;name=aarch64_rust-zune-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+default-devel}"
SRC_URI[aarch64_rust-zune-core+default-devel.sha256sum] = "73c9eb04b7950279dda778679e483352eb57c8b554b017839bffccbf92fd7119"

URI_aarch64_rust-zune-core+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+log-devel-0.4.12-2.el10_0.noarch.rpm;name=aarch64_rust-zune-core+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+log-devel}"
SRC_URI[aarch64_rust-zune-core+log-devel.sha256sum] = "6ef6f6cf09b9b296d329d1724d0e5f9aba5f9b1d9e7ec1edecf501ad3a29fb5d"

URI_aarch64_rust-zune-core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+serde-devel-0.4.12-2.el10_0.noarch.rpm;name=aarch64_rust-zune-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+serde-devel}"
SRC_URI[aarch64_rust-zune-core+serde-devel.sha256sum] = "f7dd2c526313343677057825c0afd209524c1b833c52d1414c21b670e8b28e8b"

URI_aarch64_rust-zune-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core+std-devel-0.4.12-2.el10_0.noarch.rpm;name=aarch64_rust-zune-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core+std-devel}"
SRC_URI[aarch64_rust-zune-core+std-devel.sha256sum] = "ad7f4e833b1edff63b70c71749ae3dcb1809cd4a8bf9009de88acefe84d89558"

URI_aarch64_rust-zune-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-core-devel-0.4.12-2.el10_0.noarch.rpm;name=aarch64_rust-zune-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-core-devel}"
SRC_URI[aarch64_rust-zune-core-devel.sha256sum] = "e26854e553b8919b560b4542f967e012c137a94cdf81aaa827a932d44bfd156b"

RDEPENDS:rust-zune-core+default-devel = " \
 cargo \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core+std-devel = " \
 cargo \
 rust-zune-core-devel \
 "
RDEPENDS:rust-zune-core-devel = " \
 cargo \
 "
