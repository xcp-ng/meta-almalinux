# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-partitionmanager"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kde-partitionmanager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-partitionmanager-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16d71e4053634f7ded1e0c82868372ba8ea4e174baf334585aa8755e00a75e79"

URI_x86_64_v2_kde-partitionmanager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-partitionmanager-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-partitionmanager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-partitionmanager}"
SRC_URI[x86_64_v2_kde-partitionmanager.sha256sum] = "83a6e80fece1ea9d05c62765a1a0f3e54b5a57e524c45392212be6ddcd30be6f"

URI_aarch64_kde-partitionmanager = "${EPEL_MIRROR}/aarch64/Packages/k/kde-partitionmanager-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kde-partitionmanager;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-partitionmanager}"
SRC_URI[aarch64_kde-partitionmanager.sha256sum] = "ec924138b4cda6e2ca95ba38fa73fa2be3591cee15823554dcc7026a833a7ca0"

RDEPENDS:kde-partitionmanager = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kpmcore \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
