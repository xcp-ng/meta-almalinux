# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trybuild"
PV = "1.0.112"
PR = "1.el10_1"
PACKAGES = " \
 rust-trybuild+default-devel \
 rust-trybuild+diff-devel \
 rust-trybuild-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-trybuild-1.0.112-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "659497d9392b3a77bd69400bd3ccc8b22dcbb66a83e80626b543bb427f9b5b55"

URI_x86_64_v2_rust-trybuild+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild+default-devel-1.0.112-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild+default-devel}"
SRC_URI[x86_64_v2_rust-trybuild+default-devel.sha256sum] = "87c63b1a5af978058ae1e86aa1ff0fa61c14775e79a529d130b4a82bace6cd88"

URI_x86_64_v2_rust-trybuild+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild+diff-devel-1.0.112-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild+diff-devel}"
SRC_URI[x86_64_v2_rust-trybuild+diff-devel.sha256sum] = "87c082551654661e09375599488eaa42772c74717268211a90b32ece0d8f4474"

URI_x86_64_v2_rust-trybuild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trybuild-devel-1.0.112-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trybuild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-trybuild-devel}"
SRC_URI[x86_64_v2_rust-trybuild-devel.sha256sum] = "f6235d04094a4419e3b77dc16dd41663128b157db60302c3d03e66997cf83141"

URI_aarch64_rust-trybuild+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild+default-devel-1.0.112-1.el10_1.noarch.rpm;name=aarch64_rust-trybuild+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild+default-devel}"
SRC_URI[aarch64_rust-trybuild+default-devel.sha256sum] = "4d4a190b9952d05282339276b0d7008447f9babe441890ce97d1b553f820863f"

URI_aarch64_rust-trybuild+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild+diff-devel-1.0.112-1.el10_1.noarch.rpm;name=aarch64_rust-trybuild+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild+diff-devel}"
SRC_URI[aarch64_rust-trybuild+diff-devel.sha256sum] = "fd3fc55adf3cb321bd8402a2db674a03693b66b674ed22161b24d2a2382206a5"

URI_aarch64_rust-trybuild-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-trybuild-devel-1.0.112-1.el10_1.noarch.rpm;name=aarch64_rust-trybuild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-trybuild-devel}"
SRC_URI[aarch64_rust-trybuild-devel.sha256sum] = "ce992939e3ea9dc6082f70b0482f46d4b7352c51b5d73695f03626972a548d14"

RDEPENDS:rust-trybuild+default-devel = " \
 cargo \
 rust-trybuild-devel \
 "
RDEPENDS:rust-trybuild+diff-devel = " \
 cargo \
 rust-dissimilar+default-devel \
 rust-trybuild-devel \
 "
RDEPENDS:rust-trybuild-devel = " \
 cargo \
 rust \
 rust-glob+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-target-triple+default-devel \
 rust-termcolor+default-devel \
 rust-toml+default-devel \
 "
