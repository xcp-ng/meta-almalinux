# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stats_alloc"
PV = "0.1.10"
PR = "5.el10_0"
PACKAGES = " \
 rust-stats_alloc+default-devel \
 rust-stats_alloc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stats_alloc-0.1.10-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23e1130a71b6ce4bd09d8a48c1a2ccc976c5673f1de651a3fee1f056a2fc001b"

URI_x86_64_v2_rust-stats_alloc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stats_alloc+default-devel-0.1.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stats_alloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stats_alloc+default-devel}"
SRC_URI[x86_64_v2_rust-stats_alloc+default-devel.sha256sum] = "e1779fa4dee5ff449e32c7860d49ea84a2a4a27ff7dc84975b14fc503e6e4060"

URI_x86_64_v2_rust-stats_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stats_alloc-devel-0.1.10-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stats_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stats_alloc-devel}"
SRC_URI[x86_64_v2_rust-stats_alloc-devel.sha256sum] = "fd224f2adde9dca4529c6e07f1ea234d81625554fe8550fba78d6fb29630f397"

URI_aarch64_rust-stats_alloc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stats_alloc+default-devel-0.1.10-5.el10_0.noarch.rpm;name=aarch64_rust-stats_alloc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stats_alloc+default-devel}"
SRC_URI[aarch64_rust-stats_alloc+default-devel.sha256sum] = "527f52003594b4443036c2aee5dddb5d0ec911b6612bc51c88a1d858c5dc997e"

URI_aarch64_rust-stats_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stats_alloc-devel-0.1.10-5.el10_0.noarch.rpm;name=aarch64_rust-stats_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stats_alloc-devel}"
SRC_URI[aarch64_rust-stats_alloc-devel.sha256sum] = "120ed6679e5fc58491c1231ab1e2e149d55567962648b334891f900092e358c6"

RDEPENDS:rust-stats_alloc+default-devel = " \
 cargo \
 rust-stats_alloc-devel \
 "
RDEPENDS:rust-stats_alloc-devel = " \
 cargo \
 "
