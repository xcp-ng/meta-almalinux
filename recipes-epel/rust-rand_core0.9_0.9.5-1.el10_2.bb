# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_core0.9"
PV = "0.9.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_core0.9+default-devel \
 rust-rand_core0.9+os_rng-devel \
 rust-rand_core0.9+serde-devel \
 rust-rand_core0.9+std-devel \
 rust-rand_core0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_core0.9-0.9.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f522aa9a4afb7ff80a4a842091abfaa207cf905ab22e54bce40b2bef4065b6a8"

URI_x86_64_v2_rust-rand_core0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.9+default-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.9+default-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.9+default-devel.sha256sum] = "013485b0f060ab3ee2c524cc4141e964c21ab018c5aa8ae48d1c10c2f2068ad3"

URI_x86_64_v2_rust-rand_core0.9+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.9+os_rng-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.9+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.9+os_rng-devel.sha256sum] = "56416c5e00a4b0eedec22a6cdd30c4bcdaecf473e2e5abcddb53381c061c67f4"

URI_x86_64_v2_rust-rand_core0.9+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.9+serde-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.9+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.9+serde-devel.sha256sum] = "233c552526f3a97a6298b263e0790480b1e6490e48caaa616bf129bafd475fcd"

URI_x86_64_v2_rust-rand_core0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.9+std-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.9+std-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.9+std-devel.sha256sum] = "d323c8680bb939c6a9cf55bba31a6f4eafadc3fd145ea2b2239d6b1419eef2bd"

URI_x86_64_v2_rust-rand_core0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.9-devel-0.9.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.9-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.9-devel.sha256sum] = "67fddefce21a2659d49a400624c5ea0f1b2ef60a82484daf938ea15238117774"

URI_aarch64_rust-rand_core0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.9+default-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand_core0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.9+default-devel}"
SRC_URI[aarch64_rust-rand_core0.9+default-devel.sha256sum] = "a703ba888e2820effa858e901d8f28279e31ba517ac6ec819eddf26cb9c85fb3"

URI_aarch64_rust-rand_core0.9+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.9+os_rng-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand_core0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.9+os_rng-devel}"
SRC_URI[aarch64_rust-rand_core0.9+os_rng-devel.sha256sum] = "9eda5da1ad5a2eeec3a4e95ff9beb164f129f559f939f34b642e49a03e5da7fd"

URI_aarch64_rust-rand_core0.9+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.9+serde-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand_core0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.9+serde-devel}"
SRC_URI[aarch64_rust-rand_core0.9+serde-devel.sha256sum] = "5f2114b093d619e876759fd5ebcdd4abfc25b81fc90fe75aa4540b5a1ecec23e"

URI_aarch64_rust-rand_core0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.9+std-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand_core0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.9+std-devel}"
SRC_URI[aarch64_rust-rand_core0.9+std-devel.sha256sum] = "d1052bba6fdbb50ea464ebedd6cb3cf440a51cd2c9efcfe0686cf7c6fc979ba6"

URI_aarch64_rust-rand_core0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.9-devel-0.9.5-1.el10_2.noarch.rpm;name=aarch64_rust-rand_core0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.9-devel}"
SRC_URI[aarch64_rust-rand_core0.9-devel.sha256sum] = "241d36c86a4aa05f846cd3840dea37e9e02fafffe13c4abdc59e94133484859f"

RDEPENDS:rust-rand_core0.9+default-devel = " \
 cargo \
 rust-rand_core0.9-devel \
 "
RDEPENDS:rust-rand_core0.9+os_rng-devel = " \
 cargo \
 rust-getrandom0.3+default-devel \
 rust-rand_core0.9-devel \
 "
RDEPENDS:rust-rand_core0.9+serde-devel = " \
 cargo \
 rust-rand_core0.9-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_core0.9+std-devel = " \
 cargo \
 rust-getrandom0.3+default-devel \
 rust-getrandom0.3+std-devel \
 rust-rand_core0.9-devel \
 "
RDEPENDS:rust-rand_core0.9-devel = " \
 cargo \
 rust \
 "
