# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duc"
PV = "1.4.6"
PR = "1.el10_2"
PACKAGES = " \
 duc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/duc-1.4.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b036dc89e67d437317834e037a23ebf26af3be4912b9fd45800c54f4d4750c1"

URI_x86_64_v2_duc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duc-1.4.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duc}"
SRC_URI[x86_64_v2_duc.sha256sum] = "de664b2692c1326df8a70d61770b8aa42d0a2d097c48508ebeda2137a1bd66c5"

URI_aarch64_duc = "${EPEL_MIRROR}/aarch64/Packages/d/duc-1.4.6-1.el10_2.aarch64.rpm;name=aarch64_duc;unpack=0"
SRC_URI:append = " ${URI_aarch64_duc}"
SRC_URI[aarch64_duc.sha256sum] = "1cac0c6dea405d71a21f3cceca39021b675dc89e5bfd5e6b66c78035781f5019"

RDEPENDS:duc = " \
 cairo \
 glfw \
 glib2 \
 glibc \
 ncurses-libs \
 pango \
 tokyocabinet \
 "
