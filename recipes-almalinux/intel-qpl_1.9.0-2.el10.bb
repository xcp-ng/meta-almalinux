# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-qpl"
PV = "1.9.0"
PR = "2.el10"
PACKAGES:x86_64_v2 = " \
 intel-qpl \
 intel-qpl-devel \
 intel-qpl-tests \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/intel-qpl-1.9.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "22a7df5a8f10cd7d228de5c82075cad87abedc9aff321268c1c08aa113ac6a7f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/intel-qpl-1.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_intel-qpl;unpack=0"
SRC_URI[x86_64_v2_intel-qpl.sha256sum] = "a2361c1051a1b034b24a0f1054b87ba32062aea461c8f4660647b9639d5b269c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/intel-qpl-devel-1.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_intel-qpl-devel;unpack=0"
SRC_URI[x86_64_v2_intel-qpl-devel.sha256sum] = "354e408330011de8bc7d7a7f4382b5e246d9fadd6c8f1b7c22bdb77c03b23b07"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/intel-qpl-tests-1.9.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_intel-qpl-tests;unpack=0"
SRC_URI[x86_64_v2_intel-qpl-tests.sha256sum] = "b5f8266c94c3dac141c6b23371bff05c1c0046401073b9c9aea0011deed1f6c5"

RDEPENDS:intel-qpl = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:intel-qpl-devel = " \
 accel-config-libs \
 bash \
 cmake-filesystem \
 intel-qpl \
 pkgconf-pkg-config \
 "
RDEPENDS:intel-qpl-tests = " \
 glibc \
 intel-qpl \
 libgcc \
 libstdc++ \
 "
