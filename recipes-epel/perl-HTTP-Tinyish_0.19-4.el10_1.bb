# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Tinyish"
PV = "0.19"
PR = "4.el10_1"
PACKAGES = " \
 perl-HTTP-Tinyish \
 perl-HTTP-Tinyish-Curl \
 perl-HTTP-Tinyish-HTTPTiny \
 perl-HTTP-Tinyish-LWP \
 perl-HTTP-Tinyish-Wget \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-Tinyish-0.19-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d06453e625bb8b6ebc412eb714fec9402552e57ad55cec114b469bce9508383b"

URI_x86_64_v2_perl-HTTP-Tinyish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-0.19-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish.sha256sum] = "72e5174ce1855d998d3105e45daefa24cd3dbbabbd27839c8bba89388a401a63"

URI_x86_64_v2_perl-HTTP-Tinyish-Curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-Curl-0.19-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish-Curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish-Curl}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish-Curl.sha256sum] = "7908fd835261f79f8de36a3e1b333004c34779853552497b269a51acaf0b9988"
RPROVIDES:perl-HTTP-Tinyish-Curl:append:x86_64_v2 = " virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_x86_64_v2_perl-HTTP-Tinyish-HTTPTiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-HTTPTiny-0.19-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish-HTTPTiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish-HTTPTiny}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish-HTTPTiny.sha256sum] = "8c0dbbffe1ae84fd2ea160b1838986ef6286fd13d554fc537b5bd7bdca256ceb"
RPROVIDES:perl-HTTP-Tinyish-HTTPTiny:append:x86_64_v2 = " virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_x86_64_v2_perl-HTTP-Tinyish-LWP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-LWP-0.19-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish-LWP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish-LWP}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish-LWP.sha256sum] = "f9df0943f6be3b0b8a42b217c87bf1dac0cfc3754673ccb6e151b7857661aff8"
RPROVIDES:perl-HTTP-Tinyish-LWP:append:x86_64_v2 = " virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_x86_64_v2_perl-HTTP-Tinyish-Wget = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tinyish-Wget-0.19-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tinyish-Wget;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tinyish-Wget}"
SRC_URI[x86_64_v2_perl-HTTP-Tinyish-Wget.sha256sum] = "71a0151add11e2f5ecc510e2efc2cd59ebafe81c313caa634b2ffbf8751b2955"
RPROVIDES:perl-HTTP-Tinyish-Wget:append:x86_64_v2 = " virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_aarch64_perl-HTTP-Tinyish = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-0.19-4.el10_1.noarch.rpm;name=aarch64_perl-HTTP-Tinyish;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish}"
SRC_URI[aarch64_perl-HTTP-Tinyish.sha256sum] = "6b17b9ae1beafee3759b39624c3e59bf28b1e703b23800302bac52170aaa55d7"

URI_aarch64_perl-HTTP-Tinyish-Curl = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-Curl-0.19-4.el10_1.noarch.rpm;name=aarch64_perl-HTTP-Tinyish-Curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish-Curl}"
SRC_URI[aarch64_perl-HTTP-Tinyish-Curl.sha256sum] = "18eda8a83f929a186c5ba7ca398d60dc027a0760b7b68fe4654df2909198045d"
RPROVIDES:perl-HTTP-Tinyish-Curl:append:aarch64 = " virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_aarch64_perl-HTTP-Tinyish-HTTPTiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-HTTPTiny-0.19-4.el10_1.noarch.rpm;name=aarch64_perl-HTTP-Tinyish-HTTPTiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish-HTTPTiny}"
SRC_URI[aarch64_perl-HTTP-Tinyish-HTTPTiny.sha256sum] = "c5f3ab91da2fb96da83091ca716a112f3558f525d993e6507e3398f7928b50bb"
RPROVIDES:perl-HTTP-Tinyish-HTTPTiny:append:aarch64 = " virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_aarch64_perl-HTTP-Tinyish-LWP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-LWP-0.19-4.el10_1.noarch.rpm;name=aarch64_perl-HTTP-Tinyish-LWP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish-LWP}"
SRC_URI[aarch64_perl-HTTP-Tinyish-LWP.sha256sum] = "6e735c0180226667a5865fb7710208d12285a26ea6a1af7a65639175e9f0339b"
RPROVIDES:perl-HTTP-Tinyish-LWP:append:aarch64 = " virtual/perl__HTTP-Tinyish_backend__eq_0.19"

URI_aarch64_perl-HTTP-Tinyish-Wget = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tinyish-Wget-0.19-4.el10_1.noarch.rpm;name=aarch64_perl-HTTP-Tinyish-Wget;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tinyish-Wget}"
SRC_URI[aarch64_perl-HTTP-Tinyish-Wget.sha256sum] = "26773a05a18ac5530129e1862fb6f49ff8d7d7526eb86f530f422c140f3a8278"
RPROVIDES:perl-HTTP-Tinyish-Wget:append:aarch64 = " virtual/perl__HTTP-Tinyish_backend__eq_0.19"

RDEPENDS:perl-HTTP-Tinyish = " \
 perl-Carp \
 perl-libs \
 virtual/perl__HTTP-Tinyish_backend__eq_0.19 \
 "
RDEPENDS:perl-HTTP-Tinyish-Curl = " \
 curl \
 perl-File-Temp \
 perl-File-Which \
 perl-HTTP-Tinyish \
 perl-IPC-Run3 \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-HTTP-Tinyish-HTTPTiny = " \
 perl-HTTP-Tiny \
 perl-HTTP-Tinyish \
 perl-libs \
 perl-parent \
 "
RDEPENDS:perl-HTTP-Tinyish-LWP = " \
 perl-HTTP-Tinyish \
 perl-libs \
 perl-libwww-perl \
 perl-parent \
 "
RDEPENDS:perl-HTTP-Tinyish-Wget = " \
 perl-File-Which \
 perl-HTTP-Tinyish \
 perl-IPC-Run3 \
 perl-libs \
 perl-parent \
 wget \
 "
