# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PHP-Serialization"
PV = "0.34"
PR = "40.el10_0"
PACKAGES = " \
 perl-PHP-Serialization \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-PHP-Serialization-0.34-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9d7e32ffc0bb6ede5b92f77a530de5415e8c71ea27a4e58557546c73fd703eb"

URI_x86_64_v2_perl-PHP-Serialization = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PHP-Serialization-0.34-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PHP-Serialization;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PHP-Serialization}"
SRC_URI[x86_64_v2_perl-PHP-Serialization.sha256sum] = "181f789a2a02b0e72ce0f70db292cad3642f8d37062b33153076f15b70712b6d"

URI_aarch64_perl-PHP-Serialization = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PHP-Serialization-0.34-40.el10_0.noarch.rpm;name=aarch64_perl-PHP-Serialization;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PHP-Serialization}"
SRC_URI[aarch64_perl-PHP-Serialization.sha256sum] = "41c2ea704e3b3ea812f965fd060b5c69ded4a2c6ff04cc629f8f38b5b0002c7e"

RDEPENDS:perl-PHP-Serialization = " \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-vars \
 "
