# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pimcommon"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 pimcommon \
 pimcommon-devel \
 pimcommon-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pimcommon-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c083dbaf24276970560ed32431c80fc7279fee410920930a9caf11c4079f6fb"

URI_x86_64_v2_pimcommon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon}"
SRC_URI[x86_64_v2_pimcommon.sha256sum] = "3bcb7b0427eef3e037f438cd9eaca6b9548c1d1cf1d48d3053af0a8c768f7747"

URI_x86_64_v2_pimcommon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon-devel}"
SRC_URI[x86_64_v2_pimcommon-devel.sha256sum] = "f3f82573a0e4994d3df1ea9be17bec58d9e5858a20b31502268149ad89d758e3"

URI_x86_64_v2_pimcommon-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-doc-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon-doc}"
SRC_URI[x86_64_v2_pimcommon-doc.sha256sum] = "6791e1ac7916f6170cefff8b28bac16a6240e1cdaaa50a5900d3d04e3d82c53a"

URI_aarch64_pimcommon = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_pimcommon;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon}"
SRC_URI[aarch64_pimcommon.sha256sum] = "80e228646325717d4c91369c3cf0d0889c7fd5a0e057b3afef43e5743e074aff"

URI_aarch64_pimcommon-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_pimcommon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon-devel}"
SRC_URI[aarch64_pimcommon-devel.sha256sum] = "acb7f4430f11c3d49d97ce2c9413bd95f8430442252fb90361128ecefbc1f3c9"

URI_aarch64_pimcommon-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-doc-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_pimcommon-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon-doc}"
SRC_URI[aarch64_pimcommon-doc.sha256sum] = "dd7ca4caec6fef6196914fecf0d879c0aae4d5033a0ac813477058b6d4b28a6f"

RDEPENDS:pimcommon = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kimap \
 kldap \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-devel = " \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kcontacts-devel \
 kimap-devel \
 ktextaddons-qt6-devel \
 libgcc \
 libstdc++ \
 pimcommon \
 plasma-activities-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-doc = " \
 "
