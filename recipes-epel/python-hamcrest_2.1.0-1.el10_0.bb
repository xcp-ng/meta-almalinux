# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hamcrest"
PV = "2.1.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-hamcrest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hamcrest-2.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a59c90345df094d46eb2ae5c72c041208fb3ac615d0e8cc7427611f01f968b24"

URI_x86_64_v2_python3-hamcrest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hamcrest-2.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hamcrest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hamcrest}"
SRC_URI[x86_64_v2_python3-hamcrest.sha256sum] = "69550132248252a48ffdbee15f922009ea76be57388f2f9186dc02e7f577eabf"

URI_aarch64_python3-hamcrest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hamcrest-2.1.0-1.el10_0.noarch.rpm;name=aarch64_python3-hamcrest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hamcrest}"
SRC_URI[aarch64_python3-hamcrest.sha256sum] = "7384e1cf2e166785a7872677340b2dbf79a789057615787c9c5495f527d762bc"

RDEPENDS:python3-hamcrest = " \
 python3 \
 "
