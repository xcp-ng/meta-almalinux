# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snafu-derive"
PV = "0.8.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-snafu-derive+default-devel \
 rust-snafu-derive+rust_1_61-devel \
 rust-snafu-derive+unstable-provider-api-devel \
 rust-snafu-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snafu-derive-0.8.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1094b5ce9745d7efbf57808038bd47cc61847ac59a20ca043612821fdeea5a02"

URI_x86_64_v2_rust-snafu-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive+default-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive+default-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive+default-devel.sha256sum] = "ef5eb31c6952d0ef4bdbc9e0d8c9c3dcf1e89440b124d5be3a0f6bd5f2c930aa"

URI_x86_64_v2_rust-snafu-derive+rust_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive+rust_1_61-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive+rust_1_61-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive+rust_1_61-devel.sha256sum] = "9657f7ddf6b83ee78cf835fc88e6fec7972f417bd8434f831b36e436707737c6"

URI_x86_64_v2_rust-snafu-derive+unstable-provider-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive+unstable-provider-api-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive+unstable-provider-api-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive+unstable-provider-api-devel.sha256sum] = "12ab906c633d3dc7bf2946165b9c3467edfdeb616f9ccc539ac40294632eed56"

URI_x86_64_v2_rust-snafu-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snafu-derive-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snafu-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snafu-derive-devel}"
SRC_URI[x86_64_v2_rust-snafu-derive-devel.sha256sum] = "d601688061a41d16bf9389efff45687f98a2178c9304790ad88e628f0d510375"

URI_aarch64_rust-snafu-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive+default-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive+default-devel}"
SRC_URI[aarch64_rust-snafu-derive+default-devel.sha256sum] = "7a4ccb6da9fc02a77c86990e4ba19bf0468d4087daa1588fdf22234f228e126e"

URI_aarch64_rust-snafu-derive+rust_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive+rust_1_61-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu-derive+rust_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive+rust_1_61-devel}"
SRC_URI[aarch64_rust-snafu-derive+rust_1_61-devel.sha256sum] = "f06cbf4bdd485dfc2cc78657ba4f1be89b5d6b178e5ca9e03b01686a5fdb1a37"

URI_aarch64_rust-snafu-derive+unstable-provider-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive+unstable-provider-api-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu-derive+unstable-provider-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive+unstable-provider-api-devel}"
SRC_URI[aarch64_rust-snafu-derive+unstable-provider-api-devel.sha256sum] = "60cba67e03adf2f96f6dc50f7ae5ba6d79a5a54e64802220070852a7ccb05486"

URI_aarch64_rust-snafu-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snafu-derive-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-snafu-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snafu-derive-devel}"
SRC_URI[aarch64_rust-snafu-derive-devel.sha256sum] = "94191a780d0d5b504149b44106d3b64291c32a8038e2dfc2ab5f4e5076acc3a7"

RDEPENDS:rust-snafu-derive+default-devel = " \
 cargo \
 rust-snafu-derive-devel \
 "
RDEPENDS:rust-snafu-derive+rust_1_61-devel = " \
 cargo \
 rust-snafu-derive-devel \
 "
RDEPENDS:rust-snafu-derive+unstable-provider-api-devel = " \
 cargo \
 rust-snafu-derive-devel \
 "
RDEPENDS:rust-snafu-derive-devel = " \
 cargo \
 rust \
 rust-heck-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
