# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "edg-gridftp-client"
PV = "1.2.9.2"
PR = "42.el10_3"
PACKAGES = " \
 edg-gridftp-client \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/edg-gridftp-client-1.2.9.2-42.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7fbd399aed5dcc36747d57e7a92e09f0f488fb332910891554ed33ce747acdb0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/edg-gridftp-client-1.2.9.2-42.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_edg-gridftp-client;unpack=0"
SRC_URI[x86_64_v2_edg-gridftp-client.sha256sum] = "bce206dc1708fbc73ebe826593e4f77804badb4d7efebb0335e936d246813be4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/edg-gridftp-client-1.2.9.2-42.el10_3.aarch64.rpm;name=aarch64_edg-gridftp-client;unpack=0"
SRC_URI[aarch64_edg-gridftp-client.sha256sum] = "e724e705e3f6d6693fa3df216c10129bb45e0de219e1d9c9de86d517af9998cc"

RDEPENDS:edg-gridftp-client = " \
 glibc \
 globus-common \
 globus-ftp-client \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 "
