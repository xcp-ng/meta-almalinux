# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmd"
PV = "1.2.0"
PR = "1.el10_2"
PACKAGES = " \
 libmd \
 libmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmd-1.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da1379729c53fdbe4993d62a956f682eae558b09422b9128268d5bb903f5f2d2"

URI_x86_64_v2_libmd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmd-1.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmd}"
SRC_URI[x86_64_v2_libmd.sha256sum] = "60b67e19149514d7fea0af1624212165cd7a453a4f8c2dbb646f8c927e4462e2"

URI_x86_64_v2_libmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmd-devel-1.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmd-devel}"
SRC_URI[x86_64_v2_libmd-devel.sha256sum] = "b1e76a217d8b9e360d72d4214b5ffe0f452bf22cd257fdd8451e5384ff72d49c"

URI_aarch64_libmd = "${EPEL_MIRROR}/aarch64/Packages/l/libmd-1.2.0-1.el10_2.aarch64.rpm;name=aarch64_libmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmd}"
SRC_URI[aarch64_libmd.sha256sum] = "027c80327ad4c305d8ccd776e3575870eeaf06489e6c24e99b9f41b5bdcbd847"

URI_aarch64_libmd-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmd-devel-1.2.0-1.el10_2.aarch64.rpm;name=aarch64_libmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmd-devel}"
SRC_URI[aarch64_libmd-devel.sha256sum] = "25c57b8855e409d63c850f7e9be915e0fabb1eb05b8160eddfa9211aec217724"

RDEPENDS:libmd = " \
 glibc \
 "
RDEPENDS:libmd-devel = " \
 libmd \
 pkgconf-pkg-config \
 "
