# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keditbookmarks"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 keditbookmarks \
 keditbookmarks-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keditbookmarks-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7df7ea8f369a5c726b07140443de684fc2485f4f15a65235b6388ad476e9c246"

URI_x86_64_v2_keditbookmarks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keditbookmarks-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keditbookmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keditbookmarks}"
SRC_URI[x86_64_v2_keditbookmarks.sha256sum] = "4ae3d577b52fa20bf13a306052cd9aebdebd5b1b07b8b32e2fe725c09a27b7f3"

URI_x86_64_v2_keditbookmarks-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keditbookmarks-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keditbookmarks-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keditbookmarks-libs}"
SRC_URI[x86_64_v2_keditbookmarks-libs.sha256sum] = "5af8d2e472ce7824e2d9a0f5050f589af6cf433eb0860ea9936637f8701c7003"

URI_aarch64_keditbookmarks = "${EPEL_MIRROR}/aarch64/Packages/k/keditbookmarks-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_keditbookmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_keditbookmarks}"
SRC_URI[aarch64_keditbookmarks.sha256sum] = "f65267fea5685300a12a112add429a0f575e82ee28f2e99af2db8c09f2310da8"

URI_aarch64_keditbookmarks-libs = "${EPEL_MIRROR}/aarch64/Packages/k/keditbookmarks-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_keditbookmarks-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_keditbookmarks-libs}"
SRC_URI[aarch64_keditbookmarks-libs.sha256sum] = "1a1812a4a53eaee8638ab890e3e9d808c616727e7c76741cc1c6c8100bb27a8a"

RDEPENDS:keditbookmarks = " \
 glibc \
 keditbookmarks-libs \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:keditbookmarks-libs = " \
 glibc \
 keditbookmarks \
 kf6-kbookmarks \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
