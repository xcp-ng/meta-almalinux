# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-macro"
PV = "1.0.197"
PR = "1.el10_2"
PACKAGES = " \
 rust-cxxbridge-macro+default-devel \
 rust-cxxbridge-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-macro-1.0.197-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "668ffd54696dc441f59d054dcd811c6df543ab2d0ac292de063eaab70c090f48"

URI_x86_64_v2_rust-cxxbridge-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+default-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+default-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+default-devel.sha256sum] = "6111f00e686d92f96bc5b886cd1a5293028ff5094c12c87843f24297e7ca20b0"

URI_x86_64_v2_rust-cxxbridge-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro-devel-1.0.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro-devel.sha256sum] = "4b37a5b1f22d7942ed86584d9782407edebc37c3c368ba5537e50ae89ed77e8a"

URI_aarch64_rust-cxxbridge-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+default-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+default-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+default-devel.sha256sum] = "8183b85fe3873996048787216f73a30df6ef7f87c1452654de2867e6f738dc5a"

URI_aarch64_rust-cxxbridge-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro-devel-1.0.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro-devel.sha256sum] = "591024b5f578a9238e8b0c0741b75f5c6708944b59820165beb3b01467edc726"

RDEPENDS:rust-cxxbridge-macro+default-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 "
RDEPENDS:rust-cxxbridge-macro-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
