# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dask"
PV = "2025.4.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-dask \
 python3-dask+array \
 python3-dask+bag \
 python3-dask+dataframe \
 python3-dask+delayed \
 python3-dask+distributed \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dask-2025.4.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de33bec5311ebb76173f588726a9c677bd8b9309ecf21b39a2e9365fe7c9bccf"

URI_x86_64_v2_python3-dask = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dask-2025.4.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dask;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dask}"
SRC_URI[x86_64_v2_python3-dask.sha256sum] = "b9213f54674a380a5b14dd75df7836437158c1c4af86972c1fec2e626fabe841"

URI_x86_64_v2_python3-dask+array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dask+array-2025.4.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dask+array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dask+array}"
SRC_URI[x86_64_v2_python3-dask+array.sha256sum] = "4f8c146143c784f6ea7d8ad6451dfbd7a8a6671941b16582f63bb74f47eb7bef"

URI_x86_64_v2_python3-dask+bag = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dask+bag-2025.4.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dask+bag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dask+bag}"
SRC_URI[x86_64_v2_python3-dask+bag.sha256sum] = "aed3f2486ba8721bc0df7bdc901db414c6350eaba494c926ad1ef94d0fa3ca54"

URI_x86_64_v2_python3-dask+dataframe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dask+dataframe-2025.4.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dask+dataframe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dask+dataframe}"
SRC_URI[x86_64_v2_python3-dask+dataframe.sha256sum] = "59f9a480fffe935a059882d598f5118d07619802e780ba147610ca286ed62ed6"

URI_x86_64_v2_python3-dask+delayed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dask+delayed-2025.4.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dask+delayed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dask+delayed}"
SRC_URI[x86_64_v2_python3-dask+delayed.sha256sum] = "5bb07afa11a1312c081861018fbfd065d01166afedc48ded3cad4843ae597dfd"

URI_x86_64_v2_python3-dask+distributed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dask+distributed-2025.4.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dask+distributed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dask+distributed}"
SRC_URI[x86_64_v2_python3-dask+distributed.sha256sum] = "ab80f4fd8dfbea82e40e943efe63e79b233c4cb76ba687324bf8206f77cc799f"

URI_aarch64_python3-dask = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dask-2025.4.0-3.el10_1.noarch.rpm;name=aarch64_python3-dask;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dask}"
SRC_URI[aarch64_python3-dask.sha256sum] = "76d14b64ae581e7788dfc3094e91602a15120dfdc38fe7f2987883cba62fbf56"

URI_aarch64_python3-dask+array = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dask+array-2025.4.0-3.el10_1.noarch.rpm;name=aarch64_python3-dask+array;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dask+array}"
SRC_URI[aarch64_python3-dask+array.sha256sum] = "8c155fd17af9cea481eaddf19fc5c516057c0f8515eb857603c911303131fe0d"

URI_aarch64_python3-dask+bag = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dask+bag-2025.4.0-3.el10_1.noarch.rpm;name=aarch64_python3-dask+bag;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dask+bag}"
SRC_URI[aarch64_python3-dask+bag.sha256sum] = "2e1766b8d74056dd75226eb32ab763afe8655e91f309ed6d79c810416c73586e"

URI_aarch64_python3-dask+dataframe = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dask+dataframe-2025.4.0-3.el10_1.noarch.rpm;name=aarch64_python3-dask+dataframe;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dask+dataframe}"
SRC_URI[aarch64_python3-dask+dataframe.sha256sum] = "b88593c0b2b7ea935862cf5ae05697839e50c94f6f72c009f11bd4df72cf7305"

URI_aarch64_python3-dask+delayed = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dask+delayed-2025.4.0-3.el10_1.noarch.rpm;name=aarch64_python3-dask+delayed;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dask+delayed}"
SRC_URI[aarch64_python3-dask+delayed.sha256sum] = "b70a19fcf6df1a87ad0b70d763fea763fa625ebc43213f32b37d342e347cf22a"

URI_aarch64_python3-dask+distributed = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dask+distributed-2025.4.0-3.el10_1.noarch.rpm;name=aarch64_python3-dask+distributed;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dask+distributed}"
SRC_URI[aarch64_python3-dask+distributed.sha256sum] = "9fa89cc8cb7dd865754894f6d416cbbb4d293270c222aae99376b2e71c12b9f6"

RDEPENDS:python3-dask = " \
 python3 \
 python3-click \
 python3-cloudpickle \
 python3-fsspec \
 python3-packaging \
 python3-partd \
 python3-pyyaml \
 python3-toolz \
 "
RDEPENDS:python3-dask+array = " \
 python3 \
 python3-dask \
 python3-numpy \
 "
RDEPENDS:python3-dask+bag = " \
 python3 \
 python3-dask \
 "
RDEPENDS:python3-dask+dataframe = " \
 python3 \
 python3-dask \
 python3-dask+array \
 python3-pandas \
 python3-pyarrow \
 "
RDEPENDS:python3-dask+delayed = " \
 python3 \
 python3-dask \
 "
RDEPENDS:python3-dask+distributed = " \
 python3 \
 python3-dask \
 python3-distributed \
 "
