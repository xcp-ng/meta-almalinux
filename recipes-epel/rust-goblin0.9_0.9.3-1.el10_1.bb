# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-goblin0.9"
PV = "0.9.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-goblin0.9+alloc-devel \
 rust-goblin0.9+archive-devel \
 rust-goblin0.9+default-devel \
 rust-goblin0.9+elf32-devel \
 rust-goblin0.9+elf64-devel \
 rust-goblin0.9+endian_fd-devel \
 rust-goblin0.9+log-devel \
 rust-goblin0.9+mach32-devel \
 rust-goblin0.9+mach64-devel \
 rust-goblin0.9+pe32-devel \
 rust-goblin0.9+pe64-devel \
 rust-goblin0.9+std-devel \
 rust-goblin0.9+te-devel \
 rust-goblin0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-goblin0.9-0.9.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49b5c6ed6f2e3341777fd99704c29e2c87b7cbfe70c9a32b8a7de7edac39b1b5"

URI_x86_64_v2_rust-goblin0.9+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+alloc-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+alloc-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+alloc-devel.sha256sum] = "2ed74545e54fd39f48c67575530f7f20ef893406d0511eb976d23770d3c888c4"

URI_x86_64_v2_rust-goblin0.9+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+archive-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+archive-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+archive-devel.sha256sum] = "c9097dff763a0b5d3d98fc0e8eb4de4379cb5bcb8db13b8928c77a9d591d537b"

URI_x86_64_v2_rust-goblin0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+default-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+default-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+default-devel.sha256sum] = "773468b88f2c6c42d86542a9aed022539a1903452ef59a329cfbf92ad200d07a"

URI_x86_64_v2_rust-goblin0.9+elf32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+elf32-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+elf32-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+elf32-devel.sha256sum] = "cf69d6baa15dbd3b0fed4246af9bb8affa533ced706a54b166c3c1dae91a658b"

URI_x86_64_v2_rust-goblin0.9+elf64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+elf64-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+elf64-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+elf64-devel.sha256sum] = "2b27bc3312ef3b8e5aaf6a1e8b92f72c013147f389d7ff2045948db5f53cb86a"

URI_x86_64_v2_rust-goblin0.9+endian_fd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+endian_fd-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+endian_fd-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+endian_fd-devel.sha256sum] = "1710d101dd380646a56ff79c70c312b9107d1df121dbd18f6c3274567443dd0e"

URI_x86_64_v2_rust-goblin0.9+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+log-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+log-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+log-devel.sha256sum] = "573d26070952e479bdefbb9d7c2d212db49706af7ff5bde67022ad291638376d"

URI_x86_64_v2_rust-goblin0.9+mach32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+mach32-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+mach32-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+mach32-devel.sha256sum] = "5dac8d73ee2c64ed7640f719813a20a8512df14071fbb79a75eea9b7de3443a3"

URI_x86_64_v2_rust-goblin0.9+mach64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+mach64-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+mach64-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+mach64-devel.sha256sum] = "697b858d107f44c1c9d42a31ce95ce5c5b48d92df57fba9669564f60dd5860b0"

URI_x86_64_v2_rust-goblin0.9+pe32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+pe32-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+pe32-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+pe32-devel.sha256sum] = "66c8a0528c3bc51f4d5434fd6d0639ec2fdaa8e3789eaee4dce87cfd26a365c1"

URI_x86_64_v2_rust-goblin0.9+pe64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+pe64-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+pe64-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+pe64-devel.sha256sum] = "2baa3c4a1ec02c0d7ff28ce639078c4b94a41e8f328582e5e514b9f6d8aac873"

URI_x86_64_v2_rust-goblin0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+std-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+std-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+std-devel.sha256sum] = "2012766592d765f67c53bab95649e668079a854cac452f98ae1ca65f6cfee488"

URI_x86_64_v2_rust-goblin0.9+te-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9+te-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9+te-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9+te-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9+te-devel.sha256sum] = "280af49bf343ae4a98172633feace6211d7595ded9a542e6df0c44fad2558c89"

URI_x86_64_v2_rust-goblin0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-goblin0.9-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-goblin0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-goblin0.9-devel}"
SRC_URI[x86_64_v2_rust-goblin0.9-devel.sha256sum] = "bae9e0cc86a7738fc2e87a863c361be3e851544927329bd2d55a3698c63549f8"

URI_aarch64_rust-goblin0.9+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+alloc-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+alloc-devel}"
SRC_URI[aarch64_rust-goblin0.9+alloc-devel.sha256sum] = "72d0a4cc393e72a33254e9715a680381d23acbcfb3663367ed36bed90548a493"

URI_aarch64_rust-goblin0.9+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+archive-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+archive-devel}"
SRC_URI[aarch64_rust-goblin0.9+archive-devel.sha256sum] = "7b42d52e7c087825c3d79c1c99c219d7813432d89f52e03dde859b88e27e0668"

URI_aarch64_rust-goblin0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+default-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+default-devel}"
SRC_URI[aarch64_rust-goblin0.9+default-devel.sha256sum] = "0f63c0a9f201b22618e1683c98284825ba4b5eda39da647c6404b35ba13fea89"

URI_aarch64_rust-goblin0.9+elf32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+elf32-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+elf32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+elf32-devel}"
SRC_URI[aarch64_rust-goblin0.9+elf32-devel.sha256sum] = "83f45f14b47a02da26ff7e00683d256978c71e493a3873240461303a4e3a842b"

URI_aarch64_rust-goblin0.9+elf64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+elf64-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+elf64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+elf64-devel}"
SRC_URI[aarch64_rust-goblin0.9+elf64-devel.sha256sum] = "99cfa22c3455ca53ec449725d0b79bb3ba9bf193be63162881f3ec542df116de"

URI_aarch64_rust-goblin0.9+endian_fd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+endian_fd-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+endian_fd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+endian_fd-devel}"
SRC_URI[aarch64_rust-goblin0.9+endian_fd-devel.sha256sum] = "e70852685e0bcd28e4a28c3d637821bdcb22a4fda492e5a94677eec853b64840"

URI_aarch64_rust-goblin0.9+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+log-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+log-devel}"
SRC_URI[aarch64_rust-goblin0.9+log-devel.sha256sum] = "29cf4caff2bed91c5576e2c27c412696a7b80a102263d6abe8b4ccbd44218044"

URI_aarch64_rust-goblin0.9+mach32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+mach32-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+mach32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+mach32-devel}"
SRC_URI[aarch64_rust-goblin0.9+mach32-devel.sha256sum] = "7a12fbc3ea899f05f40c8c06d73f7f57226fb0d0280ec98111e752f510dd3c5c"

URI_aarch64_rust-goblin0.9+mach64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+mach64-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+mach64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+mach64-devel}"
SRC_URI[aarch64_rust-goblin0.9+mach64-devel.sha256sum] = "b882da8535c58d42bfa8df82ad21506906d0916ed07ed4b3967a081c25d52349"

URI_aarch64_rust-goblin0.9+pe32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+pe32-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+pe32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+pe32-devel}"
SRC_URI[aarch64_rust-goblin0.9+pe32-devel.sha256sum] = "ad4bb4fbd85492f3281147a82eafe72136be4112c6b7e45eabe024fdf94d8a6f"

URI_aarch64_rust-goblin0.9+pe64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+pe64-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+pe64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+pe64-devel}"
SRC_URI[aarch64_rust-goblin0.9+pe64-devel.sha256sum] = "18eff02eecbbe5cc323ddff7f9d20b63302bc15873b1cad0cc7563e8302596fa"

URI_aarch64_rust-goblin0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+std-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+std-devel}"
SRC_URI[aarch64_rust-goblin0.9+std-devel.sha256sum] = "cd483db4fa461e44be6b5cee7eaadb3ea699296348f0ddc8ee8d0c24c2fe5ce6"

URI_aarch64_rust-goblin0.9+te-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9+te-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9+te-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9+te-devel}"
SRC_URI[aarch64_rust-goblin0.9+te-devel.sha256sum] = "074b3d0a48bf0d02918c53bdf1c08f32cf49112e46c09f76f6f4dbde667da428"

URI_aarch64_rust-goblin0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-goblin0.9-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-goblin0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-goblin0.9-devel}"
SRC_URI[aarch64_rust-goblin0.9-devel.sha256sum] = "62c624ed8119b60443d76c2a19f3d03ce573943c1678faaf4d7cc3dd36303530"

RDEPENDS:rust-goblin0.9+alloc-devel = " \
 cargo \
 rust-goblin0.9+log-devel \
 rust-goblin0.9-devel \
 rust-scroll0.12+derive-devel \
 "
RDEPENDS:rust-goblin0.9+archive-devel = " \
 cargo \
 rust-goblin0.9+alloc-devel \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9+default-devel = " \
 cargo \
 rust-goblin0.9+archive-devel \
 rust-goblin0.9+elf32-devel \
 rust-goblin0.9+elf64-devel \
 rust-goblin0.9+endian_fd-devel \
 rust-goblin0.9+mach32-devel \
 rust-goblin0.9+mach64-devel \
 rust-goblin0.9+pe32-devel \
 rust-goblin0.9+pe64-devel \
 rust-goblin0.9+std-devel \
 rust-goblin0.9+te-devel \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9+elf32-devel = " \
 cargo \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9+elf64-devel = " \
 cargo \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9+endian_fd-devel = " \
 cargo \
 rust-goblin0.9+alloc-devel \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9+log-devel = " \
 cargo \
 rust-goblin0.9-devel \
 rust-log-devel \
 "
RDEPENDS:rust-goblin0.9+mach32-devel = " \
 cargo \
 rust-goblin0.9+alloc-devel \
 rust-goblin0.9+archive-devel \
 rust-goblin0.9+endian_fd-devel \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9+mach64-devel = " \
 cargo \
 rust-goblin0.9+alloc-devel \
 rust-goblin0.9+archive-devel \
 rust-goblin0.9+endian_fd-devel \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9+pe32-devel = " \
 cargo \
 rust-goblin0.9+alloc-devel \
 rust-goblin0.9+endian_fd-devel \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9+pe64-devel = " \
 cargo \
 rust-goblin0.9+alloc-devel \
 rust-goblin0.9+endian_fd-devel \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9+std-devel = " \
 cargo \
 rust-goblin0.9+alloc-devel \
 rust-goblin0.9-devel \
 rust-scroll0.12+std-devel \
 "
RDEPENDS:rust-goblin0.9+te-devel = " \
 cargo \
 rust-goblin0.9+alloc-devel \
 rust-goblin0.9+endian_fd-devel \
 rust-goblin0.9-devel \
 "
RDEPENDS:rust-goblin0.9-devel = " \
 cargo \
 rust \
 rust-plain+default-devel \
 rust-scroll0.12-devel \
 "
