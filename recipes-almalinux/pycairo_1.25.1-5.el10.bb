# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pycairo"
PV = "1.25.1"
PR = "5.el10"
PACKAGES = " \
 python3-cairo \
 python3-cairo-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pycairo-1.25.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1c4cfd0dc60ebce808578a9a4aafe8040f59570dbcd28be987de903923b2ec4"

URI_x86_64_v2_python3-cairo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-cairo-1.25.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-cairo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cairo}"
SRC_URI[x86_64_v2_python3-cairo.sha256sum] = "fabdf8178d2d1983af2fc982e8e4099cafce5b035d49e311c9e4031c40317ba7"

URI_x86_64_v2_python3-cairo-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-cairo-devel-1.25.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-cairo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cairo-devel}"
SRC_URI[x86_64_v2_python3-cairo-devel.sha256sum] = "81f143524838addb2845718b7f18bca024d91a63ec22cf94e22bae15f6db7b14"

URI_aarch64_python3-cairo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-cairo-1.25.1-5.el10.aarch64.rpm;name=aarch64_python3-cairo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cairo}"
SRC_URI[aarch64_python3-cairo.sha256sum] = "cb4c6d35563e70a7938613c169060592dc1f2461e8ad0a330f7534794ff7fa94"

URI_aarch64_python3-cairo-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-cairo-devel-1.25.1-5.el10.aarch64.rpm;name=aarch64_python3-cairo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cairo-devel}"
SRC_URI[aarch64_python3-cairo-devel.sha256sum] = "7a98b0e87c1af75d065429faed669cb74a44011f944ec3e51c0d40257ee29ce9"

RDEPENDS:python3-cairo = " \
 cairo \
 glibc \
 python3 \
 "
RDEPENDS:python3-cairo-devel = " \
 cairo-devel \
 pkgconf-pkg-config \
 python3-cairo \
 python3-devel \
 "
