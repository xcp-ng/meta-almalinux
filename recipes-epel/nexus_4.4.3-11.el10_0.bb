# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nexus"
PV = "4.4.3"
PR = "11.el10_0"
PACKAGES = " \
 nexus \
 nexus-devel \
 nexus-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nexus-4.4.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c16be6051acea733e0d49dc9ab0e23dee25c75bd19374d0444012b875fd42744"

URI_x86_64_v2_nexus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nexus-4.4.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nexus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nexus}"
SRC_URI[x86_64_v2_nexus.sha256sum] = "36afa475691aac5029716c1850bcce26af55be57d077e277f11813ae5d1ba601"

URI_x86_64_v2_nexus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nexus-devel-4.4.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nexus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nexus-devel}"
SRC_URI[x86_64_v2_nexus-devel.sha256sum] = "685281dc2493a8cd981452c7d68badcdb357be9cb48dca678aa737dd51b17ff1"

URI_x86_64_v2_nexus-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nexus-tools-4.4.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nexus-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nexus-tools}"
SRC_URI[x86_64_v2_nexus-tools.sha256sum] = "eb55104aeb6be33ab01594c8c048fb8d711e8f019f8793c569ab6026894b9067"

URI_aarch64_nexus = "${EPEL_MIRROR}/aarch64/Packages/n/nexus-4.4.3-11.el10_0.aarch64.rpm;name=aarch64_nexus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nexus}"
SRC_URI[aarch64_nexus.sha256sum] = "0156f8c06d0791539c616b92a2f8a0a1989e598e4608721a246c212cf3a804a6"

URI_aarch64_nexus-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nexus-devel-4.4.3-11.el10_0.aarch64.rpm;name=aarch64_nexus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nexus-devel}"
SRC_URI[aarch64_nexus-devel.sha256sum] = "013b0cfe14c437a70a7b7e3706ba5581fa732eaaff5ce03e1f32061a532bf9b9"

URI_aarch64_nexus-tools = "${EPEL_MIRROR}/aarch64/Packages/n/nexus-tools-4.4.3-11.el10_0.aarch64.rpm;name=aarch64_nexus-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_nexus-tools}"
SRC_URI[aarch64_nexus-tools.sha256sum] = "ddc883d1aa81e453abba7742679ec513e00108e7a1f9bcfa674082e96416be47"

RDEPENDS:nexus = " \
 glibc \
 hdf \
 hdf5 \
 libgcc \
 libstdc++ \
 mxml \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 "
RDEPENDS:nexus-devel = " \
 hdf-devel \
 hdf5-devel \
 nexus \
 nexus-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nexus-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 nexus \
 readline \
 "
