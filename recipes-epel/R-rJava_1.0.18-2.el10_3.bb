# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-rJava"
PV = "1.0.18"
PR = "2.el10_3"
PACKAGES = " \
 R-rJava \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-rJava-1.0.18-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58b4c507eee8ee7f21fdc201135cd2ad24102c52ccdc8e9c0aeb51a480736a79"

URI_x86_64_v2_R-rJava = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-rJava-1.0.18-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-rJava;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-rJava}"
SRC_URI[x86_64_v2_R-rJava.sha256sum] = "c89810935ca51466b18ecf923318feffa5ae3a991da66619cb54e02e05502b4f"

URI_aarch64_R-rJava = "${EPEL_MIRROR}/aarch64/Packages/r/R-rJava-1.0.18-2.el10_3.aarch64.rpm;name=aarch64_R-rJava;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-rJava}"
SRC_URI[aarch64_R-rJava.sha256sum] = "1ec990ef4e486ebb30a9df3b53f973ff053affc263a75411cfe264786cde47f2"

RDEPENDS:R-rJava = " \
 R-core \
 bash \
 glibc \
 java-21-openjdk-headless \
 "
