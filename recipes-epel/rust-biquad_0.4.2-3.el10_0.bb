# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-biquad"
PV = "0.4.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-biquad+default-devel \
 rust-biquad-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-biquad-0.4.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a88f890ebf985b7a57fcd381f238aad3c286e855a7f5e1d5a78ad234cb9cfe3e"

URI_x86_64_v2_rust-biquad+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-biquad+default-devel-0.4.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-biquad+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-biquad+default-devel}"
SRC_URI[x86_64_v2_rust-biquad+default-devel.sha256sum] = "17fd5ca6c480472bce1f8608619b83f137081763d49427424a6086f3ca054e9e"

URI_x86_64_v2_rust-biquad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-biquad-devel-0.4.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-biquad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-biquad-devel}"
SRC_URI[x86_64_v2_rust-biquad-devel.sha256sum] = "72e5f968eac56680672cd1dab0c3f51b2f44ba1a8f2968ea7b14688988140f89"

URI_aarch64_rust-biquad+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-biquad+default-devel-0.4.2-3.el10_0.noarch.rpm;name=aarch64_rust-biquad+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-biquad+default-devel}"
SRC_URI[aarch64_rust-biquad+default-devel.sha256sum] = "f525673403a021b6dec10a679cbdadc4085358252cfb60000e838db5c4ba38e3"

URI_aarch64_rust-biquad-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-biquad-devel-0.4.2-3.el10_0.noarch.rpm;name=aarch64_rust-biquad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-biquad-devel}"
SRC_URI[aarch64_rust-biquad-devel.sha256sum] = "88b2d689b86ba56b9dbd7253bc8bb0bc9f06d09332793aea90c051013b8ce487"

RDEPENDS:rust-biquad+default-devel = " \
 cargo \
 rust-biquad-devel \
 "
RDEPENDS:rust-biquad-devel = " \
 cargo \
 rust-libm+default-devel \
 "
