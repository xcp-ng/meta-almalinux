# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-mixin"
PV = "0.2.3"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-mixin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-mixin-0.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edd3b868c60c2860253838006a36fb63cf6f88f93e36abd94d883a190d7755df"

URI_x86_64_v2_python3-colcon-mixin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-mixin-0.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-mixin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-mixin}"
SRC_URI[x86_64_v2_python3-colcon-mixin.sha256sum] = "7af7705aa58141eb5df9d31aa11d05ff27626118ca21c94e79dfc6d534bde0cb"

URI_aarch64_python3-colcon-mixin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-mixin-0.2.3-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-mixin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-mixin}"
SRC_URI[aarch64_python3-colcon-mixin.sha256sum] = "cc86af514d818d00db3eb518a37a209137ae28c50a8b1058ebf2ec12ca4de2cf"

RDEPENDS:python3-colcon-mixin = " \
 python3 \
 python3-colcon-core \
 python3-pyyaml \
 "
