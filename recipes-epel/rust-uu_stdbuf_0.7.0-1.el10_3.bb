# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_stdbuf"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_stdbuf+default-devel \
 rust-uu_stdbuf+feat_external_libstdbuf-devel \
 rust-uu_stdbuf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_stdbuf-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "125c3e97576abfad04d593ae9b7914cf8ec8568f994fc7bca21f8069a603011f"

URI_x86_64_v2_rust-uu_stdbuf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_stdbuf+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_stdbuf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_stdbuf+default-devel}"
SRC_URI[x86_64_v2_rust-uu_stdbuf+default-devel.sha256sum] = "2a044f54f494862c8f6ff3f5f62526356b399899f5f3fea418f499be688dea53"

URI_x86_64_v2_rust-uu_stdbuf+feat_external_libstdbuf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_stdbuf+feat_external_libstdbuf-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_stdbuf+feat_external_libstdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_stdbuf+feat_external_libstdbuf-devel}"
SRC_URI[x86_64_v2_rust-uu_stdbuf+feat_external_libstdbuf-devel.sha256sum] = "f0ed9c9231a8f5b852e4393c2ee767e566bd86218da64222f555f64d5980aca9"

URI_x86_64_v2_rust-uu_stdbuf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_stdbuf-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_stdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_stdbuf-devel}"
SRC_URI[x86_64_v2_rust-uu_stdbuf-devel.sha256sum] = "337bee9a3b582e8501fa37fa4d0d9ceb690dd83f368423d274128d6d859b16b0"

URI_aarch64_rust-uu_stdbuf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_stdbuf+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_stdbuf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_stdbuf+default-devel}"
SRC_URI[aarch64_rust-uu_stdbuf+default-devel.sha256sum] = "fe342ba3866f109552c5359eb6da175657461e2e4e857813e42bdc6c68d933e4"

URI_aarch64_rust-uu_stdbuf+feat_external_libstdbuf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_stdbuf+feat_external_libstdbuf-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_stdbuf+feat_external_libstdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_stdbuf+feat_external_libstdbuf-devel}"
SRC_URI[aarch64_rust-uu_stdbuf+feat_external_libstdbuf-devel.sha256sum] = "4e0653a72cfb7322fcc106dd62b31e2a9883753b444397d2d680b08d7c956447"

URI_aarch64_rust-uu_stdbuf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_stdbuf-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_stdbuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_stdbuf-devel}"
SRC_URI[aarch64_rust-uu_stdbuf-devel.sha256sum] = "a5617ab27a758a495f4e2ddc6beb41d49cbd933a37995f9a52637ed53c8ba3fb"

RDEPENDS:rust-uu_stdbuf+default-devel = " \
 cargo \
 rust-uu_stdbuf-devel \
 "
RDEPENDS:rust-uu_stdbuf+feat_external_libstdbuf-devel = " \
 cargo \
 rust-uu_stdbuf-devel \
 "
RDEPENDS:rust-uu_stdbuf-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 rust-uu_stdbuf_libstdbuf+default-devel \
 rust-uucore+default-devel \
 rust-uucore+parser-size-devel \
 "
