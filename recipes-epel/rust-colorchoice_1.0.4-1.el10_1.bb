# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-colorchoice"
PV = "1.0.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-colorchoice+default-devel \
 rust-colorchoice-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-colorchoice-1.0.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "774c9e2f942342751e0dd296ba5fcc8c210d990f0b49e87c919ef4523f58a969"

URI_x86_64_v2_rust-colorchoice+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colorchoice+default-devel-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colorchoice+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colorchoice+default-devel}"
SRC_URI[x86_64_v2_rust-colorchoice+default-devel.sha256sum] = "d38c4e925efb27cd1c84b8ccea4883fe9defdb0787a899623f52fd88d526d35d"

URI_x86_64_v2_rust-colorchoice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colorchoice-devel-1.0.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colorchoice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colorchoice-devel}"
SRC_URI[x86_64_v2_rust-colorchoice-devel.sha256sum] = "e8039ce4707c1a592c3a63cc246db173b3da960eb6e2e54bbb3e97f09a2b7f44"

URI_aarch64_rust-colorchoice+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colorchoice+default-devel-1.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-colorchoice+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colorchoice+default-devel}"
SRC_URI[aarch64_rust-colorchoice+default-devel.sha256sum] = "ee6ae44b62ec9d63e453f9db864605d024a2efce0b25e4c34fa0184943681d3d"

URI_aarch64_rust-colorchoice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colorchoice-devel-1.0.4-1.el10_1.noarch.rpm;name=aarch64_rust-colorchoice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colorchoice-devel}"
SRC_URI[aarch64_rust-colorchoice-devel.sha256sum] = "0be64c2e2bf719daec663fa999b2867a4996d33365b40068b5fb68b9d7b66634"

RDEPENDS:rust-colorchoice+default-devel = " \
 cargo \
 rust-colorchoice-devel \
 "
RDEPENDS:rust-colorchoice-devel = " \
 cargo \
 rust \
 "
