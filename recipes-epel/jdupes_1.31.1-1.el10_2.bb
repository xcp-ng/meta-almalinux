# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jdupes"
PV = "1.31.1"
PR = "1.el10_2"
PACKAGES = " \
 jdupes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jdupes-1.31.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e96b5cd2744930496fe40c9842560b65e4b94c76961958b4feb4e27376e06d21"

URI_x86_64_v2_jdupes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jdupes-1.31.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jdupes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jdupes}"
SRC_URI[x86_64_v2_jdupes.sha256sum] = "9895bccdec0bc993752ba893cc6bb242f9579a53634780baf026218d5c827f13"

URI_aarch64_jdupes = "${EPEL_MIRROR}/aarch64/Packages/j/jdupes-1.31.1-1.el10_2.aarch64.rpm;name=aarch64_jdupes;unpack=0"
SRC_URI:append = " ${URI_aarch64_jdupes}"
SRC_URI[aarch64_jdupes.sha256sum] = "35ed8c64a5c897ad016a99ce35c8b85d3c84cdb5123964019f705907a30a03ba"

RDEPENDS:jdupes = " \
 glibc \
 libjodycode \
 "
