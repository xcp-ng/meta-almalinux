# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-griddle"
PV = "0.6.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-griddle+ahash-compile-time-rng-devel \
 rust-griddle+ahash-devel \
 rust-griddle+ahash_-devel \
 rust-griddle+default-devel \
 rust-griddle+inline-more-devel \
 rust-griddle+rayon-devel \
 rust-griddle+rayon_-devel \
 rust-griddle+serde-devel \
 rust-griddle+serde_-devel \
 rust-griddle-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-griddle-0.6.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6f27b5f25e4fee3a17d8d0b6af89c1e7078e4d76a8d02d65178bac0922aa2c47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle+ahash-compile-time-rng-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle+ahash-compile-time-rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle+ahash-compile-time-rng-devel.sha256sum] = "6650c0e52d34cb94ce48280d5b6698cc9cb50fe67638845c4be5373fcb195c7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle+ahash-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle+ahash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle+ahash-devel.sha256sum] = "c9f73f13a198c0ff292c22c8654551a953df6c56bfa5300f2eaebbfe8b84f452"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle+ahash_-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle+ahash_-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle+ahash_-devel.sha256sum] = "61d094e71686bca7cef91f6e7d2a74f60dbd53f27c7185e90e4cafc9a68774fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle+default-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle+default-devel.sha256sum] = "4a3fed15c6f6c4cd7b69e52cf1ffd07cf4f9bf63ea5d981b37522a359ec71be9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle+inline-more-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle+inline-more-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle+inline-more-devel.sha256sum] = "731535e4cfc6d95a62a12996389a10b7260a40d6c0584ae1566deb0cf28d86b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle+rayon-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle+rayon-devel.sha256sum] = "341907fa0f217861e0657a3125ac158ec03d953930b1c29fbba3aa3312e13a06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle+rayon_-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle+rayon_-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle+rayon_-devel.sha256sum] = "639bf94613a473cd3bacaa39f82807a89f750bb13b69119f4863ffd760871774"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle+serde-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle+serde-devel.sha256sum] = "5122ff0e8f50ff3fd2ea84658a45eec7af8bcb2a46b2967c2d2c392d4e3d192f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle+serde_-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle+serde_-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle+serde_-devel.sha256sum] = "71562c74342737b54f8fe3051a90b7b844cdd90c8c10bbf26b710518f2b71f70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-griddle-devel-0.6.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-griddle-devel;unpack=0"
SRC_URI[x86_64_v2_rust-griddle-devel.sha256sum] = "9af02bb69f076988e25eb916529c696999bf13211a2695a9692148f351fe0adb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle+ahash-compile-time-rng-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle+ahash-compile-time-rng-devel;unpack=0"
SRC_URI[aarch64_rust-griddle+ahash-compile-time-rng-devel.sha256sum] = "011ea9840dd76fdaef74495d4fb3bf44b61d285f0762ff3151f7183912542feb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle+ahash-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle+ahash-devel;unpack=0"
SRC_URI[aarch64_rust-griddle+ahash-devel.sha256sum] = "7678acdcf5f317aaaf84f63903b75a5aa7dbddfb7319cb8f550b5ba4cb279041"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle+ahash_-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle+ahash_-devel;unpack=0"
SRC_URI[aarch64_rust-griddle+ahash_-devel.sha256sum] = "57f9e572097d8eeebf22850bc682eb18eeba9cc0ebfd9355cdae92b8d6fc8361"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle+default-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle+default-devel;unpack=0"
SRC_URI[aarch64_rust-griddle+default-devel.sha256sum] = "ea855eb523b276f45b9c887a03e7d2c5c44d42bfbf9bf02ea3573bf002d627be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle+inline-more-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle+inline-more-devel;unpack=0"
SRC_URI[aarch64_rust-griddle+inline-more-devel.sha256sum] = "0a45cd0885ddb69d07055126a4a3f2857f313b6ec774b09c78e7eae27e90e52b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle+rayon-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-griddle+rayon-devel.sha256sum] = "5593be203611f2b761e717bf4d99b51a2b5549a3aaea0cf4a81810c5564f5a93"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle+rayon_-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle+rayon_-devel;unpack=0"
SRC_URI[aarch64_rust-griddle+rayon_-devel.sha256sum] = "1daf6e0fe7f51d77964911f4902687d4fd69e8c6905bf3e5399791c0ff0a1889"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle+serde-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle+serde-devel;unpack=0"
SRC_URI[aarch64_rust-griddle+serde-devel.sha256sum] = "62f7fb6c5b5d60ac28d7f1ea38902604b008d1795d3798ef95af8b2c50f4fe5b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle+serde_-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle+serde_-devel;unpack=0"
SRC_URI[aarch64_rust-griddle+serde_-devel.sha256sum] = "5b217ab25140985b71e4cd6421f98fc2de9a6ae262bccf3c54146c8f7b3ed692"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-griddle-devel-0.6.0-2.el10_3.noarch.rpm;name=aarch64_rust-griddle-devel;unpack=0"
SRC_URI[aarch64_rust-griddle-devel.sha256sum] = "8ef02277968ff8b32ea395969a1494cda8617bd5a702bdc265a95381dd132e11"

RDEPENDS:rust-griddle+ahash-compile-time-rng-devel = " \
 cargo \
 rust-ahash+compile-time-rng-devel \
 rust-ahash-devel \
 rust-griddle-devel \
 "
RDEPENDS:rust-griddle+ahash-devel = " \
 cargo \
 rust-griddle+ahash_-devel \
 rust-griddle-devel \
 rust-hashbrown0.14+ahash-devel \
 "
RDEPENDS:rust-griddle+ahash_-devel = " \
 cargo \
 rust-ahash-devel \
 rust-griddle-devel \
 "
RDEPENDS:rust-griddle+default-devel = " \
 cargo \
 rust-griddle+ahash-devel \
 rust-griddle+inline-more-devel \
 rust-griddle-devel \
 "
RDEPENDS:rust-griddle+inline-more-devel = " \
 cargo \
 rust-griddle-devel \
 rust-hashbrown0.14+inline-more-devel \
 "
RDEPENDS:rust-griddle+rayon-devel = " \
 cargo \
 rust-griddle+rayon_-devel \
 rust-griddle-devel \
 rust-hashbrown0.14+rayon-devel \
 "
RDEPENDS:rust-griddle+rayon_-devel = " \
 cargo \
 rust-griddle-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-griddle+serde-devel = " \
 cargo \
 rust-griddle+serde_-devel \
 rust-griddle-devel \
 rust-hashbrown0.14+serde-devel \
 "
RDEPENDS:rust-griddle+serde_-devel = " \
 cargo \
 rust-griddle-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-griddle-devel = " \
 cargo \
 rust-hashbrown0.14+raw-devel \
 rust-hashbrown0.14-devel \
 virtual//usr/bin/gnuplot \
 "
