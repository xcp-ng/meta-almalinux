# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-resolver"
PE = "1"
PV = "1.9.18"
PR = "4.el10"
PACKAGES = " \
 maven-resolver \
 maven-resolver-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/maven-resolver-1.9.18-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e43648ad460935087af5c94257c8c7cd794b3dcbbbecf957a3c5509da108b93"

URI_x86_64_v2_maven-resolver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/maven-resolver-1.9.18-4.el10.noarch.rpm;name=x86_64_v2_maven-resolver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-resolver}"
SRC_URI[x86_64_v2_maven-resolver.sha256sum] = "320032f570a0b0fbe8e98481b0ee1fa11b68491c684acbe1a484ce82efd25d40"

URI_x86_64_v2_maven-resolver-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-resolver-javadoc-1.9.18-4.el10.noarch.rpm;name=x86_64_v2_maven-resolver-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-resolver-javadoc}"
SRC_URI[x86_64_v2_maven-resolver-javadoc.sha256sum] = "38fb200ee9256e0fa9ff46188babcc18d0e680439620f1c6345c212097cc7920"

URI_aarch64_maven-resolver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/maven-resolver-1.9.18-4.el10.noarch.rpm;name=aarch64_maven-resolver;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-resolver}"
SRC_URI[aarch64_maven-resolver.sha256sum] = "320032f570a0b0fbe8e98481b0ee1fa11b68491c684acbe1a484ce82efd25d40"

URI_aarch64_maven-resolver-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-resolver-javadoc-1.9.18-4.el10.noarch.rpm;name=aarch64_maven-resolver-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-resolver-javadoc}"
SRC_URI[aarch64_maven-resolver-javadoc.sha256sum] = "38fb200ee9256e0fa9ff46188babcc18d0e680439620f1c6345c212097cc7920"

RDEPENDS:maven-resolver = " \
 apache-commons-codec \
 httpcomponents-client \
 httpcomponents-core \
 javapackages-filesystem \
 jcl-over-slf4j \
 maven-lib \
 maven-wagon \
 slf4j \
 "
RDEPENDS:maven-resolver-javadoc = " \
 javapackages-filesystem \
 "
