# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_distr0.5"
PV = "0.5.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_distr0.5+alloc-devel \
 rust-rand_distr0.5+default-devel \
 rust-rand_distr0.5+serde-devel \
 rust-rand_distr0.5+std-devel \
 rust-rand_distr0.5+std_math-devel \
 rust-rand_distr0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_distr0.5-0.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15e3fa30208b7878c33f9fe3411e99741f2f35af6bfd5c9f55f96e65a4151e4d"

URI_x86_64_v2_rust-rand_distr0.5+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.5+alloc-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.5+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.5+alloc-devel.sha256sum] = "ff330388669d0388d41e41731ef94eb6bcac6e45bf597ec681aecfd4b9340894"

URI_x86_64_v2_rust-rand_distr0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.5+default-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.5+default-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.5+default-devel.sha256sum] = "630769ca952271ed7e6dadc23e1d7e6899d41e829daed74b24082e74fe526ed1"

URI_x86_64_v2_rust-rand_distr0.5+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.5+serde-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.5+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.5+serde-devel.sha256sum] = "bf535a9a4355116cf3280ea759d3b007febc606e5f3b3cccdc2a749673059462"

URI_x86_64_v2_rust-rand_distr0.5+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.5+std-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.5+std-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.5+std-devel.sha256sum] = "df5cb8fe1ef3c5e9abac6305546fea7d10d2c25f028acf4425219a66d97b493e"

URI_x86_64_v2_rust-rand_distr0.5+std_math-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.5+std_math-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.5+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.5+std_math-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.5+std_math-devel.sha256sum] = "0c7cd6df9bbc410214354c4a3e5254015d23143fa6c886b504af835254e08367"

URI_x86_64_v2_rust-rand_distr0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr0.5-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr0.5-devel}"
SRC_URI[x86_64_v2_rust-rand_distr0.5-devel.sha256sum] = "e6091c91b2a6f6cd73ad90290a3e73987e035a2bd1e49f42e9af90b584452113"

URI_aarch64_rust-rand_distr0.5+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.5+alloc-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr0.5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.5+alloc-devel}"
SRC_URI[aarch64_rust-rand_distr0.5+alloc-devel.sha256sum] = "d7b34afd9e186fc57a335fbb392054323cb4861628417e4ce86f06d5b27af78a"

URI_aarch64_rust-rand_distr0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.5+default-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.5+default-devel}"
SRC_URI[aarch64_rust-rand_distr0.5+default-devel.sha256sum] = "8182c7a3edca98c08e328bc721bd2e66a211ac0724a8c155d7a4232823826378"

URI_aarch64_rust-rand_distr0.5+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.5+serde-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr0.5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.5+serde-devel}"
SRC_URI[aarch64_rust-rand_distr0.5+serde-devel.sha256sum] = "ba0150b394a018bb857fc06e0453566f4c2dee90fd2282998844a4c9a664a5fd"

URI_aarch64_rust-rand_distr0.5+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.5+std-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.5+std-devel}"
SRC_URI[aarch64_rust-rand_distr0.5+std-devel.sha256sum] = "9435f9a6e0d2fa059c0a0d9bd4a75389eba8e60266d19a41c4ec7f2fa5238573"

URI_aarch64_rust-rand_distr0.5+std_math-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.5+std_math-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr0.5+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.5+std_math-devel}"
SRC_URI[aarch64_rust-rand_distr0.5+std_math-devel.sha256sum] = "b40c120777a5e096142b854fc653433698bb991cf7e5a9e3a962726577554575"

URI_aarch64_rust-rand_distr0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr0.5-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_distr0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr0.5-devel}"
SRC_URI[aarch64_rust-rand_distr0.5-devel.sha256sum] = "572f468a3010805abaf4ec753b7a4ded35748906e1c215d2c124a2c20ce3c05d"

RDEPENDS:rust-rand_distr0.5+alloc-devel = " \
 cargo \
 rust-rand0.9+alloc-devel \
 rust-rand_distr0.5-devel \
 "
RDEPENDS:rust-rand_distr0.5+default-devel = " \
 cargo \
 rust-rand_distr0.5+std-devel \
 rust-rand_distr0.5-devel \
 "
RDEPENDS:rust-rand_distr0.5+serde-devel = " \
 cargo \
 rust-rand0.9+serde-devel \
 rust-rand_distr0.5-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_with+default-devel \
 "
RDEPENDS:rust-rand_distr0.5+std-devel = " \
 cargo \
 rust-rand0.9+std-devel \
 rust-rand_distr0.5+alloc-devel \
 rust-rand_distr0.5-devel \
 "
RDEPENDS:rust-rand_distr0.5+std_math-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-rand_distr0.5-devel \
 "
RDEPENDS:rust-rand_distr0.5-devel = " \
 cargo \
 rust \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 rust-rand0.9-devel \
 "
