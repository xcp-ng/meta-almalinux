# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kparts"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kparts \
 kf6-kparts-devel \
 kf6-kparts-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kparts-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6871debd4bf10505b9e5149d4a692655cb02bdc801f89cddc99c3738c52280e6"

URI_x86_64_v2_kf6-kparts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts}"
SRC_URI[x86_64_v2_kf6-kparts.sha256sum] = "22349d1affa0f2ee545dcc284224681d0d8d80779446868bee80fba2f00b8794"

URI_x86_64_v2_kf6-kparts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-devel}"
SRC_URI[x86_64_v2_kf6-kparts-devel.sha256sum] = "f0d008013f2571d6f33e905eb4e9f6f91193b01be333855a80aac2d668180755"

URI_x86_64_v2_kf6-kparts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kparts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-doc}"
SRC_URI[x86_64_v2_kf6-kparts-doc.sha256sum] = "16087732e84d65a74760aacfc03f32001e7af63daaac331c45e4f7cc2b37bc0c"

URI_aarch64_kf6-kparts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kparts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts}"
SRC_URI[aarch64_kf6-kparts.sha256sum] = "408ea3f759822d7d2d4f9090edf09c50d954d6de5e6237aa96eb8187aa9b49f2"

URI_aarch64_kf6-kparts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kparts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-devel}"
SRC_URI[aarch64_kf6-kparts-devel.sha256sum] = "9ce6223c5e41fb4df7814df461fe0b5cba8bc61bab7d474c27d4338730756ece"

URI_aarch64_kf6-kparts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kparts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-doc}"
SRC_URI[aarch64_kf6-kparts-doc.sha256sum] = "28c0a2f25e5f90e0aa91e498a43c80021dbafe015411d76192300fc0ddece439"

RDEPENDS:kf6-kparts = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kparts-devel = " \
 cmake-filesystem \
 kf6-kio-devel \
 kf6-kparts \
 kf6-ktextwidgets-devel \
 kf6-kxmlgui-devel \
 "
RDEPENDS:kf6-kparts-doc = " \
 "
