# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pocketsphinx"
PE = "2"
PV = "5.0.4"
PR = "1.el10_2"
PACKAGES = " \
 pocketsphinx \
 pocketsphinx-devel \
 pocketsphinx-libs \
 pocketsphinx-models \
 pocketsphinx-plugin \
 python3-pocketsphinx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pocketsphinx-5.0.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "824ea687a8a3e90aaa47b97f7e58f60615c642305afc8e28753ecb208cfdf448"

URI_x86_64_v2_pocketsphinx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pocketsphinx-5.0.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pocketsphinx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pocketsphinx}"
SRC_URI[x86_64_v2_pocketsphinx.sha256sum] = "da528b9cf24209084ea10e4d27c6da58e1adc50839910f0fb66f4973a5ef41f6"

URI_x86_64_v2_pocketsphinx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pocketsphinx-devel-5.0.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pocketsphinx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pocketsphinx-devel}"
SRC_URI[x86_64_v2_pocketsphinx-devel.sha256sum] = "c6467f510fb650949afa2ae27909edb156eb6390a165ab0bb48bcb90d519bd41"

URI_x86_64_v2_pocketsphinx-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pocketsphinx-libs-5.0.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pocketsphinx-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pocketsphinx-libs}"
SRC_URI[x86_64_v2_pocketsphinx-libs.sha256sum] = "50333b6dd35a3d155e62b3a8574113584ba24c7e1aafae0853fa6c6f21356e70"

URI_x86_64_v2_pocketsphinx-models = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pocketsphinx-models-5.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pocketsphinx-models;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pocketsphinx-models}"
SRC_URI[x86_64_v2_pocketsphinx-models.sha256sum] = "fdeb65ddbc7fc62cfcf15ebdf118776aa95916d26c78b5bc3b93efe00ba0baad"

URI_x86_64_v2_pocketsphinx-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pocketsphinx-plugin-5.0.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pocketsphinx-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pocketsphinx-plugin}"
SRC_URI[x86_64_v2_pocketsphinx-plugin.sha256sum] = "604d455bed3057235302664f0b754974a75c1bd59aea0eb3c415dd4643b4301e"

URI_x86_64_v2_python3-pocketsphinx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pocketsphinx-5.0.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pocketsphinx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pocketsphinx}"
SRC_URI[x86_64_v2_python3-pocketsphinx.sha256sum] = "bfc4e4206dc8ab889a5a04654cc3d44c71191a8643c8ec44c7d4a1402260980a"

URI_aarch64_pocketsphinx = "${EPEL_MIRROR}/aarch64/Packages/p/pocketsphinx-5.0.4-1.el10_2.aarch64.rpm;name=aarch64_pocketsphinx;unpack=0"
SRC_URI:append = " ${URI_aarch64_pocketsphinx}"
SRC_URI[aarch64_pocketsphinx.sha256sum] = "334091a05a644951eab6173fae7a3dcc58998583312708a5c1266952ae509017"

URI_aarch64_pocketsphinx-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pocketsphinx-devel-5.0.4-1.el10_2.aarch64.rpm;name=aarch64_pocketsphinx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pocketsphinx-devel}"
SRC_URI[aarch64_pocketsphinx-devel.sha256sum] = "224ab0d27c0d72bdbb3209445cc9fe42c2d542b71400abc9377f665177590d76"

URI_aarch64_pocketsphinx-libs = "${EPEL_MIRROR}/aarch64/Packages/p/pocketsphinx-libs-5.0.4-1.el10_2.aarch64.rpm;name=aarch64_pocketsphinx-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pocketsphinx-libs}"
SRC_URI[aarch64_pocketsphinx-libs.sha256sum] = "8d1f0559c7796360fcb72d6a8de5b3350bcd6f24557bd9fcb67d384d7908ecfe"

URI_aarch64_pocketsphinx-models = "${EPEL_MIRROR}/aarch64/Packages/p/pocketsphinx-models-5.0.4-1.el10_2.noarch.rpm;name=aarch64_pocketsphinx-models;unpack=0"
SRC_URI:append = " ${URI_aarch64_pocketsphinx-models}"
SRC_URI[aarch64_pocketsphinx-models.sha256sum] = "cea5ed50c89643766aa8a8be7ceabc0cdf6a6855e65fff36d6520af8abd1da2f"

URI_aarch64_pocketsphinx-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/pocketsphinx-plugin-5.0.4-1.el10_2.aarch64.rpm;name=aarch64_pocketsphinx-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_pocketsphinx-plugin}"
SRC_URI[aarch64_pocketsphinx-plugin.sha256sum] = "2df6fc24e4e3c29ee76370599ba440584af5aa410870f1a3c14f5cdfa4487b6e"

URI_aarch64_python3-pocketsphinx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pocketsphinx-5.0.4-1.el10_2.aarch64.rpm;name=aarch64_python3-pocketsphinx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pocketsphinx}"
SRC_URI[aarch64_python3-pocketsphinx.sha256sum] = "a7df705138b9707d579168cb38523c296496155dd7fc94a8f9488da1caa79994"

RDEPENDS:pocketsphinx = " \
 glibc \
 pocketsphinx-libs \
 pocketsphinx-models \
 python3 \
 "
RDEPENDS:pocketsphinx-devel = " \
 pkgconf-pkg-config \
 pocketsphinx-libs \
 "
RDEPENDS:pocketsphinx-libs = " \
 glibc \
 "
RDEPENDS:pocketsphinx-models = " \
 "
RDEPENDS:pocketsphinx-plugin = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 pocketsphinx-libs \
 "
RDEPENDS:python3-pocketsphinx = " \
 glibc \
 pocketsphinx-libs \
 python3 \
 "
