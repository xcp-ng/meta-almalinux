# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus"
PV = "5.14.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-zbus+async-executor-devel \
 rust-zbus+async-fs-devel \
 rust-zbus+async-io-devel \
 rust-zbus+async-lock-devel \
 rust-zbus+async-process-devel \
 rust-zbus+async-task-devel \
 rust-zbus+blocking-api-devel \
 rust-zbus+blocking-devel \
 rust-zbus+bus-impl-devel \
 rust-zbus+camino-devel \
 rust-zbus+chrono-devel \
 rust-zbus+default-devel \
 rust-zbus+option-as-array-devel \
 rust-zbus+p2p-devel \
 rust-zbus+serde_bytes-devel \
 rust-zbus+time-devel \
 rust-zbus+tokio-devel \
 rust-zbus+url-devel \
 rust-zbus+uuid-devel \
 rust-zbus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zbus-5.14.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0914d16ce207c2a34aa4e3aa3f1e6372a5ce0e66600cc847c91a203e7356b9be"

URI_x86_64_v2_rust-zbus+async-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-executor-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-executor-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-executor-devel.sha256sum] = "f7b4aeaa080a8b2faa6b22fd849a9387f3af97805a71a8f687791e3adf8036c5"

URI_x86_64_v2_rust-zbus+async-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-fs-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-fs-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-fs-devel.sha256sum] = "dd6111c029d731132e22d25b4fe62a3e7ce741d258e44d533effe6491b05a917"

URI_x86_64_v2_rust-zbus+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-io-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-io-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-io-devel.sha256sum] = "48ce642ef3a762446371134b6eebe82358f7f902c2317f75170233dcff0f63b8"

URI_x86_64_v2_rust-zbus+async-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-lock-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-lock-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-lock-devel.sha256sum] = "cc9d217a7e568774c158912c938a8702df7b0299a8ac8d548789102683e3c304"

URI_x86_64_v2_rust-zbus+async-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-process-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-process-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-process-devel.sha256sum] = "f1e3d5ae524df00e55e85ed5c4531cb8afa0015f59fb71d09aa30d79d26f08d3"

URI_x86_64_v2_rust-zbus+async-task-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-task-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-task-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-task-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-task-devel.sha256sum] = "6852a08b8100365e8cc8c62915cab0e5e4dea6f3f3a5fc140b3d6613976a80c8"

URI_x86_64_v2_rust-zbus+blocking-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+blocking-api-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+blocking-api-devel}"
SRC_URI[x86_64_v2_rust-zbus+blocking-api-devel.sha256sum] = "f2b7096c7ad9b0663b16caa7b2388fd25fed683c1439fe658eb39674ccef1efa"

URI_x86_64_v2_rust-zbus+blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+blocking-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+blocking-devel}"
SRC_URI[x86_64_v2_rust-zbus+blocking-devel.sha256sum] = "34dfc6fe27b0ae28f1d3df5b9d766c7ed1939c0be9a44c0ec0c95d23012d02fe"

URI_x86_64_v2_rust-zbus+bus-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+bus-impl-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+bus-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+bus-impl-devel}"
SRC_URI[x86_64_v2_rust-zbus+bus-impl-devel.sha256sum] = "4f4217045f7c0aa655d891a2c522f8ea4f749033753b88ab6016a76a81979763"

URI_x86_64_v2_rust-zbus+camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+camino-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+camino-devel}"
SRC_URI[x86_64_v2_rust-zbus+camino-devel.sha256sum] = "ad5832a688909a7552c44a8ea2834b243d1cf206e8b9a44fd761a8fc2e6bb0e7"

URI_x86_64_v2_rust-zbus+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+chrono-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+chrono-devel}"
SRC_URI[x86_64_v2_rust-zbus+chrono-devel.sha256sum] = "1d73b0d8fe3451bb5539c78c11d8e3ae74cf2e26f13bc09cffe15e1f0a6bb702"

URI_x86_64_v2_rust-zbus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+default-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+default-devel}"
SRC_URI[x86_64_v2_rust-zbus+default-devel.sha256sum] = "1d25828f51c729a3982fc30560717ac5f9e3b51933f770ba6e2cb79115a45080"

URI_x86_64_v2_rust-zbus+option-as-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+option-as-array-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+option-as-array-devel}"
SRC_URI[x86_64_v2_rust-zbus+option-as-array-devel.sha256sum] = "1ee116eb07a21aaefde014dd563e29a126a11349517195dbc470693ecb4599af"

URI_x86_64_v2_rust-zbus+p2p-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+p2p-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+p2p-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+p2p-devel}"
SRC_URI[x86_64_v2_rust-zbus+p2p-devel.sha256sum] = "961b0dd7e00db322490342d829278198d37f52311a2698b0b5987dc76de13623"

URI_x86_64_v2_rust-zbus+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+serde_bytes-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-zbus+serde_bytes-devel.sha256sum] = "d25153242754fc6552e0ce4218c03e74e30f54f271b6329325bc0e77712d846b"

URI_x86_64_v2_rust-zbus+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+time-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+time-devel}"
SRC_URI[x86_64_v2_rust-zbus+time-devel.sha256sum] = "175d0670b6baa8e5faf1a11e643966e0a3bbe0a9f61ea312af268375f2cb2ab5"

URI_x86_64_v2_rust-zbus+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+tokio-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+tokio-devel}"
SRC_URI[x86_64_v2_rust-zbus+tokio-devel.sha256sum] = "48b357179f9f5c424bb4f7552a043c7b592ee97b3142304606b6e3ac166481da"

URI_x86_64_v2_rust-zbus+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+url-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+url-devel}"
SRC_URI[x86_64_v2_rust-zbus+url-devel.sha256sum] = "db5f22b273d3e346832424a8d5ad5b727f6eab5b18664c3849dc6383c0321ac7"

URI_x86_64_v2_rust-zbus+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+uuid-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+uuid-devel}"
SRC_URI[x86_64_v2_rust-zbus+uuid-devel.sha256sum] = "70a9ffe3aea4cb2c8dab4c9bb8230dee44499c4ade2765dea50ddae3ecc1c52f"

URI_x86_64_v2_rust-zbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus-devel-5.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus-devel}"
SRC_URI[x86_64_v2_rust-zbus-devel.sha256sum] = "8e2d443be1b4cee23e2dc5c4b9b142ddd1225686bd54a8e80842fa76a16ec975"

URI_aarch64_rust-zbus+async-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-executor-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-executor-devel}"
SRC_URI[aarch64_rust-zbus+async-executor-devel.sha256sum] = "b949ae6f10e11365ada4a1db9188bd8ac76939d5fe5d2c380996c3c83851509f"

URI_aarch64_rust-zbus+async-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-fs-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+async-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-fs-devel}"
SRC_URI[aarch64_rust-zbus+async-fs-devel.sha256sum] = "c19860967d2a7d2cb5508c57a78d0abf6b4851959b4a6c633594f1c69d00478c"

URI_aarch64_rust-zbus+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-io-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-io-devel}"
SRC_URI[aarch64_rust-zbus+async-io-devel.sha256sum] = "5572ab93ba1af7625e0f35b824bbe5f6a7510ada947a8ab05d77eadea11dde8e"

URI_aarch64_rust-zbus+async-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-lock-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-lock-devel}"
SRC_URI[aarch64_rust-zbus+async-lock-devel.sha256sum] = "12cfb8bef4c68e86ff7ab7980bdf83acde2c9e2785fdd76ccd20ca53773054f2"

URI_aarch64_rust-zbus+async-process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-process-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-process-devel}"
SRC_URI[aarch64_rust-zbus+async-process-devel.sha256sum] = "9b8445903cc6cf6409c9d7cdb25d714d787ba3df1b520e1cb9b421258c0b7c41"

URI_aarch64_rust-zbus+async-task-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-task-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+async-task-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-task-devel}"
SRC_URI[aarch64_rust-zbus+async-task-devel.sha256sum] = "2caa5a68fa8ddb0f2f517e6330147798c24b7cad614f28d6aa48af8daa8f4b9e"

URI_aarch64_rust-zbus+blocking-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+blocking-api-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+blocking-api-devel}"
SRC_URI[aarch64_rust-zbus+blocking-api-devel.sha256sum] = "5baffe8c0604dc895f56d78690eec11328cd09b79e5c17dde1df90c4ae30b73e"

URI_aarch64_rust-zbus+blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+blocking-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+blocking-devel}"
SRC_URI[aarch64_rust-zbus+blocking-devel.sha256sum] = "460975459642d8f8aecf63c0621b5a62ae1bdafc9f1b7da8c5764370cc6adc59"

URI_aarch64_rust-zbus+bus-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+bus-impl-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+bus-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+bus-impl-devel}"
SRC_URI[aarch64_rust-zbus+bus-impl-devel.sha256sum] = "d1d9167bb0c1a1a1292ad78be240e672e068b206949593ea329517256c37ac79"

URI_aarch64_rust-zbus+camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+camino-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+camino-devel}"
SRC_URI[aarch64_rust-zbus+camino-devel.sha256sum] = "7dad3781b8a43fc62c92bafa3594c50d09617b5825eb0ecc6f3d8db98f3c5e15"

URI_aarch64_rust-zbus+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+chrono-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+chrono-devel}"
SRC_URI[aarch64_rust-zbus+chrono-devel.sha256sum] = "965881ed453d5adb5304268a52dd213a195ecb9fb46779eb2192421f1cb1f250"

URI_aarch64_rust-zbus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+default-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+default-devel}"
SRC_URI[aarch64_rust-zbus+default-devel.sha256sum] = "7d014f32c1db111a745773276bf116ffbcc245dc1a22f3c8aa1bb8af652193d7"

URI_aarch64_rust-zbus+option-as-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+option-as-array-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+option-as-array-devel}"
SRC_URI[aarch64_rust-zbus+option-as-array-devel.sha256sum] = "b220b73e1864ca64d7f9729342fe4f9bae705b8f8264048985e3b113bdc2f785"

URI_aarch64_rust-zbus+p2p-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+p2p-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+p2p-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+p2p-devel}"
SRC_URI[aarch64_rust-zbus+p2p-devel.sha256sum] = "d6a6be3d32193df043c82ac18e51b27a247604024fdad2fb090d0fa839cabd5d"

URI_aarch64_rust-zbus+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+serde_bytes-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+serde_bytes-devel}"
SRC_URI[aarch64_rust-zbus+serde_bytes-devel.sha256sum] = "343e556260f14b483a5f3eedaf25657617992bf7f10432a92a9d2bcaa0c6d473"

URI_aarch64_rust-zbus+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+time-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+time-devel}"
SRC_URI[aarch64_rust-zbus+time-devel.sha256sum] = "4420b8a608de49d5297c1d214494af6c7f560868511003c4976f520be21cff3c"

URI_aarch64_rust-zbus+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+tokio-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+tokio-devel}"
SRC_URI[aarch64_rust-zbus+tokio-devel.sha256sum] = "73ca8143db9d0d152055b15d85f9c6abe04efdaf102ffbca20c08d1282226fcb"

URI_aarch64_rust-zbus+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+url-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+url-devel}"
SRC_URI[aarch64_rust-zbus+url-devel.sha256sum] = "b3fbab94784e3b0f4292cf62c506eef909d56bf7bdcf5ee806a43073dfee15cb"

URI_aarch64_rust-zbus+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+uuid-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+uuid-devel}"
SRC_URI[aarch64_rust-zbus+uuid-devel.sha256sum] = "f53fd2872aba9b10624f514ebced5ddd88c7f5aea25e66b155d2343babe6c89b"

URI_aarch64_rust-zbus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus-devel-5.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-zbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus-devel}"
SRC_URI[aarch64_rust-zbus-devel.sha256sum] = "71ae0e6056b996c8302ac630cd37fb5e7c0030c335917e186e8c8925f2c6fbdc"

RDEPENDS:rust-zbus+async-executor-devel = " \
 cargo \
 rust-async-executor+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-fs-devel = " \
 cargo \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-zbus+async-executor-devel \
 rust-zbus+async-fs-devel \
 rust-zbus+async-lock-devel \
 rust-zbus+async-process-devel \
 rust-zbus+async-task-devel \
 rust-zbus+blocking-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-lock-devel = " \
 cargo \
 rust-async-lock+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-process-devel = " \
 cargo \
 rust-async-process+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-task-devel = " \
 cargo \
 rust-async-task+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+blocking-api-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zbus_macros+blocking-api-devel \
 "
RDEPENDS:rust-zbus+blocking-devel = " \
 cargo \
 rust-blocking+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+bus-impl-devel = " \
 cargo \
 rust-zbus+p2p-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+camino-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+camino-devel \
 "
RDEPENDS:rust-zbus+chrono-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+chrono-devel \
 "
RDEPENDS:rust-zbus+default-devel = " \
 cargo \
 rust-zbus+async-io-devel \
 rust-zbus+blocking-api-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+option-as-array-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+option-as-array-devel \
 "
RDEPENDS:rust-zbus+p2p-devel = " \
 cargo \
 rust-uuid+v4-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+serde_bytes-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+serde_bytes-devel \
 "
RDEPENDS:rust-zbus+time-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+time-devel \
 "
RDEPENDS:rust-zbus+tokio-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+url-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+url-devel \
 "
RDEPENDS:rust-zbus+uuid-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+uuid-devel \
 "
RDEPENDS:rust-zbus-devel = " \
 cargo \
 rust \
 rust-async-broadcast+default-devel \
 rust-async-recursion+default-devel \
 rust-async-trait+default-devel \
 rust-enumflags2+default-devel \
 rust-enumflags2+serde-devel \
 rust-event-listener+default-devel \
 rust-futures-core+default-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 rust-hex+default-devel \
 rust-libc-devel \
 rust-ordered-stream+default-devel \
 rust-rustix+net-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_repr+default-devel \
 rust-tracing+default-devel \
 rust-uuid+default-devel \
 rust-uuid+serde-devel \
 rust-winnow+default-devel \
 rust-zbus_macros+default-devel \
 rust-zbus_names+default-devel \
 rust-zvariant+default-devel \
 rust-zvariant+enumflags2-devel \
 "
