# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MaxMind-DB-Reader"
PV = "1.000014"
PR = "15.el10_0"
PACKAGES = " \
 perl-MaxMind-DB-Reader \
 perl-MaxMind-DB-Reader-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MaxMind-DB-Reader-1.000014-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bb003eb84568af13988473591d85df9c5a8541326d55ab6a1e24a3cbc90c15c"

URI_x86_64_v2_perl-MaxMind-DB-Reader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MaxMind-DB-Reader-1.000014-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-MaxMind-DB-Reader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MaxMind-DB-Reader}"
SRC_URI[x86_64_v2_perl-MaxMind-DB-Reader.sha256sum] = "7d40764fc0c057ce54ac00e5ce5093ecc218189e4692ae6d27b4fff0ca4c7488"

URI_x86_64_v2_perl-MaxMind-DB-Reader-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MaxMind-DB-Reader-tests-1.000014-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-MaxMind-DB-Reader-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MaxMind-DB-Reader-tests}"
SRC_URI[x86_64_v2_perl-MaxMind-DB-Reader-tests.sha256sum] = "1302953d2739eefea5c114c91b2d2d5f7b94e187e4abd54d97dd1d47ec1a9aea"

URI_aarch64_perl-MaxMind-DB-Reader = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MaxMind-DB-Reader-1.000014-15.el10_0.aarch64.rpm;name=aarch64_perl-MaxMind-DB-Reader;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MaxMind-DB-Reader}"
SRC_URI[aarch64_perl-MaxMind-DB-Reader.sha256sum] = "1dd6170b1ecdada1cfb599f7cf90e536f8b969e33167d08326673d2fd8ad3e7b"

URI_aarch64_perl-MaxMind-DB-Reader-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MaxMind-DB-Reader-tests-1.000014-15.el10_0.aarch64.rpm;name=aarch64_perl-MaxMind-DB-Reader-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MaxMind-DB-Reader-tests}"
SRC_URI[aarch64_perl-MaxMind-DB-Reader-tests.sha256sum] = "0b28e8248d6772e65915371ae1b149d3bf38189d5e78448bd660e5266e02b42d"

RDEPENDS:perl-MaxMind-DB-Reader = " \
 perl-Carp \
 perl-Data-IEEE754 \
 perl-Data-Printer \
 perl-Data-Validate-IP \
 perl-Encode \
 perl-Getopt-Long \
 perl-List-AllUtils \
 perl-Math-BigInt \
 perl-MaxMind-DB-Common \
 perl-MaxMind-DB-Reader \
 perl-Module-Implementation \
 perl-Moo \
 perl-MooX-StrictConstructor \
 perl-Role-Tiny \
 perl-Socket \
 perl-autodie \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-namespace-autoclean \
 "
RDEPENDS:perl-MaxMind-DB-Reader-tests = " \
 bash \
 perl-Encode \
 perl-Exporter \
 perl-ExtUtils-MakeMaker \
 perl-List-AllUtils \
 perl-Math-Int128 \
 perl-MaxMind-DB-Common \
 perl-MaxMind-DB-Reader \
 perl-Module-Implementation \
 perl-Net-Works \
 perl-Path-Class \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Test-Bits \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Number-Delta \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-autodie \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
