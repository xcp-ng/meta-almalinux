# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pythia8"
PV = "8.3.17"
PR = "2.el10_2"
PACKAGES = " \
 pythia8 \
 pythia8-data \
 pythia8-devel \
 pythia8-doc \
 pythia8-examples \
 pythia8-hepmc3 \
 pythia8-lhapdf \
 python3-pythia8 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pythia8-8.3.17-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1054a9aae135aeeb4f405d576cde2d609c1a2d7f85786926cc16b4aad71155ea"

URI_x86_64_v2_pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-8.3.17-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8}"
SRC_URI[x86_64_v2_pythia8.sha256sum] = "b631147c859b907ef71c204c94b90ad43ef8523ecd9903797bef6a83ef77f86a"

URI_x86_64_v2_pythia8-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-data-8.3.17-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-data}"
SRC_URI[x86_64_v2_pythia8-data.sha256sum] = "2dafd228996c3cbcdbdf6e8fe9b4f2fc4432116d2d0d41469f103982cf8a0e9d"

URI_x86_64_v2_pythia8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-devel-8.3.17-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-devel}"
SRC_URI[x86_64_v2_pythia8-devel.sha256sum] = "2e361fc436d8609b6ffb7caf9f290135468fff337b0a7f8b73de58949804e153"

URI_x86_64_v2_pythia8-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-doc-8.3.17-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-doc}"
SRC_URI[x86_64_v2_pythia8-doc.sha256sum] = "cabbff3f348db7ec8d1ec0ad150edf1c367099c650dd75aac71728cc75b16bc4"

URI_x86_64_v2_pythia8-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-examples-8.3.17-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-examples}"
SRC_URI[x86_64_v2_pythia8-examples.sha256sum] = "50385f3c0c73462a5971835d3a828a7fe2d4a31c170c1cb7fe129101322ef67e"

URI_x86_64_v2_pythia8-hepmc3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-hepmc3-8.3.17-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-hepmc3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-hepmc3}"
SRC_URI[x86_64_v2_pythia8-hepmc3.sha256sum] = "b7fad5aaeac0c700c6b06471e5604a5820af2a46aaad1bcc1a51e018c0601d86"

URI_x86_64_v2_pythia8-lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-lhapdf-8.3.17-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-lhapdf}"
SRC_URI[x86_64_v2_pythia8-lhapdf.sha256sum] = "ab8e73007c9db7f27ed54ea47e9de97b4fb4ed31b4abf0de585952c19b6bfb6f"

URI_x86_64_v2_python3-pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pythia8-8.3.17-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pythia8}"
SRC_URI[x86_64_v2_python3-pythia8.sha256sum] = "d704e2437cfeccce933b696353832c6a04c7fc773097db4f69971460bc6d249b"

URI_aarch64_pythia8 = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-8.3.17-2.el10_2.aarch64.rpm;name=aarch64_pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8}"
SRC_URI[aarch64_pythia8.sha256sum] = "d8b2c04d2923e12c91bcdefad4eaf18fef80bcd2406b89d06e39e5f7444b499b"

URI_aarch64_pythia8-data = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-data-8.3.17-2.el10_2.noarch.rpm;name=aarch64_pythia8-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-data}"
SRC_URI[aarch64_pythia8-data.sha256sum] = "fbe11cab23b87d1ef827968321338df0762a5b9c3fc7d9bb13161482d0e97279"

URI_aarch64_pythia8-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-devel-8.3.17-2.el10_2.aarch64.rpm;name=aarch64_pythia8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-devel}"
SRC_URI[aarch64_pythia8-devel.sha256sum] = "b422539188145498e347ebb23e9448a93c62e601ae02993fa804678dd4b2dff8"

URI_aarch64_pythia8-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-doc-8.3.17-2.el10_2.noarch.rpm;name=aarch64_pythia8-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-doc}"
SRC_URI[aarch64_pythia8-doc.sha256sum] = "6c4d9de3519e0790f30d3b855e7f9aff4b6ad92a32829657befcd4465ae1f8dd"

URI_aarch64_pythia8-examples = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-examples-8.3.17-2.el10_2.noarch.rpm;name=aarch64_pythia8-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-examples}"
SRC_URI[aarch64_pythia8-examples.sha256sum] = "c9fede41a7fdb6a3973b7a9df685cd1025aea1ad49f6b27e2ce9a819daf8ae00"

URI_aarch64_pythia8-hepmc3 = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-hepmc3-8.3.17-2.el10_2.aarch64.rpm;name=aarch64_pythia8-hepmc3;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-hepmc3}"
SRC_URI[aarch64_pythia8-hepmc3.sha256sum] = "e05db62d319a28ca3a209dfc111145e458ef3294187921244b8a287b2ab6ba38"

URI_aarch64_pythia8-lhapdf = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-lhapdf-8.3.17-2.el10_2.aarch64.rpm;name=aarch64_pythia8-lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-lhapdf}"
SRC_URI[aarch64_pythia8-lhapdf.sha256sum] = "fc624bb6a34eaf6e27d2b48fcdd7f9f08eafe1e36f2570d52ea63cb6b82fdfb8"

URI_aarch64_python3-pythia8 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pythia8-8.3.17-2.el10_2.aarch64.rpm;name=aarch64_python3-pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pythia8}"
SRC_URI[aarch64_python3-pythia8.sha256sum] = "99c98781c308ecbf19f83e363bfea9d15b61cb090fa26ca948b1e21de756df2b"

RDEPENDS:pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8-data \
 zlib-ng-compat \
 "
RDEPENDS:pythia8-data = " \
 "
RDEPENDS:pythia8-devel = " \
 pythia8 \
 "
RDEPENDS:pythia8-doc = " \
 "
RDEPENDS:pythia8-examples = " \
 "
RDEPENDS:pythia8-hepmc3 = " \
 HepMC3 \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 "
RDEPENDS:pythia8-lhapdf = " \
 glibc \
 lhapdf \
 libgcc \
 libstdc++ \
 pythia8 \
 "
RDEPENDS:python3-pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 python3 \
 "
