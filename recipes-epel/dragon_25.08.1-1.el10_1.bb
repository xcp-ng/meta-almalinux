# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dragon"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 dragon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dragon-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15baf5312710082ae2c8a62f6dc822f860bfc9855888fe0e4a4d4bcc0f465f1b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - dragon: libavcodec.so.61()(64bit)
# - dragon: libavcodec.so.61(LIBAVCODEC_61)(64bit)

URI_x86_64_v2_dragon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dragon-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dragon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dragon}"
SRC_URI[x86_64_v2_dragon.sha256sum] = "01e030488b02a60634ac38af8979be63fba372595dec799dc805438e709e2fe9"

URI_aarch64_dragon = "${EPEL_MIRROR}/aarch64/Packages/d/dragon-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_dragon;unpack=0"
SRC_URI:append = " ${URI_aarch64_dragon}"
SRC_URI[aarch64_dragon.sha256sum] = "28452ec6cdd3b55f4064e0953b9e703e64fe218038a0d4ecd65bba36a5ae6a78"

RDEPENDS:dragon:x86_64_v2 = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
"
RDEPENDS:dragon:aarch64 = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 libavcodec-free \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
"
