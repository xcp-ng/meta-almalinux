# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Graph"
PV = "0.97.35"
PR = "3.el10_3"
PACKAGES = " \
 perl-Graph \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Graph-0.97.35-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "357304f05bcf67b1fe44841f79222497076ed5f0cd3633441498b2d006054950"

URI_x86_64_v2_perl-Graph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Graph-0.97.35-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Graph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Graph}"
SRC_URI[x86_64_v2_perl-Graph.sha256sum] = "73cf46d8dddb54c48af270f79900e4beb0bcf6cd70ed982d3ced90f04a2ca66c"

URI_aarch64_perl-Graph = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Graph-0.97.35-3.el10_3.noarch.rpm;name=aarch64_perl-Graph;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Graph}"
SRC_URI[aarch64_perl-Graph.sha256sum] = "78a0117ac902fa00c6be37c3b32d6d9a99aceaf4f57ce662463389bf61c863c4"

RDEPENDS:perl-Graph = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Graph \
 perl-Heap \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Set-Object \
 perl-base \
 perl-libs \
 perl-overload \
 perl-vars \
 "
