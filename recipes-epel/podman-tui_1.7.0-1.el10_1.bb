# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman-tui"
PV = "1.7.0"
PR = "1.el10_1"
PACKAGES = " \
 podman-tui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/podman-tui-1.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09ced6893407d13a441baaa51cfde7927588ed0fd90493013744983248c99be1"

URI_x86_64_v2_podman-tui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/podman-tui-1.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_podman-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-tui}"
SRC_URI[x86_64_v2_podman-tui.sha256sum] = "ba45ec0c14458e409208673ae97a204fbd49a31ce77f9f98a0d66f361c9a306b"

URI_aarch64_podman-tui = "${EPEL_MIRROR}/aarch64/Packages/p/podman-tui-1.7.0-1.el10_1.aarch64.rpm;name=aarch64_podman-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-tui}"
SRC_URI[aarch64_podman-tui.sha256sum] = "4f7638ffd5c46ff625ee1152660313b57553fe52eb408d0694d7b662ec8a43e9"

RDEPENDS:podman-tui = " \
 glibc \
 "
