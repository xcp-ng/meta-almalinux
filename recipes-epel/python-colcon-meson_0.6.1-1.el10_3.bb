# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-meson"
PV = "0.6.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-meson \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-meson-0.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5a947498af23780cb0c8c3ed5b8e0d6a3c472d398dc112631a783f0a43b8648a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-meson-0.6.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-meson;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-meson.sha256sum] = "b4f53ddf6247dd70756fb483e9e2c4e848346b959493ab3407e0e3ce5e79bc5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-meson-0.6.1-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-meson;unpack=0"
SRC_URI[aarch64_python3-colcon-meson.sha256sum] = "dba40f862d6c6bf09ff8366c1c2e37fe274247012996924c161522b97e9c008c"

RDEPENDS:python3-colcon-meson = " \
 meson \
 python3 \
 python3-colcon-core \
 python3-colcon-library-path \
 "
