# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb10.11"
PE = "3"
PV = "10.11.15"
PR = "2.el10_1"
PACKAGES = " \
 mariadb \
 mariadb-backup \
 mariadb-client-utils \
 mariadb-common \
 mariadb-devel \
 mariadb-embedded \
 mariadb-embedded-devel \
 mariadb-errmsg \
 mariadb-gssapi-server \
 mariadb-oqgraph-engine \
 mariadb-pam \
 mariadb-server \
 mariadb-server-galera \
 mariadb-server-utils \
 mariadb-test \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mariadb10.11-10.11.15-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "065ef31c9dfeab482a0d3e370b527277fab7e0ecdc378cf687ace2872b5d2e71"

URI_x86_64_v2_mariadb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb}"
SRC_URI[x86_64_v2_mariadb.sha256sum] = "594239a7d4bbd5f6668ab05438999629bac76c8fc88ab8638286c12ec8a61122"
RPROVIDES:mariadb:x86_64_v2 = "virtual//usr/bin/mysqldump"

URI_x86_64_v2_mariadb-backup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-backup-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-backup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-backup}"
SRC_URI[x86_64_v2_mariadb-backup.sha256sum] = "6f247b1e2ec427dbbe54ef17b7216601c90ae49ebe2a02c8ee783af217217863"

URI_x86_64_v2_mariadb-client-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-client-utils-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-client-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-client-utils}"
SRC_URI[x86_64_v2_mariadb-client-utils.sha256sum] = "33ca602644405b7a9dd4d31185296fe77aab49801c99a208bd4947eecf6cb921"

URI_x86_64_v2_mariadb-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-common-10.11.15-2.el10_1.noarch.rpm;name=x86_64_v2_mariadb-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-common}"
SRC_URI[x86_64_v2_mariadb-common.sha256sum] = "837a66b64a2478016403bac439c550b6208eeb848a663fc6a4d122937d67a1f2"

URI_x86_64_v2_mariadb-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-devel-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-devel}"
SRC_URI[x86_64_v2_mariadb-devel.sha256sum] = "75d22478a3249f54d6377a601ca01c0d390beea283d5a56add0e464e1419b7c6"

URI_x86_64_v2_mariadb-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-embedded-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-embedded}"
SRC_URI[x86_64_v2_mariadb-embedded.sha256sum] = "1d17857e0db39b9d7a375000d21ab3b1d6d0959a5c292dec3b09d4c808f37d2a"

URI_x86_64_v2_mariadb-embedded-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-embedded-devel-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-embedded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-embedded-devel}"
SRC_URI[x86_64_v2_mariadb-embedded-devel.sha256sum] = "2cc132f2b4ace39d94402e5326cb35ed171c07e4e8aa31d8602fcdc71973be0c"

URI_x86_64_v2_mariadb-errmsg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-errmsg-10.11.15-2.el10_1.noarch.rpm;name=x86_64_v2_mariadb-errmsg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-errmsg}"
SRC_URI[x86_64_v2_mariadb-errmsg.sha256sum] = "904df5cb91945e49bfa176b1ab13570752f2ebe1e19c11ddb1eb18687d11cda4"

URI_x86_64_v2_mariadb-gssapi-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-gssapi-server-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-gssapi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-gssapi-server}"
SRC_URI[x86_64_v2_mariadb-gssapi-server.sha256sum] = "022df03c4472b4f64fb06777223af6c655f64f3d27ad9b9187702bd6469a5bb1"

URI_x86_64_v2_mariadb-oqgraph-engine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-oqgraph-engine-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-oqgraph-engine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-oqgraph-engine}"
SRC_URI[x86_64_v2_mariadb-oqgraph-engine.sha256sum] = "049d2b1bc24653157ca767d5a3cd5d4e7c78097f9e8b4d15ce64cd026d669ef8"

URI_x86_64_v2_mariadb-pam = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-pam-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-pam}"
SRC_URI[x86_64_v2_mariadb-pam.sha256sum] = "734629ecefd5fe38eccf2611efd08a0fac690b3ec3849022ef0636d38cf68a9b"

URI_x86_64_v2_mariadb-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-server}"
SRC_URI[x86_64_v2_mariadb-server.sha256sum] = "73f67a1d6850d52c1b00621e2253bd91c4ece1b8ff89e13edb26f7f5dc5a3f7b"

URI_x86_64_v2_mariadb-server-galera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-galera-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-server-galera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-server-galera}"
SRC_URI[x86_64_v2_mariadb-server-galera.sha256sum] = "f939deddbe68022be7af2945f8f7e0a436ef936f2297d65c813fa129abfe8124"

URI_x86_64_v2_mariadb-server-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-server-utils-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-server-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-server-utils}"
SRC_URI[x86_64_v2_mariadb-server-utils.sha256sum] = "169fd1c3c4dc6833941d75fdbff873b18e3a254a336733292bfedbd37275d599"

URI_x86_64_v2_mariadb-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-test-10.11.15-2.el10_1.x86_64_v2.rpm;name=x86_64_v2_mariadb-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-test}"
SRC_URI[x86_64_v2_mariadb-test.sha256sum] = "e4fb0f66ba8b80a6af74df2a845ee2006f7660f8054101f55dd7f18f0135ee10"

URI_aarch64_mariadb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb}"
SRC_URI[aarch64_mariadb.sha256sum] = "0ad220753d6ee546b02a0a960c43ae208ebba271df4f9650fd375082a5293671"
RPROVIDES:mariadb:aarch64 = "virtual//usr/bin/mysqldump"

URI_aarch64_mariadb-backup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-backup-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-backup;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-backup}"
SRC_URI[aarch64_mariadb-backup.sha256sum] = "c779d15dff4b58ad3fae8363d325cf127069850ae8f1d1e057c5850bbd3cfc27"

URI_aarch64_mariadb-client-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-client-utils-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-client-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-client-utils}"
SRC_URI[aarch64_mariadb-client-utils.sha256sum] = "814acca15cdcbf4498a2fa7a536f96ad1b7623778379cb4bf8639e52119cd3bc"

URI_aarch64_mariadb-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-common-10.11.15-2.el10_1.noarch.rpm;name=aarch64_mariadb-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-common}"
SRC_URI[aarch64_mariadb-common.sha256sum] = "837a66b64a2478016403bac439c550b6208eeb848a663fc6a4d122937d67a1f2"

URI_aarch64_mariadb-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-devel-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-devel}"
SRC_URI[aarch64_mariadb-devel.sha256sum] = "68696cd1518f0a2bf29472eb913c390126126043ab3a4212a9e2a9dfd4d28d9c"

URI_aarch64_mariadb-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-embedded-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-embedded}"
SRC_URI[aarch64_mariadb-embedded.sha256sum] = "7c16e6c1b89f65fa06b1ea4ae044f2e86baee62ca621abd62f59f06c3224ea47"

URI_aarch64_mariadb-embedded-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-embedded-devel-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-embedded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-embedded-devel}"
SRC_URI[aarch64_mariadb-embedded-devel.sha256sum] = "510b6647b99486556852dcd8e27330d436de0cac984e01bd29923234bfb70f83"

URI_aarch64_mariadb-errmsg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-errmsg-10.11.15-2.el10_1.noarch.rpm;name=aarch64_mariadb-errmsg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-errmsg}"
SRC_URI[aarch64_mariadb-errmsg.sha256sum] = "904df5cb91945e49bfa176b1ab13570752f2ebe1e19c11ddb1eb18687d11cda4"

URI_aarch64_mariadb-gssapi-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-gssapi-server-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-gssapi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-gssapi-server}"
SRC_URI[aarch64_mariadb-gssapi-server.sha256sum] = "90b57b86e65d375db9c2902e909533c017298fccdc0f037127b5f546a71debbb"

URI_aarch64_mariadb-oqgraph-engine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-oqgraph-engine-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-oqgraph-engine;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-oqgraph-engine}"
SRC_URI[aarch64_mariadb-oqgraph-engine.sha256sum] = "804aff7170030a70a59539a430d539862e310d45913c4ad78cfc807cb619c3ae"

URI_aarch64_mariadb-pam = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-pam-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-pam}"
SRC_URI[aarch64_mariadb-pam.sha256sum] = "0a16bc89028daceba93e6f37ab6106dbe60dcb0ed5e15a1d38780a979e8c3990"

URI_aarch64_mariadb-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-server}"
SRC_URI[aarch64_mariadb-server.sha256sum] = "7ae92cac19d4513ab9c705410cee08dcb958379371bec59e075a9131da28f071"

URI_aarch64_mariadb-server-galera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-galera-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-server-galera;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-server-galera}"
SRC_URI[aarch64_mariadb-server-galera.sha256sum] = "60553d0f63fd9643e6538fdeebcead1e7b949e45a66b8042fe29a564d976f123"

URI_aarch64_mariadb-server-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-server-utils-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-server-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-server-utils}"
SRC_URI[aarch64_mariadb-server-utils.sha256sum] = "2fc8b49e00896b9fef40e6e70ee37892ef29820befea9bd7d147f4daa6ef89d3"

URI_aarch64_mariadb-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-test-10.11.15-2.el10_1.aarch64.rpm;name=aarch64_mariadb-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-test}"
SRC_URI[aarch64_mariadb-test.sha256sum] = "e73b78e384432b8539b2fb1de7dd6a5e03c36d6b6561ab0abc4ad01ecac85339"

RDEPENDS:mariadb = " \
 bash \
 glibc \
 grep \
 libedit \
 libgcc \
 libstdc++ \
 mariadb-common \
 mariadb-connector-c \
 ncurses-libs \
 openssl-libs \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-backup = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb-server \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-client-utils = " \
 mariadb \
 perl-DBI \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Sys-Hostname \
 perl-interpreter \
 "
RDEPENDS:mariadb-common = " \
 mariadb-connector-c-config \
 "
RDEPENDS:mariadb-devel = " \
 mariadb-connector-c-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:mariadb-embedded = " \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb-common \
 mariadb-errmsg \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-embedded-devel = " \
 libaio-devel \
 mariadb-devel \
 mariadb-embedded \
 "
RDEPENDS:mariadb-errmsg = " \
 mariadb-common \
 "
RDEPENDS:mariadb-gssapi-server = " \
 glibc \
 krb5-libs \
 mariadb-server \
 "
RDEPENDS:mariadb-oqgraph-engine = " \
 Judy \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-server \
 "
RDEPENDS:mariadb-pam = " \
 glibc \
 mariadb-server \
 pam-libs \
 "
RDEPENDS:mariadb-server = " \
 bash \
 bzip2-libs \
 glibc \
 iproute \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 lz4-libs \
 lzo \
 mariadb \
 mariadb-common \
 mariadb-connector-c-config \
 mariadb-errmsg \
 mysql-selinux \
 openssl-libs \
 pcre2 \
 shadow-utils \
 snappy \
 systemd \
 systemd-libs \
 virtual/coreutils \
 which \
 zlib-ng-compat \
 "
RDEPENDS:mariadb-server-galera = " \
 bash \
 galera \
 libselinux-utils \
 lsof \
 mariadb-common \
 mariadb-server \
 policycoreutils \
 policycoreutils-python-utils \
 rsync \
 "
RDEPENDS:mariadb-server-utils = " \
 glibc \
 mariadb-server \
 perl-DBD-MariaDB \
 perl-DBI \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:mariadb-test = " \
 bash \
 glibc \
 libaio \
 libgcc \
 libstdc++ \
 libxcrypt \
 mariadb \
 mariadb-common \
 mariadb-server \
 openssl-libs \
 pam-libs \
 patch \
 pcre2 \
 perl-Carp \
 perl-Data-Dumper \
 perl-English \
 perl-Env \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Memoize \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Test-Simple \
 perl-Text-Tabs+Wrap \
 perl-Time \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-threads \
 perl-threads-shared \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/mysqldump"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/mysqldump"
