# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "efivar"
PV = "39"
PR = "3.el10"
PACKAGES = " \
 efivar \
 efivar-devel \
 efivar-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/efivar-39-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c9706643660205d8dc59b1b7523856a7744beb4571324dd871ceb96a000039d"

URI_x86_64_v2_efivar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/efivar-39-3.el10.x86_64_v2.rpm;name=x86_64_v2_efivar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_efivar}"
SRC_URI[x86_64_v2_efivar.sha256sum] = "bcfc297d4020f363d7c24fad15a59c8abd195900e6812e13d86de7214fd49d0b"

URI_x86_64_v2_efivar-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/efivar-devel-39-3.el10.x86_64_v2.rpm;name=x86_64_v2_efivar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_efivar-devel}"
SRC_URI[x86_64_v2_efivar-devel.sha256sum] = "a1c0338eca9e5811a921acc7cdab8078cdf7a426e68c30409099d3ff6d3fc164"

URI_x86_64_v2_efivar-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/efivar-libs-39-3.el10.x86_64_v2.rpm;name=x86_64_v2_efivar-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_efivar-libs}"
SRC_URI[x86_64_v2_efivar-libs.sha256sum] = "e9bea7306dbfa4cf6e77b4d9b6d4152f99ab2f7bd62608205620fa8eb7f62c3c"

URI_aarch64_efivar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/efivar-39-3.el10.aarch64.rpm;name=aarch64_efivar;unpack=0"
SRC_URI:append = " ${URI_aarch64_efivar}"
SRC_URI[aarch64_efivar.sha256sum] = "b98a97213f0d1b697c0f8227f179a070de7374ddf13db510b4b6f00fd1a61578"

URI_aarch64_efivar-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/efivar-devel-39-3.el10.aarch64.rpm;name=aarch64_efivar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_efivar-devel}"
SRC_URI[aarch64_efivar-devel.sha256sum] = "fed601c7c23eeb2b039d66f12ee1a229fe2b0e2b29f0d88df2f5c10c21ce77eb"

URI_aarch64_efivar-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/efivar-libs-39-3.el10.aarch64.rpm;name=aarch64_efivar-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_efivar-libs}"
SRC_URI[aarch64_efivar-libs.sha256sum] = "a9a9e27306818c694fcb23ac2863d75c47a77975b79c67a4db53ea028e642104"

RDEPENDS:efivar = " \
 efivar-libs \
 glibc \
 "
RDEPENDS:efivar-devel = " \
 efivar-devel \
 efivar-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:efivar-libs = " \
 glibc \
 "
