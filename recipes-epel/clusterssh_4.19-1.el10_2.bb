# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clusterssh"
PV = "4.19"
PR = "1.el10_2"
PACKAGES = " \
 clusterssh \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clusterssh-4.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0aff81f65b478fb390c7500668e677eeaf3563225011fbc8fe32e64cee3037e6"

URI_x86_64_v2_clusterssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clusterssh-4.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_clusterssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clusterssh}"
SRC_URI[x86_64_v2_clusterssh.sha256sum] = "f49b5db7e410139a006b69f1a76aa131c17de3b89467802a69c22b647b01dd8a"

URI_aarch64_clusterssh = "${EPEL_MIRROR}/aarch64/Packages/c/clusterssh-4.19-1.el10_2.noarch.rpm;name=aarch64_clusterssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_clusterssh}"
SRC_URI[aarch64_clusterssh.sha256sum] = "349e2b443b41c9759b4e54dc31a22ceb99177f2ed80d070758d72bbb356bbebc"

RDEPENDS:clusterssh = " \
 clusterssh \
 perl-Carp \
 perl-English \
 perl-Exception-Class \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-Locale-Maketext \
 perl-Module-Load \
 perl-Net \
 perl-POSIX \
 perl-Pod-Usage \
 perl-Socket \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Tk \
 perl-Try-Tiny \
 perl-X11-Protocol \
 perl-X11-Protocol-Other \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 perl-vars \
 perl-version \
 xorg-x11-fonts-100dpi \
 xorg-x11-fonts-75dpi \
 xterm \
 "
