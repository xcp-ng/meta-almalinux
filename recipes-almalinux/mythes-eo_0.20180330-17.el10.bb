# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mythes-eo"
PV = "0.20180330"
PR = "17.el10"
PACKAGES = " \
 hyphen-eo \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mythes-eo-0.20180330-17.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8734fe0e5929be7d27d7271dd39512b2d44a2ff2f6663702627c91c014efd94f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-eo-0.20180330-17.el10.noarch.rpm;name=x86_64_v2_hyphen-eo;unpack=0"
SRC_URI[x86_64_v2_hyphen-eo.sha256sum] = "bbbf0a788417327dc8f88035d74cf458fe1293636a0c11d2ba98d44de9e80c1b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-eo-0.20180330-17.el10.noarch.rpm;name=aarch64_hyphen-eo;unpack=0"
SRC_URI[aarch64_hyphen-eo.sha256sum] = "bbbf0a788417327dc8f88035d74cf458fe1293636a0c11d2ba98d44de9e80c1b"

RDEPENDS:hyphen-eo = " \
 hyphen \
 "
