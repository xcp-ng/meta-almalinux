# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mohae-deepcopy"
PV = "0"
PR = "0.14.20200303gitc48cc78.el10_0"
PACKAGES = " \
 golang-github-mohae-deepcopy-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-mohae-deepcopy-0-0.14.20200303gitc48cc78.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7627dcb4dc669627f8d139938b9366a2af21794ccebe1c78bbdaf73a1d039bed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mohae-deepcopy-devel-0-0.14.20200303gitc48cc78.el10_0.noarch.rpm;name=aarch64_golang-github-mohae-deepcopy-devel;unpack=0"
SRC_URI[aarch64_golang-github-mohae-deepcopy-devel.sha256sum] = "aaf6d2b1f7dc9f45740b4405486f5f73fa12dc1c572ac44a9afa82e29e7f4c99"

RDEPENDS:golang-github-mohae-deepcopy-devel = " \
 go-filesystem \
 "
