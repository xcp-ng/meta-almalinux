# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libs3"
PV = "4.1"
PR = "0.20.20190408git287e4be.el10_1"
PACKAGES = " \
 libs3 \
 libs3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libs3-4.1-0.20.20190408git287e4be.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff7f24c461f1e8f09bee9db40d00c939c6b4dd4ed8be4dda1742074799b54bb3"

URI_x86_64_v2_libs3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libs3-4.1-0.20.20190408git287e4be.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libs3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libs3}"
SRC_URI[x86_64_v2_libs3.sha256sum] = "618cfd193e8724b8a4977bee7eefaebed691de38a565a2b80a9c5de2963323a7"

URI_x86_64_v2_libs3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libs3-devel-4.1-0.20.20190408git287e4be.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libs3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libs3-devel}"
SRC_URI[x86_64_v2_libs3-devel.sha256sum] = "6590ae4eff8feb59075d572a3202b8127608ed0aea45d378525af3764d26fc32"

URI_aarch64_libs3 = "${EPEL_MIRROR}/aarch64/Packages/l/libs3-4.1-0.20.20190408git287e4be.el10_1.aarch64.rpm;name=aarch64_libs3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libs3}"
SRC_URI[aarch64_libs3.sha256sum] = "28dca65110c2059f2336f56fcd575ef1f412804f85fe48b30ea1b5da50b17e01"

URI_aarch64_libs3-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libs3-devel-4.1-0.20.20190408git287e4be.el10_1.aarch64.rpm;name=aarch64_libs3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libs3-devel}"
SRC_URI[aarch64_libs3-devel.sha256sum] = "6d00ede0c29456ce579a6044963e56b077a5bd3638504a21157923fe2c76be85"

RDEPENDS:libs3 = " \
 glibc \
 libxml2 \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:libs3-devel = " \
 libs3 \
 "
