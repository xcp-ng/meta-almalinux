# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-once_cell"
PV = "1.21.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-once_cell+alloc-devel \
 rust-once_cell+atomic-polyfill-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell+default-devel \
 rust-once_cell+parking_lot-devel \
 rust-once_cell+portable-atomic-devel \
 rust-once_cell+race-devel \
 rust-once_cell+std-devel \
 rust-once_cell+unstable-devel \
 rust-once_cell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-once_cell-1.21.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "873037199cc5ff970038ac3100a562a82276b0fba182d6796fcf57453e25630d"

URI_x86_64_v2_rust-once_cell+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+alloc-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+alloc-devel}"
SRC_URI[x86_64_v2_rust-once_cell+alloc-devel.sha256sum] = "3893b259660b9e335f6cb14b30f126e18ee2ec2eb6a39cb01fd552ff7a46f160"

URI_x86_64_v2_rust-once_cell+atomic-polyfill-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+atomic-polyfill-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+atomic-polyfill-devel}"
SRC_URI[x86_64_v2_rust-once_cell+atomic-polyfill-devel.sha256sum] = "b7f0446dd5772038723b8caee342c9206f19b7bdb37e6be121a57f0686c7e66f"

URI_x86_64_v2_rust-once_cell+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+critical-section-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+critical-section-devel}"
SRC_URI[x86_64_v2_rust-once_cell+critical-section-devel.sha256sum] = "8c3b54de3b2d1e467cd433462c7095e265f3104437ad0cb86d70cc4d1c276f4e"

URI_x86_64_v2_rust-once_cell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+default-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+default-devel}"
SRC_URI[x86_64_v2_rust-once_cell+default-devel.sha256sum] = "f907b0efc2e3e70f17821c39ad964094cc2610c7c0975995a7833defa026dedb"

URI_x86_64_v2_rust-once_cell+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+parking_lot-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-once_cell+parking_lot-devel.sha256sum] = "e2ec0a8e8e87351ea77c1656612901a28178f7d5c57d70e38464981c9ac51cab"

URI_x86_64_v2_rust-once_cell+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+portable-atomic-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-once_cell+portable-atomic-devel.sha256sum] = "e955771477388e6d9395c40ae9c81190b4188f3423cd3aeb30744b4bd2f67fd0"

URI_x86_64_v2_rust-once_cell+race-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+race-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+race-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+race-devel}"
SRC_URI[x86_64_v2_rust-once_cell+race-devel.sha256sum] = "1afd1d08704fe2432b1c6db55fd8101d0e9060f17bf4f8134f4f4b26cb35a5ed"

URI_x86_64_v2_rust-once_cell+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+std-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+std-devel}"
SRC_URI[x86_64_v2_rust-once_cell+std-devel.sha256sum] = "c1bb2ff0c403cc2a83b7c8cc04a858d76a0e277822b7f2fff515f0d2559b1342"

URI_x86_64_v2_rust-once_cell+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell+unstable-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell+unstable-devel}"
SRC_URI[x86_64_v2_rust-once_cell+unstable-devel.sha256sum] = "d4f98f8d280597f0870fa7daa2d834ba4641d1acb2104ad7e9e2918a0aeccb5b"

URI_x86_64_v2_rust-once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-once_cell-devel-1.21.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-once_cell-devel}"
SRC_URI[x86_64_v2_rust-once_cell-devel.sha256sum] = "d7c5937ba76db598c2fd1d081ff8053f94f4f0cefde11bb8f6ab6b9e172dd761"

URI_aarch64_rust-once_cell+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+alloc-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+alloc-devel}"
SRC_URI[aarch64_rust-once_cell+alloc-devel.sha256sum] = "8ac8ccab8df78889916e59477a68665e41b859969fa0d76133e634b91c5356a5"

URI_aarch64_rust-once_cell+atomic-polyfill-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+atomic-polyfill-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell+atomic-polyfill-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+atomic-polyfill-devel}"
SRC_URI[aarch64_rust-once_cell+atomic-polyfill-devel.sha256sum] = "6e31a21a77efcff6afa90c2176492300f78993bab96fde7433289dde4cbb2093"

URI_aarch64_rust-once_cell+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+critical-section-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+critical-section-devel}"
SRC_URI[aarch64_rust-once_cell+critical-section-devel.sha256sum] = "3bb470e9a38c4c6a132c892b28e77106267c63c2b8649bd488db40da0545bdc5"

URI_aarch64_rust-once_cell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+default-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+default-devel}"
SRC_URI[aarch64_rust-once_cell+default-devel.sha256sum] = "2a735dc209ad2c992eb16848c0c31ce09a70bd043ec7b5ef3550a1152b1e439a"

URI_aarch64_rust-once_cell+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+parking_lot-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+parking_lot-devel}"
SRC_URI[aarch64_rust-once_cell+parking_lot-devel.sha256sum] = "326112fe62ebc661384173b5f226962223bef40ec3e9d5e8f7eb79d7ba793fab"

URI_aarch64_rust-once_cell+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+portable-atomic-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+portable-atomic-devel}"
SRC_URI[aarch64_rust-once_cell+portable-atomic-devel.sha256sum] = "744a6fb5fda14b6a777b8c5b0d8b6cae442721df73cc2fcc22ad2124fb20e51b"

URI_aarch64_rust-once_cell+race-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+race-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell+race-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+race-devel}"
SRC_URI[aarch64_rust-once_cell+race-devel.sha256sum] = "0e59c96f9258bb6ba0f9b7c30074669a0b6e4f279e1e4cd0106eee4489285e5f"

URI_aarch64_rust-once_cell+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+std-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+std-devel}"
SRC_URI[aarch64_rust-once_cell+std-devel.sha256sum] = "c8d0bc9be8b7f245467a9c49e6b9e5055aa5f0b0e09538183bca95b0b0c21ff1"

URI_aarch64_rust-once_cell+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell+unstable-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell+unstable-devel}"
SRC_URI[aarch64_rust-once_cell+unstable-devel.sha256sum] = "8a873a37c914fdbd23939e2891ba00d5da1213dbaa003f3f5630f3c6f1065a32"

URI_aarch64_rust-once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-once_cell-devel-1.21.4-1.el10_2.noarch.rpm;name=aarch64_rust-once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-once_cell-devel}"
SRC_URI[aarch64_rust-once_cell-devel.sha256sum] = "4724ebb4862ba114531b485770c1a661b93b6d8698b06d86eb622764783823fb"

RDEPENDS:rust-once_cell+alloc-devel = " \
 cargo \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+atomic-polyfill-devel = " \
 cargo \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+critical-section-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-once_cell+portable-atomic-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+default-devel = " \
 cargo \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+parking_lot-devel = " \
 cargo \
 rust-once_cell-devel \
 rust-parking_lot_core-devel \
 "
RDEPENDS:rust-once_cell+portable-atomic-devel = " \
 cargo \
 rust-once_cell-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-once_cell+race-devel = " \
 cargo \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+std-devel = " \
 cargo \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell+unstable-devel = " \
 cargo \
 rust-once_cell-devel \
 "
RDEPENDS:rust-once_cell-devel = " \
 cargo \
 rust \
 "
