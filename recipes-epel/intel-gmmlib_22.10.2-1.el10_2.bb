# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-gmmlib"
PV = "22.10.2"
PR = "1.el10_2"
PACKAGES = " \
 intel-gmmlib \
 intel-gmmlib-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/intel-gmmlib-22.10.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8fd25e0530e6d2520afd8227d68e996d0befe4c3428bda60626438f25f7287c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-22.10.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib;unpack=0"
SRC_URI[x86_64_v2_intel-gmmlib.sha256sum] = "44a3e3d2ae70a6282b4fd8ece30f01c5e75ec224bbc98955df7b6eb7905e5e1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-devel-22.10.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib-devel;unpack=0"
SRC_URI[x86_64_v2_intel-gmmlib-devel.sha256sum] = "15a54dce9029764eae8b6d7d839da5df07b035a30dfc5e293eb7843f0974bdb6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-22.10.2-1.el10_2.aarch64.rpm;name=aarch64_intel-gmmlib;unpack=0"
SRC_URI[aarch64_intel-gmmlib.sha256sum] = "9771619bd526eccfcd64e5cf3b09fdf05d9bbf97760f742c4d4a338c50dc9cae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-devel-22.10.2-1.el10_2.aarch64.rpm;name=aarch64_intel-gmmlib-devel;unpack=0"
SRC_URI[aarch64_intel-gmmlib-devel.sha256sum] = "5fb5a1257cdc48384a04c0486435c329a3262f86ba244a4ccb1e33eaf1c5edc9"

RDEPENDS:intel-gmmlib = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-gmmlib-devel = " \
 intel-gmmlib \
 pkgconf-pkg-config \
 "
