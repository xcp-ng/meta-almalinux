# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libaec"
PV = "1.1.3"
PR = "1.el10_0"
PACKAGES = " \
 libaec \
 libaec-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libaec-1.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c322e9ae6c2fee78f3454a91fda7249ae5ed2c295432527bd4838216e066a8eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaec-1.1.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaec;unpack=0"
SRC_URI[x86_64_v2_libaec.sha256sum] = "c1a2b12065acf2596931c5b595bdb4268f2334f8259a74be6196e60cee3baa01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaec-devel-1.1.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaec-devel;unpack=0"
SRC_URI[x86_64_v2_libaec-devel.sha256sum] = "3b296e99b563eaa1844aac62a2eac238dc0be21cda6014dc35b691f439c1d92e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libaec-1.1.3-1.el10_0.aarch64.rpm;name=aarch64_libaec;unpack=0"
SRC_URI[aarch64_libaec.sha256sum] = "7515db8d31ae5acd1a2fbfd00039ea25c2136a08147322f9e24db648f2733fe5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libaec-devel-1.1.3-1.el10_0.aarch64.rpm;name=aarch64_libaec-devel;unpack=0"
SRC_URI[aarch64_libaec-devel.sha256sum] = "5bc0a5b9d30d76fbec9d2f02f27d6b0f17c1ef4a636e1ff73b2c1b1d2a267ca6"

RDEPENDS:libaec = " \
 glibc \
 "
RDEPENDS:libaec-devel = " \
 libaec \
 "
