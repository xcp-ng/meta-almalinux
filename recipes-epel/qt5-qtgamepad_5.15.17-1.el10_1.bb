# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtgamepad"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtgamepad \
 qt5-qtgamepad-devel \
 qt5-qtgamepad-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtgamepad-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e57465387568da5b6dca463f321d37e23fec192343649786058bc90c22ed63b"

URI_x86_64_v2_qt5-qtgamepad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgamepad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad}"
SRC_URI[x86_64_v2_qt5-qtgamepad.sha256sum] = "3e98a43201a567f542a3aeab4442aa0c7124bb47ec1337f4400665c06c09da3c"

URI_x86_64_v2_qt5-qtgamepad-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgamepad-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad-devel}"
SRC_URI[x86_64_v2_qt5-qtgamepad-devel.sha256sum] = "9ffb172ca88d5dea471cdd00021cb3804dc80298f1594e4b01080ac65b61830e"

URI_x86_64_v2_qt5-qtgamepad-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtgamepad-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtgamepad-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtgamepad-examples}"
SRC_URI[x86_64_v2_qt5-qtgamepad-examples.sha256sum] = "c077cb894d0a4f8dce9ccbdbf30a876c313bbed688a0c0cd634e63d46a164df0"

URI_aarch64_qt5-qtgamepad = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtgamepad;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad}"
SRC_URI[aarch64_qt5-qtgamepad.sha256sum] = "ad90f06dd9a5dc053e7f100bdca4ae24f4da9c5ed31d28f4c5a9cfcd196bef02"

URI_aarch64_qt5-qtgamepad-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtgamepad-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad-devel}"
SRC_URI[aarch64_qt5-qtgamepad-devel.sha256sum] = "2579ae1d093622fdeb33397ce6d5a9dcf27395f55ec703882bfbcb205a5176d4"

URI_aarch64_qt5-qtgamepad-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtgamepad-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtgamepad-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtgamepad-examples}"
SRC_URI[aarch64_qt5-qtgamepad-examples.sha256sum] = "481b74e3127505b77e2d88b693a1ceee78bfb3ffb5d1f02c9a9da8d15ac32d37"

RDEPENDS:qt5-qtgamepad = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 systemd-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:qt5-qtgamepad-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtgamepad \
 "
RDEPENDS:qt5-qtgamepad-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtgamepad \
 "
