# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslotest"
PV = "6.0.0"
PR = "4.el10_3"
PACKAGES = " \
 python-oslotest-doc \
 python3-oslotest \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-oslotest-6.0.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3a5836afbbdffe587d3c6025f50cdd99b2552d9f1d7016728791b99018355e83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslotest-doc-6.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslotest-doc;unpack=0"
SRC_URI[x86_64_v2_python-oslotest-doc.sha256sum] = "1bc6f2476a13b73c50d2f9559acf0d6e6bc80956520c72a0e64d30e86183994b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslotest-6.0.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslotest;unpack=0"
SRC_URI[x86_64_v2_python3-oslotest.sha256sum] = "4be7f85a235488f203df0aa962c531d6fd0cc375765ca9399d9c93722f2bdb31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-oslotest-doc-6.0.0-4.el10_3.noarch.rpm;name=aarch64_python-oslotest-doc;unpack=0"
SRC_URI[aarch64_python-oslotest-doc.sha256sum] = "d6f9253fccaf8a85106cefbcbc8b7b325e84f0a09af368b93154b37797ad2123"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-oslotest-6.0.0-4.el10_3.noarch.rpm;name=aarch64_python3-oslotest;unpack=0"
SRC_URI[aarch64_python3-oslotest.sha256sum] = "0cfe265de4905f5eaec7ca54906609d5e86ae8b004789df8319dc79ac6ea67e9"

RDEPENDS:python-oslotest-doc = " \
 "
RDEPENDS:python3-oslotest = " \
 bash \
 python3 \
 python3-fixtures \
 python3-subunit \
 python3-testtools \
 "
