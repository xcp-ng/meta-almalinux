# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sl"
PV = "5.02"
PR = "1.el10_1"
PACKAGES = " \
 sl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sl-5.02-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39dbfec820f2ed634742a08ad20cc6dd56da28540932abcbac4e65e0be9c30c1"

URI_x86_64_v2_sl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sl-5.02-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sl}"
SRC_URI[x86_64_v2_sl.sha256sum] = "57c6d4d9a6a6534da7598aecdb185feb8b0905b067c5adc33b746e1be6ae9390"

URI_aarch64_sl = "${EPEL_MIRROR}/aarch64/Packages/s/sl-5.02-1.el10_1.aarch64.rpm;name=aarch64_sl;unpack=0"
SRC_URI:append = " ${URI_aarch64_sl}"
SRC_URI[aarch64_sl.sha256sum] = "42ab2846d95ed5e96aaeaa0d22ff2fa86c91d29a04699737f1a9d4537fcb1bc5"

RDEPENDS:sl = " \
 glibc \
 ncurses-libs \
 "
