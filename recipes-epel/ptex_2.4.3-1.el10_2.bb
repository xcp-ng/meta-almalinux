# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ptex"
PV = "2.4.3"
PR = "1.el10_2"
PACKAGES = " \
 ptex \
 ptex-devel \
 ptex-doc \
 ptex-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/ptex-2.4.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c9ee094cc604a5d7370fa307880137765f30ea3aa63f4a92d92740273909379"

URI_x86_64_v2_ptex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptex-2.4.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptex}"
SRC_URI[x86_64_v2_ptex.sha256sum] = "80e9eb1df05cfa0f5a6ba808c955cc97fc221d5c0ce9a9f16e9fd045449971a7"

URI_x86_64_v2_ptex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptex-devel-2.4.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptex-devel}"
SRC_URI[x86_64_v2_ptex-devel.sha256sum] = "a22a2040be970574b411d6d4c8977ed8f71b9aaf887a1bee7fb11113288b8800"

URI_x86_64_v2_ptex-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptex-doc-2.4.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ptex-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptex-doc}"
SRC_URI[x86_64_v2_ptex-doc.sha256sum] = "429ecbc7451784fd25ed2442ba958ccd821a9e99a5748fe098fccac5d98c0a2f"

URI_x86_64_v2_ptex-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptex-libs-2.4.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptex-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptex-libs}"
SRC_URI[x86_64_v2_ptex-libs.sha256sum] = "daf420d7260432dff2c2deaab82783a82584e91916636e958ebd4e29070e124a"

URI_aarch64_ptex = "${EPEL_MIRROR}/aarch64/Packages/p/ptex-2.4.3-1.el10_2.aarch64.rpm;name=aarch64_ptex;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptex}"
SRC_URI[aarch64_ptex.sha256sum] = "89780b088d8a75b31c91670618f25a119c6e2fbb8aaa119e123c4d486989f1e0"

URI_aarch64_ptex-devel = "${EPEL_MIRROR}/aarch64/Packages/p/ptex-devel-2.4.3-1.el10_2.aarch64.rpm;name=aarch64_ptex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptex-devel}"
SRC_URI[aarch64_ptex-devel.sha256sum] = "d7f0b1dd786dc4af5402d86d2a4f9c5f34a8ec5654c7be458a4c2f174e510dd4"

URI_aarch64_ptex-doc = "${EPEL_MIRROR}/aarch64/Packages/p/ptex-doc-2.4.3-1.el10_2.noarch.rpm;name=aarch64_ptex-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptex-doc}"
SRC_URI[aarch64_ptex-doc.sha256sum] = "8e9c0838f4fca43a0785c1c3acef4ce2c0c4e7f3c5ededdf9a5cb9aa85e2826c"

URI_aarch64_ptex-libs = "${EPEL_MIRROR}/aarch64/Packages/p/ptex-libs-2.4.3-1.el10_2.aarch64.rpm;name=aarch64_ptex-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptex-libs}"
SRC_URI[aarch64_ptex-libs.sha256sum] = "34ad4a5bd4610473f74bfb5cd4a061ae9f073a1b96369c491548d8f4becbbf07"

RDEPENDS:ptex = " \
 glibc \
 libgcc \
 libstdc++ \
 ptex-libs \
 "
RDEPENDS:ptex-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 ptex \
 ptex-libs \
 "
RDEPENDS:ptex-doc = " \
 "
RDEPENDS:ptex-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
