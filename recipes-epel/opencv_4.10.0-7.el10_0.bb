# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencv"
PV = "4.10.0"
PR = "7.el10_0"
PACKAGES = " \
 opencv \
 opencv-alphamat \
 opencv-aruco \
 opencv-bgsegm \
 opencv-bioinspired \
 opencv-calib3d \
 opencv-ccalib \
 opencv-core \
 opencv-cvv \
 opencv-data \
 opencv-datasets \
 opencv-devel \
 opencv-dnn \
 opencv-dnn_objdetect \
 opencv-dnn_superres \
 opencv-doc \
 opencv-dpm \
 opencv-face \
 opencv-features2d \
 opencv-flann \
 opencv-freetype \
 opencv-fuzzy \
 opencv-gapi \
 opencv-hdf \
 opencv-hfs \
 opencv-highgui \
 opencv-img_hash \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-intensity_transform \
 opencv-java \
 opencv-line_descriptor \
 opencv-mcc \
 opencv-ml \
 opencv-objdetect \
 opencv-optflow \
 opencv-phase_unwrapping \
 opencv-photo \
 opencv-plot \
 opencv-quality \
 opencv-rapid \
 opencv-reg \
 opencv-rgbd \
 opencv-saliency \
 opencv-shape \
 opencv-signal \
 opencv-stereo \
 opencv-stitching \
 opencv-structured_light \
 opencv-superres \
 opencv-surface_matching \
 opencv-text \
 opencv-tracking \
 opencv-video \
 opencv-videoio \
 opencv-videostab \
 opencv-wechat_qrcode \
 opencv-ximgproc \
 opencv-xobjdetect \
 opencv-xphoto \
 python3-opencv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opencv-4.10.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c52231ee31ff7673e4acd0633d41fc3ce5c9c3b13b69212612ffa7c891e0b685"

URI_aarch64_opencv = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv}"
SRC_URI[aarch64_opencv.sha256sum] = "be6b8cb6675225b92d2c4e97070a57826c36694368bbac9bc4fbca2ab2c97ac1"

URI_aarch64_opencv-alphamat = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-alphamat-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-alphamat;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-alphamat}"
SRC_URI[aarch64_opencv-alphamat.sha256sum] = "31ac47e2882b4926a3b60fe5fda5bec78eeb0b0e92a0ac7fd47bce61ad96544b"

URI_aarch64_opencv-aruco = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-aruco-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-aruco;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-aruco}"
SRC_URI[aarch64_opencv-aruco.sha256sum] = "c47cf9a47e64fa40e125098fa20c646032776be99d55abe1d92a633c55b0a567"

URI_aarch64_opencv-bgsegm = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-bgsegm-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-bgsegm;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-bgsegm}"
SRC_URI[aarch64_opencv-bgsegm.sha256sum] = "99019f5871c9453cd76d82b4eb9755c1bc7ba35b68ebf9525987aa954d389472"

URI_aarch64_opencv-bioinspired = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-bioinspired-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-bioinspired;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-bioinspired}"
SRC_URI[aarch64_opencv-bioinspired.sha256sum] = "d0221b40dbc1bd0c87f803da48779ff247a5b940d8b1b5290a57ebdcde22a765"

URI_aarch64_opencv-calib3d = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-calib3d-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-calib3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-calib3d}"
SRC_URI[aarch64_opencv-calib3d.sha256sum] = "df17ebdb943aaf890ff69ffad6cc7d802e2456372b02c26c4e8c7a33b0df5a86"

URI_aarch64_opencv-ccalib = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-ccalib-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-ccalib;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-ccalib}"
SRC_URI[aarch64_opencv-ccalib.sha256sum] = "c897dcdf62ece9715a9978dfaf391b93628e8099087e28dac40520ab6b47fb5e"

URI_aarch64_opencv-core = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-core-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-core}"
SRC_URI[aarch64_opencv-core.sha256sum] = "8ab114825ba8a7d0bc2d55c069926952d22f4ce8f810eb1830eda68fbacc0d88"

URI_aarch64_opencv-cvv = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-cvv-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-cvv;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-cvv}"
SRC_URI[aarch64_opencv-cvv.sha256sum] = "401eebb333ee0a4e0890f332efff2e012190effb1975de3b0cd4774c16642551"

URI_aarch64_opencv-data = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-data-4.10.0-7.el10_0.noarch.rpm;name=aarch64_opencv-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-data}"
SRC_URI[aarch64_opencv-data.sha256sum] = "8469d08dfd092fd9397606fd68d0f6b8ebeb65cffb1a103be05c107c0164dfce"

URI_aarch64_opencv-datasets = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-datasets-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-datasets;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-datasets}"
SRC_URI[aarch64_opencv-datasets.sha256sum] = "51b30199defff5c6e53fee393e35ed783be133afd38696eadd28a30407d0fc42"

URI_aarch64_opencv-devel = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-devel-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-devel}"
SRC_URI[aarch64_opencv-devel.sha256sum] = "714f342befe9378b6cec3da335fe7ae407e6e637d8e45d960f3990ea055765b9"

URI_aarch64_opencv-dnn = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-dnn-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-dnn;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-dnn}"
SRC_URI[aarch64_opencv-dnn.sha256sum] = "b3fa5acf5ddc247014bcfb6d3d214b66918ab8b57ec35f2a81eb1b763e2f1c53"

URI_aarch64_opencv-dnn_objdetect = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-dnn_objdetect-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-dnn_objdetect;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-dnn_objdetect}"
SRC_URI[aarch64_opencv-dnn_objdetect.sha256sum] = "90fddcde49ef9d54c33531cd7f90e9134519473d3523e6f994b4e9ed6d82a007"

URI_aarch64_opencv-dnn_superres = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-dnn_superres-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-dnn_superres;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-dnn_superres}"
SRC_URI[aarch64_opencv-dnn_superres.sha256sum] = "a16d333844427fccab0485353475819738a2d7adb58a5386d891892302cfe32f"

URI_aarch64_opencv-doc = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-doc-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-doc}"
SRC_URI[aarch64_opencv-doc.sha256sum] = "a3600ef9144310689f4941890e0849674ce893e7890d07b08500a59dac7a4c04"

URI_aarch64_opencv-dpm = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-dpm-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-dpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-dpm}"
SRC_URI[aarch64_opencv-dpm.sha256sum] = "139251c366a9961ec9f17f2804315a399fc555ca474c8913e3f5d22f846ce97c"

URI_aarch64_opencv-face = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-face-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-face;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-face}"
SRC_URI[aarch64_opencv-face.sha256sum] = "ecaba70ff4f073c4c355c799a4d1ae96f22cb2086fddb0188ec19c1aae8ff5e7"

URI_aarch64_opencv-features2d = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-features2d-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-features2d;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-features2d}"
SRC_URI[aarch64_opencv-features2d.sha256sum] = "d08c8e7ab4e4127db2bc88e3ddfd650110b0e7046c2745474714b1750d90e352"

URI_aarch64_opencv-flann = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-flann-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-flann;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-flann}"
SRC_URI[aarch64_opencv-flann.sha256sum] = "14677e8534a923b4e2335b625425ed4ce95ea425b4e88b58862f930c8976a83f"

URI_aarch64_opencv-freetype = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-freetype-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-freetype;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-freetype}"
SRC_URI[aarch64_opencv-freetype.sha256sum] = "32c4281545326dc56708e8644062d0385323a5ee48abf11a290aaa7ba2b3b89b"

URI_aarch64_opencv-fuzzy = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-fuzzy-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-fuzzy;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-fuzzy}"
SRC_URI[aarch64_opencv-fuzzy.sha256sum] = "ae57041f51e92186e5c278af32199a67e0f69d178edeabb20afb310321076d55"

URI_aarch64_opencv-gapi = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-gapi-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-gapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-gapi}"
SRC_URI[aarch64_opencv-gapi.sha256sum] = "fcc39a89c7b90295bb83e49b8bf7da6afc1355de3db487daf6e004b3096fb2d2"

URI_aarch64_opencv-hdf = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-hdf-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-hdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-hdf}"
SRC_URI[aarch64_opencv-hdf.sha256sum] = "81c1af6df4fc63501d7fa21fdc39899ce3faf3fea0f9b04126e8e7a6c72e7214"

URI_aarch64_opencv-hfs = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-hfs-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-hfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-hfs}"
SRC_URI[aarch64_opencv-hfs.sha256sum] = "2cdb78e3265eb89cd09b928f9f1d9d5df33e6bd3563bb3e65b0549eb1f397430"

URI_aarch64_opencv-highgui = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-highgui-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-highgui;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-highgui}"
SRC_URI[aarch64_opencv-highgui.sha256sum] = "0a4b14be6cbd19728842692103bda07f0549e0b8e2d2e6b5c1a27c2f7f4cf079"

URI_aarch64_opencv-img_hash = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-img_hash-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-img_hash;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-img_hash}"
SRC_URI[aarch64_opencv-img_hash.sha256sum] = "989902df267e42fb7b6a51bdf12cda085c316e7551fdca27b48001b022ef4895"

URI_aarch64_opencv-imgcodecs = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-imgcodecs-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-imgcodecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-imgcodecs}"
SRC_URI[aarch64_opencv-imgcodecs.sha256sum] = "ec09097b31c1e9697e0850638405c53682987751646df7bd81c4c12a40f4bfa8"

URI_aarch64_opencv-imgproc = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-imgproc-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-imgproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-imgproc}"
SRC_URI[aarch64_opencv-imgproc.sha256sum] = "3eca278035f2e771a87029b1ede50243ce98c536b3548daffcf63ba3018bb58c"

URI_aarch64_opencv-intensity_transform = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-intensity_transform-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-intensity_transform;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-intensity_transform}"
SRC_URI[aarch64_opencv-intensity_transform.sha256sum] = "9f6092106dd0a966ca08b9471a9286ecbdbc6e7d64c5275d25c7335ddcf15d6b"

URI_aarch64_opencv-java = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-java-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-java}"
SRC_URI[aarch64_opencv-java.sha256sum] = "2979ae6cd7431e2ba62f54f5365740f62f57ee19ec2d2c822b46e5653781ac9f"

URI_aarch64_opencv-line_descriptor = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-line_descriptor-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-line_descriptor;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-line_descriptor}"
SRC_URI[aarch64_opencv-line_descriptor.sha256sum] = "5f90e12c4598e0dd37b08975a77751f77e40e75141a79f6991e8e3056e9543d1"

URI_aarch64_opencv-mcc = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-mcc-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-mcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-mcc}"
SRC_URI[aarch64_opencv-mcc.sha256sum] = "eefe43224e0235925ea1561b016efa03d37d5463774d11b972b8693a84bac855"

URI_aarch64_opencv-ml = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-ml-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-ml;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-ml}"
SRC_URI[aarch64_opencv-ml.sha256sum] = "be70d204a4433b69eb46cde64a48eaaed09ed46ce48ca8254444ebbd615f2975"

URI_aarch64_opencv-objdetect = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-objdetect-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-objdetect;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-objdetect}"
SRC_URI[aarch64_opencv-objdetect.sha256sum] = "6cc75446810f2dd2ae7dc8f97f518dd71843d1068a3a0faaef3c0a852a629822"

URI_aarch64_opencv-optflow = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-optflow-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-optflow;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-optflow}"
SRC_URI[aarch64_opencv-optflow.sha256sum] = "e24fc2f5c44b2fad3f644561b7d35e6aa3696612696cdedcdd36424eb5a11f00"

URI_aarch64_opencv-phase_unwrapping = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-phase_unwrapping-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-phase_unwrapping;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-phase_unwrapping}"
SRC_URI[aarch64_opencv-phase_unwrapping.sha256sum] = "43d80ce628a8e263b94740c0bb782588486fcdcd756d845e7a2bc468869a0ecd"

URI_aarch64_opencv-photo = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-photo-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-photo;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-photo}"
SRC_URI[aarch64_opencv-photo.sha256sum] = "ee7b018586daaaea31d36118cc0d893d66078dabb0b6cb3b73a3989447e59706"

URI_aarch64_opencv-plot = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-plot-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-plot;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-plot}"
SRC_URI[aarch64_opencv-plot.sha256sum] = "d0359e44cc4c592cd69d8efb18391fa7bfb1fdc94a2a117166f8c19e130e81c9"

URI_aarch64_opencv-quality = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-quality-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-quality;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-quality}"
SRC_URI[aarch64_opencv-quality.sha256sum] = "8b5040eb094365158f8b5b783b7c10c0940c622fc1e6e432a6a61e557c4b6d22"

URI_aarch64_opencv-rapid = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-rapid-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-rapid;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-rapid}"
SRC_URI[aarch64_opencv-rapid.sha256sum] = "8d26fa7e59a9a3dea4b55529762bf922891fd8fe79ea08a9d139d031825b4748"

URI_aarch64_opencv-reg = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-reg-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-reg;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-reg}"
SRC_URI[aarch64_opencv-reg.sha256sum] = "01c200a6185ddbabacfcc5cf38632f9b875900924d27750fea700a9a73ce3eb3"

URI_aarch64_opencv-rgbd = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-rgbd-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-rgbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-rgbd}"
SRC_URI[aarch64_opencv-rgbd.sha256sum] = "2dfaabd513752f96533ec1054caece53d424f69008252d3b0beff77b33c6f201"

URI_aarch64_opencv-saliency = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-saliency-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-saliency;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-saliency}"
SRC_URI[aarch64_opencv-saliency.sha256sum] = "66b0a077a36f17c5b513dd0764f698bfd6862dd7997914ce9e58ca6449663b22"

URI_aarch64_opencv-shape = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-shape-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-shape;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-shape}"
SRC_URI[aarch64_opencv-shape.sha256sum] = "b863e90b03b438571051aa69c31e4afb7cbe3c3ce4ca09effeff33a0e8136e20"

URI_aarch64_opencv-signal = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-signal-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-signal;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-signal}"
SRC_URI[aarch64_opencv-signal.sha256sum] = "6bb771fb2180fd8a97f19de60ada7e1a3a597936fd0cb0f0f4e03073ae520df8"

URI_aarch64_opencv-stereo = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-stereo-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-stereo;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-stereo}"
SRC_URI[aarch64_opencv-stereo.sha256sum] = "d3414a32e868612932251a7d1af1178db7a07ce7044e6c70f903a61d2cb7d591"

URI_aarch64_opencv-stitching = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-stitching-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-stitching;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-stitching}"
SRC_URI[aarch64_opencv-stitching.sha256sum] = "c386ed5b179c9cba80700826f3ee57d8d2505c6b40e7d3d0c9af0d4a75fc5859"

URI_aarch64_opencv-structured_light = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-structured_light-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-structured_light;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-structured_light}"
SRC_URI[aarch64_opencv-structured_light.sha256sum] = "d48b24fae26cdb01ef1d24be3a8340fe555e2cdca2b96def91fe57a1219e92f1"

URI_aarch64_opencv-superres = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-superres-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-superres;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-superres}"
SRC_URI[aarch64_opencv-superres.sha256sum] = "913d3d7fe249db1ed6df8f7dc9f16c13432ffc480b38bd68c3960539e47754c4"

URI_aarch64_opencv-surface_matching = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-surface_matching-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-surface_matching;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-surface_matching}"
SRC_URI[aarch64_opencv-surface_matching.sha256sum] = "f966a85c75b8c0f24277321c2a8bd3838a202c6a443e208d01b1fbf6af0f5ecd"

URI_aarch64_opencv-text = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-text-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-text}"
SRC_URI[aarch64_opencv-text.sha256sum] = "bcb0d2354f17c35d5a289ef32093b4c30e736828f0877f20b12316bd8bf26542"

URI_aarch64_opencv-tracking = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-tracking-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-tracking;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-tracking}"
SRC_URI[aarch64_opencv-tracking.sha256sum] = "39f5fd1034c5d611c52bcd1361b33c335e07d1ef5f4595b34faf938bb0f8f6e0"

URI_aarch64_opencv-video = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-video-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-video;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-video}"
SRC_URI[aarch64_opencv-video.sha256sum] = "d46d30ca2e5989f899f31d75a8a0bc1ae3a16d13fee0bbb1a39116e7e118ac0d"

URI_aarch64_opencv-videoio = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-videoio-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-videoio;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-videoio}"
SRC_URI[aarch64_opencv-videoio.sha256sum] = "de757aab459dcaaebe37994a996fc61684e85ce06d9648a1ab82f126068f0d41"

URI_aarch64_opencv-videostab = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-videostab-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-videostab;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-videostab}"
SRC_URI[aarch64_opencv-videostab.sha256sum] = "f92c42da74688a218b4916e8d1df4a989e32c732eeb2c40f0a1865073c89b51c"

URI_aarch64_opencv-wechat_qrcode = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-wechat_qrcode-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-wechat_qrcode;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-wechat_qrcode}"
SRC_URI[aarch64_opencv-wechat_qrcode.sha256sum] = "ad655b2c0383d73e1d2b2269e2ca36394e2f92c896e85ac92df00730a3bb9afb"

URI_aarch64_opencv-ximgproc = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-ximgproc-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-ximgproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-ximgproc}"
SRC_URI[aarch64_opencv-ximgproc.sha256sum] = "b4d896d16db964e808f9ba0cac19b2f469f4482803a7864c40cc263cd68ff259"

URI_aarch64_opencv-xobjdetect = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-xobjdetect-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-xobjdetect;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-xobjdetect}"
SRC_URI[aarch64_opencv-xobjdetect.sha256sum] = "8ba5630f72b5c2283e66d40928d0318f1efc15ffde254a8e635ecbc0b2b7b606"

URI_aarch64_opencv-xphoto = "${EPEL_MIRROR}/aarch64/Packages/o/opencv-xphoto-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_opencv-xphoto;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencv-xphoto}"
SRC_URI[aarch64_opencv-xphoto.sha256sum] = "f3c49ab79ab4b78da2c97dbf18441ed0edb5da16c1defb4b62ccb65ef36cafaf"

URI_aarch64_python3-opencv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opencv-4.10.0-7.el10_0.aarch64.rpm;name=aarch64_python3-opencv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opencv}"
SRC_URI[aarch64_python3-opencv.sha256sum] = "48c3cd9bc3c6aa283c2f17c3e105a7ab25978373a62528a46a3339575f5b2ee9"

RDEPENDS:opencv = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-data \
 opencv-dnn \
 opencv-features2d \
 opencv-highgui \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-objdetect \
 opencv-videoio \
 opencv-xobjdetect \
 "
RDEPENDS:opencv-alphamat = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-aruco = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-objdetect \
 "
RDEPENDS:opencv-bgsegm = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-video \
 "
RDEPENDS:opencv-bioinspired = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-calib3d = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-core \
 opencv-features2d \
 opencv-flann \
 opencv-imgproc \
 "
RDEPENDS:opencv-ccalib = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-features2d \
 opencv-highgui \
 opencv-imgcodecs \
 opencv-imgproc \
 "
RDEPENDS:opencv-core = " \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 openblas-serial \
 tbb \
 zlib-ng-compat \
 "
RDEPENDS:opencv-cvv = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:opencv-data = " \
 "
RDEPENDS:opencv-datasets = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgcodecs \
 "
RDEPENDS:opencv-devel = " \
 cmake-filesystem \
 opencv \
 opencv-alphamat \
 opencv-aruco \
 opencv-bgsegm \
 opencv-bioinspired \
 opencv-calib3d \
 opencv-ccalib \
 opencv-core \
 opencv-cvv \
 opencv-data \
 opencv-datasets \
 opencv-dnn \
 opencv-dnn_objdetect \
 opencv-dnn_superres \
 opencv-dpm \
 opencv-face \
 opencv-features2d \
 opencv-flann \
 opencv-freetype \
 opencv-fuzzy \
 opencv-gapi \
 opencv-hdf \
 opencv-hfs \
 opencv-highgui \
 opencv-img_hash \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-intensity_transform \
 opencv-line_descriptor \
 opencv-mcc \
 opencv-ml \
 opencv-objdetect \
 opencv-optflow \
 opencv-phase_unwrapping \
 opencv-photo \
 opencv-plot \
 opencv-quality \
 opencv-rapid \
 opencv-reg \
 opencv-rgbd \
 opencv-saliency \
 opencv-shape \
 opencv-signal \
 opencv-stereo \
 opencv-stitching \
 opencv-structured_light \
 opencv-superres \
 opencv-surface_matching \
 opencv-text \
 opencv-tracking \
 opencv-video \
 opencv-videoio \
 opencv-videostab \
 opencv-wechat_qrcode \
 opencv-ximgproc \
 opencv-xobjdetect \
 opencv-xphoto \
 pkgconf-pkg-config \
 "
RDEPENDS:opencv-dnn = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 protobuf \
 "
RDEPENDS:opencv-dnn_objdetect = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-dnn_superres = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-doc = " \
 opencv-devel \
 "
RDEPENDS:opencv-dpm = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-face = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-objdetect \
 "
RDEPENDS:opencv-features2d = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-flann \
 opencv-imgproc \
 "
RDEPENDS:opencv-flann = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-freetype = " \
 freetype \
 glibc \
 harfbuzz \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-fuzzy = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-gapi = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-video \
 tbb \
 "
RDEPENDS:opencv-hdf = " \
 glibc \
 hdf5 \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-hfs = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-highgui = " \
 glibc \
 libgcc \
 libglvnd-opengl \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:opencv-img_hash = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-imgcodecs = " \
 gdal-libs \
 gdcm \
 glibc \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 libwebp \
 opencv-core \
 opencv-imgproc \
 openjpeg2 \
 "
RDEPENDS:opencv-imgproc = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-intensity_transform = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-java = " \
 glibc \
 java-21-openjdk-headless \
 javapackages-filesystem \
 libgcc \
 libstdc++ \
 opencv-aruco \
 opencv-bgsegm \
 opencv-bioinspired \
 opencv-calib3d \
 opencv-core \
 opencv-dnn \
 opencv-dnn_superres \
 opencv-face \
 opencv-features2d \
 opencv-flann \
 opencv-img_hash \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-ml \
 opencv-objdetect \
 opencv-phase_unwrapping \
 opencv-photo \
 opencv-plot \
 opencv-structured_light \
 opencv-text \
 opencv-tracking \
 opencv-video \
 opencv-videoio \
 opencv-wechat_qrcode \
 opencv-ximgproc \
 opencv-xphoto \
 "
RDEPENDS:opencv-line_descriptor = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-mcc = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-ml = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-objdetect = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-optflow = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-flann \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-video \
 opencv-ximgproc \
 "
RDEPENDS:opencv-phase_unwrapping = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-photo = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-plot = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-quality = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 opencv-ml \
 "
RDEPENDS:opencv-rapid = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-reg = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-rgbd = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-flann \
 opencv-imgproc \
 "
RDEPENDS:opencv-saliency = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-shape = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:opencv-signal = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 "
RDEPENDS:opencv-stereo = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-video \
 "
RDEPENDS:opencv-stitching = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-features2d \
 opencv-flann \
 opencv-imgproc \
 "
RDEPENDS:opencv-structured_light = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgproc \
 opencv-phase_unwrapping \
 "
RDEPENDS:opencv-superres = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 opencv-optflow \
 opencv-video \
 opencv-videoio \
 "
RDEPENDS:opencv-surface_matching = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-core \
 opencv-flann \
 "
RDEPENDS:opencv-text = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 opencv-ml \
 tesseract \
 "
RDEPENDS:opencv-tracking = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 opencv-video \
 "
RDEPENDS:opencv-video = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-videoio = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libstdc++ \
 libswscale-free \
 opencv-core \
 opencv-imgcodecs \
 opencv-imgproc \
 "
RDEPENDS:opencv-videostab = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-features2d \
 opencv-imgproc \
 opencv-photo \
 opencv-video \
 opencv-videoio \
 "
RDEPENDS:opencv-wechat_qrcode = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-dnn \
 opencv-imgproc \
 "
RDEPENDS:opencv-ximgproc = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 opencv-calib3d \
 opencv-core \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-video \
 "
RDEPENDS:opencv-xobjdetect = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-objdetect \
 "
RDEPENDS:opencv-xphoto = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 "
RDEPENDS:python3-opencv = " \
 glibc \
 libgcc \
 libstdc++ \
 opencv \
 opencv-alphamat \
 opencv-aruco \
 opencv-bgsegm \
 opencv-bioinspired \
 opencv-calib3d \
 opencv-ccalib \
 opencv-core \
 opencv-dnn \
 opencv-dnn_superres \
 opencv-face \
 opencv-features2d \
 opencv-flann \
 opencv-freetype \
 opencv-fuzzy \
 opencv-gapi \
 opencv-hdf \
 opencv-hfs \
 opencv-highgui \
 opencv-img_hash \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-intensity_transform \
 opencv-line_descriptor \
 opencv-mcc \
 opencv-ml \
 opencv-objdetect \
 opencv-optflow \
 opencv-phase_unwrapping \
 opencv-photo \
 opencv-plot \
 opencv-quality \
 opencv-rapid \
 opencv-reg \
 opencv-rgbd \
 opencv-saliency \
 opencv-shape \
 opencv-signal \
 opencv-stereo \
 opencv-stitching \
 opencv-structured_light \
 opencv-surface_matching \
 opencv-text \
 opencv-tracking \
 opencv-video \
 opencv-videoio \
 opencv-wechat_qrcode \
 opencv-ximgproc \
 opencv-xphoto \
 python3 \
 python3-numpy \
 "
