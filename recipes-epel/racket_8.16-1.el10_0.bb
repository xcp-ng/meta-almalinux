# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "racket"
PV = "8.16"
PR = "1.el10_0"
PACKAGES = " \
 racket \
 racket-collects \
 racket-devel \
 racket-doc \
 racket-minimal \
 racket-pkgs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/racket-8.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ce8730b4a99787ca19db04278d7a1081fe5306c709ea15ea9464fd62b24d304"

URI_x86_64_v2_racket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-8.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket}"
SRC_URI[x86_64_v2_racket.sha256sum] = "ab7cae64fc09fe3cb8b89deb7b9683b15ea02f380597a22d32687dc68e7be37d"

URI_x86_64_v2_racket-collects = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-collects-8.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_racket-collects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-collects}"
SRC_URI[x86_64_v2_racket-collects.sha256sum] = "e0beb358c1725c98bfd3dfb2b9ddcc140f7064c8fcf85bd88892b49e9d9dfafb"

URI_x86_64_v2_racket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-devel-8.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-devel}"
SRC_URI[x86_64_v2_racket-devel.sha256sum] = "bf05fc9baac6d882458a797ee8b9a8ad833649a908763a5c40b1b851b6871172"

URI_x86_64_v2_racket-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-doc-8.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_racket-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-doc}"
SRC_URI[x86_64_v2_racket-doc.sha256sum] = "740bcb8ee8a89da51a536bd3f58b06fe2c9ae8005ea25a9e8507c1bedd660143"

URI_x86_64_v2_racket-minimal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-minimal-8.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_racket-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-minimal}"
SRC_URI[x86_64_v2_racket-minimal.sha256sum] = "ab494004af83715c816ec5ecf61c7237006a6a872cb519c975ae234b3b26ea6a"

URI_x86_64_v2_racket-pkgs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/racket-pkgs-8.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_racket-pkgs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_racket-pkgs}"
SRC_URI[x86_64_v2_racket-pkgs.sha256sum] = "9f1cfbc539a367da215fb0d370f68a8ef7e7f670ec7416390c3ea43e400bd976"

URI_aarch64_racket = "${EPEL_MIRROR}/aarch64/Packages/r/racket-8.16-1.el10_0.aarch64.rpm;name=aarch64_racket;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket}"
SRC_URI[aarch64_racket.sha256sum] = "58ce5ed567184306e0b82b484627b9c6bc02c32b3a5687fd89e0dcfb1b0567cc"

URI_aarch64_racket-collects = "${EPEL_MIRROR}/aarch64/Packages/r/racket-collects-8.16-1.el10_0.noarch.rpm;name=aarch64_racket-collects;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-collects}"
SRC_URI[aarch64_racket-collects.sha256sum] = "2b983ddc6a8d63fef3bd4235d79f04cf9168339958938bed4e58cbde6ac94368"

URI_aarch64_racket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/racket-devel-8.16-1.el10_0.aarch64.rpm;name=aarch64_racket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-devel}"
SRC_URI[aarch64_racket-devel.sha256sum] = "bf8bd903dceb0d7eced7ba42762a2b9e0ed3719aa21eb961a00ca62802ebc885"

URI_aarch64_racket-doc = "${EPEL_MIRROR}/aarch64/Packages/r/racket-doc-8.16-1.el10_0.noarch.rpm;name=aarch64_racket-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-doc}"
SRC_URI[aarch64_racket-doc.sha256sum] = "90882809c17bf16896a8db1eccaf81c219dab89dd7a6e73904046fa5a5088258"

URI_aarch64_racket-minimal = "${EPEL_MIRROR}/aarch64/Packages/r/racket-minimal-8.16-1.el10_0.aarch64.rpm;name=aarch64_racket-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-minimal}"
SRC_URI[aarch64_racket-minimal.sha256sum] = "50bab511cd35e795a6add6c933329795ce04d17eb00c9c857fdfc64b5f361abb"

URI_aarch64_racket-pkgs = "${EPEL_MIRROR}/aarch64/Packages/r/racket-pkgs-8.16-1.el10_0.noarch.rpm;name=aarch64_racket-pkgs;unpack=0"
SRC_URI:append = " ${URI_aarch64_racket-pkgs}"
SRC_URI[aarch64_racket-pkgs.sha256sum] = "f2e790c942f7caa209652baadc3acdff02b87d9048fbbaee466988bd0a0a30f5"

RDEPENDS:racket = " \
 bash \
 glibc \
 racket-minimal \
 racket-pkgs \
 "
RDEPENDS:racket-collects = " \
 "
RDEPENDS:racket-devel = " \
 racket-minimal \
 "
RDEPENDS:racket-doc = " \
 "
RDEPENDS:racket-minimal = " \
 bash \
 glibc \
 libgcc \
 racket-collects \
 "
RDEPENDS:racket-pkgs = " \
 bash \
 cairo \
 glib2 \
 gtk3 \
 libjpeg-turbo \
 libpng \
 pango \
 racket-minimal \
 "
