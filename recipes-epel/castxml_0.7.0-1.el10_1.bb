# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "castxml"
PV = "0.7.0"
PR = "1.el10_1"
PACKAGES = " \
 castxml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/castxml-0.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe1030213a7ba10c46769a3eaa2aa0cac41f78b8b44b8aff570a5a30098cc2f7"

URI_x86_64_v2_castxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/castxml-0.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_castxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_castxml}"
SRC_URI[x86_64_v2_castxml.sha256sum] = "7ca2934f48ddcc4ee812e4b0b9fa1b13133dfef18820835b14bdb08ae91aadae"

URI_aarch64_castxml = "${EPEL_MIRROR}/aarch64/Packages/c/castxml-0.7.0-1.el10_1.aarch64.rpm;name=aarch64_castxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_castxml}"
SRC_URI[aarch64_castxml.sha256sum] = "c765e8f8328305f9343fd4d5c285339674c35ffbd5407a1fb70797a5de9c7e15"

RDEPENDS:castxml = " \
 clang-libs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
