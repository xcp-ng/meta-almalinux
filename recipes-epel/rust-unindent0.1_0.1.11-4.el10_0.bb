# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unindent0.1"
PV = "0.1.11"
PR = "4.el10_0"
PACKAGES = " \
 rust-unindent0.1+default-devel \
 rust-unindent0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unindent0.1-0.1.11-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35c75ca16eed6b048377b78ec35efbbd407143afcd41c91c920a33b64b303bf9"

URI_x86_64_v2_rust-unindent0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unindent0.1+default-devel-0.1.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unindent0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unindent0.1+default-devel}"
SRC_URI[x86_64_v2_rust-unindent0.1+default-devel.sha256sum] = "d0178168bbf63453762827bfe53b781b0c7baede4c7df3a6fb3502b53d997c1b"

URI_x86_64_v2_rust-unindent0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unindent0.1-devel-0.1.11-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unindent0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unindent0.1-devel}"
SRC_URI[x86_64_v2_rust-unindent0.1-devel.sha256sum] = "a76b018a122d90a493a58e339037acdc5f6f0fc61046565d703c8c227cec0ca1"

URI_aarch64_rust-unindent0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unindent0.1+default-devel-0.1.11-4.el10_0.noarch.rpm;name=aarch64_rust-unindent0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unindent0.1+default-devel}"
SRC_URI[aarch64_rust-unindent0.1+default-devel.sha256sum] = "24433b7f6c0cfe5a2cf15265ddfcdefee9ef4b188b4ac683c197f669a6fed139"

URI_aarch64_rust-unindent0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unindent0.1-devel-0.1.11-4.el10_0.noarch.rpm;name=aarch64_rust-unindent0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unindent0.1-devel}"
SRC_URI[aarch64_rust-unindent0.1-devel.sha256sum] = "86bc2004f5725f30c7f98762d01cbccbccf718874f8cab3db5be0f9edbd02d1b"

RDEPENDS:rust-unindent0.1+default-devel = " \
 cargo \
 rust-unindent0.1-devel \
 "
RDEPENDS:rust-unindent0.1-devel = " \
 cargo \
 "
