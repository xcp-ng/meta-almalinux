# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spectacle"
PE = "1"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 spectacle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spectacle-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "022f9b13faddc5e861eb36f3597cf30ac9332940552649dd75f37b1cbe34afff"

URI_x86_64_v2_spectacle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spectacle-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spectacle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spectacle}"
SRC_URI[x86_64_v2_spectacle.sha256sum] = "58b82d2f6ee5442f9c8d1bdabf579bf60a44acbbd4941d9b9ede02cabd877720"

URI_aarch64_spectacle = "${EPEL_MIRROR}/aarch64/Packages/s/spectacle-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_spectacle;unpack=0"
SRC_URI:append = " ${URI_aarch64_spectacle}"
SRC_URI[aarch64_spectacle.sha256sum] = "a110b766d40b6983ee8832fbb8e8b35da7321c62305e0423362dc61d134ebdf0"

RDEPENDS:spectacle = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-prison \
 kf6-purpose \
 kpipewire \
 layer-shell-qt \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 "
