# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tar"
PV = "0.5.1.1"
PR = "24.el10_0"
PACKAGES = " \
 ghc-tar \
 ghc-tar-devel \
 ghc-tar-doc \
 ghc-tar-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tar-0.5.1.1-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d3b9bfb8130b17e3c99b6a40570f548e9a79714545d6f2f7756c85dbd9c6787"

URI_x86_64_v2_ghc-tar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tar-0.5.1.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tar}"
SRC_URI[x86_64_v2_ghc-tar.sha256sum] = "aae6275d7e3127ff8cd935e072c43235bb0dd2b9ba86edc2b783f7a592720555"

URI_x86_64_v2_ghc-tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tar-devel-0.5.1.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tar-devel}"
SRC_URI[x86_64_v2_ghc-tar-devel.sha256sum] = "ea96eb1d1945429403725d2b74d09e8aec47c31687d03a9ee55b1b0fafe63e06"

URI_x86_64_v2_ghc-tar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tar-doc-0.5.1.1-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tar-doc}"
SRC_URI[x86_64_v2_ghc-tar-doc.sha256sum] = "a4ce910aa4ee6b56acd50a797a01842237e0808b21c8a27297a576ade11702af"

URI_x86_64_v2_ghc-tar-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tar-prof-0.5.1.1-24.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tar-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tar-prof}"
SRC_URI[x86_64_v2_ghc-tar-prof.sha256sum] = "0df47ff3f1c31378b59f5db37870dfbe662ac067b9b6c1a7f06f36978a51ebbb"

URI_aarch64_ghc-tar = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tar-0.5.1.1-24.el10_0.aarch64.rpm;name=aarch64_ghc-tar;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tar}"
SRC_URI[aarch64_ghc-tar.sha256sum] = "078c7ed45ef022b5cf103a484f48bfeecb98dbd080eaf96fa76965c6bc24967a"

URI_aarch64_ghc-tar-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tar-devel-0.5.1.1-24.el10_0.aarch64.rpm;name=aarch64_ghc-tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tar-devel}"
SRC_URI[aarch64_ghc-tar-devel.sha256sum] = "2637a7b614f049ccb805e6b084819d4c6ad6a80b8276464149cb8a4c59eb4f98"

URI_aarch64_ghc-tar-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tar-doc-0.5.1.1-24.el10_0.noarch.rpm;name=aarch64_ghc-tar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tar-doc}"
SRC_URI[aarch64_ghc-tar-doc.sha256sum] = "3bba8042b27c6efdba2677a60f8aa95ad68170341a16e76a9a32cab60c3e166e"

URI_aarch64_ghc-tar-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tar-prof-0.5.1.1-24.el10_0.aarch64.rpm;name=aarch64_ghc-tar-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tar-prof}"
SRC_URI[aarch64_ghc-tar-prof.sha256sum] = "fe84f39213fc266f779537969b0861586a5c55dbef4436e7d84f64443a26aeb1"

RDEPENDS:ghc-tar = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tar-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-tar \
 ghc-time-devel \
 "
RDEPENDS:ghc-tar-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tar-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-tar-devel \
 ghc-time-prof \
 "
