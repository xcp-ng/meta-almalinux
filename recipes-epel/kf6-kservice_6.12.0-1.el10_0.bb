# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kservice"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kservice \
 kf6-kservice-devel \
 kf6-kservice-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kservice-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97a51ae86cd2771fa5fc0deed63c62219983eca1e289d07f19f94cd9a2f5dd3e"

URI_x86_64_v2_kf6-kservice = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice}"
SRC_URI[x86_64_v2_kf6-kservice.sha256sum] = "9ed83168b34f9d82998579ec0ec7362de8b8876bf4f22bf84ca36fdc413fdb02"

URI_x86_64_v2_kf6-kservice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-devel}"
SRC_URI[x86_64_v2_kf6-kservice-devel.sha256sum] = "649008987b599a28d0e40ba24a45f63151024a04407fdf438b59cae12818b324"

URI_x86_64_v2_kf6-kservice-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kservice-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-doc}"
SRC_URI[x86_64_v2_kf6-kservice-doc.sha256sum] = "4497820754fbbff3871ff4a588778396d0735011cefdad21a47c7958d3b3eeee"

URI_aarch64_kf6-kservice = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kservice;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice}"
SRC_URI[aarch64_kf6-kservice.sha256sum] = "8a518322fcc9534651e53454fb61cb8d895ddebe7b01485460d3ed5d43108c63"

URI_aarch64_kf6-kservice-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kservice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-devel}"
SRC_URI[aarch64_kf6-kservice-devel.sha256sum] = "0c0f874ddf31ae912fac993b930ce14c18db3d27a906df4cd911cb1022aa05b1"

URI_aarch64_kf6-kservice-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kservice-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-doc}"
SRC_URI[aarch64_kf6-kservice-doc.sha256sum] = "1f56ae83660371b1467307948734a71707d5b41e8eb172b383143764057c983f"

RDEPENDS:kf6-kservice = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kservice-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kservice \
 "
RDEPENDS:kf6-kservice-doc = " \
 "
