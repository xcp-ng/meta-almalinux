# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ImageMagick"
PE = "1"
PV = "7.1.1.47"
PR = "1.el10_1"
PACKAGES = " \
 ImageMagick \
 ImageMagick-c++ \
 ImageMagick-c++-devel \
 ImageMagick-devel \
 ImageMagick-djvu \
 ImageMagick-doc \
 ImageMagick-heic \
 ImageMagick-libs \
 ImageMagick-perl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ImageMagick-7.1.1.47-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d048c799bb3bbd0ee97bb83470725d455a378f52b8fa06cbd07b06a0d4b996a"

URI_x86_64_v2_ImageMagick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-7.1.1.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick}"
SRC_URI[x86_64_v2_ImageMagick.sha256sum] = "c44d61d87f127ca07a07616878f3306e3895d36678f5351244317551a53a3602"

URI_x86_64_v2_ImageMagick-c++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-c++-7.1.1.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-c++}"
SRC_URI[x86_64_v2_ImageMagick-c++.sha256sum] = "d0443e4c4b48f136a442690661d75735bd4e99a911b9b1ba2460ab1d67054f0a"

URI_x86_64_v2_ImageMagick-c++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-c++-devel-7.1.1.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-c++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-c++-devel}"
SRC_URI[x86_64_v2_ImageMagick-c++-devel.sha256sum] = "77ad517ac3b663e2003bc68c9f4584d01954ce8ad6e8ce3d201546d741343508"

URI_x86_64_v2_ImageMagick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-devel-7.1.1.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-devel}"
SRC_URI[x86_64_v2_ImageMagick-devel.sha256sum] = "da80b6c895f255cdb897d9f2f3f459e55f25a444400fb99fbaa3269c6f84447e"

URI_x86_64_v2_ImageMagick-djvu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-djvu-7.1.1.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-djvu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-djvu}"
SRC_URI[x86_64_v2_ImageMagick-djvu.sha256sum] = "7d42df44e009e6892bfc14a673f890c467ec6a6249b2a36f79ec9bb25743ce8e"

URI_x86_64_v2_ImageMagick-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-doc-7.1.1.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-doc}"
SRC_URI[x86_64_v2_ImageMagick-doc.sha256sum] = "078bbc6d9ef063056c87a188267e0c3e680ab11173963886a6a31675fe7c0149"

URI_x86_64_v2_ImageMagick-heic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-heic-7.1.1.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-heic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-heic}"
SRC_URI[x86_64_v2_ImageMagick-heic.sha256sum] = "5a3a1e29ed3d880e4ac70b93a52bd3ed8e61a601ed272d62de7e8d39b3c9ed00"

URI_x86_64_v2_ImageMagick-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-libs-7.1.1.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-libs}"
SRC_URI[x86_64_v2_ImageMagick-libs.sha256sum] = "c05691abcfbdf931462b14e48e597596fc7e3f9a428290a0a8058ab18ef2c0c1"

URI_x86_64_v2_ImageMagick-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-perl-7.1.1.47-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-perl}"
SRC_URI[x86_64_v2_ImageMagick-perl.sha256sum] = "4e3e30f87d1086afb9d2d2582fed612b81de5ed6a3f75cf87d1e1fb2f163e47a"

URI_aarch64_ImageMagick = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-7.1.1.47-1.el10_1.aarch64.rpm;name=aarch64_ImageMagick;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick}"
SRC_URI[aarch64_ImageMagick.sha256sum] = "3019861d72c8aff0b48c0910c0e651522245b33eaa2f8f1abe445b92757a4e80"

URI_aarch64_ImageMagick-c++ = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-c++-7.1.1.47-1.el10_1.aarch64.rpm;name=aarch64_ImageMagick-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-c++}"
SRC_URI[aarch64_ImageMagick-c++.sha256sum] = "fb26170c1e021714459dbd989c95b5301ca75c259f8f19e6cbd9395aaa8d1f7a"

URI_aarch64_ImageMagick-c++-devel = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-c++-devel-7.1.1.47-1.el10_1.aarch64.rpm;name=aarch64_ImageMagick-c++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-c++-devel}"
SRC_URI[aarch64_ImageMagick-c++-devel.sha256sum] = "bfc5d523a38b34e9a00fdc47c098ed1514e15181a9e6dc775f166de8b4b2553b"

URI_aarch64_ImageMagick-devel = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-devel-7.1.1.47-1.el10_1.aarch64.rpm;name=aarch64_ImageMagick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-devel}"
SRC_URI[aarch64_ImageMagick-devel.sha256sum] = "346b79bf0af02f8a6959d5fcda5245e4421665e593f796101c38db16da4e7f71"

URI_aarch64_ImageMagick-djvu = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-djvu-7.1.1.47-1.el10_1.aarch64.rpm;name=aarch64_ImageMagick-djvu;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-djvu}"
SRC_URI[aarch64_ImageMagick-djvu.sha256sum] = "d47c8b78ab74f2cdf10da1713aa0b7a75f5f98129151226ea77081b0663eca57"

URI_aarch64_ImageMagick-doc = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-doc-7.1.1.47-1.el10_1.aarch64.rpm;name=aarch64_ImageMagick-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-doc}"
SRC_URI[aarch64_ImageMagick-doc.sha256sum] = "6948dba71d08ccd6e517e34eb57282ec448cd59d4c412160d3bd09f598fc0f14"

URI_aarch64_ImageMagick-heic = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-heic-7.1.1.47-1.el10_1.aarch64.rpm;name=aarch64_ImageMagick-heic;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-heic}"
SRC_URI[aarch64_ImageMagick-heic.sha256sum] = "af181694aa39d6c8c07bca8508662f0a5738f72c393c0dec69f6f617d39f6851"

URI_aarch64_ImageMagick-libs = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-libs-7.1.1.47-1.el10_1.aarch64.rpm;name=aarch64_ImageMagick-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-libs}"
SRC_URI[aarch64_ImageMagick-libs.sha256sum] = "5f1be666b5c1a2be50810b084dc90fb305cf97fa81c8c19dc03ed976c1d10581"

URI_aarch64_ImageMagick-perl = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-perl-7.1.1.47-1.el10_1.aarch64.rpm;name=aarch64_ImageMagick-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-perl}"
SRC_URI[aarch64_ImageMagick-perl.sha256sum] = "5ce0953d6fd6395a2d1eb4941856d4deeb6c6ecaccd79dcefe9453bb0cb9bf03"

RDEPENDS:ImageMagick = " \
 ImageMagick-libs \
 glibc \
 "
RDEPENDS:ImageMagick-c++ = " \
 ImageMagick-libs \
 bzip2-libs \
 fftw-libs-double \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXt \
 libgcc \
 libgomp \
 liblqr-1 \
 libraqm \
 libstdc++ \
 libtool-ltdl \
 libxml2 \
 libzip \
 zlib-ng-compat \
 "
RDEPENDS:ImageMagick-c++-devel = " \
 ImageMagick-c++ \
 ImageMagick-devel \
 bash \
 pkgconf-pkg-config \
 "
RDEPENDS:ImageMagick-devel = " \
 ImageMagick \
 ImageMagick-devel \
 ImageMagick-libs \
 bash \
 pkgconf-pkg-config \
 "
RDEPENDS:ImageMagick-djvu = " \
 ImageMagick-libs \
 bzip2-libs \
 djvulibre-libs \
 fftw-libs-double \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXt \
 libjpeg-turbo \
 liblqr-1 \
 libraqm \
 libtool-ltdl \
 libxml2 \
 libzip \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:ImageMagick-doc = " \
 "
RDEPENDS:ImageMagick-heic = " \
 ImageMagick-libs \
 bzip2-libs \
 fftw-libs-double \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXt \
 libheif \
 liblqr-1 \
 libraqm \
 libtool-ltdl \
 libxml2 \
 libzip \
 zlib-ng-compat \
 "
RDEPENDS:ImageMagick-libs = " \
 LibRaw \
 bzip2-libs \
 cairo \
 fftw-libs-double \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphviz \
 harfbuzz \
 imath \
 jbigkit-libs \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXt \
 libgcc \
 libgomp \
 libgs \
 libjpeg-turbo \
 libjxl \
 liblqr-1 \
 libpng \
 libraqm \
 librsvg2 \
 libtiff \
 libtool-ltdl \
 libwebp \
 libwmf-lite \
 libxml2 \
 libzip \
 openexr-libs \
 openjpeg2 \
 pango \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:ImageMagick-perl = " \
 ImageMagick-libs \
 ImageMagick-perl \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-parent \
 perl-vars \
 "
