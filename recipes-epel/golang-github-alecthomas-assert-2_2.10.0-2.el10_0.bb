# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-alecthomas-assert-2"
PV = "2.10.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-alecthomas-assert-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-alecthomas-assert-2-2.10.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17c880227c5d1eb561ca1d64cf4a74048202b42795533166a2f2034e57bebcac"

URI_x86_64_v2_golang-github-alecthomas-assert-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-alecthomas-assert-2-devel-2.10.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-alecthomas-assert-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-alecthomas-assert-2-devel}"
SRC_URI[x86_64_v2_golang-github-alecthomas-assert-2-devel.sha256sum] = "25d092e743ad1c6db891acfeec6fc2d9e331b7295123b9b5ee56fadf0501d35f"

URI_aarch64_golang-github-alecthomas-assert-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-alecthomas-assert-2-devel-2.10.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-alecthomas-assert-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-alecthomas-assert-2-devel}"
SRC_URI[aarch64_golang-github-alecthomas-assert-2-devel.sha256sum] = "14e2441b86b5ac4e335ecb2d35d7b03a36c6b222393fd1a1fdb1588438e29084"

RDEPENDS:golang-github-alecthomas-assert-2-devel = " \
 go-filesystem \
 golang-github-alecthomas-repr-devel \
 golang-github-hexops-gotextdiff-devel \
 "
