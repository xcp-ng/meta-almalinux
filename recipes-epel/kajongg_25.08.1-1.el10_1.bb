# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kajongg"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kajongg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kajongg-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "784b452147161624f17128525731272c6153ff45b5dcae9b223714dff58c4f68"

URI_x86_64_v2_kajongg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kajongg-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kajongg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kajongg}"
SRC_URI[x86_64_v2_kajongg.sha256sum] = "7efb93d04bd09bba961800351dff04b3a2ccee1dbf244b47768c5872cb7b4991"

URI_aarch64_kajongg = "${EPEL_MIRROR}/aarch64/Packages/k/kajongg-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kajongg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kajongg}"
SRC_URI[aarch64_kajongg.sha256sum] = "5b4b9c20ff9088cca105d410259ab280d8326ad03da4075aefc055ea0719e79b"

RDEPENDS:kajongg = " \
 libkmahjongg-data \
 python3 \
 python3-QtPy \
 python3-pyqt6 \
 python3-twisted \
 vorbis-tools \
 "
