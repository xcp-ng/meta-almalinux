# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-test"
PV = "0.3.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-futures-test+default-devel \
 rust-futures-test+std-devel \
 rust-futures-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-test-0.3.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7883a84ecd1a94de8d641f32ca86426e8f46c3001ae1e83ddc31ad7650fbbbaa"

URI_x86_64_v2_rust-futures-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test+default-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-test+default-devel}"
SRC_URI[x86_64_v2_rust-futures-test+default-devel.sha256sum] = "5cb487b7b65506645b25993d06eed1d18d41bc67ca8216375dd4fa1f03c5ef29"

URI_x86_64_v2_rust-futures-test+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test+std-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-test+std-devel}"
SRC_URI[x86_64_v2_rust-futures-test+std-devel.sha256sum] = "c2cd645c6d3dce6be567394c55c5dfb43cd71031b3e91cfc64d12f627cae834c"

URI_x86_64_v2_rust-futures-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-test-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-test-devel}"
SRC_URI[x86_64_v2_rust-futures-test-devel.sha256sum] = "985545be06ef8fd3019ae98062d4a834d7dcce6a33935410518d83304cd06bfa"

URI_aarch64_rust-futures-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test+default-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-test+default-devel}"
SRC_URI[aarch64_rust-futures-test+default-devel.sha256sum] = "5d03d9b50791fc7457aefb4c6eb1a6b46c3e8f60242d9033e407e5226c382daa"

URI_aarch64_rust-futures-test+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test+std-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-test+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-test+std-devel}"
SRC_URI[aarch64_rust-futures-test+std-devel.sha256sum] = "93f9bc99defc46e71abc52465b26e59a212bdc420bcf06fc412c71600042dc29"

URI_aarch64_rust-futures-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-test-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-test-devel}"
SRC_URI[aarch64_rust-futures-test-devel.sha256sum] = "e34d4a8b377a1599f1405afb79a0b80def4e468812fc04b2be1b0704276f7433"

RDEPENDS:rust-futures-test+default-devel = " \
 cargo \
 rust-futures-test+std-devel \
 rust-futures-test-devel \
 "
RDEPENDS:rust-futures-test+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-executor+std-devel \
 rust-futures-io+std-devel \
 rust-futures-task+std-devel \
 rust-futures-test-devel \
 rust-futures-util+io-devel \
 rust-futures-util+std-devel \
 "
RDEPENDS:rust-futures-test-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-executor-devel \
 rust-futures-io-devel \
 rust-futures-macro-devel \
 rust-futures-sink-devel \
 rust-futures-task-devel \
 rust-futures-util-devel \
 rust-pin-project+default-devel \
 "
