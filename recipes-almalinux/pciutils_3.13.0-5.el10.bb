# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pciutils"
PV = "3.13.0"
PR = "5.el10"
PACKAGES = " \
 pciutils \
 pciutils-devel \
 pciutils-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pciutils-3.13.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3332b67a9f9319687851292cd5e837027a8eb6ea4ea4fab921efbffd350eda11"

URI_x86_64_v2_pciutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pciutils-3.13.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_pciutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pciutils}"
SRC_URI[x86_64_v2_pciutils.sha256sum] = "8945c9504fd11b96a1cac9917e9a904cff39ee810a6f9459729f04d0ade51ee4"

URI_x86_64_v2_pciutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pciutils-devel-3.13.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_pciutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pciutils-devel}"
SRC_URI[x86_64_v2_pciutils-devel.sha256sum] = "2e4b3d9d36b0d4a80d788d5199b50bb72a95d40d69015e0e686645bc25d60d95"

URI_x86_64_v2_pciutils-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pciutils-libs-3.13.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_pciutils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pciutils-libs}"
SRC_URI[x86_64_v2_pciutils-libs.sha256sum] = "909a58590011b0e647643983831462a881717d92bd7172d1ba1bec3f47ca77e3"

URI_aarch64_pciutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pciutils-3.13.0-5.el10.aarch64.rpm;name=aarch64_pciutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_pciutils}"
SRC_URI[aarch64_pciutils.sha256sum] = "8dd6616397844e7ba1b65019154fd757856f09aec7b1cd581cb1ea6ccf6f533a"

URI_aarch64_pciutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pciutils-devel-3.13.0-5.el10.aarch64.rpm;name=aarch64_pciutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pciutils-devel}"
SRC_URI[aarch64_pciutils-devel.sha256sum] = "401c8d8a802c6e891979ac1a8a501ca17fc8138876262f9042ad852cf501fdea"

URI_aarch64_pciutils-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pciutils-libs-3.13.0-5.el10.aarch64.rpm;name=aarch64_pciutils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pciutils-libs}"
SRC_URI[aarch64_pciutils-libs.sha256sum] = "cbc722f8ef9582179e178e43d27ee1746346f3c3592401c07f09e2908b8ab769"

RDEPENDS:pciutils = " \
 bash \
 glibc \
 hwdata \
 kmod-libs \
 pciutils-libs \
 "
RDEPENDS:pciutils-devel = " \
 pciutils \
 pciutils-libs \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:pciutils-libs = " \
 glibc \
 "
