# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmodbus"
PV = "3.1.11"
PR = "4.el10_1"
PACKAGES = " \
 libmodbus \
 libmodbus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmodbus-3.1.11-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8e55f003567da93be35ca726900e8189ddda521880b12fe6ad01403e2107c66"

URI_x86_64_v2_libmodbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmodbus-3.1.11-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmodbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmodbus}"
SRC_URI[x86_64_v2_libmodbus.sha256sum] = "dd3bc073c4a662af82cf70da469acd06276dc8a9cd3c09b81da249a2d41658ec"

URI_x86_64_v2_libmodbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmodbus-devel-3.1.11-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmodbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmodbus-devel}"
SRC_URI[x86_64_v2_libmodbus-devel.sha256sum] = "60f45cf1ae26b9b20df9f7e4b8ea8a2501a8ddc36c08e7b0a7673efefff8091a"

URI_aarch64_libmodbus = "${EPEL_MIRROR}/aarch64/Packages/l/libmodbus-3.1.11-4.el10_1.aarch64.rpm;name=aarch64_libmodbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmodbus}"
SRC_URI[aarch64_libmodbus.sha256sum] = "198b41a92aeb27ef2c2acc1ff133a8d51a8baf5a0204e53986e5283f82fd0e36"

URI_aarch64_libmodbus-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmodbus-devel-3.1.11-4.el10_1.aarch64.rpm;name=aarch64_libmodbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmodbus-devel}"
SRC_URI[aarch64_libmodbus-devel.sha256sum] = "19edf0b9adfcf35a8ec12ffb2f00690db169448c53f7dc487d00aa3451bae80e"

RDEPENDS:libmodbus = " \
 glibc \
 "
RDEPENDS:libmodbus-devel = " \
 libmodbus \
 pkgconf-pkg-config \
 "
