# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcat"
PV = "1.7.1"
PR = "1.el10_1"
PACKAGES = " \
 kcat \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kcat-1.7.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "06f92ef29ddd64211036bb0caee5b20fd0988c91a27d3e9488bdef95b92dab77"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcat-1.7.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcat;unpack=0"
SRC_URI[x86_64_v2_kcat.sha256sum] = "36270185187d3b40b41dd81fc1d87f6e01196caeb153fd32a342de3ff4cffda9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kcat-1.7.1-1.el10_1.aarch64.rpm;name=aarch64_kcat;unpack=0"
SRC_URI[aarch64_kcat.sha256sum] = "0398e57192fbe86f9d1fdbcca96c7c8f0bdc422ff8dc2bb8b26a7b3adf88e454"

RDEPENDS:kcat = " \
 glibc \
 librdkafka \
 "
