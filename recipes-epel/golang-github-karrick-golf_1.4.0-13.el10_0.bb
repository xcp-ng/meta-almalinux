# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-karrick-golf"
PV = "1.4.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-karrick-golf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-karrick-golf-1.4.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b3145ebc6465e67315941d36c20a48a7f04f48200a5d6a1cb10e0814cb4be84"

URI_x86_64_v2_golang-github-karrick-golf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-karrick-golf-devel-1.4.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-karrick-golf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-karrick-golf-devel}"
SRC_URI[x86_64_v2_golang-github-karrick-golf-devel.sha256sum] = "21662cd6fef85332ebd49c33dbcf9bc960c828f71fe4a7f6237c1e0ca40e45f3"

URI_aarch64_golang-github-karrick-golf-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-karrick-golf-devel-1.4.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-karrick-golf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-karrick-golf-devel}"
SRC_URI[aarch64_golang-github-karrick-golf-devel.sha256sum] = "f16b898e2294e6c254415d80ff072e683b9a2f9e82ffd5aa66566ed958cbd7d0"

RDEPENDS:golang-github-karrick-golf-devel = " \
 go-filesystem \
 "
