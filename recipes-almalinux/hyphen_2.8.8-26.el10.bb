# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen"
PV = "2.8.8"
PR = "26.el10"
PACKAGES = " \
 hyphen \
 hyphen-devel \
 hyphen-en \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-2.8.8-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "614dc0fcff9b51fe4e41c37bade338f29db76b5dcf8204231557e0da02715315"

URI_x86_64_v2_hyphen = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-2.8.8-26.el10.x86_64_v2.rpm;name=x86_64_v2_hyphen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen}"
SRC_URI[x86_64_v2_hyphen.sha256sum] = "bff67dfec22a8223663163fe28912b5e56869ebd0ba98a9b05745553b18469ab"

URI_x86_64_v2_hyphen-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-devel-2.8.8-26.el10.x86_64_v2.rpm;name=x86_64_v2_hyphen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-devel}"
SRC_URI[x86_64_v2_hyphen-devel.sha256sum] = "1da322bca5bb5e771f21e1a6e31f5c3eb98bb8c0c85dfe1b914e543f42238aab"

URI_x86_64_v2_hyphen-en = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-en-2.8.8-26.el10.noarch.rpm;name=x86_64_v2_hyphen-en;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-en}"
SRC_URI[x86_64_v2_hyphen-en.sha256sum] = "b14ad4a3309bc4018c74e12f4425eeedbe31e9b8e6eebd7918b0667ec1484ef8"

URI_aarch64_hyphen = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-2.8.8-26.el10.aarch64.rpm;name=aarch64_hyphen;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen}"
SRC_URI[aarch64_hyphen.sha256sum] = "b043ad536150eec8d0ab430ff4eaf076fb1978ebc74623da9a05f6da49e5c886"

URI_aarch64_hyphen-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-devel-2.8.8-26.el10.aarch64.rpm;name=aarch64_hyphen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-devel}"
SRC_URI[aarch64_hyphen-devel.sha256sum] = "65e22dc98488f98cbef24b95efd6084ee69aba8c555b537462806609a5c166fb"

URI_aarch64_hyphen-en = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-en-2.8.8-26.el10.noarch.rpm;name=aarch64_hyphen-en;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-en}"
SRC_URI[aarch64_hyphen-en.sha256sum] = "b14ad4a3309bc4018c74e12f4425eeedbe31e9b8e6eebd7918b0667ec1484ef8"

RDEPENDS:hyphen = " \
 glibc \
 "
RDEPENDS:hyphen-devel = " \
 hyphen \
 perl-interpreter \
 "
RDEPENDS:hyphen-en = " \
 hyphen \
 "
