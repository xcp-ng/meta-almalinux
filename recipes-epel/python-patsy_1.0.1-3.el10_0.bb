# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-patsy"
PV = "1.0.1"
PR = "3.el10_0"
PACKAGES = " \
 python3-patsy \
 python3-patsy-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-patsy-1.0.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c253ba28eb749a221f19920a65019be3e94921810ac7c6162abf16a099b8b5f5"

URI_x86_64_v2_python3-patsy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-patsy-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-patsy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-patsy}"
SRC_URI[x86_64_v2_python3-patsy.sha256sum] = "823321c8e4171ecf62b613e83093cdad31962b0665a1b57fe53f0b4f4cc81d05"

URI_x86_64_v2_python3-patsy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-patsy-doc-1.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-patsy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-patsy-doc}"
SRC_URI[x86_64_v2_python3-patsy-doc.sha256sum] = "f3236f4733d4a496989aabbb202399929f5ffa000238b45fb752d6d0d15f5799"

URI_aarch64_python3-patsy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-patsy-1.0.1-3.el10_0.noarch.rpm;name=aarch64_python3-patsy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-patsy}"
SRC_URI[aarch64_python3-patsy.sha256sum] = "adefa0238cb28acae449f0d5cac8901e10adcc498e96bc9c8d1b162cea66e505"

URI_aarch64_python3-patsy-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-patsy-doc-1.0.1-3.el10_0.noarch.rpm;name=aarch64_python3-patsy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-patsy-doc}"
SRC_URI[aarch64_python3-patsy-doc.sha256sum] = "c92003c2c0741e499b12c98f0188915c28f99988e5d5b0b51331fc0954cf5f95"

RDEPENDS:python3-patsy = " \
 python3 \
 python3-numpy \
 "
RDEPENDS:python3-patsy-doc = " \
 "
