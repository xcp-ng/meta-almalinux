# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-filter"
PV = "0.22.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-filter+default-devel \
 rust-gix-filter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-filter-0.22.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0792c13966388fc5d095c6199203762ae1511f9fc52a205c5737872cb7bd72e1"

URI_x86_64_v2_rust-gix-filter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-filter+default-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-filter+default-devel}"
SRC_URI[x86_64_v2_rust-gix-filter+default-devel.sha256sum] = "415c4217871d1e6a98c094272b136252899da62106df4a0d204eb5de3b86b97e"

URI_x86_64_v2_rust-gix-filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-filter-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-filter-devel}"
SRC_URI[x86_64_v2_rust-gix-filter-devel.sha256sum] = "67f9b37bf70b85ba670844911d9d226fce3ef8e2ee3f68e0bfa46d97e622cfad"

URI_aarch64_rust-gix-filter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-filter+default-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-filter+default-devel}"
SRC_URI[aarch64_rust-gix-filter+default-devel.sha256sum] = "d20fef586994361b568e3658a633c3d6a9b25fd61314ee9598b8064af6d61794"

URI_aarch64_rust-gix-filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-filter-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-filter-devel}"
SRC_URI[aarch64_rust-gix-filter-devel.sha256sum] = "1914f23ce364fa4dcfb8ddb3a8b2cff78a8091250d45889f08b6407b1d04e5bf"

RDEPENDS:rust-gix-filter+default-devel = " \
 cargo \
 rust-gix-filter-devel \
 "
RDEPENDS:rust-gix-filter-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-encoding_rs+default-devel \
 rust-gix-attributes+default-devel \
 rust-gix-command+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-packetline+default-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-utils+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
