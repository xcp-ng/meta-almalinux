# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-atomic-waker"
PV = "1.1.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-atomic-waker+default-devel \
 rust-atomic-waker+portable-atomic-devel \
 rust-atomic-waker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-atomic-waker-1.1.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d265e3dc0fa75fb0b56f425bb1ba057d2f7028aad640a85e0204cd5a9918e184"

URI_x86_64_v2_rust-atomic-waker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic-waker+default-devel-1.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic-waker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic-waker+default-devel}"
SRC_URI[x86_64_v2_rust-atomic-waker+default-devel.sha256sum] = "9c93db652f484abaad05cc21a86f9b093b5443aa7c9b8e4cd4a86e395aa7f34b"

URI_x86_64_v2_rust-atomic-waker+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic-waker+portable-atomic-devel-1.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic-waker+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic-waker+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-atomic-waker+portable-atomic-devel.sha256sum] = "20ceef53f8c79ed5f9085d69cdcc6587c4b1362401fc01689ed608d96eaa7b1f"

URI_x86_64_v2_rust-atomic-waker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atomic-waker-devel-1.1.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atomic-waker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atomic-waker-devel}"
SRC_URI[x86_64_v2_rust-atomic-waker-devel.sha256sum] = "aae67e7d7708b7b30f4aaddf3570c04ec3c06435a68fc96e90c0cea28b42f495"

URI_aarch64_rust-atomic-waker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic-waker+default-devel-1.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-atomic-waker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic-waker+default-devel}"
SRC_URI[aarch64_rust-atomic-waker+default-devel.sha256sum] = "3c35d1da599703827a39b1552f83536ea6524faa551945ed2e1168c4a71578b2"

URI_aarch64_rust-atomic-waker+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic-waker+portable-atomic-devel-1.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-atomic-waker+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic-waker+portable-atomic-devel}"
SRC_URI[aarch64_rust-atomic-waker+portable-atomic-devel.sha256sum] = "fb9719ed8497997f91377331a30558a494fd29e5aa130e653a46b01d548df7a9"

URI_aarch64_rust-atomic-waker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atomic-waker-devel-1.1.2-3.el10_0.noarch.rpm;name=aarch64_rust-atomic-waker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atomic-waker-devel}"
SRC_URI[aarch64_rust-atomic-waker-devel.sha256sum] = "25853340e1c21e8a07c52cfdafc91226a9eae1aa8a36c18bc448ef3d47c1f87f"

RDEPENDS:rust-atomic-waker+default-devel = " \
 cargo \
 rust-atomic-waker-devel \
 "
RDEPENDS:rust-atomic-waker+portable-atomic-devel = " \
 cargo \
 rust-atomic-waker-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-atomic-waker-devel = " \
 cargo \
 rust \
 "
