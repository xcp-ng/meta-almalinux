# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb2"
PV = "2.5.2"
PR = "1.el10_3"
PACKAGES = " \
 php-pecl-mongodb2 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb2-2.5.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2bc75fc66b6dce508fece28732c5d153dd37ffb5fd50618f8cbe68dc59a701a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb2-2.5.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb2;unpack=0"
SRC_URI[x86_64_v2_php-pecl-mongodb2.sha256sum] = "a1d9cb8d08ac0285a19f5f536aa00dbdb3b035d5ba3980c1b7294e6d15d80d04"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb2-2.5.2-1.el10_3.aarch64.rpm;name=aarch64_php-pecl-mongodb2;unpack=0"
SRC_URI[aarch64_php-pecl-mongodb2.sha256sum] = "2b667c227bcbcbef51047faaca93d92906a648b7f1c9ddb34a06f68b9116303b"

RDEPENDS:php-pecl-mongodb2:x86_64_v2 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 virtual/php-json_x86-64_ \
"
RDEPENDS:php-pecl-mongodb2:aarch64 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 virtual/php-json_aarch-64_ \
"
