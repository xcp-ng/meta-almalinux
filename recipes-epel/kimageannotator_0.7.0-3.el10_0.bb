# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kimageannotator"
PV = "0.7.0"
PR = "3.el10_0"
PACKAGES = " \
 kimageannotator \
 kimageannotator-common \
 kimageannotator-devel \
 kimageannotator-qt6 \
 kimageannotator-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kimageannotator-0.7.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d30fa16703cdb35d0a06e14b41d8cae188443454e7eeb909b6f02ef650bc6ede"

URI_x86_64_v2_kimageannotator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimageannotator-0.7.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimageannotator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimageannotator}"
SRC_URI[x86_64_v2_kimageannotator.sha256sum] = "9d049f74028d675e63d4ada4304674018e4cd6091fe4e93781bc353952b873a5"

URI_x86_64_v2_kimageannotator-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimageannotator-common-0.7.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimageannotator-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimageannotator-common}"
SRC_URI[x86_64_v2_kimageannotator-common.sha256sum] = "e2d45212364b9b6a62fc55d98836fd52c3cab7e79be49ff03348041ced15afd6"

URI_x86_64_v2_kimageannotator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimageannotator-devel-0.7.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimageannotator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimageannotator-devel}"
SRC_URI[x86_64_v2_kimageannotator-devel.sha256sum] = "e3e141ff452f9001edb8f5fc787b12ff1e420a9a18af1c106ff6ed579f279a87"

URI_x86_64_v2_kimageannotator-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimageannotator-qt6-0.7.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimageannotator-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimageannotator-qt6}"
SRC_URI[x86_64_v2_kimageannotator-qt6.sha256sum] = "3bfc269dfa7fdb49c5b77e7962393dd927d5583bbaf2dfea6731ef780f74982c"

URI_x86_64_v2_kimageannotator-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kimageannotator-qt6-devel-0.7.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kimageannotator-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kimageannotator-qt6-devel}"
SRC_URI[x86_64_v2_kimageannotator-qt6-devel.sha256sum] = "a6922120a90ce941917c28f57a4e95f6494ec9ffe9fb686027a6f17542b5353b"

URI_aarch64_kimageannotator = "${EPEL_MIRROR}/aarch64/Packages/k/kimageannotator-0.7.0-3.el10_0.aarch64.rpm;name=aarch64_kimageannotator;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimageannotator}"
SRC_URI[aarch64_kimageannotator.sha256sum] = "5eb6d90d53439e04203f7cfce89c24d7d9e0e35a1f8bdf5a18f7d828265de6b6"

URI_aarch64_kimageannotator-common = "${EPEL_MIRROR}/aarch64/Packages/k/kimageannotator-common-0.7.0-3.el10_0.aarch64.rpm;name=aarch64_kimageannotator-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimageannotator-common}"
SRC_URI[aarch64_kimageannotator-common.sha256sum] = "456164386e3454cd723b22f49fa5ebccbb88d90ec75bb9e62959808189fb7b88"

URI_aarch64_kimageannotator-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kimageannotator-devel-0.7.0-3.el10_0.aarch64.rpm;name=aarch64_kimageannotator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimageannotator-devel}"
SRC_URI[aarch64_kimageannotator-devel.sha256sum] = "9477fb96a70b1f06bdb762b4fc306b51db927956b526ae5221c78b31e8429a07"

URI_aarch64_kimageannotator-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kimageannotator-qt6-0.7.0-3.el10_0.aarch64.rpm;name=aarch64_kimageannotator-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimageannotator-qt6}"
SRC_URI[aarch64_kimageannotator-qt6.sha256sum] = "c6d76af18fdcd93aaf61a021450e52b884ee4ffb8dd3b8ad72486001e8c1b163"

URI_aarch64_kimageannotator-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kimageannotator-qt6-devel-0.7.0-3.el10_0.aarch64.rpm;name=aarch64_kimageannotator-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kimageannotator-qt6-devel}"
SRC_URI[aarch64_kimageannotator-qt6-devel.sha256sum] = "10694d025f3b1acea4bd2684091de79bc74a907d30d60646dce0f0fd7367c79a"

RDEPENDS:kimageannotator = " \
 glibc \
 kcolorpicker \
 kimageannotator-common \
 libX11 \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 "
RDEPENDS:kimageannotator-common = " \
 "
RDEPENDS:kimageannotator-devel = " \
 cmake-filesystem \
 kimageannotator \
 "
RDEPENDS:kimageannotator-qt6 = " \
 glibc \
 kcolorpicker-qt6 \
 kimageannotator-common \
 libX11 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:kimageannotator-qt6-devel = " \
 cmake-filesystem \
 kimageannotator-qt6 \
 "
