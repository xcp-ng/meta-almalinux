# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zziplib"
PV = "0.13.78"
PR = "1.el10"
PACKAGES = " \
 zziplib \
 zziplib-devel \
 zziplib-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/zziplib-0.13.78-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed34d08de507064e3be5ff36c045548c41343d215c2f788b93ba93d060233976"

URI_x86_64_v2_zziplib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/zziplib-0.13.78-1.el10.x86_64_v2.rpm;name=x86_64_v2_zziplib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zziplib}"
SRC_URI[x86_64_v2_zziplib.sha256sum] = "8086bfbb40f70a4890b3e885081c637124ed82b886d41fcb8badfd0c26f6b2bb"

URI_x86_64_v2_zziplib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/zziplib-devel-0.13.78-1.el10.x86_64_v2.rpm;name=x86_64_v2_zziplib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zziplib-devel}"
SRC_URI[x86_64_v2_zziplib-devel.sha256sum] = "6bf99b807ab2c05a1914800d06738fdb178369a01792c8cb85bbdef585af8c51"

URI_x86_64_v2_zziplib-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/zziplib-utils-0.13.78-1.el10.x86_64_v2.rpm;name=x86_64_v2_zziplib-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zziplib-utils}"
SRC_URI[x86_64_v2_zziplib-utils.sha256sum] = "07a9707865900de9a2e877476b9c8eb4509a5c2de9fc3ff6410ddc8fa202d9c2"

URI_aarch64_zziplib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/zziplib-0.13.78-1.el10.aarch64.rpm;name=aarch64_zziplib;unpack=0"
SRC_URI:append = " ${URI_aarch64_zziplib}"
SRC_URI[aarch64_zziplib.sha256sum] = "e0ab148569ad3d29e7e595292b8b703ce20ac7dc8c11656d0f66226cc3412fe2"

URI_aarch64_zziplib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/zziplib-devel-0.13.78-1.el10.aarch64.rpm;name=aarch64_zziplib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zziplib-devel}"
SRC_URI[aarch64_zziplib-devel.sha256sum] = "678a6b54cd16714c217022a20ec2bc6c55b4cfb3855c237e330d3584646be9f3"

URI_aarch64_zziplib-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/zziplib-utils-0.13.78-1.el10.aarch64.rpm;name=aarch64_zziplib-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_zziplib-utils}"
SRC_URI[aarch64_zziplib-utils.sha256sum] = "2bd3d2c84507eeb0576e5a22a08f25fe8bb463d654c3ca9af72c92a5d4784af3"

RDEPENDS:zziplib = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:zziplib-devel = " \
 pkgconf-pkg-config \
 sdl12-compat-devel \
 zlib-ng-compat-devel \
 zziplib \
 zziplib-devel \
 "
RDEPENDS:zziplib-utils = " \
 glibc \
 zlib-ng-compat \
 zziplib \
 "
