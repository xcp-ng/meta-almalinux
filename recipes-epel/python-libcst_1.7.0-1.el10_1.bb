# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-libcst"
PV = "1.7.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-libcst \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-libcst-1.7.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e5df2676d2c5dc1d13126442a796d4ecee05b05ca578ecd657b5d3dca4c1220"

URI_x86_64_v2_python3-libcst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libcst-1.7.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libcst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libcst}"
SRC_URI[x86_64_v2_python3-libcst.sha256sum] = "53c96450421e8bd45ee54893d100f1813d15abcda09183acd73ffa3be8697310"

URI_aarch64_python3-libcst = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libcst-1.7.0-1.el10_1.aarch64.rpm;name=aarch64_python3-libcst;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libcst}"
SRC_URI[aarch64_python3-libcst.sha256sum] = "e2d8f2f35ace02167559815dff4749f547a64a829a99deee4325273c746da85d"

RDEPENDS:python3-libcst = " \
 glibc \
 libgcc \
 python3 \
 python3-pyyaml \
 "
