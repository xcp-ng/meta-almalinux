# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_derive"
PV = "2.8.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-pest_derive+default-devel \
 rust-pest_derive+grammar-extras-devel \
 rust-pest_derive+std-devel \
 rust-pest_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_derive-2.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16ac1e6ecb0fca4801a50d4fce0008443fa66ffab3b44ce8a13acc07861f67dc"

URI_x86_64_v2_rust-pest_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+default-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+default-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+default-devel.sha256sum] = "174ec0810f1599e9f8dc9c1b3c16aef95b16ae471db64296895313eb8b7992ab"

URI_x86_64_v2_rust-pest_derive+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+grammar-extras-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+grammar-extras-devel.sha256sum] = "74b19a6f440665ab03a1b1b05ad7e0e8cb24ebc91a615f57b6cedcc8d868079f"

URI_x86_64_v2_rust-pest_derive+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive+std-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive+std-devel}"
SRC_URI[x86_64_v2_rust-pest_derive+std-devel.sha256sum] = "56f9023a6edb3300c20d71b947ad43bc09112216e9850e430fdf1b2455e0684a"

URI_x86_64_v2_rust-pest_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_derive-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_derive-devel}"
SRC_URI[x86_64_v2_rust-pest_derive-devel.sha256sum] = "63e0943efa4acc5e21dc6c5b4f24b1173240fb3ffd4bacb19948055b67df5231"

URI_aarch64_rust-pest_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+default-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+default-devel}"
SRC_URI[aarch64_rust-pest_derive+default-devel.sha256sum] = "fceb9d8b05f289533f9428d89668cc1db407056e08b202672fe8ed128bf223de"

URI_aarch64_rust-pest_derive+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+grammar-extras-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_derive+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_derive+grammar-extras-devel.sha256sum] = "dc99292a1e696ea26ca728704c32a80c8706796e08bdc28a19e0e46c577d06d2"

URI_aarch64_rust-pest_derive+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive+std-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_derive+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive+std-devel}"
SRC_URI[aarch64_rust-pest_derive+std-devel.sha256sum] = "6068ef93f1262719137c83170f3c5ef3474d8416c4e5aa668caab1e3dc41105a"

URI_aarch64_rust-pest_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_derive-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_derive-devel}"
SRC_URI[aarch64_rust-pest_derive-devel.sha256sum] = "ee4e699437d3d66b594f2748c2e96e89269181f4eac638d02296855104817dc7"

RDEPENDS:rust-pest_derive+default-devel = " \
 cargo \
 rust-pest_derive+std-devel \
 rust-pest_derive-devel \
 "
RDEPENDS:rust-pest_derive+grammar-extras-devel = " \
 cargo \
 rust-pest_derive-devel \
 rust-pest_generator+grammar-extras-devel \
 "
RDEPENDS:rust-pest_derive+std-devel = " \
 cargo \
 rust-pest+std-devel \
 rust-pest_derive-devel \
 rust-pest_generator+std-devel \
 "
RDEPENDS:rust-pest_derive-devel = " \
 cargo \
 rust \
 rust-pest-devel \
 rust-pest_generator-devel \
 "
