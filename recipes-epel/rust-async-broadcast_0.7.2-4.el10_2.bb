# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-broadcast"
PV = "0.7.2"
PR = "4.el10_2"
PACKAGES = " \
 rust-async-broadcast+default-devel \
 rust-async-broadcast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-broadcast-0.7.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34e5c683335698f77274a6a36820ce55841413bc2c71e80e98809dfb48e65ef3"

URI_x86_64_v2_rust-async-broadcast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-broadcast+default-devel-0.7.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-broadcast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-broadcast+default-devel}"
SRC_URI[x86_64_v2_rust-async-broadcast+default-devel.sha256sum] = "075704d147a94ceec592e53c84bc1f10f3a646b451d61c06c8f886ed5c8a5336"

URI_x86_64_v2_rust-async-broadcast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-broadcast-devel-0.7.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-broadcast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-broadcast-devel}"
SRC_URI[x86_64_v2_rust-async-broadcast-devel.sha256sum] = "78bac5c9f342f6ed96fba94799154f13018eb17cbd0b5681d22c6987b6320651"

URI_aarch64_rust-async-broadcast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-broadcast+default-devel-0.7.2-4.el10_2.noarch.rpm;name=aarch64_rust-async-broadcast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-broadcast+default-devel}"
SRC_URI[aarch64_rust-async-broadcast+default-devel.sha256sum] = "42bbb4d886504d54cba2c851eaacfcfc278787ba6b48f7838344802432264d51"

URI_aarch64_rust-async-broadcast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-broadcast-devel-0.7.2-4.el10_2.noarch.rpm;name=aarch64_rust-async-broadcast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-broadcast-devel}"
SRC_URI[aarch64_rust-async-broadcast-devel.sha256sum] = "6a62186f9ce91803c9d152f9a1362476c84a4f29cefda6d4a763c7cec8d01660"

RDEPENDS:rust-async-broadcast+default-devel = " \
 cargo \
 rust-async-broadcast-devel \
 "
RDEPENDS:rust-async-broadcast-devel = " \
 cargo \
 rust \
 rust-event-listener+default-devel \
 rust-event-listener-strategy+default-devel \
 rust-futures-core+default-devel \
 rust-pin-project-lite+default-devel \
 "
