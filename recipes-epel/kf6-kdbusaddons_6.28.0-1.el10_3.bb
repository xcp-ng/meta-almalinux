# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdbusaddons"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdbusaddons \
 kf6-kdbusaddons-devel \
 kf6-kdbusaddons-doc \
 kf6-kdbusaddons-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdbusaddons-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2022b3c94b89051811438f61dbfbbcd8108fb102bfb061c9cf6895c568a6235c"

URI_x86_64_v2_kf6-kdbusaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons}"
SRC_URI[x86_64_v2_kf6-kdbusaddons.sha256sum] = "45d880f8fca5fae73c31210b665765e5a8e4f3f2fe88d6e47e7e577fe6c73b2b"

URI_x86_64_v2_kf6-kdbusaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-devel}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-devel.sha256sum] = "7df622ea044a7a39bb2c45adc30684b11ee32cc1e9ad5709d05f04873839214e"

URI_x86_64_v2_kf6-kdbusaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdbusaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-doc}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-doc.sha256sum] = "fadda3fb011b78b5deced21e8d69b9a250620daaddef0af8d3d6a3a7cb1ff418"

URI_x86_64_v2_kf6-kdbusaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdbusaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-html}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-html.sha256sum] = "c19191297ca4635d40d399a0dacc353c125f4b71bc5259cda82869e138f77898"

URI_aarch64_kf6-kdbusaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdbusaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons}"
SRC_URI[aarch64_kf6-kdbusaddons.sha256sum] = "982a0330b44c27cb009b561ac88ce50a09487783b2925872e0abb8c5df5ee86b"

URI_aarch64_kf6-kdbusaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdbusaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-devel}"
SRC_URI[aarch64_kf6-kdbusaddons-devel.sha256sum] = "b8e77c92f78321cf623605712ce304652d28672a9fffee4150a6acfd206acbc8"

URI_aarch64_kf6-kdbusaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdbusaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-doc}"
SRC_URI[aarch64_kf6-kdbusaddons-doc.sha256sum] = "45ff161e4e2cf8df1bfc886ca4e754a6397a8552f1985a666c6b34556907b3e7"

URI_aarch64_kf6-kdbusaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdbusaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-html}"
SRC_URI[aarch64_kf6-kdbusaddons-html.sha256sum] = "01d54800b1c113a8c3aaf2e15a1fa3d2bf9e26a0e6d65291a01dd082dbeeb443"

RDEPENDS:kf6-kdbusaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdbusaddons-devel = " \
 cmake-filesystem \
 kf6-kdbusaddons \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdbusaddons-doc = " \
 "
RDEPENDS:kf6-kdbusaddons-html = " \
 "
