# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-CIDR"
PV = "0.27"
PR = "1.el10_2"
PACKAGES = " \
 perl-Net-CIDR \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-CIDR-0.27-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72250266557fb46cd00667276c22217da087a894699e681c051befac7eaccab8"

URI_x86_64_v2_perl-Net-CIDR = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-CIDR-0.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-CIDR;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-CIDR}"
SRC_URI[x86_64_v2_perl-Net-CIDR.sha256sum] = "eedf2b644725d44bb33fa352a26f95abc19b5e09e5eaab98442ba23139023558"

URI_aarch64_perl-Net-CIDR = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-CIDR-0.27-1.el10_2.noarch.rpm;name=aarch64_perl-Net-CIDR;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-CIDR}"
SRC_URI[aarch64_perl-Net-CIDR.sha256sum] = "e656b6d4cfa498f6bb49b36ff26d20c908bfb973681b82c61a42a49b77c7b964"

RDEPENDS:perl-Net-CIDR = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
