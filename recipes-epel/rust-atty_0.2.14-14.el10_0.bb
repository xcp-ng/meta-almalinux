# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-atty"
PV = "0.2.14"
PR = "14.el10_0"
PACKAGES = " \
 rust-atty+default-devel \
 rust-atty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-atty-0.2.14-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c65d410997874eb9145b169a27647d0719f2be15a81f8b00aec01ea4dc0fbb2"

URI_x86_64_v2_rust-atty+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atty+default-devel-0.2.14-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atty+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atty+default-devel}"
SRC_URI[x86_64_v2_rust-atty+default-devel.sha256sum] = "e56909444444c5a8a13b3ae23751329694bbdda7eb83741e8942e17a91bbd9a0"

URI_x86_64_v2_rust-atty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atty-devel-0.2.14-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atty-devel}"
SRC_URI[x86_64_v2_rust-atty-devel.sha256sum] = "6922b57b72f6b5ba89727bb64939c5c9923fce8269ac3d1ca03d9b841dcefcae"

URI_aarch64_rust-atty+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atty+default-devel-0.2.14-14.el10_0.noarch.rpm;name=aarch64_rust-atty+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atty+default-devel}"
SRC_URI[aarch64_rust-atty+default-devel.sha256sum] = "074d9c5a3fcc3d525288a518973a1898703cfe3fa18f2db451c7f4422e1d80f3"

URI_aarch64_rust-atty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atty-devel-0.2.14-14.el10_0.noarch.rpm;name=aarch64_rust-atty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atty-devel}"
SRC_URI[aarch64_rust-atty-devel.sha256sum] = "92861313253ec9b9d9bd716c4bf4c17a89224e353b4029fd42c5728d8848703f"

RDEPENDS:rust-atty+default-devel = " \
 cargo \
 rust-atty-devel \
 "
RDEPENDS:rust-atty-devel = " \
 cargo \
 rust-libc-devel \
 "
