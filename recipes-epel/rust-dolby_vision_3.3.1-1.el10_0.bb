# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dolby_vision"
PV = "3.3.1"
PR = "1.el10_0"
PACKAGES = " \
 libdovi \
 libdovi-devel \
 rust-dolby_vision+capi-devel \
 rust-dolby_vision+default-devel \
 rust-dolby_vision+libc-devel \
 rust-dolby_vision+roxmltree-devel \
 rust-dolby_vision+serde-devel \
 rust-dolby_vision+xml-devel \
 rust-dolby_vision-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dolby_vision-3.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f9f4c558a302ad3b810cccb5ed035fc5f228e6839b1baa24a5604402dac81f3"

URI_x86_64_v2_libdovi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdovi-3.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdovi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdovi}"
SRC_URI[x86_64_v2_libdovi.sha256sum] = "c5bcd1239937902910ff1884f575cee7e93d96e37aff8da9b66a5dafbefa85b7"

URI_x86_64_v2_libdovi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdovi-devel-3.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdovi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdovi-devel}"
SRC_URI[x86_64_v2_libdovi-devel.sha256sum] = "f26514a71403a1c9fc46ebaff039954a078c9179a83e713dc3c3c06f7fb857e5"

URI_x86_64_v2_rust-dolby_vision+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+capi-devel-3.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+capi-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+capi-devel.sha256sum] = "aaa82214e691fa34504b33d86bba036e6d14a1a0659520b8e2117b723df22e65"

URI_x86_64_v2_rust-dolby_vision+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+default-devel-3.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+default-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+default-devel.sha256sum] = "2d45f31dad329572edd6e3d92790c83129109643fd0e4932630b634984b42bda"

URI_x86_64_v2_rust-dolby_vision+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+libc-devel-3.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+libc-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+libc-devel.sha256sum] = "be8a7bea22e992c21865c60f3f4bbda6467d80e12932c795b81dc2c736f34ddc"

URI_x86_64_v2_rust-dolby_vision+roxmltree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+roxmltree-devel-3.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+roxmltree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+roxmltree-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+roxmltree-devel.sha256sum] = "eadd1e7711d778bbaee6bc08ae20850bbc996c9f7eb110ca21534b1e6b3e5589"

URI_x86_64_v2_rust-dolby_vision+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+serde-devel-3.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+serde-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+serde-devel.sha256sum] = "4f6d451c5f8dbaa20c7327dc182c977a3a4aed1aee6dc1761658c0fe65e2063a"

URI_x86_64_v2_rust-dolby_vision+xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision+xml-devel-3.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision+xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision+xml-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision+xml-devel.sha256sum] = "b23ae3241ebe604112b5f33cfa9a9f575cf4d07ec9beced1c80e3d08f9de6082"

URI_x86_64_v2_rust-dolby_vision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dolby_vision-devel-3.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dolby_vision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dolby_vision-devel}"
SRC_URI[x86_64_v2_rust-dolby_vision-devel.sha256sum] = "57320a8266726096b6ac19e153ebebebea3528ae29a3d608056a4be32c07011b"

URI_aarch64_libdovi = "${EPEL_MIRROR}/aarch64/Packages/l/libdovi-3.3.1-1.el10_0.aarch64.rpm;name=aarch64_libdovi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdovi}"
SRC_URI[aarch64_libdovi.sha256sum] = "4f3f9508b424b151853ad0b9ccc6e2b8d8e1b38be4c1adceae6d8dce0f8a51dd"

URI_aarch64_libdovi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdovi-devel-3.3.1-1.el10_0.aarch64.rpm;name=aarch64_libdovi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdovi-devel}"
SRC_URI[aarch64_libdovi-devel.sha256sum] = "a363938c0c1f273b4ce633f3ec64ce281451d5643d346295f840800b10eaac85"

URI_aarch64_rust-dolby_vision+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+capi-devel-3.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-dolby_vision+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+capi-devel}"
SRC_URI[aarch64_rust-dolby_vision+capi-devel.sha256sum] = "a51fd73f06b5e9309759b4ca632ab3d0308d8c07b929e5ec6b5cade1237c343d"

URI_aarch64_rust-dolby_vision+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+default-devel-3.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-dolby_vision+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+default-devel}"
SRC_URI[aarch64_rust-dolby_vision+default-devel.sha256sum] = "5689ca5379a50d9f1d4a1430588c751a6bdcc6d0ad807fc469da22bab4d6c301"

URI_aarch64_rust-dolby_vision+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+libc-devel-3.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-dolby_vision+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+libc-devel}"
SRC_URI[aarch64_rust-dolby_vision+libc-devel.sha256sum] = "b8ae401f64cef830aeb082a9b140381f40908f8ba3db8c5062c7d4c2f7f11a12"

URI_aarch64_rust-dolby_vision+roxmltree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+roxmltree-devel-3.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-dolby_vision+roxmltree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+roxmltree-devel}"
SRC_URI[aarch64_rust-dolby_vision+roxmltree-devel.sha256sum] = "77a82612003c351086951bd7afae2ac57fb01ea034a5f772c38278b640a19739"

URI_aarch64_rust-dolby_vision+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+serde-devel-3.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-dolby_vision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+serde-devel}"
SRC_URI[aarch64_rust-dolby_vision+serde-devel.sha256sum] = "135efb94b710eb4e654180f21efec6d88d1b504536ddffe267418d58b0588150"

URI_aarch64_rust-dolby_vision+xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision+xml-devel-3.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-dolby_vision+xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision+xml-devel}"
SRC_URI[aarch64_rust-dolby_vision+xml-devel.sha256sum] = "7485edcec504d33a7c2792be4c2cd671c5c00ee68c5baa2c4a396b79ac0560f4"

URI_aarch64_rust-dolby_vision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dolby_vision-devel-3.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-dolby_vision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dolby_vision-devel}"
SRC_URI[aarch64_rust-dolby_vision-devel.sha256sum] = "373d09b3e3b3b5bd56d2c7a29bdde8e1bb31c4e5bd7d487ec423bfc2c97065f5"

RDEPENDS:libdovi = " \
 glibc \
 libgcc \
 "
RDEPENDS:libdovi-devel = " \
 libdovi \
 pkgconf-pkg-config \
 "
RDEPENDS:rust-dolby_vision+capi-devel = " \
 cargo \
 rust-dolby_vision+libc-devel \
 rust-dolby_vision-devel \
 "
RDEPENDS:rust-dolby_vision+default-devel = " \
 cargo \
 rust-dolby_vision-devel \
 "
RDEPENDS:rust-dolby_vision+libc-devel = " \
 cargo \
 rust-dolby_vision-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-dolby_vision+roxmltree-devel = " \
 cargo \
 rust-dolby_vision-devel \
 rust-roxmltree+default-devel \
 "
RDEPENDS:rust-dolby_vision+serde-devel = " \
 cargo \
 rust-dolby_vision-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-tinyvec+serde-devel \
 "
RDEPENDS:rust-dolby_vision+xml-devel = " \
 cargo \
 rust-dolby_vision+roxmltree-devel \
 rust-dolby_vision-devel \
 "
RDEPENDS:rust-dolby_vision-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-bitvec+default-devel \
 rust-bitvec_helpers+bitstream-io-devel \
 rust-bitvec_helpers-devel \
 rust-crc+default-devel \
 rust-tinyvec+default-devel \
 rust-tinyvec+rustc_1_55-devel \
 "
