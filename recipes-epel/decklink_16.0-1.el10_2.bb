# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "decklink"
PV = "16.0"
PR = "1.el10_2"
PACKAGES = " \
 decklink-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/decklink-16.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1c4716af0eaa0f292c806e06df47e1786cc7c87e146ce040a6c2aeb924cc4f3a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/decklink-devel-16.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_decklink-devel;unpack=0"
SRC_URI[x86_64_v2_decklink-devel.sha256sum] = "0b9b3070a02aad88c59d131855ec75dadab3d7079e65e7e3773668a8293d16c9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/decklink-devel-16.0-1.el10_2.noarch.rpm;name=aarch64_decklink-devel;unpack=0"
SRC_URI[aarch64_decklink-devel.sha256sum] = "0ce95dd0c259c7df7a892eaee9b59f07bd2d4c92498e20fb1534403593423fea"

RDEPENDS:decklink-devel = " \
 "
