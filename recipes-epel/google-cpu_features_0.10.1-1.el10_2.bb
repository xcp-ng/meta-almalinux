# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-cpu_features"
PV = "0.10.1"
PR = "1.el10_2"
PACKAGES = " \
 google-cpu_features \
 google-cpu_features-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/google-cpu_features-0.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be50b3b4c24049cf7da145a22ac33fb580a91f2aaeea4c408d5ee87cd764002b"

URI_x86_64_v2_google-cpu_features = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-cpu_features-0.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-cpu_features;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-cpu_features}"
SRC_URI[x86_64_v2_google-cpu_features.sha256sum] = "4a9549a58b86ebc2a6289aaef760a295ee0b4cf1aea8d9d9b45c921e8814ce2b"

URI_x86_64_v2_google-cpu_features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-cpu_features-devel-0.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-cpu_features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-cpu_features-devel}"
SRC_URI[x86_64_v2_google-cpu_features-devel.sha256sum] = "d0fca5f689756aec00ff5d1064d8fb2490d39714fdb080db740248ace279c74b"

URI_aarch64_google-cpu_features = "${EPEL_MIRROR}/aarch64/Packages/g/google-cpu_features-0.10.1-1.el10_2.aarch64.rpm;name=aarch64_google-cpu_features;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-cpu_features}"
SRC_URI[aarch64_google-cpu_features.sha256sum] = "82ab72e01c86ef0815715c70a751be225985dc0f71fcede4d0fc1deb739868f6"

URI_aarch64_google-cpu_features-devel = "${EPEL_MIRROR}/aarch64/Packages/g/google-cpu_features-devel-0.10.1-1.el10_2.aarch64.rpm;name=aarch64_google-cpu_features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-cpu_features-devel}"
SRC_URI[aarch64_google-cpu_features-devel.sha256sum] = "7e7cae603354b2cfbc4e504ff866a0f86ae64e7a4f8901687eb035352fbaaa30"

RDEPENDS:google-cpu_features = " \
 glibc \
 "
RDEPENDS:google-cpu_features-devel = " \
 cmake-filesystem \
 google-cpu_features \
 "
