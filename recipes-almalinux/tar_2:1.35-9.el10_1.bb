# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tar"
PE = "2"
PV = "1.35"
PR = "9.el10_1"
PACKAGES = " \
 tar \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tar-1.35-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac5676900df66c3576a7d9a01cd62b852a768af7b75a1fb7d6aea724ca50533f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tar-1.35-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_tar;unpack=0"
SRC_URI[x86_64_v2_tar.sha256sum] = "5f46ab44165edbfece4233fad2bad3aacf0ef615bbba4d9ccafac6bc850d12aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tar-1.35-9.el10_1.aarch64.rpm;name=aarch64_tar;unpack=0"
SRC_URI[aarch64_tar.sha256sum] = "d77ec3c5777a6c8495165d3f14c2e3c8cf7a10a604819f33daa905ab295c53ad"

RDEPENDS:tar = " \
 glibc \
 libacl \
 libselinux \
 "
