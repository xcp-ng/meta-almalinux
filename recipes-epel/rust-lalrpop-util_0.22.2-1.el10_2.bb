# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lalrpop-util"
PV = "0.22.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-lalrpop-util+default-devel \
 rust-lalrpop-util+lexer-devel \
 rust-lalrpop-util+regex-automata-devel \
 rust-lalrpop-util+std-devel \
 rust-lalrpop-util+unicode-devel \
 rust-lalrpop-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lalrpop-util-0.22.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11dff101e17a886061048c214913670007a6ef991002bf6bd2b3f382ae39382f"

URI_x86_64_v2_rust-lalrpop-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop-util+default-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop-util+default-devel}"
SRC_URI[x86_64_v2_rust-lalrpop-util+default-devel.sha256sum] = "c7ea49ddafb162bf493c9ed8f858f295c4f99c6197ce0f014b560f3bf1541e25"

URI_x86_64_v2_rust-lalrpop-util+lexer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop-util+lexer-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop-util+lexer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop-util+lexer-devel}"
SRC_URI[x86_64_v2_rust-lalrpop-util+lexer-devel.sha256sum] = "cda6286776d76dfb1da0d8501858bee73786494ea7949bdbda8f51cf25391945"

URI_x86_64_v2_rust-lalrpop-util+regex-automata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop-util+regex-automata-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop-util+regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop-util+regex-automata-devel}"
SRC_URI[x86_64_v2_rust-lalrpop-util+regex-automata-devel.sha256sum] = "3756dc86230bf2d1f393c20cf4920dfa42c4c821b190f28e4bf84eebab328190"

URI_x86_64_v2_rust-lalrpop-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop-util+std-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop-util+std-devel}"
SRC_URI[x86_64_v2_rust-lalrpop-util+std-devel.sha256sum] = "a6ff91a0c2010a9eb3d9dc9f131f98d21ee3fdfa3747f695dd280f83c1901f9c"

URI_x86_64_v2_rust-lalrpop-util+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop-util+unicode-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop-util+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop-util+unicode-devel}"
SRC_URI[x86_64_v2_rust-lalrpop-util+unicode-devel.sha256sum] = "fd6c423c9b89b0cfe1ea672a06242354c6cd9672fdfb3dffb2a5276cf6d691e5"

URI_x86_64_v2_rust-lalrpop-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lalrpop-util-devel-0.22.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lalrpop-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lalrpop-util-devel}"
SRC_URI[x86_64_v2_rust-lalrpop-util-devel.sha256sum] = "55f9b7e6e7203b061339aa969169fe7a4c2be163b386c35770c6a5b24f81d9a2"

URI_aarch64_rust-lalrpop-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop-util+default-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop-util+default-devel}"
SRC_URI[aarch64_rust-lalrpop-util+default-devel.sha256sum] = "6c4b8968cbcea77c61b9df0ddf7103405b61f776873fb124b1242cb61d59abed"

URI_aarch64_rust-lalrpop-util+lexer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop-util+lexer-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop-util+lexer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop-util+lexer-devel}"
SRC_URI[aarch64_rust-lalrpop-util+lexer-devel.sha256sum] = "c05a88c79b9982d0b5298850c1726c69e2d7ef3571d130b3453c08f1091928e1"

URI_aarch64_rust-lalrpop-util+regex-automata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop-util+regex-automata-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop-util+regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop-util+regex-automata-devel}"
SRC_URI[aarch64_rust-lalrpop-util+regex-automata-devel.sha256sum] = "0de515c7bedb011b2e0e629c9698336ef8d962f62324bd2735bfdb74debd2155"

URI_aarch64_rust-lalrpop-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop-util+std-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop-util+std-devel}"
SRC_URI[aarch64_rust-lalrpop-util+std-devel.sha256sum] = "366777e2b81b5b59af0fe7ea81e86a24e6493261621c44e23770463a206b6859"

URI_aarch64_rust-lalrpop-util+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop-util+unicode-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop-util+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop-util+unicode-devel}"
SRC_URI[aarch64_rust-lalrpop-util+unicode-devel.sha256sum] = "81ea2d526d5da3301e786afcc8ffd411eab7fb1c3ed8dad265dfe8f8e6012cc9"

URI_aarch64_rust-lalrpop-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lalrpop-util-devel-0.22.2-1.el10_2.noarch.rpm;name=aarch64_rust-lalrpop-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lalrpop-util-devel}"
SRC_URI[aarch64_rust-lalrpop-util-devel.sha256sum] = "80e8db3efc625a22210f81d9995ecd26f9ed96f33bbc623f256ce05e12ee094d"

RDEPENDS:rust-lalrpop-util+default-devel = " \
 cargo \
 rust-lalrpop-util+std-devel \
 rust-lalrpop-util+unicode-devel \
 rust-lalrpop-util-devel \
 "
RDEPENDS:rust-lalrpop-util+lexer-devel = " \
 cargo \
 rust-lalrpop-util+regex-automata-devel \
 rust-lalrpop-util-devel \
 "
RDEPENDS:rust-lalrpop-util+regex-automata-devel = " \
 cargo \
 rust-lalrpop-util-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-lalrpop-util+std-devel = " \
 cargo \
 rust-lalrpop-util-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-lalrpop-util+unicode-devel = " \
 cargo \
 rust-lalrpop-util-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-lalrpop-util-devel = " \
 cargo \
 rust \
 rust-rustversion+default-devel \
 "
