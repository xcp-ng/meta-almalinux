# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "senpai"
PV = "0.5.0"
PR = "1.el10_3"
PACKAGES = " \
 senpai \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/senpai-0.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "52544871e5095fba4046880cecb4c5e30b573d18fc271c0cf034422558bd5e21"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/senpai-0.5.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_senpai;unpack=0"
SRC_URI[x86_64_v2_senpai.sha256sum] = "9dc5aad1b7d18c94f275dad8783d64a3d2ead4c5c736250860d7575dd9c55a09"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/senpai-0.5.0-1.el10_3.aarch64.rpm;name=aarch64_senpai;unpack=0"
SRC_URI[aarch64_senpai.sha256sum] = "8e6b13a3baea7f19a6dff5e9e2591b32146c7732d310c34b57a16f6076b7d9b6"

RDEPENDS:senpai = " \
 glibc \
 "
