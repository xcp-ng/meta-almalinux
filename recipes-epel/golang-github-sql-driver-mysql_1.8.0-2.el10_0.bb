# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-sql-driver-mysql"
PV = "1.8.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-sql-driver-mysql-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-sql-driver-mysql-1.8.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6439790fe8a41320e422f3a5c348d361a765e76812977f94f75fd705bbd7e314"

URI_x86_64_v2_golang-github-sql-driver-mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-sql-driver-mysql-devel-1.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-sql-driver-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-sql-driver-mysql-devel}"
SRC_URI[x86_64_v2_golang-github-sql-driver-mysql-devel.sha256sum] = "8d6e32876de69afae53cef9311ae2f067490179d4ba15d40b8b19bc798204b79"

URI_aarch64_golang-github-sql-driver-mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-sql-driver-mysql-devel-1.8.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-sql-driver-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-sql-driver-mysql-devel}"
SRC_URI[aarch64_golang-github-sql-driver-mysql-devel.sha256sum] = "509c88efd3e84978e616bbbbd50689d90760d7b40fe79356b0a7601e9a6969dc"

RDEPENDS:golang-github-sql-driver-mysql-devel = " \
 go-filesystem \
 golang-filippo-edwards25519-devel \
 "
