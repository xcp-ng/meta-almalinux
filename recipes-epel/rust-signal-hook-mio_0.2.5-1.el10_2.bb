# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-signal-hook-mio"
PV = "0.2.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+mio-0_8-devel \
 rust-signal-hook-mio+mio-1_0-devel \
 rust-signal-hook-mio+support-v0_8-devel \
 rust-signal-hook-mio+support-v1_0-devel \
 rust-signal-hook-mio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-signal-hook-mio-0.2.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b160b86af1611cbe06c15e277eadd7a9446d50e45fd575be4d3b7b5bbb2bb8f"

URI_x86_64_v2_rust-signal-hook-mio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+default-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+default-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+default-devel.sha256sum] = "fcbdc3f77374dd4e3b1cc15c6987d30f83fb4f1f4b49dbf2e5c130543fd03190"

URI_x86_64_v2_rust-signal-hook-mio+mio-0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+mio-0_8-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+mio-0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+mio-0_8-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+mio-0_8-devel.sha256sum] = "d7ed7eeb114741c30a6733165fa1d8d9ba39c6bd846ddb81e038768ad5e30426"

URI_x86_64_v2_rust-signal-hook-mio+mio-1_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+mio-1_0-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+mio-1_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+mio-1_0-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+mio-1_0-devel.sha256sum] = "00902ef7d7fcc23829f5d5c6225696dd95410ac9c753e5e28238f6430b66e9e6"

URI_x86_64_v2_rust-signal-hook-mio+support-v0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+support-v0_8-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+support-v0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+support-v0_8-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+support-v0_8-devel.sha256sum] = "18d927205fb4d8f4f934ac508330ced7431a0d00d7111537dcbdbe92f06d28ca"

URI_x86_64_v2_rust-signal-hook-mio+support-v1_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio+support-v1_0-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio+support-v1_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio+support-v1_0-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio+support-v1_0-devel.sha256sum] = "7ca588fa66f646f1a18b7eb0333f62631174473f9edb9b7e5daa7c32f39c5231"

URI_x86_64_v2_rust-signal-hook-mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-signal-hook-mio-devel-0.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-signal-hook-mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-signal-hook-mio-devel}"
SRC_URI[x86_64_v2_rust-signal-hook-mio-devel.sha256sum] = "4c2f36d95abd4bdb8b55d2c6a3d5a19e7953aea4d6c32222784d70a60ddf1c94"

URI_aarch64_rust-signal-hook-mio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+default-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-signal-hook-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+default-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+default-devel.sha256sum] = "c54f518941a763c626fe6fa1cbce56ad933145aae9f0c9f3cdba5fe0e1c2a332"

URI_aarch64_rust-signal-hook-mio+mio-0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+mio-0_8-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-signal-hook-mio+mio-0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+mio-0_8-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+mio-0_8-devel.sha256sum] = "bfc83df96486f6c18e95b3af055711ea0c7a1a12c48555954b8bbe60b2f161c6"

URI_aarch64_rust-signal-hook-mio+mio-1_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+mio-1_0-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-signal-hook-mio+mio-1_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+mio-1_0-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+mio-1_0-devel.sha256sum] = "68b07fc1920618e42ab15f01a6a114d85aaaa4a39d38e8612b2c02605ced97e4"

URI_aarch64_rust-signal-hook-mio+support-v0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+support-v0_8-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-signal-hook-mio+support-v0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+support-v0_8-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+support-v0_8-devel.sha256sum] = "e3e4e3aeb311be943e952323b94ce42b71db7a4ac781a3fbcf21e6443c2cc299"

URI_aarch64_rust-signal-hook-mio+support-v1_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio+support-v1_0-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-signal-hook-mio+support-v1_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio+support-v1_0-devel}"
SRC_URI[aarch64_rust-signal-hook-mio+support-v1_0-devel.sha256sum] = "1d371f0c87221f7f005b2a35809d12b3fd5b4b0de7a26ee109d313dee3bb467c"

URI_aarch64_rust-signal-hook-mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-signal-hook-mio-devel-0.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-signal-hook-mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-signal-hook-mio-devel}"
SRC_URI[aarch64_rust-signal-hook-mio-devel.sha256sum] = "49335c1fb55a0087d028bf43492a8340db2b49612f6f260bd7c3610590f1bb48"

RDEPENDS:rust-signal-hook-mio+default-devel = " \
 cargo \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+mio-0_8-devel = " \
 cargo \
 rust-mio0.8+default-devel \
 rust-mio0.8+net-devel \
 rust-mio0.8+os-ext-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+mio-1_0-devel = " \
 cargo \
 rust-mio+default-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+support-v0_8-devel = " \
 cargo \
 rust-signal-hook-mio+mio-0_8-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio+support-v1_0-devel = " \
 cargo \
 rust-signal-hook-mio+mio-1_0-devel \
 rust-signal-hook-mio-devel \
 "
RDEPENDS:rust-signal-hook-mio-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-signal-hook0.3+default-devel \
 "
