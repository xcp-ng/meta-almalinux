# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-plist"
PV = "1.10.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-plist+default-devel \
 rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel \
 rust-plist+serde-devel \
 rust-plist-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-plist-1.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "938022e99f9a5b11ae682f44cbe3324088cdf3ceb9d0a7fdcba9cbf29843f149"

URI_x86_64_v2_rust-plist+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+default-devel-1.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+default-devel}"
SRC_URI[x86_64_v2_rust-plist+default-devel.sha256sum] = "e148ed540ff3ed34c8269454e40521ca49c304cb881b7ba232a9437328d29311"

URI_x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel-1.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel}"
SRC_URI[x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel.sha256sum] = "4dfc9e2ccc50b48f76c5b2a925d64c39d65eb58aee3e8e16d5faea29c1dd4b32"

URI_x86_64_v2_rust-plist+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+serde-devel-1.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+serde-devel}"
SRC_URI[x86_64_v2_rust-plist+serde-devel.sha256sum] = "de81fec9b5bb1d123878e27c88faee7e623027bc76890b0a9bc58fa177c7b74f"

URI_x86_64_v2_rust-plist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist-devel-1.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist-devel}"
SRC_URI[x86_64_v2_rust-plist-devel.sha256sum] = "f4c638a739ed2365e753ab766be9e537bc914c060a59c92b293a7d9b199376ab"

URI_aarch64_rust-plist+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+default-devel-1.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-plist+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+default-devel}"
SRC_URI[aarch64_rust-plist+default-devel.sha256sum] = "838444da721ce93d8e56667486ffb0aebabdc0ad809169b88a375442fb126fcc"

URI_aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel-1.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel}"
SRC_URI[aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel.sha256sum] = "59ba3d3ba3011d8c6eb3d24012051284b7d8071a68a1f41edb501dede03c1da3"

URI_aarch64_rust-plist+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+serde-devel-1.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-plist+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+serde-devel}"
SRC_URI[aarch64_rust-plist+serde-devel.sha256sum] = "71de34d85a5842849377e68f7888fb40a76e33b7be51991cb5c65a190956b33b"

URI_aarch64_rust-plist-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist-devel-1.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-plist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist-devel}"
SRC_URI[aarch64_rust-plist-devel.sha256sum] = "3de12ad5d81b8109c1eea4d5fcd1dc40f9b073c3ed5e7dffc26fe8c16f136717"

RDEPENDS:rust-plist+default-devel = " \
 cargo \
 rust-plist+serde-devel \
 rust-plist-devel \
 "
RDEPENDS:rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = " \
 cargo \
 rust-plist-devel \
 "
RDEPENDS:rust-plist+serde-devel = " \
 cargo \
 rust-plist-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-plist-devel = " \
 cargo \
 rust \
 rust-base64_0.22+default-devel \
 rust-indexmap+default-devel \
 rust-quick-xml+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 "
