# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crunchy"
PV = "0.2.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-crunchy+default-devel \
 rust-crunchy+limit_1024-devel \
 rust-crunchy+limit_128-devel \
 rust-crunchy+limit_2048-devel \
 rust-crunchy+limit_256-devel \
 rust-crunchy+limit_512-devel \
 rust-crunchy+limit_64-devel \
 rust-crunchy+std-devel \
 rust-crunchy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crunchy-0.2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a04d70898c58d79cf3ff19cde1b1c99c36c4502a0eeb8b5869958bd446b8c74c"

URI_x86_64_v2_rust-crunchy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+default-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+default-devel}"
SRC_URI[x86_64_v2_rust-crunchy+default-devel.sha256sum] = "a3d24e7d5d138b2dfc5c7bb732e679629e79b7ff23800018d6b8c45ee7371df6"

URI_x86_64_v2_rust-crunchy+limit_1024-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_1024-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_1024-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_1024-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_1024-devel.sha256sum] = "37e51c741f98afc31ea938b0fc3d09e6ca5615d267585511ffed14bae6db2ca1"

URI_x86_64_v2_rust-crunchy+limit_128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_128-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_128-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_128-devel.sha256sum] = "b7305f6d1870c09ef295bb7e5f1b1c6e74c28c76a344a5e8ba0a77d7c96bcb1b"

URI_x86_64_v2_rust-crunchy+limit_2048-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_2048-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_2048-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_2048-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_2048-devel.sha256sum] = "cb74e967c662dbe8b60dfad5a47f9605053af6c03b0a70b7a694700385b0f32d"

URI_x86_64_v2_rust-crunchy+limit_256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_256-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_256-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_256-devel.sha256sum] = "d4f5073927e866a7f63ad7fca60c32b77a5931a08328ac9e91d30e5bb356df41"

URI_x86_64_v2_rust-crunchy+limit_512-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_512-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_512-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_512-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_512-devel.sha256sum] = "fd44186434924e184a9aa913b4855735cfdd96e7da0e4ab595945f8803b90f75"

URI_x86_64_v2_rust-crunchy+limit_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+limit_64-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+limit_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+limit_64-devel}"
SRC_URI[x86_64_v2_rust-crunchy+limit_64-devel.sha256sum] = "4f22cf7184d6ba1c574d29f5d837dab7d674ba77b8254c4ac17faf264b81e83c"

URI_x86_64_v2_rust-crunchy+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy+std-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy+std-devel}"
SRC_URI[x86_64_v2_rust-crunchy+std-devel.sha256sum] = "636fb5cd589e7521cdb4718f2397911b40db82d27676a7ef4a9921012f5cd5de"

URI_x86_64_v2_rust-crunchy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crunchy-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crunchy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crunchy-devel}"
SRC_URI[x86_64_v2_rust-crunchy-devel.sha256sum] = "7a87f3a25ebb829d4a761dbd367045ca8b19f38cc724034a1b75d9207183e277"

URI_aarch64_rust-crunchy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+default-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-crunchy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+default-devel}"
SRC_URI[aarch64_rust-crunchy+default-devel.sha256sum] = "26522b280883f49e532669ef270c93fe90f6bc4874c50c48261b9cc935af6d24"

URI_aarch64_rust-crunchy+limit_1024-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_1024-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-crunchy+limit_1024-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_1024-devel}"
SRC_URI[aarch64_rust-crunchy+limit_1024-devel.sha256sum] = "992f52cb77f0a32162ed0ffcac9f3c2cf61696e478209711fecf3f1d735eb7f2"

URI_aarch64_rust-crunchy+limit_128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_128-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-crunchy+limit_128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_128-devel}"
SRC_URI[aarch64_rust-crunchy+limit_128-devel.sha256sum] = "35c8ebdad0d42bf64156abecda2c8a3f9b9c8b29a506990c14835a9467a93007"

URI_aarch64_rust-crunchy+limit_2048-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_2048-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-crunchy+limit_2048-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_2048-devel}"
SRC_URI[aarch64_rust-crunchy+limit_2048-devel.sha256sum] = "9585327e81ae17998c83b9d3099ab9b084986008d5009a704e2e5ad8af087cc7"

URI_aarch64_rust-crunchy+limit_256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_256-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-crunchy+limit_256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_256-devel}"
SRC_URI[aarch64_rust-crunchy+limit_256-devel.sha256sum] = "c9c71f8be5f0837d8d9bfc54584c3e43646cea8aacdf08783947675ab4739e03"

URI_aarch64_rust-crunchy+limit_512-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_512-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-crunchy+limit_512-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_512-devel}"
SRC_URI[aarch64_rust-crunchy+limit_512-devel.sha256sum] = "780d681b094d4352d594f425eb574d508ea66d8e4ced077b7688f1d0be40f6ba"

URI_aarch64_rust-crunchy+limit_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+limit_64-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-crunchy+limit_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+limit_64-devel}"
SRC_URI[aarch64_rust-crunchy+limit_64-devel.sha256sum] = "7069835369307bd071af4af19881844a7dee26867fa5d9462e60d7bdd5706cf2"

URI_aarch64_rust-crunchy+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy+std-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-crunchy+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy+std-devel}"
SRC_URI[aarch64_rust-crunchy+std-devel.sha256sum] = "345c92d5ae6886d2bdd424b2e607a22c02d6f36325526d6da0dc02f7d1639e35"

URI_aarch64_rust-crunchy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crunchy-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-crunchy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crunchy-devel}"
SRC_URI[aarch64_rust-crunchy-devel.sha256sum] = "ab4dd9474abb8b0bb3ccbc872350a1c325b45e16471c47b0c33abe02ce2d4421"

RDEPENDS:rust-crunchy+default-devel = " \
 cargo \
 rust-crunchy+limit_128-devel \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_1024-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_128-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_2048-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_256-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_512-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+limit_64-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy+std-devel = " \
 cargo \
 rust-crunchy-devel \
 "
RDEPENDS:rust-crunchy-devel = " \
 cargo \
 "
