# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-hu"
PV = "1.6.1"
PR = "30.el10"
PACKAGES = " \
 hunspell-hu \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-hu-1.6.1-30.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2cd7cae858c2ba8aefa2acfd4851a5b35ea19f144067276a4199af01dac53249"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-hu-1.6.1-30.el10.noarch.rpm;name=x86_64_v2_hunspell-hu;unpack=0"
SRC_URI[x86_64_v2_hunspell-hu.sha256sum] = "1b1a9808c539068ea5ddacacc3feef63fb573ca80b3f02ac2e4dd86bfd7ee789"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-hu-1.6.1-30.el10.noarch.rpm;name=aarch64_hunspell-hu;unpack=0"
SRC_URI[aarch64_hunspell-hu.sha256sum] = "1b1a9808c539068ea5ddacacc3feef63fb573ca80b3f02ac2e4dd86bfd7ee789"

RDEPENDS:hunspell-hu = " \
 hunspell-filesystem \
 "
