# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alertmanager"
PV = "0.33.0"
PR = "1.el10_3"
PACKAGES = " \
 alertmanager \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alertmanager-0.33.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f56efa2003bd053006f3f9c140290cc2866491eccadf77505806397805dc4a6d"

URI_x86_64_v2_alertmanager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alertmanager-0.33.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alertmanager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alertmanager}"
SRC_URI[x86_64_v2_alertmanager.sha256sum] = "486a789deed0e670b5c824e0fcf95f677306cb35f4fc3a40062e48e5ffdbd1f5"

URI_aarch64_alertmanager = "${EPEL_MIRROR}/aarch64/Packages/a/alertmanager-0.33.0-1.el10_3.aarch64.rpm;name=aarch64_alertmanager;unpack=0"
SRC_URI:append = " ${URI_aarch64_alertmanager}"
SRC_URI[aarch64_alertmanager.sha256sum] = "462a4c3a9eca41c9c9f2772cf3ba4c11cf1d48ecfd5d29f8605054f69eb4bd8b"

RDEPENDS:alertmanager = " \
 bash \
 glibc \
 shadow-utils \
 "
