# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kinfocenter"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 kinfocenter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kinfocenter-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaf67d22e4088b24ecef952f852d24550caa971ee016f9ef978087cd40cb270d"

URI_x86_64_v2_kinfocenter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kinfocenter-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kinfocenter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kinfocenter}"
SRC_URI[x86_64_v2_kinfocenter.sha256sum] = "3f037ff739396874665f2c3b39f81b0f8afc3fdb457c26ef9ba3f513e4eb3526"

URI_aarch64_kinfocenter = "${EPEL_MIRROR}/aarch64/Packages/k/kinfocenter-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kinfocenter;unpack=0"
SRC_URI:append = " ${URI_aarch64_kinfocenter}"
SRC_URI[aarch64_kinfocenter.sha256sum] = "bb53c1e2f8f3ccdc0d70eb9a139e4de9d457c709bf7b1898de70189da3d6b543"

RDEPENDS:kinfocenter = " \
 aha \
 clinfo \
 dmidecode \
 egl-utils \
 fwupd \
 glibc \
 hwdata \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kservice \
 kf6-solid \
 libdisplay-info-tools \
 libdrm \
 libstdc++ \
 libusb1 \
 plasma-systemsettings \
 pulseaudio-utils \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 vulkan-tools \
 wayland-utils \
 "
