# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scap-security-guide"
PV = "0.1.81"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 scap-security-guide \
 scap-security-guide-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/scap-security-guide-0.1.81-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7c2476af78500dca7c61dac636f88fa7db099535b0572a947ed6db0d0ff6499"

URI_x86_64_v2_scap-security-guide = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-0.1.81-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scap-security-guide}"
SRC_URI[x86_64_v2_scap-security-guide.sha256sum] = "9ea3431dc337f8b627b334d5262cde626851b48867aeefb4c739b8f872d4e4eb"

URI_x86_64_v2_scap-security-guide-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-doc-0.1.81-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scap-security-guide-doc}"
SRC_URI[x86_64_v2_scap-security-guide-doc.sha256sum] = "8ceeb0ee06b9ae33e2b4725a55e665c5dfd2af55b6cda21ed4dff32a49d6faea"

URI_aarch64_scap-security-guide = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-0.1.81-1.el10_2.alma.1.noarch.rpm;name=aarch64_scap-security-guide;unpack=0"
SRC_URI:append = " ${URI_aarch64_scap-security-guide}"
SRC_URI[aarch64_scap-security-guide.sha256sum] = "9ea3431dc337f8b627b334d5262cde626851b48867aeefb4c739b8f872d4e4eb"

URI_aarch64_scap-security-guide-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-doc-0.1.81-1.el10_2.alma.1.noarch.rpm;name=aarch64_scap-security-guide-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scap-security-guide-doc}"
SRC_URI[aarch64_scap-security-guide-doc.sha256sum] = "8ceeb0ee06b9ae33e2b4725a55e665c5dfd2af55b6cda21ed4dff32a49d6faea"

RDEPENDS:scap-security-guide = " \
 openscap-scanner \
 xml-common \
 "
RDEPENDS:scap-security-guide-doc = " \
 scap-security-guide \
 "
