# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rstest_reuse"
PV = "0.7.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rstest_reuse+default-devel \
 rust-rstest_reuse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rstest_reuse-0.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a9d7a0d0988d9714d3c3bbcd2a6ddd5481f30cd463b1dfe0bd6d31ae1d0c959"

URI_x86_64_v2_rust-rstest_reuse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_reuse+default-devel-0.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_reuse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_reuse+default-devel}"
SRC_URI[x86_64_v2_rust-rstest_reuse+default-devel.sha256sum] = "65bf3f6cc2c4d74c6418941940b850d236ef549f39a87f703ecd458864ef5537"

URI_x86_64_v2_rust-rstest_reuse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rstest_reuse-devel-0.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rstest_reuse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rstest_reuse-devel}"
SRC_URI[x86_64_v2_rust-rstest_reuse-devel.sha256sum] = "57ed20c4a0df0ebb0a8c9bc638f03dd020cbaae69248f5531e9d76c8a90860ac"

URI_aarch64_rust-rstest_reuse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_reuse+default-devel-0.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest_reuse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_reuse+default-devel}"
SRC_URI[aarch64_rust-rstest_reuse+default-devel.sha256sum] = "2956561f963be1f061368a8c08a0ef8cc4ecb4c7aa2c5c0c1e5a49661b50b458"

URI_aarch64_rust-rstest_reuse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rstest_reuse-devel-0.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-rstest_reuse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rstest_reuse-devel}"
SRC_URI[aarch64_rust-rstest_reuse-devel.sha256sum] = "01f5467a2726b920b2be7c717b6fcca18da6ebda365fdbbde2dde40ed3784c6a"

RDEPENDS:rust-rstest_reuse+default-devel = " \
 cargo \
 rust-rstest_reuse-devel \
 "
RDEPENDS:rust-rstest_reuse-devel = " \
 cargo \
 rust \
 rust-quote+default-devel \
 rust-rand0.8+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
