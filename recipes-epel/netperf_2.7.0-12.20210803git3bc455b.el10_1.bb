# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netperf"
PV = "2.7.0"
PR = "12.20210803git3bc455b.el10_1"
PACKAGES = " \
 netperf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netperf-2.7.0-12.20210803git3bc455b.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8976671ba9abc9801efcfcd89fe63ed2d11d01d5184ff8cb44a43e31d57d5f28"

URI_aarch64_netperf = "${EPEL_MIRROR}/aarch64/Packages/n/netperf-2.7.0-12.20210803git3bc455b.el10_1.aarch64.rpm;name=aarch64_netperf;unpack=0"
SRC_URI:append = " ${URI_aarch64_netperf}"
SRC_URI[aarch64_netperf.sha256sum] = "f3335323f986577468c19ddb4067aad9a5d95fe3cc33375b2617e4a478b3fa1f"

RDEPENDS:netperf = " \
 bash \
 glibc \
 lksctp-tools \
 "
