# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Gtk3-ImageView"
PV = "12"
PR = "3.el10_0"
PACKAGES = " \
 perl-Gtk3-ImageView \
 perl-Gtk3-ImageView-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Gtk3-ImageView-12-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cc0288dd21f3a5530adada69dd19bc359f359475f707d0621a0127ffbc80000"

URI_x86_64_v2_perl-Gtk3-ImageView = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-ImageView-12-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-ImageView;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-ImageView}"
SRC_URI[x86_64_v2_perl-Gtk3-ImageView.sha256sum] = "56a5db78d331a868e78a304eb062dac9f2f2b94a3ad8ba160714a45d12635ee2"

URI_x86_64_v2_perl-Gtk3-ImageView-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-ImageView-tests-12-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-ImageView-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-ImageView-tests}"
SRC_URI[x86_64_v2_perl-Gtk3-ImageView-tests.sha256sum] = "a609cc556999a8e20103492b74725e604412ef88c328e70cd46dd20d7ae21234"

URI_aarch64_perl-Gtk3-ImageView = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-ImageView-12-3.el10_0.noarch.rpm;name=aarch64_perl-Gtk3-ImageView;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-ImageView}"
SRC_URI[aarch64_perl-Gtk3-ImageView.sha256sum] = "3523cf8f0ad48fedc46609d2ebe4b69aca66ecc15fd62568a647d9c91a0b8f39"

URI_aarch64_perl-Gtk3-ImageView-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-ImageView-tests-12-3.el10_0.noarch.rpm;name=aarch64_perl-Gtk3-ImageView-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-ImageView-tests}"
SRC_URI[aarch64_perl-Gtk3-ImageView-tests.sha256sum] = "6cf553ae6ac51b8a97c693c83ddcdc442fa99b9a96a9e3888ad3484d4feb07e0"

RDEPENDS:perl-Gtk3-ImageView = " \
 perl-Cairo \
 perl-Carp \
 perl-Glib \
 perl-Gtk3 \
 perl-Gtk3-ImageView \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-base \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-Gtk3-ImageView-tests = " \
 ImageMagick-perl \
 bash \
 mutter \
 perl-Carp-Always \
 perl-ExtUtils-MakeMaker \
 perl-File-Temp \
 perl-Glib \
 perl-Gtk3 \
 perl-Gtk3-ImageView \
 perl-MIME-Base64 \
 perl-PathTools \
 perl-Test-Deep \
 perl-Test-Harness \
 perl-Test-MockObject \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 virtual/coreutils \
 xwayland-run \
 "
