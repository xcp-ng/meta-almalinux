# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cscppc"
PV = "2.2.6"
PR = "2.el10_0"
PACKAGES = " \
 csclng \
 cscppc \
 csgcca \
 csmatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cscppc-2.2.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a30afdbcde683fb4d2235de34bc5f6f49c24d4b785735b2c8df49cfd9e85fd61"

URI_x86_64_v2_csclng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csclng-2.2.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csclng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csclng}"
SRC_URI[x86_64_v2_csclng.sha256sum] = "7883dc1ac3dda1b23a7b3b2bb09f328a8dc5874a24cd8314f53d9be7ee22f3e0"

URI_x86_64_v2_cscppc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cscppc-2.2.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cscppc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cscppc}"
SRC_URI[x86_64_v2_cscppc.sha256sum] = "9b7a9cfcad88e2b1ce495d334592ebbed74a318c68ce5c21cb9efba95c8b8db7"

URI_x86_64_v2_csgcca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csgcca-2.2.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csgcca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csgcca}"
SRC_URI[x86_64_v2_csgcca.sha256sum] = "f7043d9344682fd734a5bc84a088920a943653ce8fa0ffc2d430be16f413a9ae"

URI_x86_64_v2_csmatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csmatch-2.2.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csmatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_csmatch}"
SRC_URI[x86_64_v2_csmatch.sha256sum] = "7f9ae0937428270202acf14f3b15a014f1f3bf37ea5a73a901e1265ae1fcbe27"

URI_aarch64_csclng = "${EPEL_MIRROR}/aarch64/Packages/c/csclng-2.2.6-2.el10_0.aarch64.rpm;name=aarch64_csclng;unpack=0"
SRC_URI:append = " ${URI_aarch64_csclng}"
SRC_URI[aarch64_csclng.sha256sum] = "3ae77ac3ffc5017c9d3258aad191f1e4c458bc0bcb989d402bbee13faacd7c09"

URI_aarch64_cscppc = "${EPEL_MIRROR}/aarch64/Packages/c/cscppc-2.2.6-2.el10_0.aarch64.rpm;name=aarch64_cscppc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cscppc}"
SRC_URI[aarch64_cscppc.sha256sum] = "bfb41e05a58555553e0416352e9ccca721d7fd2689f83b1c1f2fcf7da5f27cb2"

URI_aarch64_csgcca = "${EPEL_MIRROR}/aarch64/Packages/c/csgcca-2.2.6-2.el10_0.aarch64.rpm;name=aarch64_csgcca;unpack=0"
SRC_URI:append = " ${URI_aarch64_csgcca}"
SRC_URI[aarch64_csgcca.sha256sum] = "9c7cb4dbde73fbc051d7d3b3ed143d19dff29b927ba8b630b8bb00a961967a3d"

URI_aarch64_csmatch = "${EPEL_MIRROR}/aarch64/Packages/c/csmatch-2.2.6-2.el10_0.aarch64.rpm;name=aarch64_csmatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_csmatch}"
SRC_URI[aarch64_csmatch.sha256sum] = "4cada433f6d96739d2a36dd9365c2fa737ff0d3f414a2c4d2a78efaeaf6a5e1c"

RDEPENDS:csclng = " \
 clang \
 glibc \
 "
RDEPENDS:cscppc = " \
 glibc \
 "
RDEPENDS:csgcca = " \
 gcc \
 glibc \
 "
RDEPENDS:csmatch = " \
 glibc \
 "
