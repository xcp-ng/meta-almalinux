# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "boom-boot"
PV = "1.6.5"
PR = "3.el10"
PACKAGES = " \
 boom-boot \
 boom-boot-conf \
 python3-boom \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/boom-boot-1.6.5-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f560f1bdcd50e20ec886dfbe02645d43b9dbb2b6801536b53e2e2eac2c484c9"

URI_x86_64_v2_boom-boot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boom-boot-1.6.5-3.el10.noarch.rpm;name=x86_64_v2_boom-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boom-boot}"
SRC_URI[x86_64_v2_boom-boot.sha256sum] = "254212b17a73cfc951a0d1159add8bbf74256a938eb9c00e006a358458c3335a"

URI_x86_64_v2_boom-boot-conf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/boom-boot-conf-1.6.5-3.el10.noarch.rpm;name=x86_64_v2_boom-boot-conf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_boom-boot-conf}"
SRC_URI[x86_64_v2_boom-boot-conf.sha256sum] = "da4550a7cfd5ac28ac680c0171c76904d5cb67d0e230cb19eb5be4bd7937b6b5"

URI_x86_64_v2_python3-boom = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-boom-1.6.5-3.el10.noarch.rpm;name=x86_64_v2_python3-boom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-boom}"
SRC_URI[x86_64_v2_python3-boom.sha256sum] = "c805b7fd2232b0a464192280276243085c4df05a4592378eaa603aa0c830c6d9"

URI_aarch64_boom-boot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boom-boot-1.6.5-3.el10.noarch.rpm;name=aarch64_boom-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_boom-boot}"
SRC_URI[aarch64_boom-boot.sha256sum] = "254212b17a73cfc951a0d1159add8bbf74256a938eb9c00e006a358458c3335a"

URI_aarch64_boom-boot-conf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/boom-boot-conf-1.6.5-3.el10.noarch.rpm;name=aarch64_boom-boot-conf;unpack=0"
SRC_URI:append = " ${URI_aarch64_boom-boot-conf}"
SRC_URI[aarch64_boom-boot-conf.sha256sum] = "da4550a7cfd5ac28ac680c0171c76904d5cb67d0e230cb19eb5be4bd7937b6b5"

URI_aarch64_python3-boom = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-boom-1.6.5-3.el10.noarch.rpm;name=aarch64_python3-boom;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-boom}"
SRC_URI[aarch64_python3-boom.sha256sum] = "c805b7fd2232b0a464192280276243085c4df05a4592378eaa603aa0c830c6d9"

RDEPENDS:boom-boot = " \
 boom-boot-conf \
 python3 \
 python3-boom \
 python3-dbus \
 systemd \
 "
RDEPENDS:boom-boot-conf = " \
 "
RDEPENDS:python3-boom = " \
 python3 \
 python3-dbus \
 "
