# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rfc3986"
PV = "2.0.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-rfc3986 \
 python3-rfc3986+idna2008 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rfc3986-2.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21a679452ac82fb0692e499800315e4c1576ce1a6d1e950628a96b48caaf559b"

URI_x86_64_v2_python3-rfc3986 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rfc3986-2.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rfc3986;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rfc3986}"
SRC_URI[x86_64_v2_python3-rfc3986.sha256sum] = "a5e96eed9d390fbc56e49f34334ce72a28157173c92eba18cb8f9be59f7b823e"

URI_x86_64_v2_python3-rfc3986+idna2008 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rfc3986+idna2008-2.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rfc3986+idna2008;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rfc3986+idna2008}"
SRC_URI[x86_64_v2_python3-rfc3986+idna2008.sha256sum] = "bf33e270e1cb8ec892c4ebfa7ab9f0ea554770390b508c164922faca4f324d64"

URI_aarch64_python3-rfc3986 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rfc3986-2.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-rfc3986;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rfc3986}"
SRC_URI[aarch64_python3-rfc3986.sha256sum] = "0a9c3896c563db9775c6ad1fac03fdb01136659e9dc76cacbdb00e18e8eef324"

URI_aarch64_python3-rfc3986+idna2008 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rfc3986+idna2008-2.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-rfc3986+idna2008;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rfc3986+idna2008}"
SRC_URI[aarch64_python3-rfc3986+idna2008.sha256sum] = "7f3347803a50dde4a59bc2e17311b26c4368b4200c7a0c9cb90cefa22d3aed04"

RDEPENDS:python3-rfc3986 = " \
 python3 \
 "
RDEPENDS:python3-rfc3986+idna2008 = " \
 python3 \
 python3-idna \
 python3-rfc3986 \
 "
