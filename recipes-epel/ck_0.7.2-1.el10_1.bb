# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ck"
PV = "0.7.2"
PR = "1.el10_1"
PACKAGES = " \
 ck \
 ck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/ck-0.7.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b6fd428dcf535f835e6a05f93f2cb76a35ac4bd1c9f803bc61e1a82c84aae03"

URI_x86_64_v2_ck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ck-0.7.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ck}"
SRC_URI[x86_64_v2_ck.sha256sum] = "00b1cdc344a09ce0e5645450ee0c3839285d8f95f9ee2cba310fee37d65df99d"

URI_x86_64_v2_ck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ck-devel-0.7.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ck-devel}"
SRC_URI[x86_64_v2_ck-devel.sha256sum] = "e5c84ec4cc004d8d9ae4568e7fc5a08364d5165ccad7ccf32f220a0fb393d7d9"

URI_aarch64_ck = "${EPEL_MIRROR}/aarch64/Packages/c/ck-0.7.2-1.el10_1.aarch64.rpm;name=aarch64_ck;unpack=0"
SRC_URI:append = " ${URI_aarch64_ck}"
SRC_URI[aarch64_ck.sha256sum] = "a9adfb563a34ccc2bd355db027ee68e63ba99c9148649bfe837f4cd06189314e"

URI_aarch64_ck-devel = "${EPEL_MIRROR}/aarch64/Packages/c/ck-devel-0.7.2-1.el10_1.aarch64.rpm;name=aarch64_ck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ck-devel}"
SRC_URI[aarch64_ck-devel.sha256sum] = "f2281599b39ab982f7b6e51e84412b2f42a5bd6ec5bbe534101147880f05ab6e"

RDEPENDS:ck = " \
 glibc \
 "
RDEPENDS:ck-devel = " \
 ck \
 pkgconf-pkg-config \
 "
