# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libspnav"
PV = "1.1"
PR = "1.el10_0"
PACKAGES = " \
 libspnav \
 libspnav-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libspnav-1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9055192e2398dc0bd6cf85551cbdd608c40bac43dc0746f42a9dd15126534815"

URI_x86_64_v2_libspnav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libspnav-1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libspnav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspnav}"
SRC_URI[x86_64_v2_libspnav.sha256sum] = "5ed655532feba9104ff7d314c675868cb05df19bac3a6b1cb42b7771b4856688"

URI_x86_64_v2_libspnav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libspnav-devel-1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libspnav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libspnav-devel}"
SRC_URI[x86_64_v2_libspnav-devel.sha256sum] = "b623355bce0057a2c6ee82fe4a5ce6bc068f4a9170a776221bfd7b7e361bee69"

URI_aarch64_libspnav = "${EPEL_MIRROR}/aarch64/Packages/l/libspnav-1.1-1.el10_0.aarch64.rpm;name=aarch64_libspnav;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspnav}"
SRC_URI[aarch64_libspnav.sha256sum] = "2fdda0d920145046e39c64547200e0442fee85cd05fe668a28a2223f038b04bd"

URI_aarch64_libspnav-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libspnav-devel-1.1-1.el10_0.aarch64.rpm;name=aarch64_libspnav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libspnav-devel}"
SRC_URI[aarch64_libspnav-devel.sha256sum] = "b86dbbda6c373149dcbce936861a13b8a9d331526651227afeb9d87f4d94679e"

RDEPENDS:libspnav = " \
 glibc \
 libX11 \
 "
RDEPENDS:libspnav-devel = " \
 libX11-devel \
 libspnav \
 pkgconf-pkg-config \
 "
