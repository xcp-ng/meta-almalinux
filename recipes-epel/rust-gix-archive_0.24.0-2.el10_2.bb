# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-archive"
PV = "0.24.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-gix-archive+default-devel \
 rust-gix-archive+document-features-devel \
 rust-gix-archive+tar-devel \
 rust-gix-archive+tar_gz-devel \
 rust-gix-archive+zip-devel \
 rust-gix-archive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-archive-0.24.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "341b489d82a8237100340d2ff72e3ab3dd5beee6513d4d9eeafab442afe2f2d5"

URI_x86_64_v2_rust-gix-archive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+default-devel-0.24.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+default-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+default-devel.sha256sum] = "7939a8bf9b45c9651a693f78f20e4bbfd9b4237ee18b4ca249f8e4eeabc9b0e6"

URI_x86_64_v2_rust-gix-archive+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+document-features-devel-0.24.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+document-features-devel.sha256sum] = "27261165ea369b8cef7230d044646809f8c604e9574d091b44491961fd211762"

URI_x86_64_v2_rust-gix-archive+tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+tar-devel-0.24.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+tar-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+tar-devel.sha256sum] = "58ba90e4069577d2336cf49cb6c68281d4f934828579e83520fd57688118dcdb"

URI_x86_64_v2_rust-gix-archive+tar_gz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+tar_gz-devel-0.24.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+tar_gz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+tar_gz-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+tar_gz-devel.sha256sum] = "2ab2e1c6802e6d68b9d5d256314352d8fa033aa5e9c90ccfc499e525a60608f2"

URI_x86_64_v2_rust-gix-archive+zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive+zip-devel-0.24.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive+zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive+zip-devel}"
SRC_URI[x86_64_v2_rust-gix-archive+zip-devel.sha256sum] = "3ef91d5fe08d7dd1ec36904172cb3946b82c21a0cbf03b7caa94aae7fbbcb720"

URI_x86_64_v2_rust-gix-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-archive-devel-0.24.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-archive-devel}"
SRC_URI[x86_64_v2_rust-gix-archive-devel.sha256sum] = "0edad58b26a405094f498d46452bd46f27435ddc472a48d0a00ea168b7138a03"

URI_aarch64_rust-gix-archive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+default-devel-0.24.0-2.el10_2.noarch.rpm;name=aarch64_rust-gix-archive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+default-devel}"
SRC_URI[aarch64_rust-gix-archive+default-devel.sha256sum] = "f1c82c71ff00b1a4d0bbae4a085f7db7909957f883ebad249866eb82dc165ee5"

URI_aarch64_rust-gix-archive+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+document-features-devel-0.24.0-2.el10_2.noarch.rpm;name=aarch64_rust-gix-archive+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+document-features-devel}"
SRC_URI[aarch64_rust-gix-archive+document-features-devel.sha256sum] = "d30776f1c75aa65f8d96a1f1abb64c9be4242fa8c3cd04625bb6a016cbcff693"

URI_aarch64_rust-gix-archive+tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+tar-devel-0.24.0-2.el10_2.noarch.rpm;name=aarch64_rust-gix-archive+tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+tar-devel}"
SRC_URI[aarch64_rust-gix-archive+tar-devel.sha256sum] = "60cc8a9f83c1e343d17353a2a3a62c7a329863d5a99aa894e1dc1d91f7436832"

URI_aarch64_rust-gix-archive+tar_gz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+tar_gz-devel-0.24.0-2.el10_2.noarch.rpm;name=aarch64_rust-gix-archive+tar_gz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+tar_gz-devel}"
SRC_URI[aarch64_rust-gix-archive+tar_gz-devel.sha256sum] = "a26a92d6a42eb77c8dfbe45aeb4d075a3366e2c78464a24e509ad4e57bdfdc86"

URI_aarch64_rust-gix-archive+zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive+zip-devel-0.24.0-2.el10_2.noarch.rpm;name=aarch64_rust-gix-archive+zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive+zip-devel}"
SRC_URI[aarch64_rust-gix-archive+zip-devel.sha256sum] = "45b8f25866b33213613fa1a9657f016dface0223bb368972f36227982097b1a7"

URI_aarch64_rust-gix-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-archive-devel-0.24.0-2.el10_2.noarch.rpm;name=aarch64_rust-gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-archive-devel}"
SRC_URI[aarch64_rust-gix-archive-devel.sha256sum] = "97207fbfbfe3ad7c8bd66cf30d157560ca86e6440089ee7af94b6fa483b18c32"

RDEPENDS:rust-gix-archive+default-devel = " \
 cargo \
 rust-gix-archive+tar-devel \
 rust-gix-archive+tar_gz-devel \
 rust-gix-archive+zip-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+tar-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-path+default-devel \
 rust-tar+default-devel \
 "
RDEPENDS:rust-gix-archive+tar_gz-devel = " \
 cargo \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-gix-archive+tar-devel \
 rust-gix-archive-devel \
 "
RDEPENDS:rust-gix-archive+zip-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-gix-archive-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-object+default-devel \
 rust-gix-worktree-stream+default-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-thiserror+default-devel \
 "
