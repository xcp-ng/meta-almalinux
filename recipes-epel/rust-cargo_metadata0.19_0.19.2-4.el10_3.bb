# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata0.19"
PV = "0.19.2"
PR = "4.el10_3"
PACKAGES = " \
 rust-cargo_metadata0.19+builder-devel \
 rust-cargo_metadata0.19+default-devel \
 rust-cargo_metadata0.19+derive_builder-devel \
 rust-cargo_metadata0.19-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata0.19-0.19.2-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b6315992e7534a029e088a0787d371b1b7a2249ffb1912497e571564ee12736"

URI_x86_64_v2_rust-cargo_metadata0.19+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.19+builder-devel-0.19.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.19+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.19+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.19+builder-devel.sha256sum] = "da65c41bcce04a4acd52ea34ac51db875979127b1c42c3d637577ae418b487ff"

URI_x86_64_v2_rust-cargo_metadata0.19+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.19+default-devel-0.19.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.19+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.19+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.19+default-devel.sha256sum] = "fef0cec3e552bde4ee1dbe084e3bd1c88a5273f95c8e6286524d5266fee969f0"

URI_x86_64_v2_rust-cargo_metadata0.19+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.19+derive_builder-devel-0.19.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.19+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.19+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.19+derive_builder-devel.sha256sum] = "55be736c1eb79d26f820a3ec21c95acb7c34b16df4be0903c54945c66d1a7f60"

URI_x86_64_v2_rust-cargo_metadata0.19-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.19-devel-0.19.2-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.19-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.19-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.19-devel.sha256sum] = "cd83d92fb60c63ec82e6ccd9ba7bb5327d06d0341191b55edbdd95d868e093f5"

URI_aarch64_rust-cargo_metadata0.19+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.19+builder-devel-0.19.2-4.el10_3.noarch.rpm;name=aarch64_rust-cargo_metadata0.19+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.19+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.19+builder-devel.sha256sum] = "4fa8268ce670ee534ae943206ef16fc2ef585ed5ee9f09f3ebaeaf20a91abd73"

URI_aarch64_rust-cargo_metadata0.19+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.19+default-devel-0.19.2-4.el10_3.noarch.rpm;name=aarch64_rust-cargo_metadata0.19+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.19+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.19+default-devel.sha256sum] = "d2f906630a6e0251e4dc537f7ca3a5850051a2564d7d988577864bb1da630844"

URI_aarch64_rust-cargo_metadata0.19+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.19+derive_builder-devel-0.19.2-4.el10_3.noarch.rpm;name=aarch64_rust-cargo_metadata0.19+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.19+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.19+derive_builder-devel.sha256sum] = "e5b6d81020275ebbdd45c1190532fe96dc0b2d8ea4dfaec92689f48e76bfcd65"

URI_aarch64_rust-cargo_metadata0.19-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.19-devel-0.19.2-4.el10_3.noarch.rpm;name=aarch64_rust-cargo_metadata0.19-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.19-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.19-devel.sha256sum] = "ee049db73be957cb647745a20001d0e39b7da30848e7ec3415add162aec88b9f"

RDEPENDS:rust-cargo_metadata0.19+builder-devel = " \
 cargo \
 rust-cargo_metadata0.19+derive_builder-devel \
 rust-cargo_metadata0.19-devel \
 "
RDEPENDS:rust-cargo_metadata0.19+default-devel = " \
 cargo \
 rust-cargo_metadata0.19-devel \
 "
RDEPENDS:rust-cargo_metadata0.19+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata0.19-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata0.19-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform0.1+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror+default-devel \
 "
