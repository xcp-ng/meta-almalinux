# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-scanner"
PV = "0.31.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-wayland-scanner+default-devel \
 rust-wayland-scanner-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-scanner-0.31.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c12ae0ee5ee1790f9af173c83714a6d12d7baf2ffe93113f44e38a9f0363064f"

URI_x86_64_v2_rust-wayland-scanner+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner+default-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-scanner+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-scanner+default-devel.sha256sum] = "99af4422d577a6d322104531f8a5ac8008f2d2cc2e91e712cf0984b88766f1da"

URI_x86_64_v2_rust-wayland-scanner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner-devel-0.31.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-scanner-devel}"
SRC_URI[x86_64_v2_rust-wayland-scanner-devel.sha256sum] = "f0a455c1b4fbad901f15ee8655c5e6b53901bfb8ff44db3213a7d98bfefd1048"

URI_aarch64_rust-wayland-scanner+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner+default-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-scanner+default-devel}"
SRC_URI[aarch64_rust-wayland-scanner+default-devel.sha256sum] = "6ecf6f531b11d9108fb1f2072c8c9d15be9524f8fdb0c9fe96137dbf9f31167b"

URI_aarch64_rust-wayland-scanner-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner-devel-0.31.8-1.el10_1.noarch.rpm;name=aarch64_rust-wayland-scanner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-scanner-devel}"
SRC_URI[aarch64_rust-wayland-scanner-devel.sha256sum] = "8489b9875c7f44a2c1f9621573bf244dd1eb6a71cd5b159761fbfb70255c47e8"

RDEPENDS:rust-wayland-scanner+default-devel = " \
 cargo \
 rust-wayland-scanner-devel \
 "
RDEPENDS:rust-wayland-scanner-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quick-xml+default-devel \
 rust-quote+default-devel \
 "
