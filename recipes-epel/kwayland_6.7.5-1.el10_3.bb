# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwayland"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 kwayland \
 kwayland-devel \
 kwayland-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kwayland-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "92f520f0a31d432b9204280be0f098a7af1018c931e023882b36f025534ee33e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland;unpack=0"
SRC_URI[x86_64_v2_kwayland.sha256sum] = "7b259535f7bc73d2fa885a74f10bba2de9b5709f45b91f6ea24388d868294038"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwayland-devel;unpack=0"
SRC_URI[x86_64_v2_kwayland-devel.sha256sum] = "a72dedc20445e8a2bdf8ac5c21b39599ac22758a79006a99977b04db19f99fe2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwayland-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kwayland-doc;unpack=0"
SRC_URI[x86_64_v2_kwayland-doc.sha256sum] = "99e03c383cfd79866e99a5871c9d3956be301e77ec74818252b47f299c895313"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwayland-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kwayland;unpack=0"
SRC_URI[aarch64_kwayland.sha256sum] = "b05c35f43d79d9053b3a55222e180df14612e8d57be50b6fcac225672e65ba88"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwayland-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_kwayland-devel;unpack=0"
SRC_URI[aarch64_kwayland-devel.sha256sum] = "efbd3953e2906dabb6170985d3d778309bd300362ae31c25fface7a305d36c77"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwayland-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_kwayland-doc;unpack=0"
SRC_URI[aarch64_kwayland-doc.sha256sum] = "4733fbb44f0fa06abbc29e9157b56eabb960ed120371519447f4ed74ddad8d00"

RDEPENDS:kwayland = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kwayland-devel = " \
 cmake-filesystem \
 kwayland \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kwayland-doc = " \
 "
