# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bitstream"
PV = "1.6"
PR = "1.el10_2"
PACKAGES = " \
 bitstream-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bitstream-1.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7ddf09af42327dec1606fc43ab50b7203fc7835207a62a31346d02833362cd05"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bitstream-devel-1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bitstream-devel;unpack=0"
SRC_URI[x86_64_v2_bitstream-devel.sha256sum] = "77e00fe94a79f5706342cc3b82dd8cffdc59e275ac4249cfd0ae19b872a16b14"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bitstream-devel-1.6-1.el10_2.noarch.rpm;name=aarch64_bitstream-devel;unpack=0"
SRC_URI[aarch64_bitstream-devel.sha256sum] = "087d9b78caf8699ee9685c599961f3fc8923df376e96ceeb909d71985a9ce4fa"

RDEPENDS:bitstream-devel = " \
 pkgconf-pkg-config \
 "
