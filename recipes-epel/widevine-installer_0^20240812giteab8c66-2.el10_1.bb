# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "widevine-installer"
PV = "0^20240812giteab8c66"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
  \
"
PACKAGES:aarch64 = " \
 widevine-installer \
"

URI_src = "${EPELSRC_MIRROR}/Packages/w/widevine-installer-0^20240812giteab8c66-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a52c0ea9136b289ac9752e8bbba44519dec21038170280ffa6ec1a705078bf5b"

URI_aarch64_widevine-installer = "${EPEL_MIRROR}/aarch64/Packages/w/widevine-installer-0^20240812giteab8c66-2.el10_1.aarch64.rpm;name=aarch64_widevine-installer;unpack=0"
SRC_URI:append = " ${URI_aarch64_widevine-installer}"
SRC_URI[aarch64_widevine-installer.sha256sum] = "49749a86b33189b9dcc5f8cdb1accd4bd0e6e678745ae8e07e44523dd0c46b06"

RDEPENDS:widevine-installer = " \
 bash \
 curl \
 glibc \
 python3 \
 setup \
 squashfs-tools \
 systemd \
 virtual/coreutils \
 "
