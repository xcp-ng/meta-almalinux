# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_decimal_data"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_decimal_data+default-devel \
 rust-icu_decimal_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_decimal_data-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96a9319b0e5f08e33f0db96bdf5d52cc479baeed9d8ff03ff87acc27aa3aab61"

URI_x86_64_v2_rust-icu_decimal_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal_data+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal_data+default-devel.sha256sum] = "af619428b9585b2f51aced4fc43023c5394630c2502951f52ab2fd12ac2cac11"

URI_x86_64_v2_rust-icu_decimal_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_decimal_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_decimal_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_decimal_data-devel}"
SRC_URI[x86_64_v2_rust-icu_decimal_data-devel.sha256sum] = "eb3ae8ef63f2a646319324e134f85fdb94090ae9a6c8d892062271d79b5d40b0"

URI_aarch64_rust-icu_decimal_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal_data+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal_data+default-devel}"
SRC_URI[aarch64_rust-icu_decimal_data+default-devel.sha256sum] = "feeb3c577695d3d03705d91a76d629ed4b1a8b100b46349552862bab93ee0bd4"

URI_aarch64_rust-icu_decimal_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_decimal_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_decimal_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_decimal_data-devel}"
SRC_URI[aarch64_rust-icu_decimal_data-devel.sha256sum] = "101e202af3851992e14ff8cb1959dd0c2469a44c56d291413120cc9818af78ba"

RDEPENDS:rust-icu_decimal_data+default-devel = " \
 cargo \
 rust-icu_decimal_data-devel \
 "
RDEPENDS:rust-icu_decimal_data-devel = " \
 cargo \
 rust \
 "
