# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fetch-crl"
PV = "3.0.25"
PR = "1.el10_3"
PACKAGES = " \
 fetch-crl \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fetch-crl-3.0.25-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b9e098ed70d0746fd455793dbb6e79efc2fc1f68e5e0e735da50e6f711420f18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fetch-crl-3.0.25-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_fetch-crl;unpack=0"
SRC_URI[x86_64_v2_fetch-crl.sha256sum] = "23610d0d1cbcc4869c444ff37cedd95db981a4e77cbbe891770de16fa815a6d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fetch-crl-3.0.25-1.el10_3.noarch.rpm;name=aarch64_fetch-crl;unpack=0"
SRC_URI[aarch64_fetch-crl.sha256sum] = "a694948de70867b17f9d31baf5def8aa7193192261e98f00817900bb4a3f545b"

RDEPENDS:fetch-crl = " \
 bash \
 openssl \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-LWP-Protocol-https \
 perl-POSIX \
 perl-Sys-Syslog \
 perl-Time-Local \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 systemd \
 "
