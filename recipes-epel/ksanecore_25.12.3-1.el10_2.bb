# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksanecore"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ksanecore \
 ksanecore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksanecore-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51bfe76a2f05072a5373b7e6acf5c59b1d39b65435553b8b26d94f16d774c370"

URI_x86_64_v2_ksanecore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksanecore}"
SRC_URI[x86_64_v2_ksanecore.sha256sum] = "c5c5de94ece3e9829e2402466cbf2728872bbb77657ed219058dba8a9909d149"

URI_x86_64_v2_ksanecore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksanecore-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksanecore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksanecore-devel}"
SRC_URI[x86_64_v2_ksanecore-devel.sha256sum] = "d50457e5c881878e1cc2cf5973aac545dcbbe1c2ea16a62bbbf46d080495f2a5"

URI_aarch64_ksanecore = "${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ksanecore;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksanecore}"
SRC_URI[aarch64_ksanecore.sha256sum] = "335a0dbc9d1d6abe2fb7113a6c4f704484c0846edfe9001b8f1fac614d0112bc"

URI_aarch64_ksanecore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ksanecore-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ksanecore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksanecore-devel}"
SRC_URI[aarch64_ksanecore-devel.sha256sum] = "4e51d85aaa4e6f91f6f4a07c856f45c65cfdac00e83b22137782d4679e95d5a1"

RDEPENDS:ksanecore = " \
 glibc \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 sane-backends-libs \
 "
RDEPENDS:ksanecore-devel = " \
 cmake-filesystem \
 ksanecore \
 qt6-qtbase-devel \
 "
