# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom0.2"
PV = "0.2.17"
PR = "1.el10_3"
PACKAGES = " \
 rust-getrandom0.2+custom-devel \
 rust-getrandom0.2+default-devel \
 rust-getrandom0.2+linux_disable_fallback-devel \
 rust-getrandom0.2+rdrand-devel \
 rust-getrandom0.2+std-devel \
 rust-getrandom0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom0.2-0.2.17-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2d15e224fedb8f957f256e3fc37f0a07e18794b586b6703bea1e3d019ee83fb"

URI_x86_64_v2_rust-getrandom0.2+custom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+custom-devel-0.2.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+custom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+custom-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+custom-devel.sha256sum] = "c97183a236bc2b3a0914ae51e8ede79878e562f9672d92be8228c4a82f1acff1"

URI_x86_64_v2_rust-getrandom0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+default-devel-0.2.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+default-devel.sha256sum] = "772cc90ee26efe164145029515680f0f79f6305e2971be569bc899917761c2a7"

URI_x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+linux_disable_fallback-devel-0.2.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel.sha256sum] = "6b620dfe01babfbaca5399ed66149f220e22d980d39ae3c63524fa0bc7a4189b"

URI_x86_64_v2_rust-getrandom0.2+rdrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+rdrand-devel-0.2.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+rdrand-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+rdrand-devel.sha256sum] = "3f87bb35c0485c95474eabef1d8d8e91bcb04ab227847b5143305761c2d8bc11"

URI_x86_64_v2_rust-getrandom0.2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+std-devel-0.2.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+std-devel.sha256sum] = "bb136312c41d9456e5b7704317b45406d2d6efcb03ac575537b87adf7cc2a830"

URI_x86_64_v2_rust-getrandom0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2-devel-0.2.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2-devel.sha256sum] = "c9b48abf85f920554fb6162a1a9443a7474627319979eef28e29583770a5638d"

URI_aarch64_rust-getrandom0.2+custom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+custom-devel-0.2.17-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom0.2+custom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+custom-devel}"
SRC_URI[aarch64_rust-getrandom0.2+custom-devel.sha256sum] = "4d77f1f7e8a50147a8cced03d83a549105d3088cecdcf8c25879368ecd0f4a0f"

URI_aarch64_rust-getrandom0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+default-devel-0.2.17-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+default-devel}"
SRC_URI[aarch64_rust-getrandom0.2+default-devel.sha256sum] = "9a4c0ee4530072891cc913456edb858ecdaa131e899a3a7ace5690521aa987ce"

URI_aarch64_rust-getrandom0.2+linux_disable_fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+linux_disable_fallback-devel-0.2.17-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom0.2+linux_disable_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+linux_disable_fallback-devel}"
SRC_URI[aarch64_rust-getrandom0.2+linux_disable_fallback-devel.sha256sum] = "be15be649c61687c2604325166ce186c2f28e37e09f3af5c780a67dc7b482ecf"

URI_aarch64_rust-getrandom0.2+rdrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+rdrand-devel-0.2.17-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom0.2+rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+rdrand-devel}"
SRC_URI[aarch64_rust-getrandom0.2+rdrand-devel.sha256sum] = "3f7cb3f833a199a4c340f4a47a7e3dab21360fc736c6c6c58f5870b05ca98f6f"

URI_aarch64_rust-getrandom0.2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+std-devel-0.2.17-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+std-devel}"
SRC_URI[aarch64_rust-getrandom0.2+std-devel.sha256sum] = "49811115ec068b4c3b12aeb1fbe715990a548c4e83465134e7420587bf2cc506"

URI_aarch64_rust-getrandom0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2-devel-0.2.17-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2-devel}"
SRC_URI[aarch64_rust-getrandom0.2-devel.sha256sum] = "3e321eef5b9016418cd9e253f8dec1650f25dee8611948070a6b4e8478e8ba40"

RDEPENDS:rust-getrandom0.2+custom-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+default-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+linux_disable_fallback-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+rdrand-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+std-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 "
