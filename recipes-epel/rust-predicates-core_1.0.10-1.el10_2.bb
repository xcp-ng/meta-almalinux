# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates-core"
PV = "1.0.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-predicates-core+default-devel \
 rust-predicates-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates-core-1.0.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ffd33ab232ef912823e0898e8c2814bdd271553882be19f5828c49e2247fe05"

URI_x86_64_v2_rust-predicates-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-core+default-devel-1.0.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-core+default-devel}"
SRC_URI[x86_64_v2_rust-predicates-core+default-devel.sha256sum] = "07e11c4db82f706231f3b1e19f9a86b5d2018facfa24c4849c559adadad2c1bd"

URI_x86_64_v2_rust-predicates-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-core-devel-1.0.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-core-devel}"
SRC_URI[x86_64_v2_rust-predicates-core-devel.sha256sum] = "67a754db2d2628e5f36249c29d7ccfc9d315144aaa954b00160bdb8314b7775a"

URI_aarch64_rust-predicates-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-core+default-devel-1.0.10-1.el10_2.noarch.rpm;name=aarch64_rust-predicates-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-core+default-devel}"
SRC_URI[aarch64_rust-predicates-core+default-devel.sha256sum] = "49537038723badf11ed4148f169a62053381cb2c711697363c11d00f30460340"

URI_aarch64_rust-predicates-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-core-devel-1.0.10-1.el10_2.noarch.rpm;name=aarch64_rust-predicates-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-core-devel}"
SRC_URI[aarch64_rust-predicates-core-devel.sha256sum] = "b5bf4bd468a4441347ed6f40e78f27eacdff1814c062a6a5d0d902ff7aa587c3"

RDEPENDS:rust-predicates-core+default-devel = " \
 cargo \
 rust-predicates-core-devel \
 "
RDEPENDS:rust-predicates-core-devel = " \
 cargo \
 rust \
 "
