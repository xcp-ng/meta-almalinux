# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk-portable"
PE = "1"
PV = "26.0.2.0.10"
PR = "0.rolling.el8"
PACKAGES = " \
 java-latest-openjdk-portable \
 java-latest-openjdk-portable-devel \
 java-latest-openjdk-portable-devel-fastdebug \
 java-latest-openjdk-portable-devel-slowdebug \
 java-latest-openjdk-portable-docs \
 java-latest-openjdk-portable-fastdebug \
 java-latest-openjdk-portable-misc \
 java-latest-openjdk-portable-slowdebug \
 java-latest-openjdk-portable-sources \
 java-latest-openjdk-portable-static-libs \
 java-latest-openjdk-portable-static-libs-fastdebug \
 java-latest-openjdk-portable-static-libs-slowdebug \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-portable-26.0.2.0.10-0.rolling.el8.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71c58456e0cc996337e201825105f836e5a946c43e20c371d482269d47f7c4dc"

URI_x86_64_v2_java-latest-openjdk-portable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable.sha256sum] = "82c927890a88586e89994ac4b6bcad1c129a9965fa6766d4e195e1b726c3486a"

URI_x86_64_v2_java-latest-openjdk-portable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-devel}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel.sha256sum] = "9df3d22f6c38b55f62ff659f1abce02bb7a58b8d748285ee256b954c7d468270"

URI_x86_64_v2_java-latest-openjdk-portable-devel-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-fastdebug-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-devel-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel-fastdebug.sha256sum] = "99bcb53fd0af29649ab1833647c47d081bdbbb5d22029defd52cff2715ac0534"

URI_x86_64_v2_java-latest-openjdk-portable-devel-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-devel-slowdebug-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-devel-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-devel-slowdebug.sha256sum] = "e01e1ddf784ce5d0cd57698a517f56ccadc76beabd032476ac7beca0ee6b2f21"

URI_x86_64_v2_java-latest-openjdk-portable-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-docs-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-docs}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-docs.sha256sum] = "c86f60674eb4748b34bd85077089239354d8c8c80ae383a58f67d1f861fd8e3c"

URI_x86_64_v2_java-latest-openjdk-portable-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-fastdebug-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-fastdebug.sha256sum] = "7c40e662fdff2977628c6d94a9efd21a9622f4e3604dd82487d9fd7b0462596d"

URI_x86_64_v2_java-latest-openjdk-portable-misc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-misc-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-misc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-misc}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-misc.sha256sum] = "b04cdcf244329db2918c93edfd32d0d0925633af3a10f972e983de01c5d15cbe"

URI_x86_64_v2_java-latest-openjdk-portable-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-slowdebug-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-slowdebug.sha256sum] = "166f62eafbe40da174a9eafd17dd427b86c5d4df690494a08be95476a885e61c"

URI_x86_64_v2_java-latest-openjdk-portable-sources = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-sources-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-sources;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-sources}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-sources.sha256sum] = "431c21abe6ee66c1e48206dbe78e2d411a671cfa87191bc9317305e30644f17e"

URI_x86_64_v2_java-latest-openjdk-portable-static-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-static-libs}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs.sha256sum] = "9ab2d3c2cb1b1b9a9371b0636ffcbdd9b1788ec7351eacc37429baadbc0c8949"

URI_x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-fastdebug-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs-fastdebug.sha256sum] = "da4ee981c02f2e5b665157973f28d25791c6dd9efc9aaee479994468f44feba3"

URI_x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-portable-static-libs-slowdebug-26.0.2.0.10-0.rolling.el8.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-portable-static-libs-slowdebug.sha256sum] = "7e639d893feb723d3944a355a358cb80d263c42acdc552aea9a4a0ffabba743d"

URI_aarch64_java-latest-openjdk-portable = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable}"
SRC_URI[aarch64_java-latest-openjdk-portable.sha256sum] = "79432fb4146f9a806badf4d5e5c509407f5b209075f88a96c7a9b602944c8a93"

URI_aarch64_java-latest-openjdk-portable-devel = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel.sha256sum] = "07f3d7567164bb806be7d8f217e867f0691db59545259461944d21c16ed26fac"

URI_aarch64_java-latest-openjdk-portable-devel-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-fastdebug-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-fastdebug.sha256sum] = "25be580cd821bb29f714f97067464979fb9c4186df4a7ed4650794d4528682e4"

URI_aarch64_java-latest-openjdk-portable-devel-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-slowdebug-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-slowdebug.sha256sum] = "1ec4ed17f0d1b8839345ae85025b39a3e822ff99e2c11462f3b90b518fcc8a9e"

URI_aarch64_java-latest-openjdk-portable-docs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-docs-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-docs}"
SRC_URI[aarch64_java-latest-openjdk-portable-docs.sha256sum] = "6bf26b172d2fa78371f6ffb39dc9b715708be812d98325fea8f9cc0b0d88f2d3"

URI_aarch64_java-latest-openjdk-portable-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-fastdebug-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-fastdebug.sha256sum] = "6cde5ecfc1757c10a5bf335706fb03e87fd61cb56eb463323fb15719f42dbecb"

URI_aarch64_java-latest-openjdk-portable-misc = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-misc-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-misc}"
SRC_URI[aarch64_java-latest-openjdk-portable-misc.sha256sum] = "a2b4df858a6da312f6b649492305e944b8fdbd4ef0c0e42b6caaf225a5625266"

URI_aarch64_java-latest-openjdk-portable-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-slowdebug-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-slowdebug.sha256sum] = "b987799437944376f6c95a697b37259ddb8444f77e7689ed970306aae344599c"

URI_aarch64_java-latest-openjdk-portable-sources = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-sources-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-sources;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-sources}"
SRC_URI[aarch64_java-latest-openjdk-portable-sources.sha256sum] = "eeb4b67eff1e2cd972b128f9048cc196f13c91977c833418c33c07114781fa57"

URI_aarch64_java-latest-openjdk-portable-static-libs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs.sha256sum] = "2c4e8ed94ffe58b14bb59577f3a75ccf45456867113b0a8b995c52ac628349a8"

URI_aarch64_java-latest-openjdk-portable-static-libs-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-fastdebug-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-fastdebug.sha256sum] = "803e41c6f35ad11239e5e5f0dd3148143c6c8a476ac6fbcfeb8d138bbf6b10b4"

URI_aarch64_java-latest-openjdk-portable-static-libs-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-slowdebug-26.0.2.0.10-0.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-slowdebug.sha256sum] = "ff7133c622d152a1534cab051bcf480ee8364b24ffefa8ad0b8fdca057841029"

RDEPENDS:java-latest-openjdk-portable = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-docs = " \
 "
RDEPENDS:java-latest-openjdk-portable-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-misc = " \
 "
RDEPENDS:java-latest-openjdk-portable-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-sources = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-slowdebug = " \
 "
