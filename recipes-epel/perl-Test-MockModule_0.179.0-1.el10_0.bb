# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-MockModule"
PV = "0.179.0"
PR = "1.el10_0"
PACKAGES = " \
 perl-Test-MockModule \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-MockModule-0.179.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b58cf17f1a49a6558a1d4278c867942b60eef116ebec6919635590347f9010ad"

URI_x86_64_v2_perl-Test-MockModule = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-MockModule-0.179.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-MockModule;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-MockModule}"
SRC_URI[x86_64_v2_perl-Test-MockModule.sha256sum] = "641e83c50ab470ea56a8772b0e31b17df2f282a594dca9fe50028710ab4c1faf"

URI_aarch64_perl-Test-MockModule = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-MockModule-0.179.0-1.el10_0.noarch.rpm;name=aarch64_perl-Test-MockModule;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-MockModule}"
SRC_URI[aarch64_perl-Test-MockModule.sha256sum] = "3290812aca92d95a0f444c6235ec7edaa21600e667ecc76c135069f0954ac294"

RDEPENDS:perl-Test-MockModule = " \
 perl-Carp \
 perl-SUPER \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-vars \
 "
