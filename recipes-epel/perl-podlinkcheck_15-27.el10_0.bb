# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-podlinkcheck"
PV = "15"
PR = "27.el10_0"
PACKAGES = " \
 perl-podlinkcheck \
 perl-podlinkcheck-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-podlinkcheck-15-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b7618c3fa63805ad3c1219e5f36d7377164f22583e788e43dbcd7507990b90db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-podlinkcheck-15-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-podlinkcheck;unpack=0"
SRC_URI[x86_64_v2_perl-podlinkcheck.sha256sum] = "c10662cf73e0d8020a5b8ef44516b22a4c7768b71677c4f8a255d5fce2a30e7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-podlinkcheck-tests-15-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-podlinkcheck-tests;unpack=0"
SRC_URI[x86_64_v2_perl-podlinkcheck-tests.sha256sum] = "aaef5450e339324b0efda71688b6961dcc21b10d8e3188e39d809b0bf3ae9bc5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-podlinkcheck-15-27.el10_0.noarch.rpm;name=aarch64_perl-podlinkcheck;unpack=0"
SRC_URI[aarch64_perl-podlinkcheck.sha256sum] = "0c3b49f8c86a507737c1c8fbb7dba546122c26784416ff0710703219fcbdef2e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-podlinkcheck-tests-15-27.el10_0.noarch.rpm;name=aarch64_perl-podlinkcheck-tests;unpack=0"
SRC_URI[aarch64_perl-podlinkcheck-tests.sha256sum] = "682e05b9d65eb72b629821480bd2e949f732c630239e6450a1dfc9f1295d9042"

RDEPENDS:perl-podlinkcheck = " \
 perl-Carp \
 perl-File-Find-Iterator \
 perl-File-HomeDir \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IPC-Run \
 perl-PathTools \
 perl-Pod-Parser \
 perl-Pod-Simple \
 perl-Scalar-List-Utils \
 perl-Search-Dict \
 perl-Text-Tabs+Wrap \
 perl-base \
 perl-constant-defer \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 perl-podlinkcheck \
 perl-vars \
 "
RDEPENDS:perl-podlinkcheck-tests = " \
 bash \
 perl-Data-Dumper \
 perl-File-HomeDir \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-podlinkcheck \
 "
