# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-file-read-tokio"
PV = "3.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-file-read-tokio+default-devel \
 rust-reqsign-file-read-tokio-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-file-read-tokio-3.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b5c15b1768569af662cf12c9d3e552b6b7db49c46088920c5ea082f44142ecd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-file-read-tokio+default-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-file-read-tokio+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-file-read-tokio+default-devel.sha256sum] = "6920efb2e9a491ff20b8d606facb21b2f767c0a8559b0d9037ef16527b266e0d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-file-read-tokio-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-file-read-tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-file-read-tokio-devel.sha256sum] = "da114085c62ffa62b61a5586d2755de819be3a7794c9fe2426a670f62f93f35e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-file-read-tokio+default-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-file-read-tokio+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-file-read-tokio+default-devel.sha256sum] = "8eb07b50973bd495434a2bd72fc69c3bcfb1d89ad01378dbd0dc5eaa0f030a47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-file-read-tokio-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-file-read-tokio-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-file-read-tokio-devel.sha256sum] = "bce841acf0454cf91870aa879d8d30d2538db1f131ae0a67ef8a0c3bd689931f"

RDEPENDS:rust-reqsign-file-read-tokio+default-devel = " \
 cargo \
 rust-reqsign-file-read-tokio-devel \
 "
RDEPENDS:rust-reqsign-file-read-tokio-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-reqsign-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 "
