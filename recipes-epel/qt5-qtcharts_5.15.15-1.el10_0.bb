# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtcharts"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtcharts \
 qt5-qtcharts-devel \
 qt5-qtcharts-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtcharts-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cebec6ceb9e80b92d380429cf54a8d44a4fa30b1cbe3bff02a8a308649b2bf74"

URI_x86_64_v2_qt5-qtcharts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtcharts-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtcharts}"
SRC_URI[x86_64_v2_qt5-qtcharts.sha256sum] = "ab43c5c1d722a564f7c9ac135ab305924e4cd6e87e678ea7dbf0b2f3bdf3873a"

URI_x86_64_v2_qt5-qtcharts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtcharts-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtcharts-devel}"
SRC_URI[x86_64_v2_qt5-qtcharts-devel.sha256sum] = "fa7a5de32fb1a86f93acc9546cc7f6ab7cede55110a71a6b89fc2c6baa0e0b7e"

URI_x86_64_v2_qt5-qtcharts-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtcharts-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtcharts-examples}"
SRC_URI[x86_64_v2_qt5-qtcharts-examples.sha256sum] = "e68b95e1e6d67161e1e87d6565702d79bccc4e0e50719a444033d89a91ceba4d"

URI_aarch64_qt5-qtcharts = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtcharts-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtcharts}"
SRC_URI[aarch64_qt5-qtcharts.sha256sum] = "a5c3bf04ec49f04c4517886aa96f7202613e6149fc294a1e8559ce4be27c2ebe"

URI_aarch64_qt5-qtcharts-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtcharts-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtcharts-devel}"
SRC_URI[aarch64_qt5-qtcharts-devel.sha256sum] = "0958a4b866c53c8a62570cba56307fb4eaa4331d6c9ce64cc2e527d3a016d80d"

URI_aarch64_qt5-qtcharts-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtcharts-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtcharts-examples}"
SRC_URI[aarch64_qt5-qtcharts-examples.sha256sum] = "edf3624a060402103b750479d82872cb36445c33a898e659958ee9dfce5ce3ed"

RDEPENDS:qt5-qtcharts = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtcharts-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtcharts \
 "
RDEPENDS:qt5-qtcharts-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtcharts \
 qt5-qtdeclarative \
 "
