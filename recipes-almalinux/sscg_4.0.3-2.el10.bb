# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sscg"
PV = "4.0.3"
PR = "2.el10"
PACKAGES = " \
 sscg \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sscg-4.0.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a8a0a6c9fd179ecff3bf6921026a028c2f6ca6d994dea2ace08e1bb5ee0813a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sscg-4.0.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_sscg;unpack=0"
SRC_URI[x86_64_v2_sscg.sha256sum] = "424974af7bd50293b4417938db9260ac9007102e969602fa99536548e440b629"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sscg-4.0.3-2.el10.aarch64.rpm;name=aarch64_sscg;unpack=0"
SRC_URI[aarch64_sscg.sha256sum] = "6dccafee9127ca73428693933c48e657a1f3b511494f2bcab688cc41c1365eda"

RDEPENDS:sscg = " \
 glibc \
 libtalloc \
 openssl-libs \
 popt \
 "
