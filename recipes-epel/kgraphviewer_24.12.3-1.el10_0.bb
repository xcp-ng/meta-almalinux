# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgraphviewer"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kgraphviewer \
 kgraphviewer-devel \
 kgraphviewer-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgraphviewer-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4a4f2e754713e9cdf296c36909c94bd5494b6530ecbdd1e3ff2f3013ae2d472"

URI_x86_64_v2_kgraphviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgraphviewer}"
SRC_URI[x86_64_v2_kgraphviewer.sha256sum] = "44c3c0e1a473d7120f95cee3234cbe459d2cf01a95fe5a9e980e0d381665d0b5"

URI_x86_64_v2_kgraphviewer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgraphviewer-devel}"
SRC_URI[x86_64_v2_kgraphviewer-devel.sha256sum] = "3ef68d749560041f407ea5e35e266f25ec2d8e028229236e44b02f704fb9bdf3"

URI_x86_64_v2_kgraphviewer-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgraphviewer-libs}"
SRC_URI[x86_64_v2_kgraphviewer-libs.sha256sum] = "640d673c66cfc611a977c915871019e2c447ba6ccaf9fc71fb6ae3d3a62245ae"

URI_aarch64_kgraphviewer = "${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kgraphviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgraphviewer}"
SRC_URI[aarch64_kgraphviewer.sha256sum] = "413efb3bd444851c6491ac6924abdca46072ab892972f9dc791d1f176b5e8e5c"

URI_aarch64_kgraphviewer-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kgraphviewer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgraphviewer-devel}"
SRC_URI[aarch64_kgraphviewer-devel.sha256sum] = "fc92089d5371bb98d2bd2a98a5eba845911b7bd6dc92473badc385cabbea0ab3"

URI_aarch64_kgraphviewer-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kgraphviewer-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgraphviewer-libs}"
SRC_URI[aarch64_kgraphviewer-libs.sha256sum] = "0ad3e239ff1f4b604508fbe56ee8ee84f2132535faafaba288e084941b9ee726"

RDEPENDS:kgraphviewer = " \
 glibc \
 graphviz \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kgraphviewer-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kgraphviewer-devel = " \
 cmake \
 cmake-filesystem \
 kgraphviewer-libs \
 "
RDEPENDS:kgraphviewer-libs = " \
 glibc \
 graphviz \
 kde-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
