# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mariadb-connector-odbc"
PV = "3.2.4"
PR = "1.el10"
PACKAGES = " \
 mariadb-connector-odbc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mariadb-connector-odbc-3.2.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86e03ad8ff9da898d9fe000fe5e859b636f0e658f81c782b125e2e7ffdae4060"

URI_x86_64_v2_mariadb-connector-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mariadb-connector-odbc-3.2.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_mariadb-connector-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mariadb-connector-odbc}"
SRC_URI[x86_64_v2_mariadb-connector-odbc.sha256sum] = "c7a45c40700878c1d9b14201468e5883c1cf5c217c3b7f2edb33fdda4d6e8023"

URI_aarch64_mariadb-connector-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mariadb-connector-odbc-3.2.4-1.el10.aarch64.rpm;name=aarch64_mariadb-connector-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mariadb-connector-odbc}"
SRC_URI[aarch64_mariadb-connector-odbc.sha256sum] = "0d21ff5c981e9d8ce241b684e40e9e553590ef9a51b8cdcdddc9f4494a2a1f42"

RDEPENDS:mariadb-connector-odbc = " \
 glibc \
 libgcc \
 libstdc++ \
 mariadb-connector-c \
 pkgconf-pkg-config \
 unixODBC \
 "
