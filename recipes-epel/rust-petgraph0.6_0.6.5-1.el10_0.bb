# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-petgraph0.6"
PV = "0.6.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-petgraph0.6+all-devel \
 rust-petgraph0.6+default-devel \
 rust-petgraph0.6+generate-devel \
 rust-petgraph0.6+graphmap-devel \
 rust-petgraph0.6+matrix_graph-devel \
 rust-petgraph0.6+rayon-devel \
 rust-petgraph0.6+serde-1-devel \
 rust-petgraph0.6+serde-devel \
 rust-petgraph0.6+serde_derive-devel \
 rust-petgraph0.6+stable_graph-devel \
 rust-petgraph0.6+unstable-devel \
 rust-petgraph0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-petgraph0.6-0.6.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aba0df5f9d9c22c89fc5a56e521d79a3a4e83adc643f8f95c01f18ff4da1043f"

URI_x86_64_v2_rust-petgraph0.6+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+all-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+all-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+all-devel.sha256sum] = "0ebd50957735702d164b11794368eb885d7e5d05f785dcefc298e06dfafade02"

URI_x86_64_v2_rust-petgraph0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+default-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+default-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+default-devel.sha256sum] = "3ae939b4f396f0fba9a0b0523d6d1a9b62c1253c7b18c1e3e25bc9baf4d54617"

URI_x86_64_v2_rust-petgraph0.6+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+generate-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+generate-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+generate-devel.sha256sum] = "36e65481783628e963fd5316ac85a81d001ada7047949fe6af88c61d42ec6d83"

URI_x86_64_v2_rust-petgraph0.6+graphmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+graphmap-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+graphmap-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+graphmap-devel.sha256sum] = "fe66b3b9da50958a777e80729a22d9459a294cb87967b355d28453440f5e7cb1"

URI_x86_64_v2_rust-petgraph0.6+matrix_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+matrix_graph-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+matrix_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+matrix_graph-devel.sha256sum] = "df0227cca0f7f9fb8e4351565113ce539c10395b1d41aa86e1f3df687142454d"

URI_x86_64_v2_rust-petgraph0.6+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+rayon-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+rayon-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+rayon-devel.sha256sum] = "669d03cb455fefd9cfc6d428de1993ef889739d2c2656f21f3ad960d977ca156"

URI_x86_64_v2_rust-petgraph0.6+serde-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+serde-1-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+serde-1-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+serde-1-devel.sha256sum] = "e7c265f255166addc23aba159e6edfc33e6bf86c63ca974ea629d90852b2c6a5"

URI_x86_64_v2_rust-petgraph0.6+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+serde-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+serde-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+serde-devel.sha256sum] = "bf2245f181f80074f9657ff977265e88657a951704601d0d72b93e374092147d"

URI_x86_64_v2_rust-petgraph0.6+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+serde_derive-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+serde_derive-devel.sha256sum] = "ab23fde255090a01f242d5b7170589b0bb3b45fcde02f0f4618d75746bcf7dbd"

URI_x86_64_v2_rust-petgraph0.6+stable_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+stable_graph-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+stable_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+stable_graph-devel.sha256sum] = "4cba0ae686500a75c1a97e9686ea7a922072de5ced9e59d44478a54b50e6ec0e"

URI_x86_64_v2_rust-petgraph0.6+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6+unstable-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6+unstable-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6+unstable-devel.sha256sum] = "6a83cb87c56353b56eeaa8850253247e6d5145bcf279f32860688bf7bc651c65"

URI_x86_64_v2_rust-petgraph0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph0.6-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph0.6-devel}"
SRC_URI[x86_64_v2_rust-petgraph0.6-devel.sha256sum] = "8984d9db5e0f61d18f0f9ae773e333efa7923166cc2e725eb0ce5ab31b437f56"

URI_aarch64_rust-petgraph0.6+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+all-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+all-devel}"
SRC_URI[aarch64_rust-petgraph0.6+all-devel.sha256sum] = "b14442a92d5b02f09c7c2b44d00e0b2cede92d896316ec6e3503056853f1b606"

URI_aarch64_rust-petgraph0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+default-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+default-devel}"
SRC_URI[aarch64_rust-petgraph0.6+default-devel.sha256sum] = "cfd6a3ecb30bd5188714090a03999161cb6aaa67838ad330816a280bd081da4c"

URI_aarch64_rust-petgraph0.6+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+generate-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+generate-devel}"
SRC_URI[aarch64_rust-petgraph0.6+generate-devel.sha256sum] = "5d86d6d695545f67d5ce80b35b832759dd3b9c01e3b3578a399dd074ccb05ead"

URI_aarch64_rust-petgraph0.6+graphmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+graphmap-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+graphmap-devel}"
SRC_URI[aarch64_rust-petgraph0.6+graphmap-devel.sha256sum] = "b60c0e8ca3f094b9218cd071bce7a68c99ffb449adedec0891dcc7862c918c9b"

URI_aarch64_rust-petgraph0.6+matrix_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+matrix_graph-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+matrix_graph-devel}"
SRC_URI[aarch64_rust-petgraph0.6+matrix_graph-devel.sha256sum] = "95c745eb165ef595a9ed8dd5dfd197d01a3f371ac51fad85c24e8c2a9a371f4e"

URI_aarch64_rust-petgraph0.6+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+rayon-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+rayon-devel}"
SRC_URI[aarch64_rust-petgraph0.6+rayon-devel.sha256sum] = "b7f2c6e3856a2883773f5da81821dab4b776b3f0af06f2c2fbd95404f71eae47"

URI_aarch64_rust-petgraph0.6+serde-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+serde-1-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+serde-1-devel}"
SRC_URI[aarch64_rust-petgraph0.6+serde-1-devel.sha256sum] = "6bbe36b82b58eb2f30546fd2f5484bbf9013eb495323dc045eebe25d0f2080bc"

URI_aarch64_rust-petgraph0.6+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+serde-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+serde-devel}"
SRC_URI[aarch64_rust-petgraph0.6+serde-devel.sha256sum] = "3c67bd798af0457eafffad652d62eb8d77382d89e06b34851747e760d80e7a1b"

URI_aarch64_rust-petgraph0.6+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+serde_derive-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+serde_derive-devel}"
SRC_URI[aarch64_rust-petgraph0.6+serde_derive-devel.sha256sum] = "757c6c4ea070b516dd8600f32ae73f947cf57cc4709a6872c7b26bfa2d6e2f61"

URI_aarch64_rust-petgraph0.6+stable_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+stable_graph-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+stable_graph-devel}"
SRC_URI[aarch64_rust-petgraph0.6+stable_graph-devel.sha256sum] = "272c7cb8b226f37a611d003162026aa535f45073a31e7fd428f67caafdd6bb58"

URI_aarch64_rust-petgraph0.6+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6+unstable-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6+unstable-devel}"
SRC_URI[aarch64_rust-petgraph0.6+unstable-devel.sha256sum] = "982b72592f18b0845a7df6a98c5d897f4c5c1c3cb85c7adb03dcc04f26385fb8"

URI_aarch64_rust-petgraph0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph0.6-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph0.6-devel}"
SRC_URI[aarch64_rust-petgraph0.6-devel.sha256sum] = "4d5fea69c7e7088e0b2ccbf2399b68a37c76dbc52b2535de6526caa4d3bd49d0"

RDEPENDS:rust-petgraph0.6+all-devel = " \
 cargo \
 rust-petgraph0.6+graphmap-devel \
 rust-petgraph0.6+matrix_graph-devel \
 rust-petgraph0.6+rayon-devel \
 rust-petgraph0.6+stable_graph-devel \
 rust-petgraph0.6+unstable-devel \
 rust-petgraph0.6-devel \
 "
RDEPENDS:rust-petgraph0.6+default-devel = " \
 cargo \
 rust-petgraph0.6+graphmap-devel \
 rust-petgraph0.6+matrix_graph-devel \
 rust-petgraph0.6+stable_graph-devel \
 rust-petgraph0.6-devel \
 "
RDEPENDS:rust-petgraph0.6+generate-devel = " \
 cargo \
 rust-petgraph0.6-devel \
 "
RDEPENDS:rust-petgraph0.6+graphmap-devel = " \
 cargo \
 rust-petgraph0.6-devel \
 "
RDEPENDS:rust-petgraph0.6+matrix_graph-devel = " \
 cargo \
 rust-petgraph0.6-devel \
 "
RDEPENDS:rust-petgraph0.6+rayon-devel = " \
 cargo \
 rust-indexmap+rayon-devel \
 rust-petgraph0.6-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-petgraph0.6+serde-1-devel = " \
 cargo \
 rust-petgraph0.6+serde-devel \
 rust-petgraph0.6+serde_derive-devel \
 rust-petgraph0.6-devel \
 "
RDEPENDS:rust-petgraph0.6+serde-devel = " \
 cargo \
 rust-petgraph0.6-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-petgraph0.6+serde_derive-devel = " \
 cargo \
 rust-petgraph0.6-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-petgraph0.6+stable_graph-devel = " \
 cargo \
 rust-petgraph0.6-devel \
 "
RDEPENDS:rust-petgraph0.6+unstable-devel = " \
 cargo \
 rust-petgraph0.6+generate-devel \
 rust-petgraph0.6-devel \
 "
RDEPENDS:rust-petgraph0.6-devel = " \
 cargo \
 rust \
 rust-fixedbitset0.4-devel \
 rust-indexmap+default-devel \
 "
