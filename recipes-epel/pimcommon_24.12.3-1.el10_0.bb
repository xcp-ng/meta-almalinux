# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pimcommon"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 pimcommon \
 pimcommon-devel \
 pimcommon-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pimcommon-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "093bee0c74a879d5da405d71fd66da90d80ea3c7ed267be10992f894d7b452e4"

URI_x86_64_v2_pimcommon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon}"
SRC_URI[x86_64_v2_pimcommon.sha256sum] = "b80710007299d192d17099f900d021901ea3fd8fadcc2e8e86c482b7f53190c7"

URI_x86_64_v2_pimcommon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon-devel}"
SRC_URI[x86_64_v2_pimcommon-devel.sha256sum] = "ee9129b6a2cb5c6893e5b87ac94294824fa5bc911a24931cb50f53ca274ee92f"

URI_x86_64_v2_pimcommon-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-doc-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon-doc}"
SRC_URI[x86_64_v2_pimcommon-doc.sha256sum] = "e53b5dfe3a7f860dfd8a87dafe9f0aeae68d7f0fac5d7828ae137e946c6c0f61"

URI_aarch64_pimcommon = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_pimcommon;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon}"
SRC_URI[aarch64_pimcommon.sha256sum] = "8ddf6853da96a546bbd9fc407c207e4c8b26ace760d31a115e654ae8f6c18a6f"

URI_aarch64_pimcommon-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_pimcommon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon-devel}"
SRC_URI[aarch64_pimcommon-devel.sha256sum] = "98806ea8fd4c5eb1bf5db4989f8e35d07ea43440324e76f0349a94839744fa3a"

URI_aarch64_pimcommon-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-doc-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_pimcommon-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon-doc}"
SRC_URI[aarch64_pimcommon-doc.sha256sum] = "e9265bcf7731cc3c98156a600a17235c6920dc22a65a0b7505b7d8c828c58e29"

RDEPENDS:pimcommon = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kimap \
 kldap \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-devel = " \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kcontacts-devel \
 kimap-devel \
 ktextaddons-qt6-devel \
 libgcc \
 libstdc++ \
 pimcommon \
 plasma-activities-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-doc = " \
 "
