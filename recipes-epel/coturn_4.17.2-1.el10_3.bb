# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "coturn"
PV = "4.17.2"
PR = "1.el10_3"
PACKAGES = " \
 coturn \
 coturn-client-devel \
 coturn-client-libs \
 coturn-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/coturn-4.17.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b22e1ee8881bfb9adf63fa6413a954221d8475a35bed6e317e5ac0fffd4ab5c8"

URI_x86_64_v2_coturn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-4.17.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn}"
SRC_URI[x86_64_v2_coturn.sha256sum] = "feea132964672c99162df7c3a65366cb5f16d83a809283968ab57a1243976a8a"

URI_x86_64_v2_coturn-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-devel-4.17.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn-client-devel}"
SRC_URI[x86_64_v2_coturn-client-devel.sha256sum] = "4649d9ac6d4d6182ddb6c2da70c0b452de8888a8100cb99a1babe3b452e856ef"

URI_x86_64_v2_coturn-client-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-client-libs-4.17.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-client-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn-client-libs}"
SRC_URI[x86_64_v2_coturn-client-libs.sha256sum] = "26a499515c06902bfd3d52deb6f8fa83e1606376ee5d991573f9abb8499e05ae"

URI_x86_64_v2_coturn-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/coturn-utils-4.17.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_coturn-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coturn-utils}"
SRC_URI[x86_64_v2_coturn-utils.sha256sum] = "0568daf299122727b83bbdd50df5e8597c6d3f3aa6e5c48dc819a5e46d6ea828"

URI_aarch64_coturn = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-4.17.2-1.el10_3.aarch64.rpm;name=aarch64_coturn;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn}"
SRC_URI[aarch64_coturn.sha256sum] = "1740cfd5ea14c5100076765029b7a496ef41a44a0074f70858b107ef7f56d7d6"

URI_aarch64_coturn-client-devel = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-devel-4.17.2-1.el10_3.aarch64.rpm;name=aarch64_coturn-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn-client-devel}"
SRC_URI[aarch64_coturn-client-devel.sha256sum] = "5d45787a8bff3317bc828fd3023de2bfdefb98d4f25ffcc24d32d84648dfa233"

URI_aarch64_coturn-client-libs = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-client-libs-4.17.2-1.el10_3.aarch64.rpm;name=aarch64_coturn-client-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn-client-libs}"
SRC_URI[aarch64_coturn-client-libs.sha256sum] = "a30699baec104f378703c082a9c94fd1e83726f774f1f1f75078fd7e8b049668"

URI_aarch64_coturn-utils = "${EPEL_MIRROR}/aarch64/Packages/c/coturn-utils-4.17.2-1.el10_3.aarch64.rpm;name=aarch64_coturn-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_coturn-utils}"
SRC_URI[aarch64_coturn-utils.sha256sum] = "368d3777388848b37afc6509d58d9616faa7c0be4ef8f329acf445739081d27a"

RDEPENDS:coturn = " \
 bash \
 glibc \
 hiredis \
 libevent \
 libmicrohttpd \
 libpq \
 mariadb-connector-c \
 openssl-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:coturn-client-devel = " \
 "
RDEPENDS:coturn-client-libs = " \
 "
RDEPENDS:coturn-utils = " \
 glibc \
 libevent \
 openssl-libs \
 "
