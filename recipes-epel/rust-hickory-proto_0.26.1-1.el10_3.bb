# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-proto"
PV = "0.26.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-hickory-proto+access-control-devel \
 rust-hickory-proto+default-devel \
 rust-hickory-proto+mdns-devel \
 rust-hickory-proto+no-std-rand-devel \
 rust-hickory-proto+serde-devel \
 rust-hickory-proto+std-devel \
 rust-hickory-proto+testing-devel \
 rust-hickory-proto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-proto-0.26.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1f345ba483532720e23d8f32181762abb8e91c9b3d2334a3ff8274d347348d4"

URI_x86_64_v2_rust-hickory-proto+access-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+access-control-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+access-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+access-control-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+access-control-devel.sha256sum] = "df0b77decee3c09871b960ebcf2691e70c7b6a3e87c77f27113853965c031463"

URI_x86_64_v2_rust-hickory-proto+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+default-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+default-devel.sha256sum] = "376b548f3d121eccb5dafab578880bfccb8d369c2017ff20c13ea5a0bd62c569"

URI_x86_64_v2_rust-hickory-proto+mdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+mdns-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+mdns-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+mdns-devel.sha256sum] = "4dd83f9907c5490c00bd292983e026601a4edc8f66cfea88a66a27eedf801325"

URI_x86_64_v2_rust-hickory-proto+no-std-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+no-std-rand-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+no-std-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+no-std-rand-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+no-std-rand-devel.sha256sum] = "e5576b2313e29950d4b475a4b772463d3fc03a66cf7394a69871af52d74ab370"

URI_x86_64_v2_rust-hickory-proto+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+serde-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+serde-devel.sha256sum] = "ea4f685c2d5ad1c60dd22b46c31be33fd30fa897bff38ae789f57e5412478c65"

URI_x86_64_v2_rust-hickory-proto+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+std-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+std-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+std-devel.sha256sum] = "58be93b1ce60aaf3d8b858aee3853aa0d6f1eacd9cbcaccec5d323da82092de7"

URI_x86_64_v2_rust-hickory-proto+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+testing-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+testing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+testing-devel.sha256sum] = "2784aaa0351774521c241382f9f51ab3b7f34128f73247c65e9591445dd1ca7d"

URI_x86_64_v2_rust-hickory-proto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto-devel-0.26.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto-devel.sha256sum] = "5fd944da69edbe0ef5b7cb93160352798231204fb2bacaac4d8bda5137d09c0e"

URI_aarch64_rust-hickory-proto+access-control-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+access-control-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+access-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+access-control-devel}"
SRC_URI[aarch64_rust-hickory-proto+access-control-devel.sha256sum] = "1faadef625f5ab9f629abeaa5d1041cefb4efa3412f96269592f2587a3333566"

URI_aarch64_rust-hickory-proto+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+default-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+default-devel}"
SRC_URI[aarch64_rust-hickory-proto+default-devel.sha256sum] = "707fe44ee921cd0db773fce6aa2597b3025e34e7883565795a6b0febfa6df695"

URI_aarch64_rust-hickory-proto+mdns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+mdns-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+mdns-devel}"
SRC_URI[aarch64_rust-hickory-proto+mdns-devel.sha256sum] = "c7f8c2e6e6d666b3c9a01be43c22d07e929d8d1982f1f01210c3d39e8a1b7c2e"

URI_aarch64_rust-hickory-proto+no-std-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+no-std-rand-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+no-std-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+no-std-rand-devel}"
SRC_URI[aarch64_rust-hickory-proto+no-std-rand-devel.sha256sum] = "b8f47f815c45e8e613cdb3ee5dabbb13fff09aaa5bf2f32d3cd7c771d889de9d"

URI_aarch64_rust-hickory-proto+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+serde-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+serde-devel}"
SRC_URI[aarch64_rust-hickory-proto+serde-devel.sha256sum] = "e8798023f5b12ee52db165d1b838a97b677277585017423fdb624baeba9396d3"

URI_aarch64_rust-hickory-proto+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+std-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+std-devel}"
SRC_URI[aarch64_rust-hickory-proto+std-devel.sha256sum] = "17eac9ec44709a0e47788e651607d1b066e802398f41712c06d3083990a7a069"

URI_aarch64_rust-hickory-proto+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+testing-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+testing-devel}"
SRC_URI[aarch64_rust-hickory-proto+testing-devel.sha256sum] = "4c994f84f91c157805c16e91bf4dfb57dc794a88e9ee5d70e51cb876ace8b7c7"

URI_aarch64_rust-hickory-proto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto-devel-0.26.1-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto-devel}"
SRC_URI[aarch64_rust-hickory-proto-devel.sha256sum] = "9ca05a272eaef66d209b391e19815c69265e4acc7d6f5c6b07c79b98436e8221"

RDEPENDS:rust-hickory-proto+access-control-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-prefix-trie+default-devel \
 "
RDEPENDS:rust-hickory-proto+default-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+mdns-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+no-std-rand-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-hickory-proto-devel \
 rust-once_cell+critical-section-devel \
 "
RDEPENDS:rust-hickory-proto+serde-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-hickory-proto+std-devel = " \
 cargo \
 rust-data-encoding+std-devel \
 rust-hickory-proto-devel \
 rust-ipnet+std-devel \
 rust-rand+std-devel \
 rust-rand+thread_rng-devel \
 rust-ring+default-devel \
 rust-ring+std-devel \
 rust-thiserror+std-devel \
 rust-tracing+std-devel \
 rust-url+std-devel \
 "
RDEPENDS:rust-hickory-proto+testing-devel = " \
 cargo \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto-devel = " \
 cargo \
 rust \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna-devel \
 rust-ipnet-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 rust-rand+alloc-devel \
 rust-rand+std_rng-devel \
 rust-rand-devel \
 rust-thiserror-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 rust-tracing-devel \
 rust-url-devel \
 "
