# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nfs-utils"
PE = "1"
PV = "2.8.3"
PR = "9.el10"
PACKAGES = " \
 libnfsidmap \
 libnfsidmap-devel \
 nfs-utils \
 nfs-utils-coreos \
 nfsv4-client-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nfs-utils-2.8.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3cfb377c7261d722ce80905053b691c51af1c6cd2c317ea63e80b3eb387b89dd"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - nfs-utils-coreos: libcap.so.2()(64bit)
# - nfs-utils: libcap
# - nfs-utils: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnfsidmap-2.8.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap;unpack=0"
SRC_URI[x86_64_v2_libnfsidmap.sha256sum] = "cb4a9e96bf9db7cda92d0e6bb00dabcc789b61c33f0c88b204619c65d8d41c19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnfsidmap-devel-2.8.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_libnfsidmap-devel;unpack=0"
SRC_URI[x86_64_v2_libnfsidmap-devel.sha256sum] = "b2fdd4cbfabbf871d27411641d12239befc077057d8827f9cfbac162485dfcf8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nfs-utils-2.8.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_nfs-utils;unpack=0"
SRC_URI[x86_64_v2_nfs-utils.sha256sum] = "a30537b44e0dfa9ddcfb3a1a349499486ab4014d120f6ce87bd9ca95555006d2"
RPROVIDES:nfs-utils:append:x86_64_v2 = " virtual/nfs-utils_or_nfsv4-client-utils"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfs-utils-coreos-2.8.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_nfs-utils-coreos;unpack=0"
SRC_URI[x86_64_v2_nfs-utils-coreos.sha256sum] = "28a8d5ef01bf33b9d567992c6eec68592944161e38a04a0476d451704d0bc71c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nfsv4-client-utils-2.8.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_nfsv4-client-utils;unpack=0"
SRC_URI[x86_64_v2_nfsv4-client-utils.sha256sum] = "decbdf80ee1d643657dcf84ed8aa9fa19ca8f7afef0574b12f2d9e4a7ef080b7"
RPROVIDES:nfsv4-client-utils:append:x86_64_v2 = " virtual/nfs-utils_or_nfsv4-client-utils"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnfsidmap-2.8.3-9.el10.aarch64.rpm;name=aarch64_libnfsidmap;unpack=0"
SRC_URI[aarch64_libnfsidmap.sha256sum] = "222d713a0b2fef540cd7353ea93670d7145a3e82caba13019c6d7bad051e403b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnfsidmap-devel-2.8.3-9.el10.aarch64.rpm;name=aarch64_libnfsidmap-devel;unpack=0"
SRC_URI[aarch64_libnfsidmap-devel.sha256sum] = "4629b6cde9258ea893fd1d588813a1b27c464935a1b2a4e7d917374e5a953bc8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nfs-utils-2.8.3-9.el10.aarch64.rpm;name=aarch64_nfs-utils;unpack=0"
SRC_URI[aarch64_nfs-utils.sha256sum] = "9bc20bfe47315accc2f4c3281c4fd6d04730656915362ff7009557beccef1aba"
RPROVIDES:nfs-utils:append:aarch64 = " virtual/nfs-utils_or_nfsv4-client-utils"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfs-utils-coreos-2.8.3-9.el10.aarch64.rpm;name=aarch64_nfs-utils-coreos;unpack=0"
SRC_URI[aarch64_nfs-utils-coreos.sha256sum] = "1d8441c90e1e2778b4d5dc91306acb95f123c581506eeb315180d2a5adad20f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nfsv4-client-utils-2.8.3-9.el10.aarch64.rpm;name=aarch64_nfsv4-client-utils;unpack=0"
SRC_URI[aarch64_nfsv4-client-utils.sha256sum] = "ad94d42fd869c9e4ebebb6d51b53bc04f9267e2b704563f1dda29bbe64d4b796"
RPROVIDES:nfsv4-client-utils:append:aarch64 = " virtual/nfs-utils_or_nfsv4-client-utils"

RDEPENDS:libnfsidmap = " \
 glibc \
 krb5-libs \
 openldap \
 "
RDEPENDS:libnfsidmap-devel = " \
 libnfsidmap \
 pkgconf-pkg-config \
 "
RDEPENDS:nfs-utils:x86_64_v2 = " \
 bash \
 device-mapper-libs \
 gawk \
 glibc \
 grep \
 gssproxy \
 keyutils \
 keyutils-libs \
 kmod \
 krb5-libs \
 libblkid \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libnl3 \
 libtirpc \
 libuuid \
 libxml2 \
 python3 \
 quota \
 readline \
 rpcbind \
 sed \
 selinux-policy \
 shadow-utils \
 sqlite-libs \
 systemd \
 util-linux \
 virtual/coreutils \
"
RDEPENDS:nfs-utils:aarch64 = " \
 bash \
 device-mapper-libs \
 gawk \
 glibc \
 grep \
 gssproxy \
 keyutils \
 keyutils-libs \
 kmod \
 krb5-libs \
 libblkid \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libnl3 \
 libtirpc \
 libuuid \
 libxml2 \
 python3 \
 quota \
 readline \
 rpcbind \
 sed \
 selinux-policy \
 shadow-utils \
 sqlite-libs \
 systemd \
 util-linux \
 virtual/coreutils \
"
RDEPENDS:nfs-utils-coreos:x86_64_v2 = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcap \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 rpcbind \
 systemd \
"
RDEPENDS:nfs-utils-coreos:aarch64 = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 rpcbind \
 systemd \
"
RDEPENDS:nfsv4-client-utils = " \
 glibc \
 gssproxy \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 libevent \
 libgcc \
 libmount \
 libnfsidmap \
 libtirpc \
 "
