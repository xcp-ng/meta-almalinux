# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-blaze-html"
PV = "0.9.2.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-blaze-html \
 ghc-blaze-html-devel \
 ghc-blaze-html-doc \
 ghc-blaze-html-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-blaze-html-0.9.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7b985f788d3126377d3d03d2e33f0b9cad54a1523adc8fbd6efdddba20c4ee3"

URI_x86_64_v2_ghc-blaze-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-html-0.9.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-blaze-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-html}"
SRC_URI[x86_64_v2_ghc-blaze-html.sha256sum] = "d425bdf4e798fb0aff9eb8a2dbb74490703aecd915b2b03ad2e92392a8be8c83"

URI_x86_64_v2_ghc-blaze-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-html-devel-0.9.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-blaze-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-html-devel}"
SRC_URI[x86_64_v2_ghc-blaze-html-devel.sha256sum] = "18e5969fa2432637930e50c0bcf3460b8c267ca0e24ecc994ebea210c51a5acd"

URI_x86_64_v2_ghc-blaze-html-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-html-doc-0.9.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-blaze-html-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-html-doc}"
SRC_URI[x86_64_v2_ghc-blaze-html-doc.sha256sum] = "78e1a9e77d802b4e9743523b4c06a9859a57e6ba332ec544ae4643ddc1277406"

URI_x86_64_v2_ghc-blaze-html-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-blaze-html-prof-0.9.2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-blaze-html-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-blaze-html-prof}"
SRC_URI[x86_64_v2_ghc-blaze-html-prof.sha256sum] = "df9f89f5c1829167d667c1145d074e4594ea1b1604b178d88d0441d58ed1479b"

URI_aarch64_ghc-blaze-html = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-html-0.9.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-blaze-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-html}"
SRC_URI[aarch64_ghc-blaze-html.sha256sum] = "eaa9b47e191f329180e18a4e4ce3508c617c3eab9ae6b687051286f3f7e882ac"

URI_aarch64_ghc-blaze-html-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-html-devel-0.9.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-blaze-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-html-devel}"
SRC_URI[aarch64_ghc-blaze-html-devel.sha256sum] = "c324a13da8fda076c92562103a3c802a6aeb17f3ac7343257bd7ab7e8995796b"

URI_aarch64_ghc-blaze-html-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-html-doc-0.9.2.0-1.el10_0.noarch.rpm;name=aarch64_ghc-blaze-html-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-html-doc}"
SRC_URI[aarch64_ghc-blaze-html-doc.sha256sum] = "a443582ebab412c5efa6a8abc4211b371b8734dda9655e6153ab8b5955f47e64"

URI_aarch64_ghc-blaze-html-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-blaze-html-prof-0.9.2.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-blaze-html-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-blaze-html-prof}"
SRC_URI[aarch64_ghc-blaze-html-prof.sha256sum] = "9a77629ad83b229a1383cd82bdbae55258079e7e5caa767e5946d5e7d1d1de03"

RDEPENDS:ghc-blaze-html = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-blaze-builder \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-blaze-html-devel = " \
 ghc-base-devel \
 ghc-blaze-builder-devel \
 ghc-blaze-html \
 ghc-blaze-markup-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-text-devel \
 "
RDEPENDS:ghc-blaze-html-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-blaze-html-prof = " \
 ghc-base-prof \
 ghc-blaze-builder-prof \
 ghc-blaze-html-devel \
 ghc-blaze-markup-prof \
 ghc-bytestring-prof \
 ghc-text-prof \
 "
