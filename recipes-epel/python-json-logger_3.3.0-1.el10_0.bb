# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-json-logger"
PV = "3.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-json-logger \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-json-logger-3.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ae717fa1589f68f34b90d59fa52f8b2c17edbf9bcf62edb02b84e7410ddd5f35"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-json-logger-3.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-json-logger;unpack=0"
SRC_URI[x86_64_v2_python3-json-logger.sha256sum] = "6080f62e7f645d0461f0c7e948ddc614bcf563295436a3806152fe0aa78c48e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-json-logger-3.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-json-logger;unpack=0"
SRC_URI[aarch64_python3-json-logger.sha256sum] = "c57c00ef2fc58729adb2187f7451c7f49c3d4fa8f0aa50c38fed59a3812a127c"

RDEPENDS:python3-json-logger = " \
 python3 \
 "
