# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audiocd-kio"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 audiocd-kio \
 audiocd-kio-devel \
 audiocd-kio-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audiocd-kio-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdeb1ca68c78b38a75373f562a430ab9403885a0a50e7036c01b7e56b83c70e6"

URI_x86_64_v2_audiocd-kio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio}"
SRC_URI[x86_64_v2_audiocd-kio.sha256sum] = "fadf1d23fbcf00e7c2a8ad9c62547df2cda4ae6633b7cf29eecda4c070fcbc99"

URI_x86_64_v2_audiocd-kio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio-devel}"
SRC_URI[x86_64_v2_audiocd-kio-devel.sha256sum] = "6027d2797cb808050977dad1516256387e60471b21e9751881b73b80e6a0f986"

URI_x86_64_v2_audiocd-kio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_audiocd-kio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio-doc}"
SRC_URI[x86_64_v2_audiocd-kio-doc.sha256sum] = "706f5bf2e68e8f736b5e9f1b733a1504616795c0daa07adb48f7f472af08f622"

URI_aarch64_audiocd-kio = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_audiocd-kio;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio}"
SRC_URI[aarch64_audiocd-kio.sha256sum] = "d9c5263adb1c0ab5593a270fc219bb1fd8cefed9642df8533a92275829f03351"

URI_aarch64_audiocd-kio-devel = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_audiocd-kio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio-devel}"
SRC_URI[aarch64_audiocd-kio-devel.sha256sum] = "5053fa23c365c706af8826d839f9e3b8c72a35f2d7fc10ffc50fa5460ae65e9a"

URI_aarch64_audiocd-kio-doc = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_audiocd-kio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio-doc}"
SRC_URI[aarch64_audiocd-kio-doc.sha256sum] = "ad669ad04a0999f9e9dd272581c96f491e4eded40ca7cc67c309624afa36a620"

RDEPENDS:audiocd-kio = " \
 audiocd-kio-doc \
 cdparanoia-libs \
 flac-libs \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 libkcddb \
 libkcompactdisc \
 libogg \
 libstdc++ \
 libvorbis \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:audiocd-kio-devel = " \
 audiocd-kio \
 "
RDEPENDS:audiocd-kio-doc = " \
 audiocd-kio \
 "
