# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is-terminal"
PV = "0.4.17"
PR = "3.el10_1"
PACKAGES = " \
 rust-is-terminal+default-devel \
 rust-is-terminal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is-terminal-0.4.17-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "265ee92f0ebc6eb776571f1f4db3d7a04aec41857dcaaa9485ce4ba91ba7b29e"

URI_x86_64_v2_rust-is-terminal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-terminal+default-devel-0.4.17-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-terminal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-terminal+default-devel}"
SRC_URI[x86_64_v2_rust-is-terminal+default-devel.sha256sum] = "a7d4f6697cb324d47061830b85245860141a81fa4538f0bc408240da843d9630"

URI_x86_64_v2_rust-is-terminal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-terminal-devel-0.4.17-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-terminal-devel}"
SRC_URI[x86_64_v2_rust-is-terminal-devel.sha256sum] = "674c03f8490c678eb087117c1dca4fd1ad41041a9f501f0745a1f47bfc1ea027"

URI_aarch64_rust-is-terminal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-terminal+default-devel-0.4.17-3.el10_1.noarch.rpm;name=aarch64_rust-is-terminal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-terminal+default-devel}"
SRC_URI[aarch64_rust-is-terminal+default-devel.sha256sum] = "3fc7ac8dba0269be37463c6ad5057d3a4f35dd8422a3a81e0a0f39d8cecf94ec"

URI_aarch64_rust-is-terminal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-terminal-devel-0.4.17-3.el10_1.noarch.rpm;name=aarch64_rust-is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-terminal-devel}"
SRC_URI[aarch64_rust-is-terminal-devel.sha256sum] = "c4a5440b4d32257a38fe0562b25e9cfa2408d08cedd0e5be458c23f86ce4d35e"

RDEPENDS:rust-is-terminal+default-devel = " \
 cargo \
 rust-is-terminal-devel \
 "
RDEPENDS:rust-is-terminal-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
