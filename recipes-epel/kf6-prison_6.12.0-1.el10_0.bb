# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-prison"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-prison \
 kf6-prison-devel \
 kf6-prison-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-prison-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "daade47cdc51beb73802daa68ecc0e06d22568b82e02601753717c812f912485"

URI_x86_64_v2_kf6-prison = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison}"
SRC_URI[x86_64_v2_kf6-prison.sha256sum] = "d12fb313fa235c8247ae68f530e9030feef511c5ceb0d9526632c887dfa3d3df"

URI_x86_64_v2_kf6-prison-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-devel}"
SRC_URI[x86_64_v2_kf6-prison-devel.sha256sum] = "0991d1f5bc23be3ad8e6bfaf627320c1dc219bb555668300af76bc0b38201ab0"

URI_x86_64_v2_kf6-prison-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-prison-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-prison-doc}"
SRC_URI[x86_64_v2_kf6-prison-doc.sha256sum] = "0df83a72fb94961d0bf06d783aa7b62fb43a5e662113fa479b96fa89164bff4f"

URI_aarch64_kf6-prison = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-prison;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison}"
SRC_URI[aarch64_kf6-prison.sha256sum] = "992e92ace836e46145a1507f99e70492e5a35615fb93f041b96db93f514434c6"

URI_aarch64_kf6-prison-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-prison-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-devel}"
SRC_URI[aarch64_kf6-prison-devel.sha256sum] = "e286e266d9da21037a8b76e0d789c54671295693da4ba6ca13c317158d40af44"

URI_aarch64_kf6-prison-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-prison-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-prison-doc}"
SRC_URI[aarch64_kf6-prison-doc.sha256sum] = "26e3f7442aaca2c8d152b254eeaef84b4d1a28c7dd712996f4271181ed2fa120"

RDEPENDS:kf6-prison = " \
 glibc \
 kf6-filesystem \
 libdmtx \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 zxing-cpp \
 "
RDEPENDS:kf6-prison-devel = " \
 cmake-filesystem \
 kf6-prison \
 "
RDEPENDS:kf6-prison-doc = " \
 "
