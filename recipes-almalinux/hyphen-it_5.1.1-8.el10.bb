# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-it"
PV = "5.1.1"
PR = "8.el10"
PACKAGES = " \
 hyphen-it \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-it-5.1.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "006ad041fa0b22aae050244541b0177f7919804fe833048b07d2fa21ac1e02dd"

URI_x86_64_v2_hyphen-it = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-it-5.1.1-8.el10.noarch.rpm;name=x86_64_v2_hyphen-it;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-it}"
SRC_URI[x86_64_v2_hyphen-it.sha256sum] = "afb19ac2561f4f4694966f447435d1c4ff10b8d26b7ef703878b2e881ab27f08"

URI_aarch64_hyphen-it = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-it-5.1.1-8.el10.noarch.rpm;name=aarch64_hyphen-it;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-it}"
SRC_URI[aarch64_hyphen-it.sha256sum] = "afb19ac2561f4f4694966f447435d1c4ff10b8d26b7ef703878b2e881ab27f08"

RDEPENDS:hyphen-it = " \
 hyphen \
 "
