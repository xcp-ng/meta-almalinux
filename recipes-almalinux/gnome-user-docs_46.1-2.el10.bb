# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-user-docs"
PV = "46.1"
PR = "2.el10"
PACKAGES = " \
 gnome-user-docs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-user-docs-46.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3c9fea810a3af9a0deb94f714d1e428d8f2b18aba530091323e4b371f73a7b1e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-user-docs-46.1-2.el10.noarch.rpm;name=x86_64_v2_gnome-user-docs;unpack=0"
SRC_URI[x86_64_v2_gnome-user-docs.sha256sum] = "f84768aed4df3d7799dac33c4a054500d768b6c696a18406f2a8049b22d123d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-user-docs-46.1-2.el10.noarch.rpm;name=aarch64_gnome-user-docs;unpack=0"
SRC_URI[aarch64_gnome-user-docs.sha256sum] = "f84768aed4df3d7799dac33c4a054500d768b6c696a18406f2a8049b22d123d1"

RDEPENDS:gnome-user-docs = " \
 "
