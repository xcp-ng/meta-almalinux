# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo"
PV = "0.98.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo+default-devel \
 rust-cargo+http-transport-curl-devel \
 rust-cargo+http-transport-reqwest-devel \
 rust-cargo+openssl-devel \
 rust-cargo-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-0.98.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7a2dc1453b9feacce736594028be80e80af3a30fa8c5d6c685ca7aee1f329aad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+default-devel-0.98.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo+default-devel.sha256sum] = "cfe4e04a97b1d5e79fcdb655ca3ffd5cd5504e97b8728bed2ae1665dc7e56da6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+http-transport-curl-devel-0.98.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+http-transport-curl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo+http-transport-curl-devel.sha256sum] = "156db772d877411f51376e219a796cc683ebf74916bc0a349c5d449f1989afcb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+http-transport-reqwest-devel-0.98.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+http-transport-reqwest-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo+http-transport-reqwest-devel.sha256sum] = "f6b76972c25098886787364d0437123addb8f68d5e1d04b5db737314d3c2f243"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+openssl-devel-0.98.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+openssl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo+openssl-devel.sha256sum] = "49b77a8d908af20a4865a68ba3a393fa64bf3db6eeeb38411ffdc75c1842976b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-devel-0.98.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-devel.sha256sum] = "b8eb6912322a907e084a4ffa18c155be8ce13c48a1ca693628b85b9f8b308bdb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+default-devel-0.98.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo+default-devel;unpack=0"
SRC_URI[aarch64_rust-cargo+default-devel.sha256sum] = "bb2c4d71567acbad0f6bcc8a3dc98343861fa7f5ffd7cf2dafa6dee0d95b23e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+http-transport-curl-devel-0.98.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo+http-transport-curl-devel;unpack=0"
SRC_URI[aarch64_rust-cargo+http-transport-curl-devel.sha256sum] = "a953ff15d63c2a40bf9dfcdb2418cae32343915742f5d0ddf4596a0808e5657d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+http-transport-reqwest-devel-0.98.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo+http-transport-reqwest-devel;unpack=0"
SRC_URI[aarch64_rust-cargo+http-transport-reqwest-devel.sha256sum] = "6eadd4efceb99121c35b5f3fb8ec5856003b200a86e4fc33cd06b31b092a9434"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+openssl-devel-0.98.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo+openssl-devel;unpack=0"
SRC_URI[aarch64_rust-cargo+openssl-devel.sha256sum] = "53d3042567173fe75767e4f3c89d09f530e8282cb29583f21a863fc28838525b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-devel-0.98.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-devel.sha256sum] = "7fadc4a0bacdd417e3910c70c3d11de337c70dddc11ffdab0021cd63559d3733"

RDEPENDS:rust-cargo+default-devel = " \
 cargo \
 rust-cargo+http-transport-curl-devel \
 rust-cargo-devel \
 "
RDEPENDS:rust-cargo+http-transport-curl-devel = " \
 cargo \
 rust-cargo-devel \
 rust-gix+blocking-http-transport-curl-devel \
 "
RDEPENDS:rust-cargo+http-transport-reqwest-devel = " \
 cargo \
 rust-cargo-devel \
 rust-gix+blocking-http-transport-reqwest-devel \
 "
RDEPENDS:rust-cargo+openssl-devel = " \
 cargo \
 rust-cargo-devel \
 rust-openssl+default-devel \
 "
RDEPENDS:rust-cargo-devel = " \
 cargo \
 rust \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-anstyle-progress+default-devel \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-base64_0.22+default-devel \
 rust-blake3+default-devel \
 rust-cargo-credential+default-devel \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-platform+default-devel \
 rust-cargo-util+default-devel \
 rust-cargo-util-schemas+default-devel \
 rust-cargo-util-terminal+default-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete+unstable-dynamic-devel \
 rust-color-print+default-devel \
 rust-crates-io+default-devel \
 rust-curl+default-devel \
 rust-curl+http2-devel \
 rust-curl-sys+default-devel \
 rust-filetime+default-devel \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-futures+async-await-devel \
 rust-futures+executor-devel \
 rust-futures+std-devel \
 rust-futures-devel \
 rust-futures-timer+default-devel \
 rust-git2-curl+default-devel \
 rust-git2_0.20+default-devel \
 rust-gix+dirwalk-devel \
 rust-gix+parallel-devel \
 rust-gix+progress-tree-devel \
 rust-gix+sha1-devel \
 rust-gix+status-devel \
 rust-gix-devel \
 rust-glob+default-devel \
 rust-heck+default-devel \
 rust-hex+default-devel \
 rust-hmac+default-devel \
 rust-home+default-devel \
 rust-http+default-devel \
 rust-http-auth-devel \
 rust-ignore+default-devel \
 rust-im-rc+default-devel \
 rust-indexmap+default-devel \
 rust-itertools0.14+default-devel \
 rust-jiff+serde-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-jobserver+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-memchr+default-devel \
 rust-opener+default-devel \
 rust-os_info-devel \
 rust-pasetors+default-devel \
 rust-pasetors+paserk-devel \
 rust-pasetors+serde-devel \
 rust-pasetors+std-devel \
 rust-pasetors+v3-devel \
 rust-pathdiff+default-devel \
 rust-portable-atomic+default-devel \
 rust-rand+default-devel \
 rust-regex+default-devel \
 rust-rusqlite+default-devel \
 rust-rusqlite+fallible_uint-devel \
 rust-rustc-hash+default-devel \
 rust-rustc-stable-hash+default-devel \
 rust-rustfix+default-devel \
 rust-same-file+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde-untagged+default-devel \
 rust-serde_ignored+default-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-sha1+default-devel \
 rust-shell-escape+default-devel \
 rust-tar-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-toml+display-devel \
 rust-toml+parse-devel \
 rust-toml+preserve_order-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+serde-devel \
 rust-toml_parser+default-devel \
 rust-toml_writer+default-devel \
 rust-tracing+attributes-devel \
 rust-tracing+std-devel \
 rust-tracing-chrome+default-devel \
 rust-tracing-devel \
 rust-tracing-subscriber+default-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-unicase+default-devel \
 rust-unicode-ident+default-devel \
 rust-unicode-width+default-devel \
 rust-url+default-devel \
 rust-walkdir+default-devel \
 rust-winnow+default-devel \
 "
