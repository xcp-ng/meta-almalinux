# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgedit-tepl"
PV = "6.12.0"
PR = "1.el10_1"
PACKAGES = " \
 libgedit-tepl \
 libgedit-tepl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgedit-tepl-6.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c4831f96d861e26c70fcb4715ace1fe3e201f26e2dc179b0192c815409b29c6"

URI_x86_64_v2_libgedit-tepl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-tepl-6.12.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-tepl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-tepl}"
SRC_URI[x86_64_v2_libgedit-tepl.sha256sum] = "7a102f41c7e6c745c1102c6934d5918c7a60e4b85c614ce71c69d54befa7b0fa"

URI_x86_64_v2_libgedit-tepl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-tepl-devel-6.12.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-tepl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-tepl-devel}"
SRC_URI[x86_64_v2_libgedit-tepl-devel.sha256sum] = "b9073930ded7e055af7659331f74f59f555b099ac66c05dda0861da313848d95"

URI_aarch64_libgedit-tepl = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-tepl-6.12.0-1.el10_1.aarch64.rpm;name=aarch64_libgedit-tepl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-tepl}"
SRC_URI[aarch64_libgedit-tepl.sha256sum] = "31643228b5bb92ed836f645b2e2396d99648d3141375c0e64d5fb8fd00879073"

URI_aarch64_libgedit-tepl-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-tepl-devel-6.12.0-1.el10_1.aarch64.rpm;name=aarch64_libgedit-tepl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-tepl-devel}"
SRC_URI[aarch64_libgedit-tepl-devel.sha256sum] = "6f3a8eb53c09810ee1c5a04487a2dcceca25e4f7f951e972f7a5d9726dc634e4"

RDEPENDS:libgedit-tepl = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 libgedit-amtk \
 libgedit-gfls \
 libgedit-gtksourceview \
 libhandy \
 libicu \
 pango \
 "
RDEPENDS:libgedit-tepl-devel = " \
 glib2-devel \
 gsettings-desktop-schemas-devel \
 gtk3-devel \
 libgedit-amtk-devel \
 libgedit-gfls-devel \
 libgedit-gtksourceview-devel \
 libgedit-tepl \
 libhandy-devel \
 libicu-devel \
 pkgconf-pkg-config \
 "
