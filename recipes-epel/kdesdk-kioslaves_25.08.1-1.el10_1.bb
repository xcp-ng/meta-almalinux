# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-kioslaves"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kdesdk-kioslaves \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdesdk-kioslaves-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b6250d2b33ee6376311430d81bbe604a10903e85534bcf4a483c7d347e03102"

URI_x86_64_v2_kdesdk-kioslaves = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-kioslaves-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-kioslaves;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesdk-kioslaves}"
SRC_URI[x86_64_v2_kdesdk-kioslaves.sha256sum] = "b96a746b3edf9d15e7607af4c37c06f49e4dc187736dfc0365c23d51ebbff99d"

URI_aarch64_kdesdk-kioslaves = "${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-kioslaves-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kdesdk-kioslaves;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesdk-kioslaves}"
SRC_URI[aarch64_kdesdk-kioslaves.sha256sum] = "31103f1ea50cce02a009e62e04c5bcc003b66b4242ce598c7328c9da2f40b6de"

RDEPENDS:kdesdk-kioslaves = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 perl-Carp \
 perl-English \
 perl-Pod-Parser \
 perl-base \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 "
