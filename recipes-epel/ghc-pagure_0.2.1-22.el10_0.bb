# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-pagure"
PV = "0.2.1"
PR = "22.el10_0"
PACKAGES = " \
 ghc-pagure \
 ghc-pagure-devel \
 ghc-pagure-doc \
 ghc-pagure-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-pagure-0.2.1-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45caa6429abcc4c1d1f03b50575dda5ab14581fc37e7a446b97c0722526517ad"

URI_x86_64_v2_ghc-pagure = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pagure-0.2.1-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pagure;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pagure}"
SRC_URI[x86_64_v2_ghc-pagure.sha256sum] = "8e5837844ab23fba169f53660bf31e06a34ff79d5a3c48d0452b182e80f10c2c"

URI_x86_64_v2_ghc-pagure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pagure-devel-0.2.1-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pagure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pagure-devel}"
SRC_URI[x86_64_v2_ghc-pagure-devel.sha256sum] = "8e9b9eb36c07246447000c9efc1b65550bb689b69e9e8581651b48fcbe3edec3"

URI_x86_64_v2_ghc-pagure-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pagure-doc-0.2.1-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pagure-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pagure-doc}"
SRC_URI[x86_64_v2_ghc-pagure-doc.sha256sum] = "6c239ce5e3fd7e042d4d74d123a6828dcb0b28e6576edba320b039f130633609"

URI_x86_64_v2_ghc-pagure-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pagure-prof-0.2.1-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pagure-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pagure-prof}"
SRC_URI[x86_64_v2_ghc-pagure-prof.sha256sum] = "62851c4f847b64930489c56c1983d7bf2f5f7a1b19b3c31ee0b6ccd71e45d94f"

URI_aarch64_ghc-pagure = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pagure-0.2.1-22.el10_0.aarch64.rpm;name=aarch64_ghc-pagure;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pagure}"
SRC_URI[aarch64_ghc-pagure.sha256sum] = "8bde96ddafbf9d568f86cd986e34d7d6ffd106a56578bcb448dc80821c44da47"

URI_aarch64_ghc-pagure-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pagure-devel-0.2.1-22.el10_0.aarch64.rpm;name=aarch64_ghc-pagure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pagure-devel}"
SRC_URI[aarch64_ghc-pagure-devel.sha256sum] = "f93ccca5f3dd05ab703114c6825fd97b48c1f71d7ae4402b867fc561cfd0a3dc"

URI_aarch64_ghc-pagure-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pagure-doc-0.2.1-22.el10_0.noarch.rpm;name=aarch64_ghc-pagure-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pagure-doc}"
SRC_URI[aarch64_ghc-pagure-doc.sha256sum] = "b5dd9602f76f7a7a344ec13f3fad40000154b3e5199411b4fc1d767ead21badd"

URI_aarch64_ghc-pagure-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pagure-prof-0.2.1-22.el10_0.aarch64.rpm;name=aarch64_ghc-pagure-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pagure-prof}"
SRC_URI[aarch64_ghc-pagure-prof.sha256sum] = "ac5b0ae1f70a6117b25b360fd1ef5d62afa21a35cf26aa60faabd2c7405aca9f"

RDEPENDS:ghc-pagure = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-query \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-pagure-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-http-query-devel \
 ghc-pagure \
 ghc-text-devel \
 "
RDEPENDS:ghc-pagure-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pagure-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-http-query-prof \
 ghc-pagure-devel \
 ghc-text-prof \
 "
