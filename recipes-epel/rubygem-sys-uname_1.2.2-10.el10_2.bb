# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-sys-uname"
PV = "1.2.2"
PR = "10.el10_2"
PACKAGES = " \
 rubygem-sys-uname \
 rubygem-sys-uname-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-sys-uname-1.2.2-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12c2b04d4cb1debc3f647ca1e4b7e539e92795e84a0050f829685020b8fdc70b"

URI_x86_64_v2_rubygem-sys-uname = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-sys-uname-1.2.2-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-sys-uname;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-sys-uname}"
SRC_URI[x86_64_v2_rubygem-sys-uname.sha256sum] = "1a0476ba2f24971309283b521fa0fdaf286fc9101d084cd0c3972cc89f14d746"

URI_x86_64_v2_rubygem-sys-uname-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-sys-uname-doc-1.2.2-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-sys-uname-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-sys-uname-doc}"
SRC_URI[x86_64_v2_rubygem-sys-uname-doc.sha256sum] = "2aad868b0358ed0cfcb33c285ed80e2012400a0c01b3ab45088c65685bc4b805"

URI_aarch64_rubygem-sys-uname = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-sys-uname-1.2.2-10.el10_2.noarch.rpm;name=aarch64_rubygem-sys-uname;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-sys-uname}"
SRC_URI[aarch64_rubygem-sys-uname.sha256sum] = "c939ccb45c77feab01b3583d4749a468daeedc4c55bfa13746d8495beef9d7b5"

URI_aarch64_rubygem-sys-uname-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-sys-uname-doc-1.2.2-10.el10_2.noarch.rpm;name=aarch64_rubygem-sys-uname-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-sys-uname-doc}"
SRC_URI[aarch64_rubygem-sys-uname-doc.sha256sum] = "df791aab99a8de1904c8f217c3441005671aac1c2cf25afb6eb3c9f97081cc3e"

RDEPENDS:rubygem-sys-uname = " \
 rubygem-ffi \
 rubygems \
 "
RDEPENDS:rubygem-sys-uname-doc = " \
 rubygem-sys-uname \
 "
