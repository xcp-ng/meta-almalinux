# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xfsdump"
PV = "3.2.0"
PR = "1.el10"
PACKAGES = " \
 xfsdump \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/xfsdump-3.2.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec6a54336729e11b245b6e03e77dcc764e00ecb8a980a751491e3cc4b8fc634c"

URI_x86_64_v2_xfsdump = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xfsdump-3.2.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_xfsdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xfsdump}"
SRC_URI[x86_64_v2_xfsdump.sha256sum] = "9099fb4e416ff1f15a7757fb4ddb8ac430a0f6447a256d67de910026f79dca7a"

URI_aarch64_xfsdump = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xfsdump-3.2.0-1.el10.aarch64.rpm;name=aarch64_xfsdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_xfsdump}"
SRC_URI[aarch64_xfsdump.sha256sum] = "a873aba64150fca06475860686ab45e2aeab15c4367cf00548ba52f67d4f3ce3"

RDEPENDS:xfsdump = " \
 attr \
 glibc \
 libattr \
 libgcc \
 libuuid \
 ncurses-libs \
 xfsprogs \
 "
