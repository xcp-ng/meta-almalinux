# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libssh2-sys"
PV = "0.3.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-libssh2-sys+default-devel \
 rust-libssh2-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libssh2-sys-0.3.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a36bcf1197b39720ffd588179391295609dbaf70055f498996feebc598269314"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys+default-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libssh2-sys+default-devel.sha256sum] = "fc5eeea032cc413da4b5fb2eca02bd439e36f222931794d375a17ab34e137e34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libssh2-sys-devel-0.3.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libssh2-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libssh2-sys-devel.sha256sum] = "55cef0c7f95c070101da5c446c8aa73729bb26eaeffa3702c728acf6f32e265b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys+default-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-libssh2-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-libssh2-sys+default-devel.sha256sum] = "a0fc8a31f5df04733e83f3af8d7e26e52499bed393e331b1ac1a27110348c541"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libssh2-sys-devel-0.3.3-1.el10_2.noarch.rpm;name=aarch64_rust-libssh2-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libssh2-sys-devel.sha256sum] = "f8792c9829bed17abc7e4a8461a4b61de3347d10070af3643cc31789ff32e5f2"

RDEPENDS:rust-libssh2-sys+default-devel = " \
 cargo \
 rust-libssh2-sys-devel \
 "
RDEPENDS:rust-libssh2-sys-devel = " \
 cargo \
 libssh2-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-openssl-sys+default-devel \
 rust-pkg-config+default-devel \
 "
