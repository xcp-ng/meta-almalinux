# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "waypipe"
PV = "0.8.6"
PR = "7.el10"
PACKAGES = " \
 waypipe \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/waypipe-0.8.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c38d6cee34be501c7cbaaaf2da041c78fd412950715411d46d942d67fd06afaf"

URI_x86_64_v2_waypipe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/waypipe-0.8.6-7.el10.x86_64_v2.rpm;name=x86_64_v2_waypipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_waypipe}"
SRC_URI[x86_64_v2_waypipe.sha256sum] = "4334d15eabc6001723c0d2f3f0c96e1ab4dd92582d0fb36055ca4b2755c6bc94"

URI_aarch64_waypipe = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/waypipe-0.8.6-7.el10.aarch64.rpm;name=aarch64_waypipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_waypipe}"
SRC_URI[aarch64_waypipe.sha256sum] = "d4a44a0c55f1184d7a3077df55f61275e1fce0404d22f5dc23a3c7841b5127f4"

RDEPENDS:waypipe = " \
 glibc \
 libzstd \
 lz4-libs \
 mesa-libgbm \
 "
