# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-FCGI-Client"
PV = "0.09"
PR = "19.el10_0"
PACKAGES = " \
 perl-FCGI-Client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-FCGI-Client-0.09-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44088cca1d39b76b59c1c3bdddaf4cac3bd83519b6ccf5e9a6fe3793bf6fa24f"

URI_x86_64_v2_perl-FCGI-Client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-FCGI-Client-0.09-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-FCGI-Client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-FCGI-Client}"
SRC_URI[x86_64_v2_perl-FCGI-Client.sha256sum] = "e79808d17ca1aec9dbcd9225aa7516a2ed4ee126760902abbc2e933c5448ad79"

URI_aarch64_perl-FCGI-Client = "${EPEL_MIRROR}/aarch64/Packages/p/perl-FCGI-Client-0.09-19.el10_0.noarch.rpm;name=aarch64_perl-FCGI-Client;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-FCGI-Client}"
SRC_URI[aarch64_perl-FCGI-Client.sha256sum] = "4b342323bee2a1f9ff4dbf6f439267d6a4708de31cbc92de88e8d10cf6ef0210"

RDEPENDS:perl-FCGI-Client = " \
 perl-Carp \
 perl-Moo \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-Type-Tiny \
 perl-libs \
 "
