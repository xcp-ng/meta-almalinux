# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "389-ds-base"
PV = "3.3.0"
PR = "4.el10"
PACKAGES = " \
 389-ds-base \
 389-ds-base-bdb \
 389-ds-base-devel \
 389-ds-base-libs \
 389-ds-base-snmp \
 python3-lib389 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/389-ds-base-3.3.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "62ab7c3732abd735353e4347d8d798f33a4fe97057c2b6a4697517e0267a01de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-3.3.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base;unpack=0"
SRC_URI[x86_64_v2_389-ds-base.sha256sum] = "a53a0f17d712beb060c9a994748b3c033f66106de4afd6b709df84242322e1c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-bdb-3.3.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-bdb;unpack=0"
SRC_URI[x86_64_v2_389-ds-base-bdb.sha256sum] = "dfe166ca2190fe507c04e0f65d1685bd28a4cc0781dcd4bec1de841bd247dc31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-devel-3.3.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-devel;unpack=0"
SRC_URI[x86_64_v2_389-ds-base-devel.sha256sum] = "0b8d55d4ad4a668e14d58a199cb74578ea15be8baef8c5b988d34c4146ab79bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-libs-3.3.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-libs;unpack=0"
SRC_URI[x86_64_v2_389-ds-base-libs.sha256sum] = "f9a0ec32ddd10d5195a6d68c03e871d545756526b7a8bdac56d367bac6a1d5af"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-snmp-3.3.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-snmp;unpack=0"
SRC_URI[x86_64_v2_389-ds-base-snmp.sha256sum] = "35d618fc958c2344cb53a8bd3fe259bbda1b9f1c513f26addbf5460e385aac23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lib389-3.3.0-4.el10.noarch.rpm;name=x86_64_v2_python3-lib389;unpack=0"
SRC_URI[x86_64_v2_python3-lib389.sha256sum] = "fcfb3b87f6a1b335ca3fa5a6a1b43b75ad7c8289d60d6697ac0a8d6d6ae4e437"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-3.3.0-4.el10.aarch64.rpm;name=aarch64_389-ds-base;unpack=0"
SRC_URI[aarch64_389-ds-base.sha256sum] = "071c1ff7d2d1ee7915a69f16f89f97005f443bf8d62e05f0a279f5fb7e9f2308"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-bdb-3.3.0-4.el10.aarch64.rpm;name=aarch64_389-ds-base-bdb;unpack=0"
SRC_URI[aarch64_389-ds-base-bdb.sha256sum] = "efe1409c67cf6264d3af4a8d14c0dcbb14a0aab8c998e9e57ec4f7e7931f9346"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-devel-3.3.0-4.el10.aarch64.rpm;name=aarch64_389-ds-base-devel;unpack=0"
SRC_URI[aarch64_389-ds-base-devel.sha256sum] = "16f1a54839795f4ba6bc97a035d48349c4857067523543191f64f6f7d2eed490"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-libs-3.3.0-4.el10.aarch64.rpm;name=aarch64_389-ds-base-libs;unpack=0"
SRC_URI[aarch64_389-ds-base-libs.sha256sum] = "425a51e2c4798da2a3e3a1c678328a733899a0bec4b6b2570123882e1373a628"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-snmp-3.3.0-4.el10.aarch64.rpm;name=aarch64_389-ds-base-snmp;unpack=0"
SRC_URI[aarch64_389-ds-base-snmp.sha256sum] = "47248dbffce721d134ba1dc37939243e7d69c5ec3df26f9582dde8b421fe6803"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lib389-3.3.0-4.el10.noarch.rpm;name=aarch64_python3-lib389;unpack=0"
SRC_URI[aarch64_python3-lib389.sha256sum] = "fcfb3b87f6a1b335ca3fa5a6a1b43b75ad7c8289d60d6697ac0a8d6d6ae4e437"

RDEPENDS:389-ds-base = " \
 389-ds-base-libs \
 acl \
 bash \
 cracklib \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 cyrus-sasl-md5 \
 cyrus-sasl-plain \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libstdc++ \
 libxcrypt \
 lmdb-libs \
 nspr \
 nss \
 nss-tools \
 nss-util \
 openldap \
 openldap-clients \
 openssl-libs \
 pam-libs \
 pcre2 \
 perl-Archive-Tar \
 perl-debugger \
 perl-interpreter \
 perl-sigtrap \
 policycoreutils-python-utils \
 python3 \
 python3-file-magic \
 python3-lib389 \
 python3-libsemanage \
 selinux-policy \
 shadow-utils \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:389-ds-base-bdb = " \
 389-ds-base \
 389-ds-base-libs \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 lmdb-libs \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-devel = " \
 389-ds-base-libs \
 nspr-devel \
 nss-devel \
 openldap-devel \
 pkgconf-pkg-config \
 systemd-libs \
 "
RDEPENDS:389-ds-base-libs = " \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-snmp = " \
 389-ds-base \
 bash \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 nspr \
 openldap \
 "
RDEPENDS:python3-lib389 = " \
 389-ds-base \
 iproute \
 openssl \
 openssl-perl \
 python3 \
 python3-argcomplete \
 python3-cryptography \
 python3-dateutil \
 python3-distro \
 python3-ldap \
 python3-libselinux \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-setuptools \
 "
