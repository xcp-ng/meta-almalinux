# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmousetool"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kmousetool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmousetool-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae10b45f21e47e241803c7d04d1ccb43ec122617ece503c352eb5108b3b9749c"

URI_x86_64_v2_kmousetool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmousetool-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmousetool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmousetool}"
SRC_URI[x86_64_v2_kmousetool.sha256sum] = "f2a6d31bb25d8d5c3be1e05da3f061178ae9893ba72aba8cdcb69c419bff3003"

URI_aarch64_kmousetool = "${EPEL_MIRROR}/aarch64/Packages/k/kmousetool-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kmousetool;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmousetool}"
SRC_URI[aarch64_kmousetool.sha256sum] = "86295e86b2376891e6b755d072adcdad6d245e9606bf3ab39af7db9999426bb6"

RDEPENDS:kmousetool = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libX11 \
 libXtst \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
