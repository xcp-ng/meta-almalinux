# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jansi"
PV = "2.4.1"
PR = "5.el10"
PACKAGES = " \
 jansi \
 jansi-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jansi-2.4.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e637485f942da49c69ee7a2c3ce10993ec8ac8e5293aa3a3459aebf1baf52bb0"

URI_x86_64_v2_jansi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jansi-2.4.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_jansi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jansi}"
SRC_URI[x86_64_v2_jansi.sha256sum] = "ee81a7e329e0dbe5094c3aaac44cb3824b9ee31967d3ce18cb64678753aef15e"

URI_x86_64_v2_jansi-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jansi-javadoc-2.4.1-5.el10.noarch.rpm;name=x86_64_v2_jansi-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jansi-javadoc}"
SRC_URI[x86_64_v2_jansi-javadoc.sha256sum] = "056dfe2526b3d183d7a4da8edcaa7eb51616866640beaab1693b3c2b41dc69a1"

URI_aarch64_jansi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jansi-2.4.1-5.el10.aarch64.rpm;name=aarch64_jansi;unpack=0"
SRC_URI:append = " ${URI_aarch64_jansi}"
SRC_URI[aarch64_jansi.sha256sum] = "3d5eaa8c4a0f1e7cb56acfeddfef59ba76a77a4d9046a619b23c2d78ce8b93a0"

URI_aarch64_jansi-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jansi-javadoc-2.4.1-5.el10.noarch.rpm;name=aarch64_jansi-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jansi-javadoc}"
SRC_URI[aarch64_jansi-javadoc.sha256sum] = "056dfe2526b3d183d7a4da8edcaa7eb51616866640beaab1693b3c2b41dc69a1"

RDEPENDS:jansi = " \
 glibc \
 javapackages-filesystem \
 "
RDEPENDS:jansi-javadoc = " \
 javapackages-filesystem \
 "
