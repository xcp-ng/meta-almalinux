# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glslang"
PV = "15.1.0"
PR = "1.el10"
PACKAGES = " \
 glslang \
 glslang-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/glslang-15.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b65efacdc5778457175e70d1fc394c974d354a253f8a5b1da270214010c288f"

URI_x86_64_v2_glslang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glslang-15.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslang}"
SRC_URI[x86_64_v2_glslang.sha256sum] = "8015f3a4febfb1947aebca9d0951abea441b0eee1edb7cdf49402d565039d367"

URI_x86_64_v2_glslang-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glslang-devel-15.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslang-devel}"
SRC_URI[x86_64_v2_glslang-devel.sha256sum] = "51b7e8b03835d3ef89cd291b19eb36b7ebf948d093890c69f6563e0dacbea76c"

URI_aarch64_glslang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glslang-15.1.0-1.el10.aarch64.rpm;name=aarch64_glslang;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslang}"
SRC_URI[aarch64_glslang.sha256sum] = "757940d9ad20b5cd2e8e1d11d44c31202853cd5679583fde417855c2bd27a79c"

URI_aarch64_glslang-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glslang-devel-15.1.0-1.el10.aarch64.rpm;name=aarch64_glslang-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslang-devel}"
SRC_URI[aarch64_glslang-devel.sha256sum] = "e819b5bb1de407ced100115afb6127759fced6c34148f473585df3aff8cd2df0"

RDEPENDS:glslang = " \
 glibc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:glslang-devel = " \
 cmake-filesystem \
 glslang \
 pkgconf-pkg-config \
 "
