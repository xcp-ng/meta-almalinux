# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-write16"
PV = "1.0.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-write16+alloc-devel \
 rust-write16+arrayvec-devel \
 rust-write16+default-devel \
 rust-write16+smallvec-devel \
 rust-write16-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-write16-1.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4487e2ab1999afc0bcdd1a25e7921a961ecd9970c2c29b79a6388a93429158ae"

URI_x86_64_v2_rust-write16+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16+alloc-devel-1.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16+alloc-devel}"
SRC_URI[x86_64_v2_rust-write16+alloc-devel.sha256sum] = "c87af31d3d37127ad4048d2897650ec85611b97c31f0598af88184af71ca987d"

URI_x86_64_v2_rust-write16+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16+arrayvec-devel-1.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-write16+arrayvec-devel.sha256sum] = "04bf9577d9b8035669f3ad771d487bea4549da1a7e6372d3b1a27d2c05e2565b"

URI_x86_64_v2_rust-write16+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16+default-devel-1.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16+default-devel}"
SRC_URI[x86_64_v2_rust-write16+default-devel.sha256sum] = "fb6a2266fa482943067504f3345d3f7bfe383759ac855a53d80806a191932e23"

URI_x86_64_v2_rust-write16+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16+smallvec-devel-1.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16+smallvec-devel}"
SRC_URI[x86_64_v2_rust-write16+smallvec-devel.sha256sum] = "6b14565f6071008aa0ee88de229ee8f391b64a0e796bb5d021c2b9bded7aef37"

URI_x86_64_v2_rust-write16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16-devel-1.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16-devel}"
SRC_URI[x86_64_v2_rust-write16-devel.sha256sum] = "4f31601c7b927855207c1f95dee6e684576df88164f18b21b97e8bc659fd272d"

URI_aarch64_rust-write16+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16+alloc-devel-1.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-write16+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16+alloc-devel}"
SRC_URI[aarch64_rust-write16+alloc-devel.sha256sum] = "487ff58bd48094c78ce9f09fdd0df9fd6da2f1dfd0d93c618fb5040cef9178ee"

URI_aarch64_rust-write16+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16+arrayvec-devel-1.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-write16+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16+arrayvec-devel}"
SRC_URI[aarch64_rust-write16+arrayvec-devel.sha256sum] = "582d791f8b64f20ac8629063c64a3dc5d1605983b44a6efb6559eaf30234bf31"

URI_aarch64_rust-write16+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16+default-devel-1.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-write16+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16+default-devel}"
SRC_URI[aarch64_rust-write16+default-devel.sha256sum] = "f8564eb3461409ef50533a2f3c5ac4ef4868b1e0221a59095b14c143febe3e6a"

URI_aarch64_rust-write16+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16+smallvec-devel-1.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-write16+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16+smallvec-devel}"
SRC_URI[aarch64_rust-write16+smallvec-devel.sha256sum] = "2492fa139614552abe2b662f534f16f91fc4c55a34a2a6119c711e18cd3e6536"

URI_aarch64_rust-write16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16-devel-1.0.0-1.el10_0.noarch.rpm;name=aarch64_rust-write16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16-devel}"
SRC_URI[aarch64_rust-write16-devel.sha256sum] = "e6cb4da5404369717f0878da9b796081b7d8c089317253ccc23d4199b1cab5aa"

RDEPENDS:rust-write16+alloc-devel = " \
 cargo \
 rust-write16-devel \
 "
RDEPENDS:rust-write16+arrayvec-devel = " \
 cargo \
 rust-arrayvec+default-devel \
 rust-write16-devel \
 "
RDEPENDS:rust-write16+default-devel = " \
 cargo \
 rust-write16-devel \
 "
RDEPENDS:rust-write16+smallvec-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-write16-devel \
 "
RDEPENDS:rust-write16-devel = " \
 cargo \
 "
