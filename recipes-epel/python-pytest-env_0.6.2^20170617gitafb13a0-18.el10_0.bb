# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-env"
PV = "0.6.2^20170617gitafb13a0"
PR = "18.el10_0"
PACKAGES = " \
 python3-pytest-env \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-env-0.6.2^20170617gitafb13a0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb56264ec925d402a54c9d1ae2ff173b022968a323f29184eb9b83916904f70f"

URI_x86_64_v2_python3-pytest-env = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-env-0.6.2^20170617gitafb13a0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-env;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-env}"
SRC_URI[x86_64_v2_python3-pytest-env.sha256sum] = "f06e0b05858146ad7aa933640878e9c36bad8b8527e85da29945d4462e8b8f3b"

URI_aarch64_python3-pytest-env = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-env-0.6.2^20170617gitafb13a0-18.el10_0.noarch.rpm;name=aarch64_python3-pytest-env;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-env}"
SRC_URI[aarch64_python3-pytest-env.sha256sum] = "652f470f101038c2e13dbc18727db09ef3aa5f01e4cfd3b305995e423f1898af"

RDEPENDS:python3-pytest-env = " \
 python3 \
 python3-pytest \
 "
