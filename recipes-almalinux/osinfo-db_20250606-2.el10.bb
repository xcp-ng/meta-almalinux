# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osinfo-db"
PV = "20250606"
PR = "2.el10"
PACKAGES = " \
 osinfo-db \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osinfo-db-20250606-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0ed13ff128d55b59fa6ba9efe8454ab24562dc4f8b0289674e0b13d230e8fc8"

URI_x86_64_v2_osinfo-db = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osinfo-db-20250606-2.el10.noarch.rpm;name=x86_64_v2_osinfo-db;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osinfo-db}"
SRC_URI[x86_64_v2_osinfo-db.sha256sum] = "760c3fb448456e46da2efb6099e95ca318ede480943058184f6460338b858889"

URI_aarch64_osinfo-db = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osinfo-db-20250606-2.el10.noarch.rpm;name=aarch64_osinfo-db;unpack=0"
SRC_URI:append = " ${URI_aarch64_osinfo-db}"
SRC_URI[aarch64_osinfo-db.sha256sum] = "760c3fb448456e46da2efb6099e95ca318ede480943058184f6460338b858889"

RDEPENDS:osinfo-db = " \
 hwdata \
 "
