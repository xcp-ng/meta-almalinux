# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-opensearch-py"
PV = "3.0.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-opensearch-py \
 python3-opensearch-py+async \
 python3-opensearch-py+kerberos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-opensearch-py-3.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7924bc15d158b4274221fb102312af355cd59bab2dc0fe800dffac396b1da17"

URI_x86_64_v2_python3-opensearch-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py}"
SRC_URI[x86_64_v2_python3-opensearch-py.sha256sum] = "ae2c87be4cbee550258834ad4be7947845b7446e7bfc9e6d1366b96e83cb2c4a"

URI_x86_64_v2_python3-opensearch-py+async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py+async-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py+async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py+async}"
SRC_URI[x86_64_v2_python3-opensearch-py+async.sha256sum] = "eb3529e82847a572763e100215a3178705eea77dcaed91178df67376612afcc0"

URI_x86_64_v2_python3-opensearch-py+kerberos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py+kerberos-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py+kerberos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py+kerberos}"
SRC_URI[x86_64_v2_python3-opensearch-py+kerberos.sha256sum] = "abacb5e8457b8732cbd40fcf7cb9e962cc82f5e1a5723648da0dfb651d7ec7c5"

URI_aarch64_python3-opensearch-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py-3.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-opensearch-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py}"
SRC_URI[aarch64_python3-opensearch-py.sha256sum] = "274a28cd7c048f148d56c07d7d8a1df7f2d91e8d4394cda170fb564ad0a109c3"

URI_aarch64_python3-opensearch-py+async = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py+async-3.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-opensearch-py+async;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py+async}"
SRC_URI[aarch64_python3-opensearch-py+async.sha256sum] = "6a9fb4574f822381ab3c479c156ca503a277d345d61bdc6635ca0ec52a1fe6f7"

URI_aarch64_python3-opensearch-py+kerberos = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py+kerberos-3.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-opensearch-py+kerberos;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py+kerberos}"
SRC_URI[aarch64_python3-opensearch-py+kerberos.sha256sum] = "b7a8c6f74f3beb708865be8cf8d1a22cc13747fd6bf59e4bd124016a34ac3f7c"

RDEPENDS:python3-opensearch-py = " \
 python3 \
 python3-certifi \
 python3-dateutil \
 python3-events \
 python3-requests \
 python3-urllib3 \
 "
RDEPENDS:python3-opensearch-py+async = " \
 python3 \
 python3-aiohttp \
 python3-opensearch-py \
 "
RDEPENDS:python3-opensearch-py+kerberos = " \
 python3 \
 python3-opensearch-py \
 python3-requests-kerberos \
 "
