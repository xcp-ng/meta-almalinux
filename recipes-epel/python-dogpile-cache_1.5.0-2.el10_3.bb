# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dogpile-cache"
PV = "1.5.0"
PR = "2.el10_3"
PACKAGES = " \
 python3-dogpile-cache \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-dogpile-cache-1.5.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d57f0aafab231f36be318d24c9dc6c71af93b03b69f767285886481ed539601b"

URI_x86_64_v2_python3-dogpile-cache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dogpile-cache-1.5.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dogpile-cache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dogpile-cache}"
SRC_URI[x86_64_v2_python3-dogpile-cache.sha256sum] = "0615f46139e2e2b26990b9ded3c1cab513a04d647c876485ef916578e82ab3eb"

URI_aarch64_python3-dogpile-cache = "${EPEL_MIRROR}/aarch64/Packages/p/python3-dogpile-cache-1.5.0-2.el10_3.noarch.rpm;name=aarch64_python3-dogpile-cache;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dogpile-cache}"
SRC_URI[aarch64_python3-dogpile-cache.sha256sum] = "afb5f698f50e3ef81933b7b8a753c31d21398f758ecf3a4121ea9b346389ab1c"

RDEPENDS:python3-dogpile-cache = " \
 python3 \
 python3-decorator \
 python3-mako \
 python3-stevedore \
 "
