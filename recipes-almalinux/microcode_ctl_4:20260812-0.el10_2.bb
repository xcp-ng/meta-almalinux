# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "microcode_ctl"
PE = "4"
PV = "20260812"
PR = "0.el10_2"
PACKAGES = " \
 microcode_ctl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/microcode_ctl-20260812-0.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "581edecc13d328d55a6ecab904c3482dd2d6bd1742c3396bfd73f6da89c8ec9c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/microcode_ctl-20260812-0.el10_2.noarch.rpm;name=x86_64_v2_microcode_ctl;unpack=0"
SRC_URI[x86_64_v2_microcode_ctl.sha256sum] = "279818930889e71890d29b684ab5b01d79e6011dcffa88ebcd21e519cc793568"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/microcode_ctl-20260812-0.el10_2.noarch.rpm;name=aarch64_microcode_ctl;unpack=0"
SRC_URI[aarch64_microcode_ctl.sha256sum] = "279818930889e71890d29b684ab5b01d79e6011dcffa88ebcd21e519cc793568"

RDEPENDS:microcode_ctl = " \
 bash \
 dracut \
 systemd \
 virtual/coreutils \
 "
