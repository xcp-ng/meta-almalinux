# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "treelayout"
PV = "1.0.3"
PR = "29.el10_3"
PACKAGES = " \
 treelayout \
 treelayout-demo \
 treelayout-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/treelayout-1.0.3-29.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52ea2b9ab97cf04320fdfe7669f41c58066f906aa16a94da94b940107e76eea1"

URI_x86_64_v2_treelayout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/treelayout-1.0.3-29.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_treelayout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_treelayout}"
SRC_URI[x86_64_v2_treelayout.sha256sum] = "8ec22a8e558a6960f75cd4e5ee9018175f32879c4fe3741dd0812081634d6515"

URI_x86_64_v2_treelayout-demo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/treelayout-demo-1.0.3-29.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_treelayout-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_treelayout-demo}"
SRC_URI[x86_64_v2_treelayout-demo.sha256sum] = "febbde64266ad616f3354d3858eea4882efadfbe579b57d4ae77f72b6f73591a"

URI_x86_64_v2_treelayout-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/treelayout-javadoc-1.0.3-29.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_treelayout-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_treelayout-javadoc}"
SRC_URI[x86_64_v2_treelayout-javadoc.sha256sum] = "7dee6bacf17d77c283ce188424c3337a61078a3f8d9c5250eb2d9d7fc506044e"

URI_aarch64_treelayout = "${EPEL_MIRROR}/aarch64/Packages/t/treelayout-1.0.3-29.el10_3.noarch.rpm;name=aarch64_treelayout;unpack=0"
SRC_URI:append = " ${URI_aarch64_treelayout}"
SRC_URI[aarch64_treelayout.sha256sum] = "41ce4adcc4e242db08f2cd8d85b4f1462d523e8de657e39bfde26f3fdc684a4a"

URI_aarch64_treelayout-demo = "${EPEL_MIRROR}/aarch64/Packages/t/treelayout-demo-1.0.3-29.el10_3.noarch.rpm;name=aarch64_treelayout-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_treelayout-demo}"
SRC_URI[aarch64_treelayout-demo.sha256sum] = "0ecc9a48ced18d1ed7e0a69125ebc03e8490fe5fcc2ebef5fa90fce91098c864"

URI_aarch64_treelayout-javadoc = "${EPEL_MIRROR}/aarch64/Packages/t/treelayout-javadoc-1.0.3-29.el10_3.noarch.rpm;name=aarch64_treelayout-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_treelayout-javadoc}"
SRC_URI[aarch64_treelayout-javadoc.sha256sum] = "6c86dd71edbf7908703e8df5586302093395ef56f2ec93479796e1f9a98a889e"

RDEPENDS:treelayout = " \
 javapackages-filesystem \
 "
RDEPENDS:treelayout-demo = " \
 javapackages-filesystem \
 treelayout \
 "
RDEPENDS:treelayout-javadoc = " \
 javapackages-filesystem \
 "
