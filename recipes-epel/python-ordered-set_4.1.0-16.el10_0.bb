# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ordered-set"
PV = "4.1.0"
PR = "16.el10_0"
PACKAGES = " \
 python3-ordered-set \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ordered-set-4.1.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6a53ff1a8d4cb99b58dbf4fd0e8b37db4d1890de07828ea0bd8c46cc6a7cb45"

URI_x86_64_v2_python3-ordered-set = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ordered-set-4.1.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ordered-set;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ordered-set}"
SRC_URI[x86_64_v2_python3-ordered-set.sha256sum] = "ffcc1f401881f33e53c1a4eebff34a0ffa2e3e6dac3672feb31628dbc06d8109"

URI_aarch64_python3-ordered-set = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ordered-set-4.1.0-16.el10_0.noarch.rpm;name=aarch64_python3-ordered-set;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ordered-set}"
SRC_URI[aarch64_python3-ordered-set.sha256sum] = "d7655ef46962994db90cf42ebc2b40ef51ad6bd9bcc5c8d8935b01ca5d79d844"

RDEPENDS:python3-ordered-set = " \
 python3 \
 "
