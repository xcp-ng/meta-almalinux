# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krecorder"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 krecorder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krecorder-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7c97c14f0e96005356fa2ea4de8c3608e2c2464d12565f84235df351ca820c9"

URI_x86_64_v2_krecorder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krecorder-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krecorder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krecorder}"
SRC_URI[x86_64_v2_krecorder.sha256sum] = "c485b0de0313d52076e4f3aaa10eac25a0cd989b497ba98480276328964d7766"

URI_aarch64_krecorder = "${EPEL_MIRROR}/aarch64/Packages/k/krecorder-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_krecorder;unpack=0"
SRC_URI:append = " ${URI_aarch64_krecorder}"
SRC_URI[aarch64_krecorder.sha256sum] = "464e7ae4f2b374725772e99c4cf7f5799d2ea84bc320f98cd47c38a44e2e1340"

RDEPENDS:krecorder = " \
 glibc \
 gstreamer1-plugins-good \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
