# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-rsc-qr"
PV = "0.2.0"
PR = "19.20230806gitb6857d4.el10_1"
PACKAGES = " \
 golang-rsc-qr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-rsc-qr-0.2.0-19.20230806gitb6857d4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21f1125f8ef046a4f821027845e771d86ff950edfdd3d3d73bdaf49eecededd2"

URI_aarch64_golang-rsc-qr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-rsc-qr-devel-0.2.0-19.20230806gitb6857d4.el10_1.noarch.rpm;name=aarch64_golang-rsc-qr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-rsc-qr-devel}"
SRC_URI[aarch64_golang-rsc-qr-devel.sha256sum] = "7ab09b218fc9f451e47aee946dff0e5c5fa870aa71bad8d410ba7eafc0acf15d"

RDEPENDS:golang-rsc-qr-devel = " \
 go-filesystem \
 qrencode-devel \
 "
