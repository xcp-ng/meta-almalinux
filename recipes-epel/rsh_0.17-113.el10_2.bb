# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsh"
PV = "0.17"
PR = "113.el10_2"
PACKAGES = " \
 rsh \
 rsh-server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rsh-0.17-113.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f559789e5513d2363ceca9505ed79f657cfbc743d5e1121f24a623e48755aa2"

URI_x86_64_v2_rsh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rsh-0.17-113.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rsh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsh}"
SRC_URI[x86_64_v2_rsh.sha256sum] = "76d29d4119a064c35b486283033bbad7343d1016f695304cc33b4b50ee715156"

URI_x86_64_v2_rsh-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rsh-server-0.17-113.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rsh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsh-server}"
SRC_URI[x86_64_v2_rsh-server.sha256sum] = "148fa726037dbe01af79df7e9f5ebb5ad4819adecbbe9734af89dae2ecd01c8a"

URI_aarch64_rsh = "${EPEL_MIRROR}/aarch64/Packages/r/rsh-0.17-113.el10_2.aarch64.rpm;name=aarch64_rsh;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsh}"
SRC_URI[aarch64_rsh.sha256sum] = "3beea940180ca06af6289dbe2649390bd6b5a0ca78714eaa0634fcc84140ce74"

URI_aarch64_rsh-server = "${EPEL_MIRROR}/aarch64/Packages/r/rsh-server-0.17-113.el10_2.aarch64.rpm;name=aarch64_rsh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsh-server}"
SRC_URI[aarch64_rsh-server.sha256sum] = "7bc475d0217bf0e33ecc520b5a35d78324c93c23a3586e55a5d87046810f3138"

RDEPENDS:rsh = " \
 glibc \
 "
RDEPENDS:rsh-server = " \
 audit-libs \
 authselect-libs \
 bash \
 glibc \
 pam \
 pam-libs \
 systemd \
 "
