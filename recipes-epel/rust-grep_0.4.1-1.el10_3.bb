# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep"
PV = "0.4.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-grep+default-devel \
 rust-grep+grep-pcre2-devel \
 rust-grep+pcre2-devel \
 rust-grep-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-0.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45a28bafc2b7fa70fc70f7061ccfaab7ec784a0db538a6bac2cf180f2b552110"

URI_x86_64_v2_rust-grep+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep+default-devel-0.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep+default-devel}"
SRC_URI[x86_64_v2_rust-grep+default-devel.sha256sum] = "35b267e684e917a6bf0f94988af41cca4f246f897d2030fe6fe5a11de7dba17d"

URI_x86_64_v2_rust-grep+grep-pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep+grep-pcre2-devel-0.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep+grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep+grep-pcre2-devel}"
SRC_URI[x86_64_v2_rust-grep+grep-pcre2-devel.sha256sum] = "9d25c3abf9255f0d7d80c5cd56a79cfb21644fac38d05e0b41542ab8e84b0004"

URI_x86_64_v2_rust-grep+pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep+pcre2-devel-0.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep+pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep+pcre2-devel}"
SRC_URI[x86_64_v2_rust-grep+pcre2-devel.sha256sum] = "1222e6ba20383743ef274f75a36caca3bbf09989daa10f6692aea1663f6549ab"

URI_x86_64_v2_rust-grep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-devel-0.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-devel}"
SRC_URI[x86_64_v2_rust-grep-devel.sha256sum] = "ac52e60d631203c452ff4960a20182801bbda78cfdfefeb8611c3b4aa33c9146"

URI_aarch64_rust-grep+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep+default-devel-0.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-grep+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep+default-devel}"
SRC_URI[aarch64_rust-grep+default-devel.sha256sum] = "71465dd3a1a834788a7cc8b699b8d90ba323e7e69a7d6aac29891ff3068c5f10"

URI_aarch64_rust-grep+grep-pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep+grep-pcre2-devel-0.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-grep+grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep+grep-pcre2-devel}"
SRC_URI[aarch64_rust-grep+grep-pcre2-devel.sha256sum] = "2722516d0a67b91241a9036e6dc27876a1367ff2bff26f2b044dfbd52b97a31f"

URI_aarch64_rust-grep+pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep+pcre2-devel-0.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-grep+pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep+pcre2-devel}"
SRC_URI[aarch64_rust-grep+pcre2-devel.sha256sum] = "92613ffd02461fe012077f42423fb21c263d9ccad85971fef8572bbd323f72bb"

URI_aarch64_rust-grep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-devel-0.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-grep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-devel}"
SRC_URI[aarch64_rust-grep-devel.sha256sum] = "e498fe77da0310378729efa9c3e5ad2061c9b69b8fb92e919abe860e79d4c858"

RDEPENDS:rust-grep+default-devel = " \
 cargo \
 rust-grep-devel \
 "
RDEPENDS:rust-grep+grep-pcre2-devel = " \
 cargo \
 rust-grep-devel \
 rust-grep-pcre2+default-devel \
 "
RDEPENDS:rust-grep+pcre2-devel = " \
 cargo \
 rust-grep+grep-pcre2-devel \
 rust-grep-devel \
 "
RDEPENDS:rust-grep-devel = " \
 cargo \
 rust-grep-cli+default-devel \
 rust-grep-matcher+default-devel \
 rust-grep-printer+default-devel \
 rust-grep-regex+default-devel \
 rust-grep-searcher+default-devel \
 "
