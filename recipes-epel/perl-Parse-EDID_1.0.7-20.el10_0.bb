# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parse-EDID"
PV = "1.0.7"
PR = "20.el10_0"
PACKAGES = " \
 perl-Parse-EDID \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Parse-EDID-1.0.7-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f9578b05ad57c585b8e0283df3eb64d21ea019c849e28d3289354e38c7b1bc5"

URI_x86_64_v2_perl-Parse-EDID = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parse-EDID-1.0.7-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parse-EDID;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parse-EDID}"
SRC_URI[x86_64_v2_perl-Parse-EDID.sha256sum] = "2e2e9dc01dfe530f3921e0000e2528bc48cb40e4fd13bf5239628c9bc7271ee9"

URI_aarch64_perl-Parse-EDID = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parse-EDID-1.0.7-20.el10_0.noarch.rpm;name=aarch64_perl-Parse-EDID;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parse-EDID}"
SRC_URI[aarch64_perl-Parse-EDID.sha256sum] = "6e371b97f886955fd46ae55dc6ac8ac002713d5e44c0e56e6f539f2b43599697"

RDEPENDS:perl-Parse-EDID = " \
 perl-Exporter \
 perl-base \
 perl-libs \
 "
