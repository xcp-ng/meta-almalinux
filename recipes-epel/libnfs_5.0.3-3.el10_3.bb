# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnfs"
PV = "5.0.3"
PR = "3.el10_3"
PACKAGES = " \
 libnfs \
 libnfs-devel \
 libnfs-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnfs-5.0.3-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4feff2a8ee7e81c129796f16a265ffadde43fe0cd797684d8772d3d84c8d5c01"

URI_x86_64_v2_libnfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnfs-5.0.3-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfs}"
SRC_URI[x86_64_v2_libnfs.sha256sum] = "3ee8916ad4d15cb2a9cdd9958a4013a50e93277bb3bc972aeb3958da794a3bd4"

URI_x86_64_v2_libnfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnfs-devel-5.0.3-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfs-devel}"
SRC_URI[x86_64_v2_libnfs-devel.sha256sum] = "2d3d702cabc04d46b5d2ab3473b35ac90775e96c737b4972481c3b9017b51008"

URI_x86_64_v2_libnfs-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnfs-utils-5.0.3-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnfs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfs-utils}"
SRC_URI[x86_64_v2_libnfs-utils.sha256sum] = "bd31f5e87949376fa53436b556e4987e4f90abe6214d8272e25f0663d0f36b87"

URI_aarch64_libnfs = "${EPEL_MIRROR}/aarch64/Packages/l/libnfs-5.0.3-3.el10_3.aarch64.rpm;name=aarch64_libnfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfs}"
SRC_URI[aarch64_libnfs.sha256sum] = "13cde8c499357be00d323cd905c22f83a239497005c867016c2c63ace1314e90"

URI_aarch64_libnfs-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libnfs-devel-5.0.3-3.el10_3.aarch64.rpm;name=aarch64_libnfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfs-devel}"
SRC_URI[aarch64_libnfs-devel.sha256sum] = "f8e33fac5c8560356744ddc16906d893abfdec29a768f649062d266d2b6c083f"

URI_aarch64_libnfs-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libnfs-utils-5.0.3-3.el10_3.aarch64.rpm;name=aarch64_libnfs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfs-utils}"
SRC_URI[aarch64_libnfs-utils.sha256sum] = "3896bddea19c921f83a095fb269e7f004e2d39382d90f2b94a8ed41079ef1fe1"

RDEPENDS:libnfs = " \
 glibc \
 "
RDEPENDS:libnfs-devel = " \
 libnfs \
 pkgconf-pkg-config \
 "
RDEPENDS:libnfs-utils = " \
 glibc \
 libnfs \
 "
