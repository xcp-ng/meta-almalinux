# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gscan2pdf"
PV = "2.13.5"
PR = "1.el10_1"
PACKAGES = " \
 gscan2pdf \
 gscan2pdf-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gscan2pdf-2.13.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52f51b51fda3293e22c34a96093e8aadfc67c77d49edf5f22d67b9eebd8eace6"

URI_x86_64_v2_gscan2pdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gscan2pdf-2.13.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gscan2pdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gscan2pdf}"
SRC_URI[x86_64_v2_gscan2pdf.sha256sum] = "6e2082318d36f4b3ebbf9e345acb606306a04911b2c3e18218f4e5c273fa304d"

URI_x86_64_v2_gscan2pdf-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gscan2pdf-tests-2.13.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gscan2pdf-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gscan2pdf-tests}"
SRC_URI[x86_64_v2_gscan2pdf-tests.sha256sum] = "f1bef3d1842efe48fc6a5220613ba273862a76145c2fda2ff5d4df8e28b8a9a3"

URI_aarch64_gscan2pdf = "${EPEL_MIRROR}/aarch64/Packages/g/gscan2pdf-2.13.5-1.el10_1.noarch.rpm;name=aarch64_gscan2pdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_gscan2pdf}"
SRC_URI[aarch64_gscan2pdf.sha256sum] = "e80569541f217bc2613bba103257ea865a81925e8ecf0d29bff4f5a0c9eb7937"

URI_aarch64_gscan2pdf-tests = "${EPEL_MIRROR}/aarch64/Packages/g/gscan2pdf-tests-2.13.5-1.el10_1.noarch.rpm;name=aarch64_gscan2pdf-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_gscan2pdf-tests}"
SRC_URI[aarch64_gscan2pdf-tests.sha256sum] = "56d2679599f5496798a6317df5b252ae1796c92ad4fb9e5f81e3b354682c0f63"

RDEPENDS:gscan2pdf = " \
 ImageMagick \
 ImageMagick-perl \
 bash \
 gscan2pdf \
 libtiff-tools \
 perl-Archive-Tar \
 perl-Carp \
 perl-Config-General \
 perl-Data-Dumper \
 perl-Data-UUID \
 perl-Date-Calc \
 perl-Encode \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Filesys-Df \
 perl-Getopt-Long \
 perl-Glib \
 perl-Glib-Object-Introspection \
 perl-GooCanvas2 \
 perl-Gtk3 \
 perl-Gtk3-ImageView \
 perl-Gtk3-SimpleList \
 perl-HTML-Parser \
 perl-IO \
 perl-IPC-Cmd \
 perl-IPC-Open3 \
 perl-Image-Sane \
 perl-JSON-PP \
 perl-List-MoreUtils \
 perl-Locale-Codes \
 perl-Locale-gettext \
 perl-Log-Log4perl \
 perl-PDF-Builder \
 perl-POSIX \
 perl-PathTools \
 perl-Proc-ProcessTable \
 perl-Readonly \
 perl-Set-IntSpan \
 perl-Socket \
 perl-Storable \
 perl-Symbol \
 perl-Text-ParseWords \
 perl-Thread-Queue \
 perl-Time-Piece \
 perl-Try-Tiny \
 perl-base \
 perl-if \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 perl-version \
 sane-backends \
 sane-frontends \
 "
RDEPENDS:gscan2pdf-tests = " \
 ImageMagick-djvu \
 bash \
 dejavu-sans-fonts \
 file \
 fontconfig \
 ghostscript \
 gscan2pdf \
 mutter \
 perl-Carp \
 perl-Data-Dumper \
 perl-Date-Calc \
 perl-Encode \
 perl-Exception-Class \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-File-stat \
 perl-Glib \
 perl-Gtk3 \
 perl-IPC-Cmd \
 perl-IPC-System-Simple \
 perl-Image-Sane \
 perl-Log-Log4perl \
 perl-MIME-Base64 \
 perl-PDF-Builder \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sub-Override \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 perl-version \
 poppler-utils \
 sane-backends-drivers-scanners \
 sane-frontends \
 virtual/coreutils \
 xwayland-run \
 "
