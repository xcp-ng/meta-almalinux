# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg_aliases0.1"
PV = "0.1.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-cfg_aliases0.1+default-devel \
 rust-cfg_aliases0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg_aliases0.1-0.1.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee46d4757463bc9c16a4188744ec53ab4717a92fdf68a03fa9127801d9b67c72"

URI_x86_64_v2_rust-cfg_aliases0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg_aliases0.1+default-devel-0.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg_aliases0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg_aliases0.1+default-devel}"
SRC_URI[x86_64_v2_rust-cfg_aliases0.1+default-devel.sha256sum] = "25d7b79efc70e8dbceebe373393990df82c52c7d440a8b028b637ac3c66f3c51"

URI_x86_64_v2_rust-cfg_aliases0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg_aliases0.1-devel-0.1.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg_aliases0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg_aliases0.1-devel}"
SRC_URI[x86_64_v2_rust-cfg_aliases0.1-devel.sha256sum] = "ff2df2990ee07f72dca3c482ddd2a1e46cf4e7f622b8170920b607a06c401cb7"

URI_aarch64_rust-cfg_aliases0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg_aliases0.1+default-devel-0.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-cfg_aliases0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg_aliases0.1+default-devel}"
SRC_URI[aarch64_rust-cfg_aliases0.1+default-devel.sha256sum] = "b4d136f144bd4c9dd5aa6b69606cf1090d785c4d8869672ec2266e0f8444d711"

URI_aarch64_rust-cfg_aliases0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg_aliases0.1-devel-0.1.1-2.el10_0.noarch.rpm;name=aarch64_rust-cfg_aliases0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg_aliases0.1-devel}"
SRC_URI[aarch64_rust-cfg_aliases0.1-devel.sha256sum] = "d0437a04618601baa584be935c2addc2cbe01dfca5bc2f2341cac5feadc55c7c"

RDEPENDS:rust-cfg_aliases0.1+default-devel = " \
 cargo \
 rust-cfg_aliases0.1-devel \
 "
RDEPENDS:rust-cfg_aliases0.1-devel = " \
 cargo \
 "
