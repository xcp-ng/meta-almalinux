# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmodtool"
PV = "1.1"
PR = "11.el10_0"
PACKAGES = " \
 kmodtool \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmodtool-1.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "974f8e58b772187d964e52e1803fe18e9e4e9f9f8e28b732fc76700763c63b63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmodtool-1.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kmodtool;unpack=0"
SRC_URI[x86_64_v2_kmodtool.sha256sum] = "ccaaff34817fa0ee40ce2063369206cdc5a4a919171b1d0b4118a2416c15f0f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmodtool-1.1-11.el10_0.noarch.rpm;name=aarch64_kmodtool;unpack=0"
SRC_URI[aarch64_kmodtool.sha256sum] = "a01318d0991a9832371a52ccebb699cd40ff6dc3b82c6a14ea9eb8a502024f45"

RDEPENDS:kmodtool = " \
 bash \
 "
