# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wireplumber"
PV = "0.5.5"
PR = "2.el10"
PACKAGES = " \
 wireplumber \
 wireplumber-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wireplumber-0.5.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f3a12f570644393fa94f40c9fe73c9bb4394267a2abe0941b2b1805860a626a"

URI_x86_64_v2_wireplumber = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireplumber-0.5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_wireplumber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireplumber}"
SRC_URI[x86_64_v2_wireplumber.sha256sum] = "0783aedea24b9b416d5a0c498e14c7d92270e249fd1e1655c837da80ff282b1d"

URI_x86_64_v2_wireplumber-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireplumber-libs-0.5.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_wireplumber-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireplumber-libs}"
SRC_URI[x86_64_v2_wireplumber-libs.sha256sum] = "a252340bd0c057f550f6e14e704da5a9defa32a5f74f22e0b0a59edc44d4f233"

URI_aarch64_wireplumber = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireplumber-0.5.5-2.el10.aarch64.rpm;name=aarch64_wireplumber;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireplumber}"
SRC_URI[aarch64_wireplumber.sha256sum] = "d61763f4c47741db627288774767c0fee854d55b467ad86919516379a942a463"

URI_aarch64_wireplumber-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireplumber-libs-0.5.5-2.el10.aarch64.rpm;name=aarch64_wireplumber-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireplumber-libs}"
SRC_URI[aarch64_wireplumber-libs.sha256sum] = "bc03e48a271b9931b16781f91b21836cafc5e2b613172a63aae59fcf0579f2c6"

RDEPENDS:wireplumber = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 pipewire-libs \
 wireplumber-libs \
 "
RDEPENDS:wireplumber-libs = " \
 glib2 \
 glibc \
 libgcc \
 lua-libs \
 pipewire-libs \
 systemd-libs \
 "
