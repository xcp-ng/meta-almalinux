# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert-json-diff"
PV = "2.0.2"
PR = "9.el10_1"
PACKAGES = " \
 rust-assert-json-diff+default-devel \
 rust-assert-json-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert-json-diff-2.0.2-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0226099512a4b02be2b7e7b3eccb2fcfe8023c4ba8c8baa2b2fc853f70e2355"

URI_x86_64_v2_rust-assert-json-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert-json-diff+default-devel-2.0.2-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert-json-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert-json-diff+default-devel}"
SRC_URI[x86_64_v2_rust-assert-json-diff+default-devel.sha256sum] = "e08f3b76d51c9fe16ae85eff45aa4c94cab7a12e5843dc9e5df717ddf5815156"

URI_x86_64_v2_rust-assert-json-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert-json-diff-devel-2.0.2-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert-json-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert-json-diff-devel}"
SRC_URI[x86_64_v2_rust-assert-json-diff-devel.sha256sum] = "29e853307964fe0a9625b144757b71f3d68b69a11cd12396083d688697de2156"

URI_aarch64_rust-assert-json-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert-json-diff+default-devel-2.0.2-9.el10_1.noarch.rpm;name=aarch64_rust-assert-json-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert-json-diff+default-devel}"
SRC_URI[aarch64_rust-assert-json-diff+default-devel.sha256sum] = "991e3266683194dc602314595744621e08066a07921a05cf461f305a10a7f182"

URI_aarch64_rust-assert-json-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert-json-diff-devel-2.0.2-9.el10_1.noarch.rpm;name=aarch64_rust-assert-json-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert-json-diff-devel}"
SRC_URI[aarch64_rust-assert-json-diff-devel.sha256sum] = "68fbc3735cb11276a7d093c678d88f5d06d48f45f47b3d601f5ec02f11252cd0"

RDEPENDS:rust-assert-json-diff+default-devel = " \
 cargo \
 rust-assert-json-diff-devel \
 "
RDEPENDS:rust-assert-json-diff-devel = " \
 bash \
 cargo \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
