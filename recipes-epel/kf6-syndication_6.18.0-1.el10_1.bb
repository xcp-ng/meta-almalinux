# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syndication"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-syndication \
 kf6-syndication-devel \
 kf6-syndication-doc \
 kf6-syndication-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-syndication-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08ff4993f2c5bc4206c2b765f17014323c1ab9599a88c90c515f87c2bd2d8906"

URI_x86_64_v2_kf6-syndication = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication}"
SRC_URI[x86_64_v2_kf6-syndication.sha256sum] = "5a50d668932c2c356e2b0c5788efb1879dc63d5937caad6b3c34c9f0113d7d20"

URI_x86_64_v2_kf6-syndication-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication-devel}"
SRC_URI[x86_64_v2_kf6-syndication-devel.sha256sum] = "58e026d29112c0f76455dfd079035ffb4899fafc5d37ec5b0b598a18868c7d00"

URI_x86_64_v2_kf6-syndication-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syndication-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication-doc}"
SRC_URI[x86_64_v2_kf6-syndication-doc.sha256sum] = "51dc3f6c8a0a82ba61d9a9ba15f38e9d3124c14615603a50902cc1367ba1da53"

URI_x86_64_v2_kf6-syndication-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syndication-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication-html}"
SRC_URI[x86_64_v2_kf6-syndication-html.sha256sum] = "74f46128c31895f38a3d08d758f9e071143bb18a514c2d45a31d1855745cd6c3"

URI_aarch64_kf6-syndication = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-syndication;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication}"
SRC_URI[aarch64_kf6-syndication.sha256sum] = "b97a7ee44004807da7c1d44d174ff8ae4eb994b449d00df9efce73ad833b853d"

URI_aarch64_kf6-syndication-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-syndication-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication-devel}"
SRC_URI[aarch64_kf6-syndication-devel.sha256sum] = "24cd9e29388b6857761a8860770b0ff5cbf7c487683e776e5d4d975a5fe047c6"

URI_aarch64_kf6-syndication-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-syndication-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication-doc}"
SRC_URI[aarch64_kf6-syndication-doc.sha256sum] = "a3b87381fc46c7615a169498e279d321cff4d0d06787c6a69b7b7ca084abaf5b"

URI_aarch64_kf6-syndication-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-syndication-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication-html}"
SRC_URI[aarch64_kf6-syndication-html.sha256sum] = "215b3505e72b35496103f2e632bbf331097a6193c54ac005bc5de56d17182be2"

RDEPENDS:kf6-syndication = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-syndication-devel = " \
 cmake-filesystem \
 kf6-syndication \
 "
RDEPENDS:kf6-syndication-doc = " \
 "
RDEPENDS:kf6-syndication-html = " \
 "
