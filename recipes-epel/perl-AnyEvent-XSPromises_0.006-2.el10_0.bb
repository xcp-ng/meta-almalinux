# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-AnyEvent-XSPromises"
PV = "0.006"
PR = "2.el10_0"
PACKAGES = " \
 perl-AnyEvent-XSPromises \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-AnyEvent-XSPromises-0.006-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eaeebb5c4ffaebe1fa3a37b9270e002500b8be3462bfa7f16b8611c8812f9903"

URI_x86_64_v2_perl-AnyEvent-XSPromises = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-AnyEvent-XSPromises-0.006-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-AnyEvent-XSPromises;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-AnyEvent-XSPromises}"
SRC_URI[x86_64_v2_perl-AnyEvent-XSPromises.sha256sum] = "8efa747a5b6bb6e10047c6903890e50df5b63dbd3c5ec8a5cc3d133d6a735a1a"

URI_aarch64_perl-AnyEvent-XSPromises = "${EPEL_MIRROR}/aarch64/Packages/p/perl-AnyEvent-XSPromises-0.006-2.el10_0.aarch64.rpm;name=aarch64_perl-AnyEvent-XSPromises;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-AnyEvent-XSPromises}"
SRC_URI[aarch64_perl-AnyEvent-XSPromises.sha256sum] = "84c60e15a4a3bf38dc12909ff75ef8c9be6880b2fef0b63b3115fe8785ed4b2a"

RDEPENDS:perl-AnyEvent-XSPromises = " \
 glibc \
 perl-AnyEvent \
 perl-AnyEvent-XSPromises \
 perl-Exporter \
 perl-libs \
 "
