# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdns-recursor"
PV = "5.4.5"
PR = "2.el10_3"
PACKAGES = " \
 pdns-recursor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pdns-recursor-5.4.5-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d55cc2a61ad473012ea08df191ca18a2895bcd1d2915c4d341e1e6d6efcded9"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - pdns-recursor: libcap.so.2()(64bit)

URI_x86_64_v2_pdns-recursor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdns-recursor-5.4.5-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdns-recursor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdns-recursor}"
SRC_URI[x86_64_v2_pdns-recursor.sha256sum] = "97a44fa469aa22384703616be8ab734ae1137bd6fdb38368631b266e8a5f3681"

URI_aarch64_pdns-recursor = "${EPEL_MIRROR}/aarch64/Packages/p/pdns-recursor-5.4.5-2.el10_3.aarch64.rpm;name=aarch64_pdns-recursor;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdns-recursor}"
SRC_URI[aarch64_pdns-recursor.sha256sum] = "21873f89925418b36ab2b16fca362fcadb7ea4fc6a21556bb6ee1093fadfc852"

RDEPENDS:pdns-recursor:x86_64_v2 = " \
 bash \
 boost-context \
 boost-filesystem \
 fstrm \
 glibc \
 libcap \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:pdns-recursor:aarch64 = " \
 bash \
 boost-context \
 boost-filesystem \
 fstrm \
 glibc \
 libgcc \
 libsodium \
 libstdc++ \
 luajit \
 openssl-libs \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
"
