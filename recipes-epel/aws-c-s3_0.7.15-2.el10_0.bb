# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-s3"
PV = "0.7.15"
PR = "2.el10_0"
PACKAGES = " \
 aws-c-s3 \
 aws-c-s3-devel \
 aws-c-s3-doc \
 aws-c-s3-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-s3-0.7.15-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c92e3f2ac04b0723a4ec22fbf1862a6a5c394810c20f6348880bbb559f299581"

URI_x86_64_v2_aws-c-s3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-s3-0.7.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-s3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-s3}"
SRC_URI[x86_64_v2_aws-c-s3.sha256sum] = "44cef99ee8771016d225bb72daf4ba80ced5a66d9727095a732c17364d70cf23"

URI_x86_64_v2_aws-c-s3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-s3-devel-0.7.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-s3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-s3-devel}"
SRC_URI[x86_64_v2_aws-c-s3-devel.sha256sum] = "c9b125d326e87648e1da6e038e7c0294bc814db1b8e3d2f0a830abe195ef5b96"

URI_x86_64_v2_aws-c-s3-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-s3-doc-0.7.15-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_aws-c-s3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-s3-doc}"
SRC_URI[x86_64_v2_aws-c-s3-doc.sha256sum] = "c48af2083b8a36dccec34a67e549baab69cc3e79c68dcff102e678a725fce10e"

URI_x86_64_v2_aws-c-s3-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-s3-libs-0.7.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-s3-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-s3-libs}"
SRC_URI[x86_64_v2_aws-c-s3-libs.sha256sum] = "440aed1f2527f5efb70ad58b4482f566ce647c600cab3736872afe96ded8a554"

URI_aarch64_aws-c-s3 = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-s3-0.7.15-2.el10_0.aarch64.rpm;name=aarch64_aws-c-s3;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-s3}"
SRC_URI[aarch64_aws-c-s3.sha256sum] = "ee6a24b2791511499ce4957a9aa19d2d61df3566eb1fc0d34e8e6fd51d5d3989"

URI_aarch64_aws-c-s3-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-s3-devel-0.7.15-2.el10_0.aarch64.rpm;name=aarch64_aws-c-s3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-s3-devel}"
SRC_URI[aarch64_aws-c-s3-devel.sha256sum] = "91f4aa8ac5a3587f3d851e233647169743ca94af25078d9e8f04293846dc6304"

URI_aarch64_aws-c-s3-doc = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-s3-doc-0.7.15-2.el10_0.noarch.rpm;name=aarch64_aws-c-s3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-s3-doc}"
SRC_URI[aarch64_aws-c-s3-doc.sha256sum] = "14f3b7f42d5fdfe11de40daebf49b0e77b6fe1103a5e85ea783a44bd232240d9"

URI_aarch64_aws-c-s3-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-s3-libs-0.7.15-2.el10_0.aarch64.rpm;name=aarch64_aws-c-s3-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-s3-libs}"
SRC_URI[aarch64_aws-c-s3-libs.sha256sum] = "60cb8ca678489e1159708ac090038998e23ca17d591cca436d4c549a21dfb766"

RDEPENDS:aws-c-s3 = " \
 aws-c-auth \
 aws-c-common-libs \
 aws-c-http-libs \
 aws-c-io \
 aws-c-s3-libs \
 glibc \
 "
RDEPENDS:aws-c-s3-devel = " \
 aws-c-auth-devel \
 aws-c-http-devel \
 aws-c-s3-libs \
 aws-c-sdkutils-devel \
 aws-checksums-devel \
 cmake-filesystem \
 openssl-devel \
 "
RDEPENDS:aws-c-s3-doc = " \
 "
RDEPENDS:aws-c-s3-libs = " \
 aws-c-auth \
 aws-c-cal-libs \
 aws-c-common-libs \
 aws-c-http-libs \
 aws-c-io \
 aws-checksums-libs \
 glibc \
 "
