# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linuxconsoletools"
PV = "1.8.1"
PR = "9.el10_0"
PACKAGES = " \
 linuxconsoletools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/linuxconsoletools-1.8.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6063ffc04999de7a0e30dff2705de9166c1bdc60993063e4a91c5716e66b8239"

URI_x86_64_v2_linuxconsoletools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/linuxconsoletools-1.8.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_linuxconsoletools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linuxconsoletools}"
SRC_URI[x86_64_v2_linuxconsoletools.sha256sum] = "846e16b65e9611d28462acdeb8406eb655f9ee5853d8836e850dd0b870927a9c"

URI_aarch64_linuxconsoletools = "${EPEL_MIRROR}/aarch64/Packages/l/linuxconsoletools-1.8.1-9.el10_0.aarch64.rpm;name=aarch64_linuxconsoletools;unpack=0"
SRC_URI:append = " ${URI_aarch64_linuxconsoletools}"
SRC_URI[aarch64_linuxconsoletools.sha256sum] = "12bad3c38b3b82d93de1411ed07948baf8f13b45f84815553412742ba07c1bb1"

RDEPENDS:linuxconsoletools = " \
 bash \
 gawk \
 glibc \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
