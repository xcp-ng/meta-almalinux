# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dash"
PV = "0.5.11.5"
PR = "4.el10_1"
PACKAGES = " \
 dash \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dash-0.5.11.5-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1ab0e83eef98bfa0b3456d4e4c6d899fa3747695344821479561fc82fc8919b"

URI_x86_64_v2_dash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dash-0.5.11.5-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dash}"
SRC_URI[x86_64_v2_dash.sha256sum] = "ad9e3deb01211a25e17670fe669418daf427734989263448acd0f559f81f9515"

URI_aarch64_dash = "${EPEL_MIRROR}/aarch64/Packages/d/dash-0.5.11.5-4.el10_1.aarch64.rpm;name=aarch64_dash;unpack=0"
SRC_URI:append = " ${URI_aarch64_dash}"
SRC_URI[aarch64_dash.sha256sum] = "08a0918c48e4b8edb17b49d2e35259c9a590f9af406ed0e4077c6f2d3f361ebb"

RDEPENDS:dash = " \
 bash \
 glibc \
 "
