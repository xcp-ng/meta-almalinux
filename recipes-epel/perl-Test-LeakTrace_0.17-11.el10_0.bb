# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-LeakTrace"
PV = "0.17"
PR = "11.el10_0"
PACKAGES = " \
 perl-Test-LeakTrace \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-LeakTrace-0.17-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e637d15fa35b0674905f51972fb50706f9fe28aa9234bac52adc2ea7f82da207"

URI_x86_64_v2_perl-Test-LeakTrace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-LeakTrace-0.17-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Test-LeakTrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-LeakTrace}"
SRC_URI[x86_64_v2_perl-Test-LeakTrace.sha256sum] = "5c964a526ec5096f869cae98e132511fbfc7a4cd7bed850307211a1af305f3f3"

URI_aarch64_perl-Test-LeakTrace = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-LeakTrace-0.17-11.el10_0.aarch64.rpm;name=aarch64_perl-Test-LeakTrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-LeakTrace}"
SRC_URI[aarch64_perl-Test-LeakTrace.sha256sum] = "87bd169f54d9fbab29952134f4845c9d8b7ea8a87e2a9eba07f374216cce0c17"

RDEPENDS:perl-Test-LeakTrace = " \
 glibc \
 perl-Exporter \
 perl-Test-LeakTrace \
 perl-Test-Simple \
 perl-libs \
 "
