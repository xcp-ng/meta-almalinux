# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libucontext"
PV = "1.5.1"
PR = "1.el10_3"
PACKAGES = " \
 libucontext \
 libucontext-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libucontext-1.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82e2551aad18ef8bfc0eecaf67dbb838ae41f2cffa70db274ce605bf231db2a7"

URI_x86_64_v2_libucontext = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libucontext-1.5.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libucontext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libucontext}"
SRC_URI[x86_64_v2_libucontext.sha256sum] = "f51c03f904844911c65edf8697a9d444a60aba477d91673360deae207885d14e"

URI_x86_64_v2_libucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libucontext-devel-1.5.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libucontext-devel}"
SRC_URI[x86_64_v2_libucontext-devel.sha256sum] = "2387ae06d2a424b304b4d68ffb069c58714cd5cf802cdede1355af313ae2d2cf"

URI_aarch64_libucontext = "${EPEL_MIRROR}/aarch64/Packages/l/libucontext-1.5.1-1.el10_3.aarch64.rpm;name=aarch64_libucontext;unpack=0"
SRC_URI:append = " ${URI_aarch64_libucontext}"
SRC_URI[aarch64_libucontext.sha256sum] = "c6f832f0c807fd5351acf09ec0c546a24601e11f5ce52941e47973aa25b039b5"

URI_aarch64_libucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libucontext-devel-1.5.1-1.el10_3.aarch64.rpm;name=aarch64_libucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libucontext-devel}"
SRC_URI[aarch64_libucontext-devel.sha256sum] = "a606d0166ba05814989b5e8aa7c92b87fe0a3739c0df047f3669c57e2b75b798"

RDEPENDS:libucontext = " \
 glibc \
 "
RDEPENDS:libucontext-devel = " \
 libucontext \
 pkgconf-pkg-config \
 "
