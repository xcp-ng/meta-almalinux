# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-rpm-macros"
PV = "1"
PR = "15.el10"
PACKAGES = " \
 lua-rpm-macros \
 lua-srpm-macros \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lua-rpm-macros-1-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3706ff7e8b0880cfaff9347f317d1d44918a1a7d084751a87be4bab25d7fd0ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lua-rpm-macros-1-15.el10.noarch.rpm;name=x86_64_v2_lua-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_lua-rpm-macros.sha256sum] = "d828b280afb9ee6e2ad06b26ac7da9d8e5086b14c82a79e1d8d0407e29a87f29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lua-srpm-macros-1-15.el10.noarch.rpm;name=x86_64_v2_lua-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_lua-srpm-macros.sha256sum] = "fabbbdf4425d90ccd25458e3b16b0f698427be88eeefaf78b6a081daf60de2bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lua-rpm-macros-1-15.el10.noarch.rpm;name=aarch64_lua-rpm-macros;unpack=0"
SRC_URI[aarch64_lua-rpm-macros.sha256sum] = "d828b280afb9ee6e2ad06b26ac7da9d8e5086b14c82a79e1d8d0407e29a87f29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lua-srpm-macros-1-15.el10.noarch.rpm;name=aarch64_lua-srpm-macros;unpack=0"
SRC_URI[aarch64_lua-srpm-macros.sha256sum] = "fabbbdf4425d90ccd25458e3b16b0f698427be88eeefaf78b6a081daf60de2bb"

RDEPENDS:lua-rpm-macros = " \
 lua-srpm-macros \
 "
RDEPENDS:lua-srpm-macros = " \
 rpm \
 "
