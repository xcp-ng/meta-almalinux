# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-x-term"
PV = "0.25.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-x-term-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-x-term-0.25.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87bcd51c0168dd0baf440fd497e339393db693ed82a35ef9320d7f67b183faa4"

URI_x86_64_v2_golang-x-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-x-term-devel-0.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-x-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-x-term-devel}"
SRC_URI[x86_64_v2_golang-x-term-devel.sha256sum] = "cf2824cc581d7ac0cd780117d583751a75d8850641dcbbf33e77af378bca7f97"

URI_aarch64_golang-x-term-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-x-term-devel-0.25.0-1.el10_0.noarch.rpm;name=aarch64_golang-x-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-x-term-devel}"
SRC_URI[aarch64_golang-x-term-devel.sha256sum] = "f9fe1b45b1209a4920fdf534cb10c425f2e63bd9b7c812013664fabbf69de728"

RDEPENDS:golang-x-term-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
