# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytesize1"
PV = "1.3.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-bytesize1+default-devel \
 rust-bytesize1+serde-devel \
 rust-bytesize1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytesize1-1.3.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b89fe4137aa5496178d820169b1636a47dbca339e94c253b82c6c760fee05dc"

URI_x86_64_v2_rust-bytesize1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize1+default-devel-1.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize1+default-devel}"
SRC_URI[x86_64_v2_rust-bytesize1+default-devel.sha256sum] = "49257f85a8c3fece047aabc0bce79cd3d619a53c6bef5cd2bf60030ab83c53fc"

URI_x86_64_v2_rust-bytesize1+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize1+serde-devel-1.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize1+serde-devel}"
SRC_URI[x86_64_v2_rust-bytesize1+serde-devel.sha256sum] = "4fd835f4f93cdcb44d6f5371a1a49e7c0da6d91188440a39e5b5965190f197a5"

URI_x86_64_v2_rust-bytesize1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytesize1-devel-1.3.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytesize1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytesize1-devel}"
SRC_URI[x86_64_v2_rust-bytesize1-devel.sha256sum] = "944a27585c36400cc4c8fe7058f032e09563e4da3cdd36312234f121bb00c141"

URI_aarch64_rust-bytesize1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize1+default-devel-1.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-bytesize1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize1+default-devel}"
SRC_URI[aarch64_rust-bytesize1+default-devel.sha256sum] = "31b40188437749dbda5ed868fa18d3af183f2cc01c3d7c4f6dd53252262b4586"

URI_aarch64_rust-bytesize1+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize1+serde-devel-1.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-bytesize1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize1+serde-devel}"
SRC_URI[aarch64_rust-bytesize1+serde-devel.sha256sum] = "2e3c021ff2bb5ffa9e7bb8cae96aa8efef39e53e2e7027e37c3e84fbfea02784"

URI_aarch64_rust-bytesize1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytesize1-devel-1.3.3-1.el10_1.noarch.rpm;name=aarch64_rust-bytesize1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytesize1-devel}"
SRC_URI[aarch64_rust-bytesize1-devel.sha256sum] = "6ec73e05689f0a6bd125ddff2cb1060eb95079dde04c02a9a7709fabc09cb624"

RDEPENDS:rust-bytesize1+default-devel = " \
 cargo \
 rust-bytesize1-devel \
 "
RDEPENDS:rust-bytesize1+serde-devel = " \
 cargo \
 rust-bytesize1-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-bytesize1-devel = " \
 cargo \
 rust \
 "
