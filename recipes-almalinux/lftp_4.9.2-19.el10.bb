# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lftp"
PV = "4.9.2"
PR = "19.el10"
PACKAGES = " \
 lftp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lftp-4.9.2-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61d25758c850ed445607dd985d9410be46514f3d8c4b23da59446663ab2577c1"

URI_x86_64_v2_lftp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lftp-4.9.2-19.el10.x86_64_v2.rpm;name=x86_64_v2_lftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lftp}"
SRC_URI[x86_64_v2_lftp.sha256sum] = "685389d7e1c1eefdc1b744906b9eec56d30f0e96207d154fe3b504c5a60d1181"

URI_aarch64_lftp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lftp-4.9.2-19.el10.aarch64.rpm;name=aarch64_lftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_lftp}"
SRC_URI[aarch64_lftp.sha256sum] = "7bbc34b061ce20bf7bcc3ff272a0092eed22511beda50d138df50b9a6238e65b"

RDEPENDS:lftp = " \
 bash \
 glibc \
 gnutls \
 libgcc \
 libidn2 \
 libstdc++ \
 ncurses-libs \
 readline \
 zlib-ng-compat \
 "
