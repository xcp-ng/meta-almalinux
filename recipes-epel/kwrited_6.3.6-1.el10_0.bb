# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kwrited"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kwrited \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kwrited-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3c5f61fc184c3abd692383175757565ef3339c82185866aa34c6fe22b88b7c0"

URI_x86_64_v2_kwrited = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwrited-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwrited;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwrited}"
SRC_URI[x86_64_v2_kwrited.sha256sum] = "1b41c93d38073e35973ec242280f58ed175a1a16d9f74af8c3f7ae67ac9dcbdb"

URI_aarch64_kwrited = "${EPEL_MIRROR}/aarch64/Packages/k/kwrited-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kwrited;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwrited}"
SRC_URI[aarch64_kwrited.sha256sum] = "4d3d1b78445a22990e2a33177e22b7979a2d90e2d51b7f537637d5c0b2d5f664"

RDEPENDS:kwrited = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-knotifications \
 kf6-kpty \
 libstdc++ \
 qt6-qtbase \
 "
