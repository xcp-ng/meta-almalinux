# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jzlib"
PV = "1.1.3"
PR = "30.el10"
PACKAGES = " \
 jzlib \
 jzlib-demo \
 jzlib-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jzlib-1.1.3-30.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "783fd0efcf3f8d0089066d23611d9752f9013ff70adc36b3f42893074398f6f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jzlib-1.1.3-30.el10.noarch.rpm;name=x86_64_v2_jzlib;unpack=0"
SRC_URI[x86_64_v2_jzlib.sha256sum] = "f023faa26b4a70c8db0dfb9feb7bd2f23d1296160c764379992c45f395e7aece"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jzlib-demo-1.1.3-30.el10.noarch.rpm;name=x86_64_v2_jzlib-demo;unpack=0"
SRC_URI[x86_64_v2_jzlib-demo.sha256sum] = "7befec9856b9e3349a5379f3ee5fab4db979dc23f5671d049f8a9a5cbc987822"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jzlib-javadoc-1.1.3-30.el10.noarch.rpm;name=x86_64_v2_jzlib-javadoc;unpack=0"
SRC_URI[x86_64_v2_jzlib-javadoc.sha256sum] = "4faeb582a9fcf7ed00bb72c1e89daa8c76b6f8a3714f0cc22a2d66414fcc3898"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jzlib-1.1.3-30.el10.noarch.rpm;name=aarch64_jzlib;unpack=0"
SRC_URI[aarch64_jzlib.sha256sum] = "f023faa26b4a70c8db0dfb9feb7bd2f23d1296160c764379992c45f395e7aece"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jzlib-demo-1.1.3-30.el10.noarch.rpm;name=aarch64_jzlib-demo;unpack=0"
SRC_URI[aarch64_jzlib-demo.sha256sum] = "7befec9856b9e3349a5379f3ee5fab4db979dc23f5671d049f8a9a5cbc987822"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jzlib-javadoc-1.1.3-30.el10.noarch.rpm;name=aarch64_jzlib-javadoc;unpack=0"
SRC_URI[aarch64_jzlib-javadoc.sha256sum] = "4faeb582a9fcf7ed00bb72c1e89daa8c76b6f8a3714f0cc22a2d66414fcc3898"

RDEPENDS:jzlib = " \
 javapackages-filesystem \
 "
RDEPENDS:jzlib-demo = " \
 jzlib \
 "
RDEPENDS:jzlib-javadoc = " \
 javapackages-filesystem \
 "
