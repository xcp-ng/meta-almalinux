# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Changes"
PV = "0.500004"
PR = "1.el10_0"
PACKAGES = " \
 perl-CPAN-Changes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CPAN-Changes-0.500004-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba1e9a6d2567ed7b326c9c799a5d80adf1af11706916d7565a08707da229bec9"

URI_x86_64_v2_perl-CPAN-Changes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-Changes-0.500004-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-Changes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-Changes}"
SRC_URI[x86_64_v2_perl-CPAN-Changes.sha256sum] = "d7dc593d100568cc360804571a11de7b42ccf10069b1d8e1aa0046dea8fe2db0"

URI_aarch64_perl-CPAN-Changes = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-Changes-0.500004-1.el10_0.noarch.rpm;name=aarch64_perl-CPAN-Changes;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-Changes}"
SRC_URI[aarch64_perl-CPAN-Changes.sha256sum] = "2a0fe7b60a53bf3008d89b95553cdeeb0403bebdeb411940750eb1a1ceab3ced"

RDEPENDS:perl-CPAN-Changes = " \
 perl-CPAN-Changes \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Module-Runtime \
 perl-Moo \
 perl-Pod-Usage \
 perl-Sub-Quote \
 perl-Test-Simple \
 perl-Type-Tiny \
 perl-interpreter \
 perl-libs \
 perl-version \
 "
