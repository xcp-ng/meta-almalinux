# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-gcfg-1"
PV = "1.2.3"
PR = "18.el10_0"
PACKAGES = " \
 golang-gopkg-gcfg-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-gcfg-1-1.2.3-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf870c3843730debbb0f268367946fdb2d56b0377a79bdb222429cc5b4396dce"

URI_x86_64_v2_golang-gopkg-gcfg-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-gcfg-1-devel-1.2.3-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-gcfg-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-gcfg-1-devel}"
SRC_URI[x86_64_v2_golang-gopkg-gcfg-1-devel.sha256sum] = "3c196f0d656218cd7f1ab642e94a86fe16abbfb4f56e0fbe629da905e43ad986"

URI_aarch64_golang-gopkg-gcfg-1-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-gcfg-1-devel-1.2.3-18.el10_0.noarch.rpm;name=aarch64_golang-gopkg-gcfg-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-gcfg-1-devel}"
SRC_URI[aarch64_golang-gopkg-gcfg-1-devel.sha256sum] = "a69e827df6db587527006e6ce02f48ee97df4efa03934c8935ee70c73284ecd9"

RDEPENDS:golang-gopkg-gcfg-1-devel = " \
 go-filesystem \
 golang-gopkg-warnings-0-devel \
 "
