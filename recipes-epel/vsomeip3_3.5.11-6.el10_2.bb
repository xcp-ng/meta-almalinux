# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vsomeip3"
PV = "3.5.11"
PR = "6.el10_2"
PACKAGES = " \
 vsomeip3 \
 vsomeip3-compat \
 vsomeip3-compat-devel \
 vsomeip3-devel \
 vsomeip3-examples \
 vsomeip3-routingmanager \
 vsomeip3-selinux \
 vsomeip3-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vsomeip3-3.5.11-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2119636effe68048d8fbffa1215bd43aa3ab120795fcb80609a4349e858dfd97"

URI_x86_64_v2_vsomeip3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-3.5.11-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3}"
SRC_URI[x86_64_v2_vsomeip3.sha256sum] = "8e8cb98bf7efc3ee235aa862305c27a591d35cc0c2839488e6904fbba920cdfb"

URI_x86_64_v2_vsomeip3-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-compat-3.5.11-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-compat}"
SRC_URI[x86_64_v2_vsomeip3-compat.sha256sum] = "d98e96d79587f912614dfb364ad2ae3677eaf7574589b6e7904c7803934630e9"

URI_x86_64_v2_vsomeip3-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-compat-devel-3.5.11-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-compat-devel}"
SRC_URI[x86_64_v2_vsomeip3-compat-devel.sha256sum] = "9a394c85fae84748fec901b7d7f5d3030481d211b49d7c4885c6dcffd247e469"

URI_x86_64_v2_vsomeip3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-devel-3.5.11-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-devel}"
SRC_URI[x86_64_v2_vsomeip3-devel.sha256sum] = "bf4c49be0c030594af7dcea10468f0bd56ca6ea8e29be8b73ad06ee69cf87e17"

URI_x86_64_v2_vsomeip3-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-examples-3.5.11-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-examples}"
SRC_URI[x86_64_v2_vsomeip3-examples.sha256sum] = "587a0ca23a4aa098dc43399c415749a35fb4038f227345ca4f119c99127d7875"

URI_x86_64_v2_vsomeip3-routingmanager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-routingmanager-3.5.11-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-routingmanager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-routingmanager}"
SRC_URI[x86_64_v2_vsomeip3-routingmanager.sha256sum] = "a1e068ef1814f955c1852f1f6b7a2c2a8505edbc734577b8808f23c5796c6024"

URI_x86_64_v2_vsomeip3-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-selinux-3.5.11-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_vsomeip3-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-selinux}"
SRC_URI[x86_64_v2_vsomeip3-selinux.sha256sum] = "ff23b31f74192fdb4fa11b10056fc448ecc417eb232793537f544346a067b94b"

URI_x86_64_v2_vsomeip3-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vsomeip3-tools-3.5.11-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vsomeip3-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vsomeip3-tools}"
SRC_URI[x86_64_v2_vsomeip3-tools.sha256sum] = "4a9efd87a2e617155af1128f894d62821e29401934575ddb9cf141490ccacfa7"

URI_aarch64_vsomeip3 = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-3.5.11-6.el10_2.aarch64.rpm;name=aarch64_vsomeip3;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3}"
SRC_URI[aarch64_vsomeip3.sha256sum] = "071c703d172dc81e34644325ac4c161f342614bf7590d1e25dbddd730da66347"

URI_aarch64_vsomeip3-compat = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-compat-3.5.11-6.el10_2.aarch64.rpm;name=aarch64_vsomeip3-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-compat}"
SRC_URI[aarch64_vsomeip3-compat.sha256sum] = "ebe2ffd162b9d16028cd9080f451a921584a162d322015a90d1dfdcefc34ee09"

URI_aarch64_vsomeip3-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-compat-devel-3.5.11-6.el10_2.aarch64.rpm;name=aarch64_vsomeip3-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-compat-devel}"
SRC_URI[aarch64_vsomeip3-compat-devel.sha256sum] = "f161803fd7f27e840e4d17a27eb737b33bb300ae1ccf28dafd41c6722b19e079"

URI_aarch64_vsomeip3-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-devel-3.5.11-6.el10_2.aarch64.rpm;name=aarch64_vsomeip3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-devel}"
SRC_URI[aarch64_vsomeip3-devel.sha256sum] = "91a191e6bdcf00756a8d9dc9c73b66e1b778e4b58eafbe14c8ce4a3620e1e9c0"

URI_aarch64_vsomeip3-examples = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-examples-3.5.11-6.el10_2.aarch64.rpm;name=aarch64_vsomeip3-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-examples}"
SRC_URI[aarch64_vsomeip3-examples.sha256sum] = "585842b5e66628c84e769434b655a9cb0c375447b97f96e0aabb9b7f1e8d2987"

URI_aarch64_vsomeip3-routingmanager = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-routingmanager-3.5.11-6.el10_2.aarch64.rpm;name=aarch64_vsomeip3-routingmanager;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-routingmanager}"
SRC_URI[aarch64_vsomeip3-routingmanager.sha256sum] = "61a404b9d36c46fefcdb019d141b0858186e5e7835b063ae73cbf1da604e07e8"

URI_aarch64_vsomeip3-selinux = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-selinux-3.5.11-6.el10_2.noarch.rpm;name=aarch64_vsomeip3-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-selinux}"
SRC_URI[aarch64_vsomeip3-selinux.sha256sum] = "0ffce000f94d2a64b18fc7dcb76343ffec0aa6e891e6a1d61422986cc8730bdf"

URI_aarch64_vsomeip3-tools = "${EPEL_MIRROR}/aarch64/Packages/v/vsomeip3-tools-3.5.11-6.el10_2.aarch64.rpm;name=aarch64_vsomeip3-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vsomeip3-tools}"
SRC_URI[aarch64_vsomeip3-tools.sha256sum] = "fc4e2a553ad0988e34840335688d883eec4dd467fefc4bc5f9b056af0ca24fb4"

RDEPENDS:vsomeip3 = " \
 boost-filesystem \
 boost-thread \
 dlt-libs \
 glibc \
 libgcc \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:vsomeip3-compat = " \
 glibc \
 libgcc \
 libstdc++ \
 vsomeip3 \
 "
RDEPENDS:vsomeip3-compat-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 vsomeip3-compat \
 "
RDEPENDS:vsomeip3-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 vsomeip3 \
 "
RDEPENDS:vsomeip3-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 vsomeip3 \
 "
RDEPENDS:vsomeip3-routingmanager = " \
 bash \
 dlt-daemon \
 dlt-libs \
 glibc \
 libgcc \
 libstdc++ \
 systemd \
 vsomeip3 \
 "
RDEPENDS:vsomeip3-selinux:x86_64_v2 = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.13 \
"
RDEPENDS:vsomeip3-selinux:aarch64 = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.12 \
"
RDEPENDS:vsomeip3-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 vsomeip3 \
 "
