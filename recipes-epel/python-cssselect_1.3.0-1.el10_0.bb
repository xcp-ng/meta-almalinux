# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cssselect"
PV = "1.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-cssselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cssselect-1.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04cd2e1f65309fe17448e1b374f064e7ea46cce7937a6b8f99c761456866a3f1"

URI_x86_64_v2_python3-cssselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cssselect-1.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cssselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cssselect}"
SRC_URI[x86_64_v2_python3-cssselect.sha256sum] = "e78942a8d635c66ece4584e1b24a562fbdb5c046f6eca84271bf2b9670ed4a98"

URI_aarch64_python3-cssselect = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cssselect-1.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-cssselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cssselect}"
SRC_URI[aarch64_python3-cssselect.sha256sum] = "7ae90cee7073c6ca30761b9a1703f71237b074264f371ac8d712512f0ffa9905"

RDEPENDS:python3-cssselect = " \
 python3 \
 "
