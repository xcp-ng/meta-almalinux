# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcel"
PV = "6.8.1"
PR = "4.el10"
PACKAGES = " \
 bcel \
 bcel-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bcel-6.8.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50b935d19b00b90642b971286229e6ccb4698b0718e7004c64f3f584d8221df1"

URI_x86_64_v2_bcel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bcel-6.8.1-4.el10.noarch.rpm;name=x86_64_v2_bcel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcel}"
SRC_URI[x86_64_v2_bcel.sha256sum] = "7238f26da659f61bc35a9f0084182dfdf03e906ba31380f286a67c0f8ad0f822"

URI_x86_64_v2_bcel-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bcel-javadoc-6.8.1-4.el10.noarch.rpm;name=x86_64_v2_bcel-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcel-javadoc}"
SRC_URI[x86_64_v2_bcel-javadoc.sha256sum] = "c641daeb8e2cce8350ba5b2e778f9269127f54531a0633d15c73bbf290085dc9"

URI_aarch64_bcel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bcel-6.8.1-4.el10.noarch.rpm;name=aarch64_bcel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcel}"
SRC_URI[aarch64_bcel.sha256sum] = "7238f26da659f61bc35a9f0084182dfdf03e906ba31380f286a67c0f8ad0f822"

URI_aarch64_bcel-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bcel-javadoc-6.8.1-4.el10.noarch.rpm;name=aarch64_bcel-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcel-javadoc}"
SRC_URI[aarch64_bcel-javadoc.sha256sum] = "c641daeb8e2cce8350ba5b2e778f9269127f54531a0633d15c73bbf290085dc9"

RDEPENDS:bcel = " \
 apache-commons-lang3 \
 javapackages-filesystem \
 "
RDEPENDS:bcel-javadoc = " \
 javapackages-filesystem \
 "
