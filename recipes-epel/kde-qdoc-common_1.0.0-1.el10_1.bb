# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-qdoc-common"
PV = "1.0.0"
PR = "1.el10_1"
PACKAGES = " \
 kde-qdoc-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-qdoc-common-1.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb0bad6b0ec10a17fd1c387650a068d4b64a80037463058273e477909b85c4d9"

URI_x86_64_v2_kde-qdoc-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-qdoc-common-1.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kde-qdoc-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-qdoc-common}"
SRC_URI[x86_64_v2_kde-qdoc-common.sha256sum] = "87b90731c241fd3a56144c3e498bd52640489619f9a87c78b3befeb2d5765b05"

URI_aarch64_kde-qdoc-common = "${EPEL_MIRROR}/aarch64/Packages/k/kde-qdoc-common-1.0.0-1.el10_1.noarch.rpm;name=aarch64_kde-qdoc-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-qdoc-common}"
SRC_URI[aarch64_kde-qdoc-common.sha256sum] = "9097112c64adcd7b544b007139eef06d734143a764acc0e1a5bad42fd14147bd"

RDEPENDS:kde-qdoc-common = " \
 "
