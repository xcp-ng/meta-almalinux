# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-http"
PV = "0.9.7"
PR = "2.el10_1"
PACKAGES = " \
 aws-c-http \
 aws-c-http-devel \
 aws-c-http-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-http-0.9.7-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dcc166ca752a6467a4a172d7731f11a810aa067ed861cadea8b9c0983b9a2a3"

URI_x86_64_v2_aws-c-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-http-0.9.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-http}"
SRC_URI[x86_64_v2_aws-c-http.sha256sum] = "a0da62116c33a922197f39158256684f4534d61b8bd97d0df6ecbf84116fd37c"

URI_x86_64_v2_aws-c-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-http-devel-0.9.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-http-devel}"
SRC_URI[x86_64_v2_aws-c-http-devel.sha256sum] = "34417f66d8038ba7b327c78f965793f282f476f8a825a7a80193ebb37a25e003"

URI_x86_64_v2_aws-c-http-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-http-libs-0.9.7-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-http-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-http-libs}"
SRC_URI[x86_64_v2_aws-c-http-libs.sha256sum] = "ce045099f15679118b6fa2f21ec791300336b11bb8e2ef7c039f4aed3f813763"

URI_aarch64_aws-c-http = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-http-0.9.7-2.el10_1.aarch64.rpm;name=aarch64_aws-c-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-http}"
SRC_URI[aarch64_aws-c-http.sha256sum] = "38cf8c71c7ed6795415a9c7b7c589c9c353d1e5590ec827cb08fd56a80696392"

URI_aarch64_aws-c-http-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-http-devel-0.9.7-2.el10_1.aarch64.rpm;name=aarch64_aws-c-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-http-devel}"
SRC_URI[aarch64_aws-c-http-devel.sha256sum] = "e78c34181889d21558ab0993b729420b41c3b0953942e8d15d37889532ef50a0"

URI_aarch64_aws-c-http-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-http-libs-0.9.7-2.el10_1.aarch64.rpm;name=aarch64_aws-c-http-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-http-libs}"
SRC_URI[aarch64_aws-c-http-libs.sha256sum] = "f31d4990ea782a8f0da65917d93c356cc58234eabe592beb782e64795af367b6"

RDEPENDS:aws-c-http = " \
 aws-c-common-libs \
 aws-c-http-libs \
 aws-c-io \
 glibc \
 "
RDEPENDS:aws-c-http-devel = " \
 aws-c-compression-devel \
 aws-c-http-libs \
 aws-c-io-devel \
 cmake-filesystem \
 openssl-devel \
 "
RDEPENDS:aws-c-http-libs = " \
 aws-c-cal-libs \
 aws-c-common-libs \
 aws-c-compression-libs \
 aws-c-io \
 glibc \
 "
