# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-FTP-AutoReconnect"
PV = "0.3"
PR = "46.el10_1"
PACKAGES = " \
 perl-Net-FTP-AutoReconnect \
 perl-Net-FTP-AutoReconnect-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-FTP-AutoReconnect-0.3-46.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84280679f04a8e9b008024502122cf95e1d95a7b0921cfc341da910e6700598c"

URI_x86_64_v2_perl-Net-FTP-AutoReconnect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-AutoReconnect-0.3-46.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-AutoReconnect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-AutoReconnect}"
SRC_URI[x86_64_v2_perl-Net-FTP-AutoReconnect.sha256sum] = "f71403c53abbbd2a32fe1c1cbc85b4059dd0e6a2ba6b4ebc96edcd7e2f58e575"

URI_x86_64_v2_perl-Net-FTP-AutoReconnect-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-AutoReconnect-tests-0.3-46.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-AutoReconnect-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-AutoReconnect-tests}"
SRC_URI[x86_64_v2_perl-Net-FTP-AutoReconnect-tests.sha256sum] = "407c5910a1408faf4021edfa55fbfe664c34a7464be2761dda3bdba1a5ea235e"

URI_aarch64_perl-Net-FTP-AutoReconnect = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-AutoReconnect-0.3-46.el10_1.noarch.rpm;name=aarch64_perl-Net-FTP-AutoReconnect;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-AutoReconnect}"
SRC_URI[aarch64_perl-Net-FTP-AutoReconnect.sha256sum] = "13a9b21305b0beb609a2576516758f40d49b66032ad5d687c6390091dbdabf61"

URI_aarch64_perl-Net-FTP-AutoReconnect-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-AutoReconnect-tests-0.3-46.el10_1.noarch.rpm;name=aarch64_perl-Net-FTP-AutoReconnect-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-AutoReconnect-tests}"
SRC_URI[aarch64_perl-Net-FTP-AutoReconnect-tests.sha256sum] = "3c7a57aa55682ab9312962a7352f2bf34e3d9e88f6a43db4c957c290632e8d7f"

RDEPENDS:perl-Net-FTP-AutoReconnect = " \
 perl-libnet \
 perl-libs \
 "
RDEPENDS:perl-Net-FTP-AutoReconnect-tests = " \
 bash \
 perl-Net-FTP-AutoReconnect \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
