# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cepces"
PV = "0.5.0"
PR = "1.el10"
PACKAGES = " \
 cepces \
 cepces-certmonger \
 cepces-selinux \
 python3-cepces \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cepces-0.5.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d5c9d54ac50b590e42ed37f0cdb18c752815bcac066d2a70aaadd9ec0078343"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-0.5.0-1.el10.noarch.rpm;name=x86_64_v2_cepces;unpack=0"
SRC_URI[x86_64_v2_cepces.sha256sum] = "a791fd226d49e10500a8c92b3cc48b8d43251129822c085ca1494c2383c2d395"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-certmonger-0.5.0-1.el10.noarch.rpm;name=x86_64_v2_cepces-certmonger;unpack=0"
SRC_URI[x86_64_v2_cepces-certmonger.sha256sum] = "8f76f39a40a5731c4a108acc8068291a3aef9c8082e649dccb183aa7a47324de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-selinux-0.5.0-1.el10.noarch.rpm;name=x86_64_v2_cepces-selinux;unpack=0"
SRC_URI[x86_64_v2_cepces-selinux.sha256sum] = "9e0570a56d6f4603ac960f5e05d946b30734d9fe4ec707e24fdc1f3aa7f013a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-cepces-0.5.0-1.el10.noarch.rpm;name=x86_64_v2_python3-cepces;unpack=0"
SRC_URI[x86_64_v2_python3-cepces.sha256sum] = "72db8e962bc25df6e340823eeac6fa231f8eb154ba47eb3b39dd3387bafaffc3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-0.5.0-1.el10.noarch.rpm;name=aarch64_cepces;unpack=0"
SRC_URI[aarch64_cepces.sha256sum] = "a791fd226d49e10500a8c92b3cc48b8d43251129822c085ca1494c2383c2d395"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-certmonger-0.5.0-1.el10.noarch.rpm;name=aarch64_cepces-certmonger;unpack=0"
SRC_URI[aarch64_cepces-certmonger.sha256sum] = "8f76f39a40a5731c4a108acc8068291a3aef9c8082e649dccb183aa7a47324de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-selinux-0.5.0-1.el10.noarch.rpm;name=aarch64_cepces-selinux;unpack=0"
SRC_URI[aarch64_cepces-selinux.sha256sum] = "9e0570a56d6f4603ac960f5e05d946b30734d9fe4ec707e24fdc1f3aa7f013a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-cepces-0.5.0-1.el10.noarch.rpm;name=aarch64_python3-cepces;unpack=0"
SRC_URI[aarch64_python3-cepces.sha256sum] = "72db8e962bc25df6e340823eeac6fa231f8eb154ba47eb3b39dd3387bafaffc3"

RDEPENDS:cepces = " \
 cepces-selinux \
 python3-cepces \
 "
RDEPENDS:cepces-certmonger = " \
 bash \
 cepces \
 certmonger \
 python3 \
 "
RDEPENDS:cepces-selinux = " \
 bash \
 cepces \
 selinux-policy-targeted \
 "
RDEPENDS:python3-cepces = " \
 krb5-libs \
 python3 \
 python3-cryptography \
 python3-requests \
 python3-requests-gssapi \
 "
