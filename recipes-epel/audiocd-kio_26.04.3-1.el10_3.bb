# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audiocd-kio"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 audiocd-kio \
 audiocd-kio-devel \
 audiocd-kio-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audiocd-kio-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f257f7c58614c80621104a00e61e53c8e432ac1cc8f8b2d3d1784de4dd66f6e2"

URI_x86_64_v2_audiocd-kio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio}"
SRC_URI[x86_64_v2_audiocd-kio.sha256sum] = "29d6e32af3552e51b560379cc86c927c77a13016d5b9fa8a71b6ae6e6f6588aa"

URI_x86_64_v2_audiocd-kio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio-devel}"
SRC_URI[x86_64_v2_audiocd-kio-devel.sha256sum] = "3fdf364de0b99c326cdc20900d700982d6c9d08a0a5b8cfa54bd74755d64095e"

URI_x86_64_v2_audiocd-kio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_audiocd-kio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio-doc}"
SRC_URI[x86_64_v2_audiocd-kio-doc.sha256sum] = "317623d624a5a64cb45844192c19a7566aa4046562b63a54848a8633271cfc0d"

URI_aarch64_audiocd-kio = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_audiocd-kio;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio}"
SRC_URI[aarch64_audiocd-kio.sha256sum] = "febc68aac3336627a1b47dbde0b6fce9250b7b05d1a728f0cdd7a9c29d381e7d"

URI_aarch64_audiocd-kio-devel = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_audiocd-kio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio-devel}"
SRC_URI[aarch64_audiocd-kio-devel.sha256sum] = "74891de69b3d376426119e00ba35f97c1f57f6923bb4243ccbeb7a9b1479c569"

URI_aarch64_audiocd-kio-doc = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_audiocd-kio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio-doc}"
SRC_URI[aarch64_audiocd-kio-doc.sha256sum] = "ae3c4071c58a72a4586d4d8957b8e1eb06edfc7b42a7b14ae9fe617076f7c573"

RDEPENDS:audiocd-kio = " \
 audiocd-kio-doc \
 cdparanoia-libs \
 flac-libs \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-solid \
 libkcddb \
 libogg \
 libstdc++ \
 libvorbis \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:audiocd-kio-devel = " \
 audiocd-kio \
 "
RDEPENDS:audiocd-kio-doc = " \
 audiocd-kio \
 "
