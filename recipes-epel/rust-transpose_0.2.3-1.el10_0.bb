# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-transpose"
PV = "0.2.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-transpose+default-devel \
 rust-transpose-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-transpose-0.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b002e3841825edf9dce386ca403a6d85504e8ab2244cea5d1da8f789f0438e9"

URI_x86_64_v2_rust-transpose+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-transpose+default-devel-0.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-transpose+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-transpose+default-devel}"
SRC_URI[x86_64_v2_rust-transpose+default-devel.sha256sum] = "617a0907e93705451885bc8e52e57febfda13ccfb70a44838bbd771a042fc457"

URI_x86_64_v2_rust-transpose-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-transpose-devel-0.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-transpose-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-transpose-devel}"
SRC_URI[x86_64_v2_rust-transpose-devel.sha256sum] = "7c83fb3fa7219a0b30be5d4516f40440cc2c36b7267c11d8f4c078dd5535ba18"

URI_aarch64_rust-transpose+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-transpose+default-devel-0.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-transpose+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-transpose+default-devel}"
SRC_URI[aarch64_rust-transpose+default-devel.sha256sum] = "5c887d4c066e41ceb6c5207db8a2c458e7f001ddef00caa56765f8e7f600f7ef"

URI_aarch64_rust-transpose-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-transpose-devel-0.2.3-1.el10_0.noarch.rpm;name=aarch64_rust-transpose-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-transpose-devel}"
SRC_URI[aarch64_rust-transpose-devel.sha256sum] = "88c43d2ac6d84f89a02727f0a0ab0a6b0019b04abf96c65f728957038dbbe19b"

RDEPENDS:rust-transpose+default-devel = " \
 cargo \
 rust-transpose-devel \
 "
RDEPENDS:rust-transpose-devel = " \
 cargo \
 rust-num-integer-devel \
 rust-strength_reduce+default-devel \
 "
