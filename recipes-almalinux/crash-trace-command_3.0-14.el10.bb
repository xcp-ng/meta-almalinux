# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crash-trace-command"
PV = "3.0"
PR = "14.el10"
PACKAGES = " \
 crash-trace-command \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/crash-trace-command-3.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0b655e2d72b2f006bf58673744fbce340a9b5d61241760b9b416318dfb8153e"

URI_x86_64_v2_crash-trace-command = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/crash-trace-command-3.0-14.el10.x86_64_v2.rpm;name=x86_64_v2_crash-trace-command;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_crash-trace-command}"
SRC_URI[x86_64_v2_crash-trace-command.sha256sum] = "c0142828fde5dcfbb09074d684dc69c32a3022b19f841515e135feecb0e0f9bf"

URI_aarch64_crash-trace-command = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/crash-trace-command-3.0-14.el10.aarch64.rpm;name=aarch64_crash-trace-command;unpack=0"
SRC_URI:append = " ${URI_aarch64_crash-trace-command}"
SRC_URI[aarch64_crash-trace-command.sha256sum] = "619edbbde36409b1d53c49a2578480c6fb6f41ccf3ff7f82192afb25466055a1"

RDEPENDS:crash-trace-command = " \
 crash \
 glibc \
 trace-cmd \
 "
