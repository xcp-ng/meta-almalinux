# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerdevil"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 powerdevil \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/powerdevil-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "16273f76dfa43752406399c208c4b31190a6e3203d7c173c3b965a7c2ee24412"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerdevil-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerdevil;unpack=0"
SRC_URI[x86_64_v2_powerdevil.sha256sum] = "7707584027d8fa2b0665e5cb48ca8f1216d1119d888c87435319b30792efbf07"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/powerdevil-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_powerdevil;unpack=0"
SRC_URI[aarch64_powerdevil.sha256sum] = "25b126baa4637289b7438225de2cd243e6f5ed93213ab3733bbc4e0b8c3fa837"

RDEPENDS:powerdevil = " \
 ddcutil \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-kxmlgui \
 kf6-solid \
 libddcutil \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 "
