# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SDL2_image"
PV = "2.8.12"
PR = "1.el10_3"
PACKAGES = " \
 SDL2_image \
 SDL2_image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SDL2_image-2.8.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3789f1a6106191ff259b9b0283f646a885b1611e274d195cafb3a082e1e53724"

URI_x86_64_v2_SDL2_image = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_image-2.8.12-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_image;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_image}"
SRC_URI[x86_64_v2_SDL2_image.sha256sum] = "3480f6de3d3783c4ac3611172a7a9bd69de558a89467a09ae8c9c92db4978c71"

URI_x86_64_v2_SDL2_image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SDL2_image-devel-2.8.12-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SDL2_image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2_image-devel}"
SRC_URI[x86_64_v2_SDL2_image-devel.sha256sum] = "0001e4d0aff2cdfd21b762baf91ab9d79ec10223c40d453f66604c9b8deba831"

URI_aarch64_SDL2_image = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_image-2.8.12-1.el10_3.aarch64.rpm;name=aarch64_SDL2_image;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_image}"
SRC_URI[aarch64_SDL2_image.sha256sum] = "10e3812dfe0a67d330358dd5b893a6313796b7d864389f0979deeb937d4c8e21"

URI_aarch64_SDL2_image-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SDL2_image-devel-2.8.12-1.el10_3.aarch64.rpm;name=aarch64_SDL2_image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2_image-devel}"
SRC_URI[aarch64_SDL2_image-devel.sha256sum] = "f8fceab13bc53594c1374e0d2883f1d066c622f6355ba6cb979ef865bee13502"

RDEPENDS:SDL2_image = " \
 glibc \
 libavif \
 libjxl \
 libtiff \
 libwebp \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:SDL2_image-devel = " \
 SDL2-devel \
 SDL2_image \
 libavif-devel \
 libjxl-devel \
 libtiff-devel \
 libwebp-devel \
 pkgconf-pkg-config \
 "
