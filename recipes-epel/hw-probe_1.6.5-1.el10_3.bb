# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hw-probe"
PV = "1.6.5"
PR = "1.el10_3"
PACKAGES = " \
 hw-probe \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hw-probe-1.6.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e778c88922edf58733bd14607bb324911ec28ddf8dbde6e70940dae98cf1cb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hw-probe-1.6.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_hw-probe;unpack=0"
SRC_URI[x86_64_v2_hw-probe.sha256sum] = "80fc5f03b8bc5ffeb0266ec1413b53968babdbde5e4b12df5ce0bbecba68dd9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hw-probe-1.6.5-1.el10_3.noarch.rpm;name=aarch64_hw-probe;unpack=0"
SRC_URI[aarch64_hw-probe.sha256sum] = "86f8ee76cca1bb1839548a9e08b93db08b288e54373dfcdade7fd322ab386a6d"

RDEPENDS:hw-probe = " \
 curl \
 hdparm \
 hwinfo \
 lm_sensors \
 pciutils \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-PathTools \
 perl-interpreter \
 perl-libwww-perl \
 smartmontools \
 sysstat \
 usbutils \
 util-linux \
 "
