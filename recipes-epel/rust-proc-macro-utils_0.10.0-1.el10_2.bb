# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro-utils"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-proc-macro-utils+default-devel \
 rust-proc-macro-utils+parser-devel \
 rust-proc-macro-utils+proc-macro-devel \
 rust-proc-macro-utils+proc-macro2-devel \
 rust-proc-macro-utils+quote-devel \
 rust-proc-macro-utils+smallvec-devel \
 rust-proc-macro-utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro-utils-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8be5e401e56e3a6b6ce8f5d86fffdd103d6cf080f3449447e3869af4bf2b57f"

URI_x86_64_v2_rust-proc-macro-utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-utils+default-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-utils+default-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-utils+default-devel.sha256sum] = "d01aa1f7c365cbdab08b84bd46a36f5ad558ba723ec5aba92cafe6c68bc2b34b"

URI_x86_64_v2_rust-proc-macro-utils+parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-utils+parser-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-utils+parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-utils+parser-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-utils+parser-devel.sha256sum] = "c02139a8838727b0de114d572130f3043a23352f73e733c28e8e18d8e8cbb333"

URI_x86_64_v2_rust-proc-macro-utils+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-utils+proc-macro-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-utils+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-utils+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-utils+proc-macro-devel.sha256sum] = "46dff42f8293b10e08241d92a1bbf4679bda5cdbf66597042c031fb33e1ffcc2"

URI_x86_64_v2_rust-proc-macro-utils+proc-macro2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-utils+proc-macro2-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-utils+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-utils+proc-macro2-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-utils+proc-macro2-devel.sha256sum] = "d361827b92a6a07520a8b510d498c226f75885fb67b6fd21aa1342134b8d8192"

URI_x86_64_v2_rust-proc-macro-utils+quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-utils+quote-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-utils+quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-utils+quote-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-utils+quote-devel.sha256sum] = "2f94ad44562afa83a5dd533e506931e5cf156b12b466688d87baa7bae4f24152"

URI_x86_64_v2_rust-proc-macro-utils+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-utils+smallvec-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-utils+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-utils+smallvec-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-utils+smallvec-devel.sha256sum] = "25e1fa49f7d7ddfe2428ee3ba31e2e94fdd8478968d1084bab33b63d46f30f0f"

URI_x86_64_v2_rust-proc-macro-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro-utils-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-proc-macro-utils-devel}"
SRC_URI[x86_64_v2_rust-proc-macro-utils-devel.sha256sum] = "3f80e9590d90225e01ec0c0d7318e32514fe455059e8f0823a56f78abc15b98c"

URI_aarch64_rust-proc-macro-utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-utils+default-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-utils+default-devel}"
SRC_URI[aarch64_rust-proc-macro-utils+default-devel.sha256sum] = "911a1d24e98efa0393a8af1aced871584e445dbb3394507963eb29ff52cd7d33"

URI_aarch64_rust-proc-macro-utils+parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-utils+parser-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-utils+parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-utils+parser-devel}"
SRC_URI[aarch64_rust-proc-macro-utils+parser-devel.sha256sum] = "9548d0e74f70bf30cbadf485e60c8d71c41dfab1e81898d8ed46df726262ac1e"

URI_aarch64_rust-proc-macro-utils+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-utils+proc-macro-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-utils+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-utils+proc-macro-devel}"
SRC_URI[aarch64_rust-proc-macro-utils+proc-macro-devel.sha256sum] = "78a1ae23066c3f43513a0384069462b7b3ef894f046c71f4153365dc74220ba5"

URI_aarch64_rust-proc-macro-utils+proc-macro2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-utils+proc-macro2-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-utils+proc-macro2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-utils+proc-macro2-devel}"
SRC_URI[aarch64_rust-proc-macro-utils+proc-macro2-devel.sha256sum] = "f694952f59d8c97af9e190dfcde77a586dc7c0d6bac39057fd7d62fec05bfd4b"

URI_aarch64_rust-proc-macro-utils+quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-utils+quote-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-utils+quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-utils+quote-devel}"
SRC_URI[aarch64_rust-proc-macro-utils+quote-devel.sha256sum] = "0084611def66fe57e863369cae9cc12018133d2f110f4c84a0454ca80d147406"

URI_aarch64_rust-proc-macro-utils+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-utils+smallvec-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-utils+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-utils+smallvec-devel}"
SRC_URI[aarch64_rust-proc-macro-utils+smallvec-devel.sha256sum] = "f47062afe29eda41bf1a2ed0bac6c4683a58d7dc50f68c08ef4855945aedf6e1"

URI_aarch64_rust-proc-macro-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro-utils-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-proc-macro-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-proc-macro-utils-devel}"
SRC_URI[aarch64_rust-proc-macro-utils-devel.sha256sum] = "08d4b8ee944fdadfd46cdbe12fead183ba853c387e3445b5509f96cad7f59e91"

RDEPENDS:rust-proc-macro-utils+default-devel = " \
 cargo \
 rust-proc-macro-utils+parser-devel \
 rust-proc-macro-utils+proc-macro-devel \
 rust-proc-macro-utils+proc-macro2-devel \
 rust-proc-macro-utils+quote-devel \
 rust-proc-macro-utils-devel \
 "
RDEPENDS:rust-proc-macro-utils+parser-devel = " \
 cargo \
 rust-proc-macro-utils+proc-macro2-devel \
 rust-proc-macro-utils+smallvec-devel \
 rust-proc-macro-utils-devel \
 "
RDEPENDS:rust-proc-macro-utils+proc-macro-devel = " \
 cargo \
 rust-proc-macro-utils-devel \
 "
RDEPENDS:rust-proc-macro-utils+proc-macro2-devel = " \
 cargo \
 rust-proc-macro-utils-devel \
 rust-proc-macro2+default-devel \
 "
RDEPENDS:rust-proc-macro-utils+quote-devel = " \
 cargo \
 rust-proc-macro-utils-devel \
 rust-quote+default-devel \
 "
RDEPENDS:rust-proc-macro-utils+smallvec-devel = " \
 cargo \
 rust-proc-macro-utils-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-proc-macro-utils-devel = " \
 cargo \
 "
