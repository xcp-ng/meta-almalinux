# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pasetors"
PV = "0.6.8"
PR = "3.el10_0"
PACKAGES = " \
 rust-pasetors+default-devel \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors+p384-devel \
 rust-pasetors+paserk-devel \
 rust-pasetors+rand_core-devel \
 rust-pasetors+regex-devel \
 rust-pasetors+serde-devel \
 rust-pasetors+serde_json-devel \
 rust-pasetors+sha2-devel \
 rust-pasetors+std-devel \
 rust-pasetors+time-devel \
 rust-pasetors+v2-devel \
 rust-pasetors+v3-devel \
 rust-pasetors+v4-devel \
 rust-pasetors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pasetors-0.6.8-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8fc3998b16db7f858c0ba6ec16d7f0651a08913ca5d2fed61f04896a83ba90a"

URI_x86_64_v2_rust-pasetors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+default-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+default-devel}"
SRC_URI[x86_64_v2_rust-pasetors+default-devel.sha256sum] = "9c240c042245a7dd1d4f336a61300a14cdee815a3616badee242e688744799f1"

URI_x86_64_v2_rust-pasetors+ed25519-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+ed25519-compact-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+ed25519-compact-devel}"
SRC_URI[x86_64_v2_rust-pasetors+ed25519-compact-devel.sha256sum] = "91ee9ce3034d20b21ba25be40c104d8826f2987914ad19bc99d175d74fd92a5a"

URI_x86_64_v2_rust-pasetors+orion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+orion-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+orion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+orion-devel}"
SRC_URI[x86_64_v2_rust-pasetors+orion-devel.sha256sum] = "2b023af2f4077baad07e3adcc5a0269b2864c24264e06f533cb9b7a1f3c501ea"

URI_x86_64_v2_rust-pasetors+p384-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+p384-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+p384-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+p384-devel}"
SRC_URI[x86_64_v2_rust-pasetors+p384-devel.sha256sum] = "517bc9c22d99bed860f6d8b8e0206ac82978d5765c5d37e9aef3d1650f2aded0"

URI_x86_64_v2_rust-pasetors+paserk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+paserk-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+paserk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+paserk-devel}"
SRC_URI[x86_64_v2_rust-pasetors+paserk-devel.sha256sum] = "5b3fe8d625745592d89dcd4d8acdad8ba6e31429a49038afc07232d603b604a0"

URI_x86_64_v2_rust-pasetors+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+rand_core-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+rand_core-devel}"
SRC_URI[x86_64_v2_rust-pasetors+rand_core-devel.sha256sum] = "7b27be030c72731e65d51e9f7a5fe7c749ef8446407ec856b406f8ace62fe13d"

URI_x86_64_v2_rust-pasetors+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+regex-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+regex-devel}"
SRC_URI[x86_64_v2_rust-pasetors+regex-devel.sha256sum] = "f5d25a7d2056c34a28711b8b7b9842e5b57c2977e581fb13fb378653237ad44e"

URI_x86_64_v2_rust-pasetors+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+serde-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+serde-devel}"
SRC_URI[x86_64_v2_rust-pasetors+serde-devel.sha256sum] = "33c598abbd3d81edff5017b838f22b07ea734262729e9197f5314f289a5869a9"

URI_x86_64_v2_rust-pasetors+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+serde_json-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+serde_json-devel}"
SRC_URI[x86_64_v2_rust-pasetors+serde_json-devel.sha256sum] = "ef5f2527b53637bd007af829c91fdb7f189ab73c9853aedda661eee17d524855"

URI_x86_64_v2_rust-pasetors+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+sha2-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+sha2-devel}"
SRC_URI[x86_64_v2_rust-pasetors+sha2-devel.sha256sum] = "d4e6321facbeb65bfb7942cb66cfb6d5dad32e15061bb6815e4fa0dcccd151fa"

URI_x86_64_v2_rust-pasetors+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+std-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+std-devel}"
SRC_URI[x86_64_v2_rust-pasetors+std-devel.sha256sum] = "3179af4102e5e7bccb4a965d4b34ade367f797e1b86481702f3b0cceecc89b3a"

URI_x86_64_v2_rust-pasetors+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+time-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+time-devel}"
SRC_URI[x86_64_v2_rust-pasetors+time-devel.sha256sum] = "dd8515dafe37748db92c7a7b84c436b7df4c9f27395b49b23c8ea10c7e53e4c2"

URI_x86_64_v2_rust-pasetors+v2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v2-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v2-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v2-devel.sha256sum] = "ab0a758e8e440887e7c558ddbc8c90247c443f71de93b1549f5e9658a362d05a"

URI_x86_64_v2_rust-pasetors+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v3-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v3-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v3-devel.sha256sum] = "4139a4f80ce27aead498b95926274861640b6c486a76acd5934ec2fdcb25b615"

URI_x86_64_v2_rust-pasetors+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v4-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v4-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v4-devel.sha256sum] = "f66a88bbf5655f83bb68ebaf5ddabda8967d4fb7eed65da7756a1a9942b45132"

URI_x86_64_v2_rust-pasetors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors-devel-0.6.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors-devel}"
SRC_URI[x86_64_v2_rust-pasetors-devel.sha256sum] = "f07d7b1df3dfa092eeb8e23d462deb481219ae992c7e4e9d9d396176464287d2"

URI_aarch64_rust-pasetors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+default-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+default-devel}"
SRC_URI[aarch64_rust-pasetors+default-devel.sha256sum] = "f708553bdfd74d1208a941d8f6deaed0dfa33843e2267b664382d3bb9ec776ab"

URI_aarch64_rust-pasetors+ed25519-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+ed25519-compact-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+ed25519-compact-devel}"
SRC_URI[aarch64_rust-pasetors+ed25519-compact-devel.sha256sum] = "1070aaf515143c8882b04fc86a701d66b5bab9bb8d2f539b257ac90b3662e876"

URI_aarch64_rust-pasetors+orion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+orion-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+orion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+orion-devel}"
SRC_URI[aarch64_rust-pasetors+orion-devel.sha256sum] = "683e9c5b5c6b78c282a5e42e8317d06bbbefbe66dae105446bdcd5c0dd90cac5"

URI_aarch64_rust-pasetors+p384-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+p384-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+p384-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+p384-devel}"
SRC_URI[aarch64_rust-pasetors+p384-devel.sha256sum] = "cc3d5114e272d78920c5327d999ef4f05bdd418a2016faf0f207886f4927646b"

URI_aarch64_rust-pasetors+paserk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+paserk-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+paserk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+paserk-devel}"
SRC_URI[aarch64_rust-pasetors+paserk-devel.sha256sum] = "02117cd16c45f6a582c1190694aafb27082700f1430f52450ef19cb42c195df9"

URI_aarch64_rust-pasetors+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+rand_core-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+rand_core-devel}"
SRC_URI[aarch64_rust-pasetors+rand_core-devel.sha256sum] = "4e5de621eab420015afb902ad34b09b80bd3985734c8df0db73603378a820b5c"

URI_aarch64_rust-pasetors+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+regex-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+regex-devel}"
SRC_URI[aarch64_rust-pasetors+regex-devel.sha256sum] = "b62c27ba3c7df30b8138e835981237691509700d876ba5db4e533c79c12e236d"

URI_aarch64_rust-pasetors+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+serde-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+serde-devel}"
SRC_URI[aarch64_rust-pasetors+serde-devel.sha256sum] = "c8f10c19f14d5a5295618da3e9e2e9ec30579c2e9a74b6a704e984da0bfaf97c"

URI_aarch64_rust-pasetors+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+serde_json-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+serde_json-devel}"
SRC_URI[aarch64_rust-pasetors+serde_json-devel.sha256sum] = "eaf3b0ff37fd71acd783f432baca2fc69598318538d6c4a52e881af7db40eac8"

URI_aarch64_rust-pasetors+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+sha2-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+sha2-devel}"
SRC_URI[aarch64_rust-pasetors+sha2-devel.sha256sum] = "8f09e7492cde62f72e3b0ae3d8123ec9b45cb308d5c5cec0b1081555aefd017a"

URI_aarch64_rust-pasetors+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+std-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+std-devel}"
SRC_URI[aarch64_rust-pasetors+std-devel.sha256sum] = "b0b9b84e2061b612f8309d32dfff925d0bfa20854ee6ac287994b19ebf760c2f"

URI_aarch64_rust-pasetors+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+time-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+time-devel}"
SRC_URI[aarch64_rust-pasetors+time-devel.sha256sum] = "002b0ffc5bda2b1c0a2733624f0c7ad50d80f216b5cd23f77eccf96d1aafce0d"

URI_aarch64_rust-pasetors+v2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v2-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+v2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v2-devel}"
SRC_URI[aarch64_rust-pasetors+v2-devel.sha256sum] = "5c54bf9400c3d7d966b51004ebff6077e84737eb451d23e12b9e0795e95ae40c"

URI_aarch64_rust-pasetors+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v3-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v3-devel}"
SRC_URI[aarch64_rust-pasetors+v3-devel.sha256sum] = "787138ef1b5859b2c153e95540c5a460700ce3be658121b59529a65fd5759d11"

URI_aarch64_rust-pasetors+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v4-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v4-devel}"
SRC_URI[aarch64_rust-pasetors+v4-devel.sha256sum] = "dda83efbaf1a067e6eef4336f36547945ea068df4a8d29302cad099594b285e9"

URI_aarch64_rust-pasetors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors-devel-0.6.8-3.el10_0.noarch.rpm;name=aarch64_rust-pasetors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors-devel}"
SRC_URI[aarch64_rust-pasetors-devel.sha256sum] = "f69ec32a39c10fbf409bfef9044d5c58c7c112b04731107cfb0c53c044abb255"

RDEPENDS:rust-pasetors+default-devel = " \
 cargo \
 rust-pasetors+paserk-devel \
 rust-pasetors+std-devel \
 rust-pasetors+v4-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+ed25519-compact-devel = " \
 cargo \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+orion-devel = " \
 cargo \
 rust-orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+p384-devel = " \
 cargo \
 rust-p384+default-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+paserk-devel = " \
 cargo \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+rand_core-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-pasetors+regex-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-pasetors+serde-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pasetors+serde_json-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-pasetors+sha2-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-pasetors+std-devel = " \
 cargo \
 rust-pasetors+regex-devel \
 rust-pasetors+serde_json-devel \
 rust-pasetors+time-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+time-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-pasetors+v2-devel = " \
 cargo \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+v3-devel = " \
 cargo \
 rust-pasetors+p384-devel \
 rust-pasetors+rand_core-devel \
 rust-pasetors+sha2-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+v4-devel = " \
 cargo \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors-devel = " \
 cargo \
 rust \
 rust-ct-codecs-devel \
 rust-getrandom0.2+default-devel \
 rust-subtle-devel \
 rust-zeroize-devel \
 "
