# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta_derive0.1"
PV = "0.1.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-ptr_meta_derive0.1+default-devel \
 rust-ptr_meta_derive0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta_derive0.1-0.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7a17ba26052d8831d905f4014d9b65bf8c18b7f9bdfbbd6ca1ad0e8f24ba0a4"

URI_x86_64_v2_rust-ptr_meta_derive0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive0.1+default-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive0.1+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive0.1+default-devel.sha256sum] = "5e0ac6581c5228f2f6420765968a502377f6ff76e6f8a312ab61053ee04082be"

URI_x86_64_v2_rust-ptr_meta_derive0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta_derive0.1-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta_derive0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta_derive0.1-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta_derive0.1-devel.sha256sum] = "f02489b678fdf25e6e42dd52cc2aac5c4046fd1b0906f9099ef249c89a694b29"

URI_aarch64_rust-ptr_meta_derive0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive0.1+default-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta_derive0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive0.1+default-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive0.1+default-devel.sha256sum] = "5be792dfb8c07f2be456ec30362ede0ddca08984fb28f5b2dce7385958b1d6d9"

URI_aarch64_rust-ptr_meta_derive0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta_derive0.1-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-ptr_meta_derive0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta_derive0.1-devel}"
SRC_URI[aarch64_rust-ptr_meta_derive0.1-devel.sha256sum] = "80b9027250273581e66dcfe518e8752b237d090f1dc673e21e651d5760f322b7"

RDEPENDS:rust-ptr_meta_derive0.1+default-devel = " \
 cargo \
 rust-ptr_meta_derive0.1-devel \
 "
RDEPENDS:rust-ptr_meta_derive0.1-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 rust-syn1+full-devel \
 "
