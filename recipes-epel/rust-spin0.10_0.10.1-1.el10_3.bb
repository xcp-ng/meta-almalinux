# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spin0.10"
PV = "0.10.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-spin0.10+barrier-devel \
 rust-spin0.10+default-devel \
 rust-spin0.10+fair_mutex-devel \
 rust-spin0.10+lazy-devel \
 rust-spin0.10+lock_api-devel \
 rust-spin0.10+mutex-devel \
 rust-spin0.10+once-devel \
 rust-spin0.10+portable-atomic-devel \
 rust-spin0.10+portable_atomic-devel \
 rust-spin0.10+rwlock-devel \
 rust-spin0.10+spin_mutex-devel \
 rust-spin0.10+std-devel \
 rust-spin0.10+ticket_mutex-devel \
 rust-spin0.10+use_ticket_mutex-devel \
 rust-spin0.10-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spin0.10-0.10.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e3c25fcc5f40e76d27a60ed99f88233db185715705c8ba24b22a2b6c21f3e35"

URI_x86_64_v2_rust-spin0.10+barrier-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+barrier-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+barrier-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+barrier-devel.sha256sum] = "0e19becd7ffd70f58c008ee7cf37e1d853bb3599e55fe4f9c633d8e80d3c79f6"

URI_x86_64_v2_rust-spin0.10+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+default-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+default-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+default-devel.sha256sum] = "42ddd8e404cb5302be6fe82581e2d73948b9a319c63e1c1615ead820c0db1006"

URI_x86_64_v2_rust-spin0.10+fair_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+fair_mutex-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+fair_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+fair_mutex-devel.sha256sum] = "5f1bc00b9e28d6aa00d9eab9d00607700783695f852da6ab10475cb30f6faa82"

URI_x86_64_v2_rust-spin0.10+lazy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+lazy-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+lazy-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+lazy-devel.sha256sum] = "cfb824f33bee9deb02ef25271603cafd050292b94be79ca0db2c78ec47b42d95"

URI_x86_64_v2_rust-spin0.10+lock_api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+lock_api-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+lock_api-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+lock_api-devel.sha256sum] = "97089a3c49701a877fa3d845aef47f10a788661c696bfee2d08fe01fb034b7cf"

URI_x86_64_v2_rust-spin0.10+mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+mutex-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+mutex-devel.sha256sum] = "62b00a067e8bbda24dd232900679835c5549485e6af05555fb27e449194c3123"

URI_x86_64_v2_rust-spin0.10+once-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+once-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+once-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+once-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+once-devel.sha256sum] = "0ef2669f3525c21fa1f5d8c99ab57d4f05d3159c53f9887a432cb84da13faaf8"

URI_x86_64_v2_rust-spin0.10+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+portable-atomic-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+portable-atomic-devel.sha256sum] = "60867c68e2474636e4e576cfe2df2e2fec62f4cc9251047abdfefef9a274d8e9"

URI_x86_64_v2_rust-spin0.10+portable_atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+portable_atomic-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+portable_atomic-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+portable_atomic-devel.sha256sum] = "8fec199b80910b88c1043d116249375ad00c9d47db76433f6bff8fb9d3b57642"

URI_x86_64_v2_rust-spin0.10+rwlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+rwlock-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+rwlock-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+rwlock-devel.sha256sum] = "7496fd180bd01cd9f4d63160945d153ef5f07a5e93612f4464d49437fe52184d"

URI_x86_64_v2_rust-spin0.10+spin_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+spin_mutex-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+spin_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+spin_mutex-devel.sha256sum] = "34ada6ce36373936b66e4d57c4c85fd2e2da5c283ed0dd5b55782e916ce1071d"

URI_x86_64_v2_rust-spin0.10+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+std-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+std-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+std-devel.sha256sum] = "e6f1ef68b5e1fc5941cc391ef017f686ad214082874f09a45c6abfe70ea3cb6c"

URI_x86_64_v2_rust-spin0.10+ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+ticket_mutex-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+ticket_mutex-devel.sha256sum] = "c35adb003d346859d5013eefa862205a57bbcd5dfb19bc7a507125821510a2cd"

URI_x86_64_v2_rust-spin0.10+use_ticket_mutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10+use_ticket_mutex-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10+use_ticket_mutex-devel}"
SRC_URI[x86_64_v2_rust-spin0.10+use_ticket_mutex-devel.sha256sum] = "1873aabb71938fdbfde89a466bb909adeabafcba086a2215499bd92323e3c83e"

URI_x86_64_v2_rust-spin0.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin0.10-devel-0.10.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin0.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin0.10-devel}"
SRC_URI[x86_64_v2_rust-spin0.10-devel.sha256sum] = "e5e9059368b1d8350f6796908d26ce892b2b06b78bee7b5a1950bb7ed5620dd8"

URI_aarch64_rust-spin0.10+barrier-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+barrier-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+barrier-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+barrier-devel}"
SRC_URI[aarch64_rust-spin0.10+barrier-devel.sha256sum] = "81e76c69664572fd710618f19f86285f522a53d06961e965cf10526920a7652b"

URI_aarch64_rust-spin0.10+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+default-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+default-devel}"
SRC_URI[aarch64_rust-spin0.10+default-devel.sha256sum] = "e3c0f8bba2fd94a2f004045c6e40c313e1d35b833053ca170cb56f0fb0a5adc5"

URI_aarch64_rust-spin0.10+fair_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+fair_mutex-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+fair_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+fair_mutex-devel}"
SRC_URI[aarch64_rust-spin0.10+fair_mutex-devel.sha256sum] = "6d25917f8119f802a380c26c6a5e90ce220bd15bf5b5f117031a8e734f073b53"

URI_aarch64_rust-spin0.10+lazy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+lazy-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+lazy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+lazy-devel}"
SRC_URI[aarch64_rust-spin0.10+lazy-devel.sha256sum] = "41aa25079c1da7b2fb14cbecff735d3135332569f0271699ab3951d699a5facd"

URI_aarch64_rust-spin0.10+lock_api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+lock_api-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+lock_api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+lock_api-devel}"
SRC_URI[aarch64_rust-spin0.10+lock_api-devel.sha256sum] = "436b39765e80674432f81076f36f10d6e7c58a08563a9f7e4eb58c3beb8d9d26"

URI_aarch64_rust-spin0.10+mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+mutex-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+mutex-devel}"
SRC_URI[aarch64_rust-spin0.10+mutex-devel.sha256sum] = "e101f59aff483185d0f672d3f08ca9e33296a88c6a2500f4c618c7189948f103"

URI_aarch64_rust-spin0.10+once-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+once-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+once-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+once-devel}"
SRC_URI[aarch64_rust-spin0.10+once-devel.sha256sum] = "1d1aec36dd7162c06bad45d73d82b43b63aa6b74c74713e275d451804e0dab4d"

URI_aarch64_rust-spin0.10+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+portable-atomic-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+portable-atomic-devel}"
SRC_URI[aarch64_rust-spin0.10+portable-atomic-devel.sha256sum] = "9e97a87f57d6e8a3643fdd6a56a29ab3fcfa98d03f85f37f4531e325cff95f98"

URI_aarch64_rust-spin0.10+portable_atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+portable_atomic-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+portable_atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+portable_atomic-devel}"
SRC_URI[aarch64_rust-spin0.10+portable_atomic-devel.sha256sum] = "bc9dabc683fd3944ca1eda07d9c3a3de1fa15d5f210cb99959c0caa5626a351c"

URI_aarch64_rust-spin0.10+rwlock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+rwlock-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+rwlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+rwlock-devel}"
SRC_URI[aarch64_rust-spin0.10+rwlock-devel.sha256sum] = "ba7bb1b9875ff6a663f4d1d074ea842bfda96e405865569c66e4542ef03b8d8f"

URI_aarch64_rust-spin0.10+spin_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+spin_mutex-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+spin_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+spin_mutex-devel}"
SRC_URI[aarch64_rust-spin0.10+spin_mutex-devel.sha256sum] = "88536e2fd280b0dfa044378b06f815aa5cce4cb56dbe5544b38a3ad1bb647ee9"

URI_aarch64_rust-spin0.10+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+std-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+std-devel}"
SRC_URI[aarch64_rust-spin0.10+std-devel.sha256sum] = "f7ac2da44e60cc805dfda0ee4d8376d20c33a8935b277c92c2c2987ca982a11d"

URI_aarch64_rust-spin0.10+ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+ticket_mutex-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin0.10+ticket_mutex-devel.sha256sum] = "d498bba52b55fe93b5d81d74fbf772775d13dd1f1c5f1943488e563883de405b"

URI_aarch64_rust-spin0.10+use_ticket_mutex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10+use_ticket_mutex-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10+use_ticket_mutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10+use_ticket_mutex-devel}"
SRC_URI[aarch64_rust-spin0.10+use_ticket_mutex-devel.sha256sum] = "1d6205ac01da119ca5df0af4e16468cb8a6837f17d69f66f8974b2ab19f00641"

URI_aarch64_rust-spin0.10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin0.10-devel-0.10.1-1.el10_3.noarch.rpm;name=aarch64_rust-spin0.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin0.10-devel}"
SRC_URI[aarch64_rust-spin0.10-devel.sha256sum] = "12613b6ea2e6ec38971d1df0c09f755698ce7054f0138448b315ffc91935c9aa"

RDEPENDS:rust-spin0.10+barrier-devel = " \
 cargo \
 rust-spin0.10+mutex-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+default-devel = " \
 cargo \
 rust-spin0.10+barrier-devel \
 rust-spin0.10+lazy-devel \
 rust-spin0.10+lock_api-devel \
 rust-spin0.10+mutex-devel \
 rust-spin0.10+once-devel \
 rust-spin0.10+rwlock-devel \
 rust-spin0.10+spin_mutex-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+fair_mutex-devel = " \
 cargo \
 rust-spin0.10+mutex-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+lazy-devel = " \
 cargo \
 rust-spin0.10+once-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+lock_api-devel = " \
 cargo \
 rust-lock_api+default-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+mutex-devel = " \
 cargo \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+once-devel = " \
 cargo \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+portable-atomic-devel = " \
 cargo \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+portable_atomic-devel = " \
 cargo \
 rust-spin0.10+portable-atomic-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+rwlock-devel = " \
 cargo \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+spin_mutex-devel = " \
 cargo \
 rust-spin0.10+mutex-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+std-devel = " \
 cargo \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+ticket_mutex-devel = " \
 cargo \
 rust-spin0.10+mutex-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10+use_ticket_mutex-devel = " \
 cargo \
 rust-spin0.10+mutex-devel \
 rust-spin0.10+ticket_mutex-devel \
 rust-spin0.10-devel \
 "
RDEPENDS:rust-spin0.10-devel = " \
 cargo \
 rust \
 "
