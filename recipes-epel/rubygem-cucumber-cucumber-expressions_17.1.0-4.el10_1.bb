# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-cucumber-expressions"
PV = "17.1.0"
PR = "4.el10_1"
PACKAGES = " \
 rubygem-cucumber-cucumber-expressions \
 rubygem-cucumber-cucumber-expressions-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-cucumber-expressions-17.1.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd8abe02bab1be47c7e44d44af16b9c0387ceba41fc00f5d0788f5f880ffc145"

URI_x86_64_v2_rubygem-cucumber-cucumber-expressions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-cucumber-expressions-17.1.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-cucumber-expressions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-cucumber-expressions}"
SRC_URI[x86_64_v2_rubygem-cucumber-cucumber-expressions.sha256sum] = "2de6abffe8440551486ef8100691308a03652d93535e684be4cc06b7d39ecc1d"

URI_x86_64_v2_rubygem-cucumber-cucumber-expressions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-cucumber-expressions-doc-17.1.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-cucumber-expressions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-cucumber-expressions-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-cucumber-expressions-doc.sha256sum] = "ece21714ababb220e92801d2145000dae940b85691163ccbf34006a748ce5942"

URI_aarch64_rubygem-cucumber-cucumber-expressions = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-cucumber-expressions-17.1.0-4.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-cucumber-expressions;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-cucumber-expressions}"
SRC_URI[aarch64_rubygem-cucumber-cucumber-expressions.sha256sum] = "5057da254d6dbf2a1a17532a3a17c14deb0fd0b67118416fe8cc5f1bd1e0ac25"

URI_aarch64_rubygem-cucumber-cucumber-expressions-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-cucumber-expressions-doc-17.1.0-4.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-cucumber-expressions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-cucumber-expressions-doc}"
SRC_URI[aarch64_rubygem-cucumber-cucumber-expressions-doc.sha256sum] = "55df52c132ede6be3cf4a45d5c84010951b7fbbd402dbb15f8e0c01622c562d8"

RDEPENDS:rubygem-cucumber-cucumber-expressions = " \
 rubygem-bigdecimal \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-cucumber-expressions-doc = " \
 rubygem-cucumber-cucumber-expressions \
 "
