# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samurai"
PV = "1.3"
PR = "1.el10_1"
PACKAGES = " \
 samurai \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/samurai-1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15d28268d622485666861b803f6b4650a2f3a9a9bcb7cd1a2585c3f2c83274c1"

URI_x86_64_v2_samurai = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/samurai-1.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_samurai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samurai}"
SRC_URI[x86_64_v2_samurai.sha256sum] = "cdf2a69ab02a933ab96e1583e74452ae8bee98f2defd6e6402f9334d23d3ba14"

URI_aarch64_samurai = "${EPEL_MIRROR}/aarch64/Packages/s/samurai-1.3-1.el10_1.aarch64.rpm;name=aarch64_samurai;unpack=0"
SRC_URI:append = " ${URI_aarch64_samurai}"
SRC_URI[aarch64_samurai.sha256sum] = "af3dad9fdb6235930eef2d4702037d947359cf9f150c9bd801559e1c018cdd5d"

RDEPENDS:samurai = " \
 glibc \
 "
