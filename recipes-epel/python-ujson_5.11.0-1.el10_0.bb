# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ujson"
PV = "5.11.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-ujson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ujson-5.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b467752d19836bcc140fbed0e9e5bf64f7cc70cafc13c9fe550bc3ef39cc8920"

URI_x86_64_v2_python3-ujson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ujson-5.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-ujson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ujson}"
SRC_URI[x86_64_v2_python3-ujson.sha256sum] = "8c50d5a531910465d250350c013a3fdda8a2f2cdd3c5de8cd5a568e5089e7c13"

URI_aarch64_python3-ujson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ujson-5.11.0-1.el10_0.aarch64.rpm;name=aarch64_python3-ujson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ujson}"
SRC_URI[aarch64_python3-ujson.sha256sum] = "0be7f7326246e33cbcf199a503d3bc89b47acd655eba5adfacad8e064067d2e7"

RDEPENDS:python3-ujson = " \
 double-conversion \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
