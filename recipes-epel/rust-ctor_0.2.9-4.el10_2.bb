# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctor"
PV = "0.2.9"
PR = "4.el10_2"
PACKAGES = " \
 rust-ctor+default-devel \
 rust-ctor+used_linker-devel \
 rust-ctor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ctor-0.2.9-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1394c7148505a4c52fd0c52c9a4814dfdcfc62c042b9fa79e498a9d130628d54"

URI_x86_64_v2_rust-ctor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+default-devel-0.2.9-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor+default-devel}"
SRC_URI[x86_64_v2_rust-ctor+default-devel.sha256sum] = "c75cbe8cf272312387769433b75ec980fe0e68e0e24b314b4142796ea01eca90"

URI_x86_64_v2_rust-ctor+used_linker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+used_linker-devel-0.2.9-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+used_linker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor+used_linker-devel}"
SRC_URI[x86_64_v2_rust-ctor+used_linker-devel.sha256sum] = "466afc46e28546d8684964eae34c3b429ea6c472bccedeb632fc9791ae380d92"

URI_x86_64_v2_rust-ctor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor-devel-0.2.9-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor-devel}"
SRC_URI[x86_64_v2_rust-ctor-devel.sha256sum] = "db84ecea32e35c77a095c5dbbe4cf03b43eb298f4b668466d1f3c5250fb10cae"

URI_aarch64_rust-ctor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+default-devel-0.2.9-4.el10_2.noarch.rpm;name=aarch64_rust-ctor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor+default-devel}"
SRC_URI[aarch64_rust-ctor+default-devel.sha256sum] = "85b067cdd352194fbf8ac96cfc4847d319a85de0771c120512710aa327f5a8e0"

URI_aarch64_rust-ctor+used_linker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+used_linker-devel-0.2.9-4.el10_2.noarch.rpm;name=aarch64_rust-ctor+used_linker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor+used_linker-devel}"
SRC_URI[aarch64_rust-ctor+used_linker-devel.sha256sum] = "7c21878156de2f2841ec8e2d40cfe9535fc21c3bf05f8027d36920d329542f75"

URI_aarch64_rust-ctor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor-devel-0.2.9-4.el10_2.noarch.rpm;name=aarch64_rust-ctor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor-devel}"
SRC_URI[aarch64_rust-ctor-devel.sha256sum] = "2938ac004d97d6fa0a81f6febf075bd279e8f273d2e29f617e81eb531fac3799"

RDEPENDS:rust-ctor+default-devel = " \
 cargo \
 rust-ctor-devel \
 "
RDEPENDS:rust-ctor+used_linker-devel = " \
 cargo \
 rust-ctor-devel \
 "
RDEPENDS:rust-ctor-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
