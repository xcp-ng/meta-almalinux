# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kactivitymanagerd"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kactivitymanagerd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kactivitymanagerd-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18c48a89170f2a78c4c0772785975e73e2d591acddfcef6b8b44859b363adcd1"

URI_x86_64_v2_kactivitymanagerd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kactivitymanagerd-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kactivitymanagerd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kactivitymanagerd}"
SRC_URI[x86_64_v2_kactivitymanagerd.sha256sum] = "f5a226defe195a736b8175aa63bea8524c75d4666e5d0036de2e6ea3b7befaaf"

URI_aarch64_kactivitymanagerd = "${EPEL_MIRROR}/aarch64/Packages/k/kactivitymanagerd-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kactivitymanagerd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kactivitymanagerd}"
SRC_URI[aarch64_kactivitymanagerd.sha256sum] = "07cc59f24eaa187aa39659a5fd87586affc899059aff6c24117e825b4d5cadc6"

RDEPENDS:kactivitymanagerd = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
