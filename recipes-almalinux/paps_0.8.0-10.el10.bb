# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "paps"
PV = "0.8.0"
PR = "10.el10"
PACKAGES = " \
 paps \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/paps-0.8.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75049e1983d76052e15752aa30f46bf2403e57375ba7e2297708c0911dcaa692"

URI_x86_64_v2_paps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/paps-0.8.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_paps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_paps}"
SRC_URI[x86_64_v2_paps.sha256sum] = "89ef93ff41a5d5ff7505a3cf1d0c28521ef695431781822e1b2aeaf74e31f28c"

URI_aarch64_paps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/paps-0.8.0-10.el10.aarch64.rpm;name=aarch64_paps;unpack=0"
SRC_URI:append = " ${URI_aarch64_paps}"
SRC_URI[aarch64_paps.sha256sum] = "09d5835b38e7030866e8429f796d2ea4d3cbc03f64e24c3c25bab150b80a079a"

RDEPENDS:paps = " \
 cairo \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 pango \
 python3 \
 "
