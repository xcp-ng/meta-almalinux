# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-ethtool"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-below-ethtool+default-devel \
 rust-below-ethtool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-ethtool-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d4d09195701f69bbcf9ab2cabae0ca9ff88e3d33e929dcdb1bbcfe63252d2eb"

URI_x86_64_v2_rust-below-ethtool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-ethtool+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-ethtool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-ethtool+default-devel}"
SRC_URI[x86_64_v2_rust-below-ethtool+default-devel.sha256sum] = "77dc8e679dd2f78c4bfe8cfb135bb3c929c7722dfc64b2cc06bec533dc65587d"

URI_x86_64_v2_rust-below-ethtool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-ethtool-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-ethtool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-ethtool-devel}"
SRC_URI[x86_64_v2_rust-below-ethtool-devel.sha256sum] = "cc12ec60db1250f3aa54a162d01cfd179a4c54255ada65b4b9fcb1dc8dba0d55"

URI_aarch64_rust-below-ethtool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-ethtool+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-ethtool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-ethtool+default-devel}"
SRC_URI[aarch64_rust-below-ethtool+default-devel.sha256sum] = "1a32644d7c35417e13b21e2dd283c2103103d16ff0234fda0b455f74e4c5f29e"

URI_aarch64_rust-below-ethtool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-ethtool-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below-ethtool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-ethtool-devel}"
SRC_URI[aarch64_rust-below-ethtool-devel.sha256sum] = "db9b54bcf012c076d3595ade4cac7d3a5083bbc800063340209e836c4f637868"

RDEPENDS:rust-below-ethtool+default-devel = " \
 cargo \
 rust-below-ethtool-devel \
 "
RDEPENDS:rust-below-ethtool-devel = " \
 cargo \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+event-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+net-devel \
 rust-nix+poll-devel \
 rust-nix+ptrace-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-thiserror+default-devel \
 "
