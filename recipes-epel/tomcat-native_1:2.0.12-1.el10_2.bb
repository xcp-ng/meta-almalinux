# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat-native"
PE = "1"
PV = "2.0.12"
PR = "1.el10_2"
PACKAGES = " \
 tomcat-native \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tomcat-native-2.0.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ce9b5087bbb02615501d9daaffe025bc2d6efd4b50edc41a0c3dfcbfde7d605"

URI_x86_64_v2_tomcat-native = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tomcat-native-2.0.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tomcat-native;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat-native}"
SRC_URI[x86_64_v2_tomcat-native.sha256sum] = "d1eea77996858a56db5120b9b0ee73bb9f212d3a1a46fb48edde7af48dca807c"

URI_aarch64_tomcat-native = "${EPEL_MIRROR}/aarch64/Packages/t/tomcat-native-2.0.12-1.el10_2.aarch64.rpm;name=aarch64_tomcat-native;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat-native}"
SRC_URI[aarch64_tomcat-native.sha256sum] = "6fe15f9909c76b9ca0559f8862cf19443413f175dac39341126cb169cbd61abc"

RDEPENDS:tomcat-native = " \
 apr \
 glibc \
 openssl-libs \
 "
