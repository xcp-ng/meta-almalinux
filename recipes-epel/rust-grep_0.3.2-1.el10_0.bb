# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep"
PV = "0.3.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-grep+default-devel \
 rust-grep+grep-pcre2-devel \
 rust-grep+pcre2-devel \
 rust-grep-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-0.3.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef2d052c9f49de90febef57abf7db37d29e096537ea856fa9d352d506912f465"

URI_x86_64_v2_rust-grep+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep+default-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep+default-devel}"
SRC_URI[x86_64_v2_rust-grep+default-devel.sha256sum] = "afba5785e4f25513f76e6337702db30d2612e0c85e6c6c577af117abc4f33ee9"

URI_x86_64_v2_rust-grep+grep-pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep+grep-pcre2-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep+grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep+grep-pcre2-devel}"
SRC_URI[x86_64_v2_rust-grep+grep-pcre2-devel.sha256sum] = "83410543f772149b2c3c37accbdeedce1d0b9e9b4e9d6f9fac98d9f63c1a4ac0"

URI_x86_64_v2_rust-grep+pcre2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep+pcre2-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep+pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep+pcre2-devel}"
SRC_URI[x86_64_v2_rust-grep+pcre2-devel.sha256sum] = "a8d33dac1da3de6cd5476ac9be532a881404dd8be02f2fd681f76069c0a64ba0"

URI_x86_64_v2_rust-grep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-devel-0.3.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-devel}"
SRC_URI[x86_64_v2_rust-grep-devel.sha256sum] = "7ffe0eb01de671a10268c947a87c47055582253b765670b48eaa24202516a1c3"

URI_aarch64_rust-grep+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep+default-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-grep+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep+default-devel}"
SRC_URI[aarch64_rust-grep+default-devel.sha256sum] = "a68f927c0dc7eacd6695a91083e00837173634fbeb29c66d7fea1e73529e0339"

URI_aarch64_rust-grep+grep-pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep+grep-pcre2-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-grep+grep-pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep+grep-pcre2-devel}"
SRC_URI[aarch64_rust-grep+grep-pcre2-devel.sha256sum] = "19453a77a5a8f643803f4b843224b8385cc2450dd0b19da3c6d41b4f25dd189b"

URI_aarch64_rust-grep+pcre2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep+pcre2-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-grep+pcre2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep+pcre2-devel}"
SRC_URI[aarch64_rust-grep+pcre2-devel.sha256sum] = "1f0dab2f19825793aa8865e3337bbea151d14e539290362a507ead0b9b83bac0"

URI_aarch64_rust-grep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-devel-0.3.2-1.el10_0.noarch.rpm;name=aarch64_rust-grep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-devel}"
SRC_URI[aarch64_rust-grep-devel.sha256sum] = "81e552ff50c6d4a8bd5a413858d5d4cdad2bfa3a6cff02333f4fa2190af166a8"

RDEPENDS:rust-grep+default-devel = " \
 cargo \
 rust-grep-devel \
 "
RDEPENDS:rust-grep+grep-pcre2-devel = " \
 cargo \
 rust-grep-devel \
 rust-grep-pcre2+default-devel \
 "
RDEPENDS:rust-grep+pcre2-devel = " \
 cargo \
 rust-grep+grep-pcre2-devel \
 rust-grep-devel \
 "
RDEPENDS:rust-grep-devel = " \
 cargo \
 rust-grep-cli+default-devel \
 rust-grep-matcher+default-devel \
 rust-grep-printer+default-devel \
 rust-grep-regex+default-devel \
 rust-grep-searcher+default-devel \
 "
