# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-msal-extensions"
PV = "1.3.1"
PR = "4.el10_2"
PACKAGES = " \
 python3-msal-extensions \
 python3-msal-extensions+portalocker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-msal-extensions-1.3.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53674460cec5d404073dd659795c8392e9ef4cb29c84673ff75c35633d8c80fd"

URI_x86_64_v2_python3-msal-extensions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-msal-extensions-1.3.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-msal-extensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-msal-extensions}"
SRC_URI[x86_64_v2_python3-msal-extensions.sha256sum] = "b08c4bb90b543856cbf7c6cd9438c21aa0de1371d00b327cdd5718b2c7207b7d"

URI_x86_64_v2_python3-msal-extensions+portalocker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-msal-extensions+portalocker-1.3.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-msal-extensions+portalocker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-msal-extensions+portalocker}"
SRC_URI[x86_64_v2_python3-msal-extensions+portalocker.sha256sum] = "8cc3c335bb4a02a737f1282438c22b898ac45ed1dcd0aaca2462999749df4e47"

URI_aarch64_python3-msal-extensions = "${EPEL_MIRROR}/aarch64/Packages/p/python3-msal-extensions-1.3.1-4.el10_2.noarch.rpm;name=aarch64_python3-msal-extensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-msal-extensions}"
SRC_URI[aarch64_python3-msal-extensions.sha256sum] = "ea1f979597da17a60c8363bbe52404ba756d778433451ea481663557f8211b4b"

URI_aarch64_python3-msal-extensions+portalocker = "${EPEL_MIRROR}/aarch64/Packages/p/python3-msal-extensions+portalocker-1.3.1-4.el10_2.noarch.rpm;name=aarch64_python3-msal-extensions+portalocker;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-msal-extensions+portalocker}"
SRC_URI[aarch64_python3-msal-extensions+portalocker.sha256sum] = "15b6bf0ee9f03e7bf97151414c602f17f43061181d3032424dbda6c1b893b7c6"

RDEPENDS:python3-msal-extensions = " \
 python3 \
 python3-gobject-base \
 python3-msal \
 "
RDEPENDS:python3-msal-extensions+portalocker = " \
 python3 \
 python3-msal-extensions \
 python3-portalocker \
 "
