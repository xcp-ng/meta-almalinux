# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deadpool"
PV = "0.13.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-deadpool+default-devel \
 rust-deadpool+managed-devel \
 rust-deadpool+rt_smol_2-devel \
 rust-deadpool+rt_tokio_1-devel \
 rust-deadpool+serde-devel \
 rust-deadpool+unmanaged-devel \
 rust-deadpool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deadpool-0.13.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72e79d57202107b6a501be42f82e986ef784bcaa517a06043268d449d9fd75c2"

URI_x86_64_v2_rust-deadpool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+default-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+default-devel}"
SRC_URI[x86_64_v2_rust-deadpool+default-devel.sha256sum] = "8dfe1be86272037cd831a0903af7950e7742626bfe6621664377bcc7f6f15a7f"

URI_x86_64_v2_rust-deadpool+managed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+managed-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+managed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+managed-devel}"
SRC_URI[x86_64_v2_rust-deadpool+managed-devel.sha256sum] = "d87255a4e0f2c052c66f0163f382a96134e09a656966883e8108d4e53dca351f"

URI_x86_64_v2_rust-deadpool+rt_smol_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+rt_smol_2-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+rt_smol_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+rt_smol_2-devel}"
SRC_URI[x86_64_v2_rust-deadpool+rt_smol_2-devel.sha256sum] = "fcf1fe15e3ae7dbd58056ca574dab445ed43679c909c971d4c32ccad4b1a61a5"

URI_x86_64_v2_rust-deadpool+rt_tokio_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+rt_tokio_1-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+rt_tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+rt_tokio_1-devel}"
SRC_URI[x86_64_v2_rust-deadpool+rt_tokio_1-devel.sha256sum] = "7564fe600f685d43aff2b32837824de86f1d6affb5087b7e7c3f203cf2c3ae5e"

URI_x86_64_v2_rust-deadpool+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+serde-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+serde-devel}"
SRC_URI[x86_64_v2_rust-deadpool+serde-devel.sha256sum] = "9fe2c030dcd0abad6d064df9c1fad1f0e7941adf35c0130a1f5a73ef343fac10"

URI_x86_64_v2_rust-deadpool+unmanaged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool+unmanaged-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool+unmanaged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool+unmanaged-devel}"
SRC_URI[x86_64_v2_rust-deadpool+unmanaged-devel.sha256sum] = "5a86ea7c0d643201b0bef9147c4dd18d81f2fd496c976d6f4bb1dea7027f7e1f"

URI_x86_64_v2_rust-deadpool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deadpool-devel-0.13.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deadpool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deadpool-devel}"
SRC_URI[x86_64_v2_rust-deadpool-devel.sha256sum] = "27d7108feaec11d2c7ae3115c093f415c403fab1ad6eac456053d9fd09de3d7b"

URI_aarch64_rust-deadpool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+default-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+default-devel}"
SRC_URI[aarch64_rust-deadpool+default-devel.sha256sum] = "867e3f10953c4fc5bbd4fb58ae7c325f23e4b20d9931943577c05ea368fc9550"

URI_aarch64_rust-deadpool+managed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+managed-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool+managed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+managed-devel}"
SRC_URI[aarch64_rust-deadpool+managed-devel.sha256sum] = "425d5492c09bf4905aa9e3afa757c68df6ca73ed7b828d21912a0487df4c9295"

URI_aarch64_rust-deadpool+rt_smol_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+rt_smol_2-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool+rt_smol_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+rt_smol_2-devel}"
SRC_URI[aarch64_rust-deadpool+rt_smol_2-devel.sha256sum] = "871974c784a2f27354c9f94e3062c6bff1b0841de1f1089260e6a02104017347"

URI_aarch64_rust-deadpool+rt_tokio_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+rt_tokio_1-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool+rt_tokio_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+rt_tokio_1-devel}"
SRC_URI[aarch64_rust-deadpool+rt_tokio_1-devel.sha256sum] = "16451a14822a0ed03c62e2c235a487d7691825aae45e37b139d6fa49fad11ed2"

URI_aarch64_rust-deadpool+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+serde-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+serde-devel}"
SRC_URI[aarch64_rust-deadpool+serde-devel.sha256sum] = "0d20ba907f97da9dfe62af53acbd65315709196b536f715340f152dbda9cc6a4"

URI_aarch64_rust-deadpool+unmanaged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool+unmanaged-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool+unmanaged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool+unmanaged-devel}"
SRC_URI[aarch64_rust-deadpool+unmanaged-devel.sha256sum] = "5e6e89da3e70465e8afc6e6da9e19ee8287cc7f16d3822624e7c1d8a366aba6a"

URI_aarch64_rust-deadpool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deadpool-devel-0.13.0-2.el10_3.noarch.rpm;name=aarch64_rust-deadpool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deadpool-devel}"
SRC_URI[aarch64_rust-deadpool-devel.sha256sum] = "684c5d9ff9eade95c78a5e11a95a488a5ed7f9bdac01a49e5e25b72bfc540cc1"

RDEPENDS:rust-deadpool+default-devel = " \
 cargo \
 rust-deadpool+managed-devel \
 rust-deadpool+unmanaged-devel \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool+managed-devel = " \
 cargo \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool+rt_smol_2-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-deadpool-runtime+smol_2-devel \
 "
RDEPENDS:rust-deadpool+rt_tokio_1-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-deadpool-runtime+tokio_1-devel \
 "
RDEPENDS:rust-deadpool+serde-devel = " \
 cargo \
 rust-deadpool-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-deadpool+unmanaged-devel = " \
 cargo \
 rust-deadpool-devel \
 "
RDEPENDS:rust-deadpool-devel = " \
 cargo \
 rust \
 rust-deadpool-runtime+default-devel \
 rust-num_cpus+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
