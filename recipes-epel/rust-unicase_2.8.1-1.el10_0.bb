# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicase"
PV = "2.8.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-unicase+default-devel \
 rust-unicase+nightly-devel \
 rust-unicase-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicase-2.8.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17f18a961b397ec2276e7a67979f1769022dfa088cf45923e0fe0e04f758da15"

URI_x86_64_v2_rust-unicase+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicase+default-devel-2.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicase+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicase+default-devel}"
SRC_URI[x86_64_v2_rust-unicase+default-devel.sha256sum] = "a0a4a62b5d152238b6a7060aee099182b2acb0898bbdbe918a66c003d08abab0"

URI_x86_64_v2_rust-unicase+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicase+nightly-devel-2.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicase+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicase+nightly-devel}"
SRC_URI[x86_64_v2_rust-unicase+nightly-devel.sha256sum] = "7c099457709b85bc28be81f81490114712da49c70e215d3bf83666ac09938a23"

URI_x86_64_v2_rust-unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicase-devel-2.8.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicase-devel}"
SRC_URI[x86_64_v2_rust-unicase-devel.sha256sum] = "b5f33defbf0990c3f54f31bdab3645994813d5a47241f7953848476dbe2be2d8"

URI_aarch64_rust-unicase+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicase+default-devel-2.8.1-1.el10_0.noarch.rpm;name=aarch64_rust-unicase+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicase+default-devel}"
SRC_URI[aarch64_rust-unicase+default-devel.sha256sum] = "dc761956cb3208abc2a80e485c6137fc130ac650e5d6e669b9bc982140f83498"

URI_aarch64_rust-unicase+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicase+nightly-devel-2.8.1-1.el10_0.noarch.rpm;name=aarch64_rust-unicase+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicase+nightly-devel}"
SRC_URI[aarch64_rust-unicase+nightly-devel.sha256sum] = "33a55bccc44e75499723caa0fa25078f705cd6f3163546f5cb2ec4db198e9624"

URI_aarch64_rust-unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicase-devel-2.8.1-1.el10_0.noarch.rpm;name=aarch64_rust-unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicase-devel}"
SRC_URI[aarch64_rust-unicase-devel.sha256sum] = "2a671998181dd770478bdd6eacfba86875e9ff004e0467997edc30dcdccfc947"

RDEPENDS:rust-unicase+default-devel = " \
 cargo \
 rust-unicase-devel \
 "
RDEPENDS:rust-unicase+nightly-devel = " \
 cargo \
 rust-unicase-devel \
 "
RDEPENDS:rust-unicase-devel = " \
 cargo \
 "
