# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-html2text"
PV = "2025.4.15"
PR = "1.el10_1"
PACKAGES = " \
 python3-html2text \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-html2text-2025.4.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51d0880971ede78a1f3a2db32da5adc962464010c0d9b4b2152ef74031c00122"

URI_x86_64_v2_python3-html2text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-html2text-2025.4.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-html2text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-html2text}"
SRC_URI[x86_64_v2_python3-html2text.sha256sum] = "a5a18a2ef0b923a1985ebcaf97f3c0647e24de5d6b87ebf1f9cc88a4d6588a1c"

URI_aarch64_python3-html2text = "${EPEL_MIRROR}/aarch64/Packages/p/python3-html2text-2025.4.15-1.el10_1.noarch.rpm;name=aarch64_python3-html2text;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-html2text}"
SRC_URI[aarch64_python3-html2text.sha256sum] = "a57838e49911899729d72f7addf6b4bb57f306743f8d52dce30d31df4216bf05"

RDEPENDS:python3-html2text = " \
 python3 \
 "
