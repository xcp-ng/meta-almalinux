# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-path-dedot"
PV = "3.1.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-path-dedot+default-devel \
 rust-path-dedot+lazy_static-devel \
 rust-path-dedot+lazy_static_cache-devel \
 rust-path-dedot+once_cell_cache-devel \
 rust-path-dedot+unsafe_cache-devel \
 rust-path-dedot+use_unix_paths_on_wasm-devel \
 rust-path-dedot-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-path-dedot-3.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eeb1589cc1cef3321de0f06a4843d34cf584b377dbd335d2e643c441e12fd849"

URI_x86_64_v2_rust-path-dedot+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot+default-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-dedot+default-devel}"
SRC_URI[x86_64_v2_rust-path-dedot+default-devel.sha256sum] = "7f6281e9619f4707e162bf0cf596a5fa637943b5b5c06c3cf7a36d5465978af2"

URI_x86_64_v2_rust-path-dedot+lazy_static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot+lazy_static-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-dedot+lazy_static-devel}"
SRC_URI[x86_64_v2_rust-path-dedot+lazy_static-devel.sha256sum] = "153652870ee6882acfeb8d329fa6838d20f2cb78ab3d6a694b9fcf8e6b5793d4"

URI_x86_64_v2_rust-path-dedot+lazy_static_cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot+lazy_static_cache-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot+lazy_static_cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-dedot+lazy_static_cache-devel}"
SRC_URI[x86_64_v2_rust-path-dedot+lazy_static_cache-devel.sha256sum] = "24dd8f28aafb4de3a8b2394287f3737707463c9fada2d4a9785cae34880694ff"

URI_x86_64_v2_rust-path-dedot+once_cell_cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot+once_cell_cache-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot+once_cell_cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-dedot+once_cell_cache-devel}"
SRC_URI[x86_64_v2_rust-path-dedot+once_cell_cache-devel.sha256sum] = "7e8a4585a61b860fcb994a873ad2d0ff1a8209ed422d46b7a5a58b0d6557a1f7"

URI_x86_64_v2_rust-path-dedot+unsafe_cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot+unsafe_cache-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot+unsafe_cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-dedot+unsafe_cache-devel}"
SRC_URI[x86_64_v2_rust-path-dedot+unsafe_cache-devel.sha256sum] = "0472e07babefb14f6381978b1f5b1dec4019c84fdd17f08970d7d2f412ee20da"

URI_x86_64_v2_rust-path-dedot+use_unix_paths_on_wasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot+use_unix_paths_on_wasm-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot+use_unix_paths_on_wasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-dedot+use_unix_paths_on_wasm-devel}"
SRC_URI[x86_64_v2_rust-path-dedot+use_unix_paths_on_wasm-devel.sha256sum] = "384e9a2db139262487a941a5b4dd0ca145dab7c623a2cc47f2a57531fc7732e1"

URI_x86_64_v2_rust-path-dedot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-path-dedot-devel-3.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-path-dedot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-path-dedot-devel}"
SRC_URI[x86_64_v2_rust-path-dedot-devel.sha256sum] = "e8e372fd42c5493851d5126d19a0d793d5983b30c93ca72f1c49118b37f492a4"

URI_aarch64_rust-path-dedot+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot+default-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-dedot+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-dedot+default-devel}"
SRC_URI[aarch64_rust-path-dedot+default-devel.sha256sum] = "aca49f4b41b8d36bc37ae05b2762af4dcce984da2f345a7a7311d2c9ec0615fe"

URI_aarch64_rust-path-dedot+lazy_static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot+lazy_static-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-dedot+lazy_static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-dedot+lazy_static-devel}"
SRC_URI[aarch64_rust-path-dedot+lazy_static-devel.sha256sum] = "79f208e76d388d4e3773228f613297c4327b16b8e6a3e8bc0a9932ca2773d933"

URI_aarch64_rust-path-dedot+lazy_static_cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot+lazy_static_cache-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-dedot+lazy_static_cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-dedot+lazy_static_cache-devel}"
SRC_URI[aarch64_rust-path-dedot+lazy_static_cache-devel.sha256sum] = "da80fb4d84a964dc6b3bb231866a801bc3ddbe723dbe6741cde17f68754bc420"

URI_aarch64_rust-path-dedot+once_cell_cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot+once_cell_cache-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-dedot+once_cell_cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-dedot+once_cell_cache-devel}"
SRC_URI[aarch64_rust-path-dedot+once_cell_cache-devel.sha256sum] = "82310cc809ec0ff6fec64f44d21f4d280a5fa5b0c6e8bc1b39387871e88130a7"

URI_aarch64_rust-path-dedot+unsafe_cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot+unsafe_cache-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-dedot+unsafe_cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-dedot+unsafe_cache-devel}"
SRC_URI[aarch64_rust-path-dedot+unsafe_cache-devel.sha256sum] = "9f23152d4bdb674168b60cd86c26789d91c8d5c81feb87f16fdb9b78160fab95"

URI_aarch64_rust-path-dedot+use_unix_paths_on_wasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot+use_unix_paths_on_wasm-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-dedot+use_unix_paths_on_wasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-dedot+use_unix_paths_on_wasm-devel}"
SRC_URI[aarch64_rust-path-dedot+use_unix_paths_on_wasm-devel.sha256sum] = "5894945a130f3189ac65f1dd567f4fbd20be24fbfb3f307f9debf9fbb1baad32"

URI_aarch64_rust-path-dedot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-path-dedot-devel-3.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-path-dedot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-path-dedot-devel}"
SRC_URI[aarch64_rust-path-dedot-devel.sha256sum] = "e2f7fb5d3050a81814fc7cace12060d51e590420ad24b300f25adef1e16175ff"

RDEPENDS:rust-path-dedot+default-devel = " \
 cargo \
 rust-path-dedot-devel \
 "
RDEPENDS:rust-path-dedot+lazy_static-devel = " \
 cargo \
 rust-lazy_static+default-devel \
 rust-path-dedot-devel \
 "
RDEPENDS:rust-path-dedot+lazy_static_cache-devel = " \
 cargo \
 rust-path-dedot+lazy_static-devel \
 rust-path-dedot-devel \
 "
RDEPENDS:rust-path-dedot+once_cell_cache-devel = " \
 cargo \
 rust-path-dedot-devel \
 "
RDEPENDS:rust-path-dedot+unsafe_cache-devel = " \
 cargo \
 rust-path-dedot-devel \
 "
RDEPENDS:rust-path-dedot+use_unix_paths_on_wasm-devel = " \
 cargo \
 rust-path-dedot-devel \
 "
RDEPENDS:rust-path-dedot-devel = " \
 cargo \
 rust \
 rust-once_cell+default-devel \
 "
