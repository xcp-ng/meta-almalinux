# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mock-core-configs"
PV = "43.2"
PR = "1.el10_0"
PACKAGES = " \
 mock-core-configs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mock-core-configs-43.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d46c2797f3ac4edf09b6485dc1adfcca4a0f51725837ad93def522e73eff3884"

URI_x86_64_v2_mock-core-configs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mock-core-configs-43.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mock-core-configs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mock-core-configs}"
SRC_URI[x86_64_v2_mock-core-configs.sha256sum] = "2b26e6eaf93f40b09aba4b86e8647cf841dc04f7c042c3cb252203e66da23d5b"

URI_aarch64_mock-core-configs = "${EPEL_MIRROR}/aarch64/Packages/m/mock-core-configs-43.2-1.el10_0.noarch.rpm;name=aarch64_mock-core-configs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mock-core-configs}"
SRC_URI[aarch64_mock-core-configs.sha256sum] = "804d8119c4eab4c13d0ed437ffaf228f64b5d6ac9e2918421e76b29cabd34178"

RDEPENDS:mock-core-configs = " \
 almalinux-release \
 bash \
 distribution-gpg-keys \
 mock \
 mock-filesystem \
 python3 \
 python3-dnf \
 python3-hawkey \
 sed \
 virtual/coreutils \
 "
