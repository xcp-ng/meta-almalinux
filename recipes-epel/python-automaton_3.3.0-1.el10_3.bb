# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-automaton"
PV = "3.3.0"
PR = "1.el10_3"
PACKAGES = " \
 python-automaton-doc \
 python3-automaton \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-automaton-3.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a9143d82bfed29d3270ebeaf911d123ec70df41e6fc724ff2bd1b874dbd97b2"

URI_x86_64_v2_python-automaton-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-automaton-doc-3.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-automaton-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-automaton-doc}"
SRC_URI[x86_64_v2_python-automaton-doc.sha256sum] = "c949932d9f667f2237993697789dd4b2a32eefcd4b8982fbc2332687365fd0a2"

URI_x86_64_v2_python3-automaton = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-automaton-3.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-automaton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-automaton}"
SRC_URI[x86_64_v2_python3-automaton.sha256sum] = "b8fd836225d9ade6ef3e96e75e7bb78e7146ed555127a117b3eb9d20c3c10a48"

URI_aarch64_python-automaton-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-automaton-doc-3.3.0-1.el10_3.noarch.rpm;name=aarch64_python-automaton-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-automaton-doc}"
SRC_URI[aarch64_python-automaton-doc.sha256sum] = "87be1fa64e0b8a27463f634956712a444fc196fd93c3f0e6e6c231bcceb842cf"

URI_aarch64_python3-automaton = "${EPEL_MIRROR}/aarch64/Packages/p/python3-automaton-3.3.0-1.el10_3.noarch.rpm;name=aarch64_python3-automaton;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-automaton}"
SRC_URI[aarch64_python3-automaton.sha256sum] = "d2b89385526b755a5b0871fa4fef89796bfefc7ab75d0af5113636d14d8364e1"

RDEPENDS:python-automaton-doc = " \
 "
RDEPENDS:python3-automaton = " \
 python3 \
 python3-pbr \
 python3-prettytable \
 "
