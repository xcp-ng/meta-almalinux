# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pypandoc"
PV = "1.15"
PR = "3.el10_2"
PACKAGES = " \
 python3-pypandoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pypandoc-1.15-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b90a77fc139cf4863365869a4eed6ba81e687c619c5e94dbe36464f2b9b1d2a9"

URI_x86_64_v2_python3-pypandoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pypandoc-1.15-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pypandoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pypandoc}"
SRC_URI[x86_64_v2_python3-pypandoc.sha256sum] = "1500fe1cb508748db138b6c813f26195c40e934414a43c10a5ffcf8327a920ce"

URI_aarch64_python3-pypandoc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pypandoc-1.15-3.el10_2.noarch.rpm;name=aarch64_python3-pypandoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pypandoc}"
SRC_URI[aarch64_python3-pypandoc.sha256sum] = "31a686837776f99650b495039c358e58f102980f7a7d9db91fa80b536d47cd1e"

RDEPENDS:python3-pypandoc = " \
 pandoc \
 python3 \
 "
