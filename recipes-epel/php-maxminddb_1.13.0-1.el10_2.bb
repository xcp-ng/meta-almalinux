# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-maxminddb"
PV = "1.13.0"
PR = "1.el10_2"
PACKAGES = " \
 php-maxmind-db-reader \
 php-maxminddb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-maxminddb-1.13.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1777ea3170aab6a62a1b0dc82e83d6e565ecde230fc7be81641a693495bd2951"

URI_x86_64_v2_php-maxmind-db-reader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-maxmind-db-reader-1.13.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_php-maxmind-db-reader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-maxmind-db-reader}"
SRC_URI[x86_64_v2_php-maxmind-db-reader.sha256sum] = "5dae8e00ec1d21c6de65093f46396314e0d93f37c04fd800f9856f085b1b793b"

URI_x86_64_v2_php-maxminddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-maxminddb-1.13.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-maxminddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-maxminddb}"
SRC_URI[x86_64_v2_php-maxminddb.sha256sum] = "cf972fb1d5c616e098025c250b1c2443ddef0891149fb6a30bdecdbd029e2962"

URI_aarch64_php-maxmind-db-reader = "${EPEL_MIRROR}/aarch64/Packages/p/php-maxmind-db-reader-1.13.0-1.el10_2.noarch.rpm;name=aarch64_php-maxmind-db-reader;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-maxmind-db-reader}"
SRC_URI[aarch64_php-maxmind-db-reader.sha256sum] = "311694497241abc62354199f59889456ab910adcc83e7e1aefaf528826374ffa"

URI_aarch64_php-maxminddb = "${EPEL_MIRROR}/aarch64/Packages/p/php-maxminddb-1.13.0-1.el10_2.aarch64.rpm;name=aarch64_php-maxminddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-maxminddb}"
SRC_URI[aarch64_php-maxminddb.sha256sum] = "9588a46c189659febc22106a8800da065c33cbdad6119f836028f046eb0aa755"

RDEPENDS:php-maxmind-db-reader = " \
 php-fedora-autoloader \
 virtual/php-filter \
 virtual/php-spl \
 virtual/php_language__ge_7.2 \
 "
RDEPENDS:php-maxminddb = " \
 glibc \
 libmaxminddb \
 php-common \
 "
