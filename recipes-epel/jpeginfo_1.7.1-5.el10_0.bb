# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jpeginfo"
PV = "1.7.1"
PR = "5.el10_0"
PACKAGES = " \
 jpeginfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jpeginfo-1.7.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eeb457d53b44cc70f87fb337c0af498ec0bd9d02f02ff8106056014bb680ad53"

URI_x86_64_v2_jpeginfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jpeginfo-1.7.1-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jpeginfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jpeginfo}"
SRC_URI[x86_64_v2_jpeginfo.sha256sum] = "dbd7a02b6483a90225d379c0a8137dc78f6ff5839bd948cf2429f95fc881a86c"

URI_aarch64_jpeginfo = "${EPEL_MIRROR}/aarch64/Packages/j/jpeginfo-1.7.1-5.el10_0.aarch64.rpm;name=aarch64_jpeginfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_jpeginfo}"
SRC_URI[aarch64_jpeginfo.sha256sum] = "07be35f3488f9cec7d03704d0a2def320d09ed5a64ba022db9a4bc5c33d717d5"

RDEPENDS:jpeginfo = " \
 glibc \
 libjpeg-turbo \
 "
