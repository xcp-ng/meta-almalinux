# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-subscriber"
PV = "0.3.20"
PR = "1.el10_2"
PACKAGES = " \
 rust-tracing-subscriber+alloc-devel \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+chrono-devel \
 rust-tracing-subscriber+default-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+json-devel \
 rust-tracing-subscriber+local-time-devel \
 rust-tracing-subscriber+matchers-devel \
 rust-tracing-subscriber+nu-ansi-term-devel \
 rust-tracing-subscriber+once_cell-devel \
 rust-tracing-subscriber+parking_lot-devel \
 rust-tracing-subscriber+regex-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+serde-devel \
 rust-tracing-subscriber+serde_json-devel \
 rust-tracing-subscriber+sharded-slab-devel \
 rust-tracing-subscriber+smallvec-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+thread_local-devel \
 rust-tracing-subscriber+time-devel \
 rust-tracing-subscriber+tracing-devel \
 rust-tracing-subscriber+tracing-log-devel \
 rust-tracing-subscriber+tracing-serde-devel \
 rust-tracing-subscriber-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-subscriber-0.3.20-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e167174bdd013434b5a82382dc824b3f2f26966503705f3b0bd7be025e4a24e"

URI_x86_64_v2_rust-tracing-subscriber+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+alloc-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+alloc-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+alloc-devel.sha256sum] = "fc532c87eb23f1bc3015163230146ecf6a6e28c2e483c761c60788d4dbe74310"

URI_x86_64_v2_rust-tracing-subscriber+ansi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+ansi-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+ansi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+ansi-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+ansi-devel.sha256sum] = "fb043a7f3040fb11cbab0417a66f5ece9bd1f4ae7769867d37d26cbc06afce3d"

URI_x86_64_v2_rust-tracing-subscriber+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+chrono-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+chrono-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+chrono-devel.sha256sum] = "d375717f0cf8f5c6ddb3fc74027ea0fefb37552d53b0a5fa7b06ce1be44862a6"

URI_x86_64_v2_rust-tracing-subscriber+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+default-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+default-devel.sha256sum] = "dd57e5eb376940275c896aab67c4bd779ab84b7573e2d2c18c03b38f9d28fe5f"

URI_x86_64_v2_rust-tracing-subscriber+env-filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+env-filter-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+env-filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+env-filter-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+env-filter-devel.sha256sum] = "5837bc45098b4c2f970a9a1eef7e4e06bd607c74e8eceb6bf9eb882bfe0946cf"

URI_x86_64_v2_rust-tracing-subscriber+fmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+fmt-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+fmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+fmt-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+fmt-devel.sha256sum] = "eb9a792a6c262fab65b455588331652d60654df0fdeefd3eeb3ce7988fdb5d5d"

URI_x86_64_v2_rust-tracing-subscriber+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+json-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+json-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+json-devel.sha256sum] = "88edf5dda45522cf4931d3e162d3034bcb8f5d4b35f1fc8a6e2d736aa011f13d"

URI_x86_64_v2_rust-tracing-subscriber+local-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+local-time-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+local-time-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+local-time-devel.sha256sum] = "4676e2c598972b6c86e7e7aab0cab2caedf5fca1c4027f07941377ed7f048b2f"

URI_x86_64_v2_rust-tracing-subscriber+matchers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+matchers-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+matchers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+matchers-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+matchers-devel.sha256sum] = "0eda85e8ec4fb0c879a7fca29cdba5a9837cfea6074fbe50a0289afa2039649f"

URI_x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+nu-ansi-term-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+nu-ansi-term-devel.sha256sum] = "d85a86ea19848b50eced93550451d912c65be92aaf0459f2bdbe68181642b5a4"

URI_x86_64_v2_rust-tracing-subscriber+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+once_cell-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+once_cell-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+once_cell-devel.sha256sum] = "86a6b792a36ed502a712a10a3c3f104baf69467f2841bbc1231db611851dbb70"

URI_x86_64_v2_rust-tracing-subscriber+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+parking_lot-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+parking_lot-devel.sha256sum] = "65916af0ab8825910b997eace8dc8edb1797066f3aedeef00d522927988ab2a9"

URI_x86_64_v2_rust-tracing-subscriber+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+regex-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+regex-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+regex-devel.sha256sum] = "e8c1c5ce5374b788426f0e53977bbd3f7876a43142d05be93ead3d1408c7448e"

URI_x86_64_v2_rust-tracing-subscriber+registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+registry-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+registry-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+registry-devel.sha256sum] = "23a471618ac2e10154b3aac284157239653cd030d63a4995cc41b8948181124f"

URI_x86_64_v2_rust-tracing-subscriber+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+serde-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+serde-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+serde-devel.sha256sum] = "429b9ef3337b0876c9d2c95da21a6134177efd079eb2a252ac9d890a64a293bf"

URI_x86_64_v2_rust-tracing-subscriber+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+serde_json-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+serde_json-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+serde_json-devel.sha256sum] = "63ad96f3fe3994423a1e99d9c09b4a8d7b902e6039c27b37274ca756f20f6d7d"

URI_x86_64_v2_rust-tracing-subscriber+sharded-slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+sharded-slab-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+sharded-slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+sharded-slab-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+sharded-slab-devel.sha256sum] = "7e88bd15ef9a178ed85b82ba6a9e82790b52e5ba4386c17a9d71dd1af182c735"

URI_x86_64_v2_rust-tracing-subscriber+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+smallvec-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+smallvec-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+smallvec-devel.sha256sum] = "421f6537337f83be055ff63e8189d59a163b481739a335ee446297fe50ee562d"

URI_x86_64_v2_rust-tracing-subscriber+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+std-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+std-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+std-devel.sha256sum] = "304dc9e6414361cffe1dca0bdd18dae80acce8c4b5b3b38ed2419a296580f2a7"

URI_x86_64_v2_rust-tracing-subscriber+thread_local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+thread_local-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+thread_local-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+thread_local-devel.sha256sum] = "db7b0835b37f97c99150d105d2bf26040c68b44698c1e6b516f5ef3ece8baa86"

URI_x86_64_v2_rust-tracing-subscriber+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+time-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+time-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+time-devel.sha256sum] = "453b4f436c65f6f134da2a8fcae8d684af920abb6ad14b4bd11dba6ae0fc8bcb"

URI_x86_64_v2_rust-tracing-subscriber+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+tracing-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+tracing-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+tracing-devel.sha256sum] = "bc88070776019c00c277eab173129cb587fdb334654c9111217c0cb117bc9562"

URI_x86_64_v2_rust-tracing-subscriber+tracing-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+tracing-log-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+tracing-log-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+tracing-log-devel.sha256sum] = "db1f212c145f27ed3ef4139c18e275d70f38112be8e70234a6f399b6fba766f3"

URI_x86_64_v2_rust-tracing-subscriber+tracing-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber+tracing-serde-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber+tracing-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber+tracing-serde-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber+tracing-serde-devel.sha256sum] = "aaed1944a10957faebe6dfb4d0b9828c2471dbfe4ff1f069c95e8892d3c420c9"

URI_x86_64_v2_rust-tracing-subscriber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-subscriber-devel-0.3.20-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-subscriber-devel}"
SRC_URI[x86_64_v2_rust-tracing-subscriber-devel.sha256sum] = "f1ac966c4dc8392743b7e402b989907121221f19508394db5c942a8ad7434dd0"

URI_aarch64_rust-tracing-subscriber+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+alloc-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+alloc-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+alloc-devel.sha256sum] = "6fe396f45334d654d1a3263f826cc3ce455cd9ae432b64e5b9e1b00369ea1cb4"

URI_aarch64_rust-tracing-subscriber+ansi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+ansi-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+ansi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+ansi-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+ansi-devel.sha256sum] = "94dd730a5138ef4482191a04c51d7615bf3ad4cff55ad01d3c72c0482312a439"

URI_aarch64_rust-tracing-subscriber+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+chrono-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+chrono-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+chrono-devel.sha256sum] = "24fc4e1bbe5faaa2276c170c9c2c4cf4355a73562de4a3aa1a049a5b331148af"

URI_aarch64_rust-tracing-subscriber+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+default-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+default-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+default-devel.sha256sum] = "60b8a9ccb2662e5c7b07ed4ae6c92e986316185946eec641b9f0944b0b836a4a"

URI_aarch64_rust-tracing-subscriber+env-filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+env-filter-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+env-filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+env-filter-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+env-filter-devel.sha256sum] = "d18849d6deeb9bc30a7878d21da178ef790983c04f0599ce3af24808a92cd8cd"

URI_aarch64_rust-tracing-subscriber+fmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+fmt-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+fmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+fmt-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+fmt-devel.sha256sum] = "dcdbae51d54f12d5af211f401bb628439eb2c75d1c8864ecd8c411e5d574ee62"

URI_aarch64_rust-tracing-subscriber+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+json-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+json-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+json-devel.sha256sum] = "55628ce531be0c047a95d7f7e9ba20d18d364b97821dd7c5d943ecd7ac2f7522"

URI_aarch64_rust-tracing-subscriber+local-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+local-time-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+local-time-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+local-time-devel.sha256sum] = "e111b879fc73741b27422a8e2d724a4307759a3af8a8944eb68ae2745af0bfda"

URI_aarch64_rust-tracing-subscriber+matchers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+matchers-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+matchers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+matchers-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+matchers-devel.sha256sum] = "2ce8352de565b2e51bdcb3503b54077b143ebbf4bd396557cd293664fadeda6f"

URI_aarch64_rust-tracing-subscriber+nu-ansi-term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+nu-ansi-term-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+nu-ansi-term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+nu-ansi-term-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+nu-ansi-term-devel.sha256sum] = "cd370cbb5cd166ee4ff237b100f2d605d1bbbab7d36903e9dff3bd8f24cb5dbc"

URI_aarch64_rust-tracing-subscriber+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+once_cell-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+once_cell-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+once_cell-devel.sha256sum] = "dbc86b388648c8029e7f64bce2c9fa3d7a500de46be3a029566fbe86e26c4f7d"

URI_aarch64_rust-tracing-subscriber+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+parking_lot-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+parking_lot-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+parking_lot-devel.sha256sum] = "7896e54f0ebfaa4104bc43f411fbf76cd99721adc80b7d73fa51f91b6c55f7fe"

URI_aarch64_rust-tracing-subscriber+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+regex-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+regex-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+regex-devel.sha256sum] = "05c8aef7c68d7907b3b8a0eee40eab2399a77d354251a3eb35a2ca0cc88f7caa"

URI_aarch64_rust-tracing-subscriber+registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+registry-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+registry-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+registry-devel.sha256sum] = "2a9a8f4dee32caaeb22515fb346ac4454bfbdc1b57aa9def432d5e0549a2f977"

URI_aarch64_rust-tracing-subscriber+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+serde-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+serde-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+serde-devel.sha256sum] = "2651afde6038b8d8c34a4775c28ca43e73cf75c44177417a1a3b5c5c9e55d86f"

URI_aarch64_rust-tracing-subscriber+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+serde_json-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+serde_json-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+serde_json-devel.sha256sum] = "96df0492c9cd4c58c9565f40553ea6b3bc980a05282d2314f8d191017f777ffc"

URI_aarch64_rust-tracing-subscriber+sharded-slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+sharded-slab-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+sharded-slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+sharded-slab-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+sharded-slab-devel.sha256sum] = "2749184db823c0765d263e4e830bf146c7f0f32c8070a2040fa036f1911dbb7a"

URI_aarch64_rust-tracing-subscriber+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+smallvec-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+smallvec-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+smallvec-devel.sha256sum] = "d719deddc8585fe430f5cc2072aca960fa078dd6d22e9bf9a867b0a46edd13f5"

URI_aarch64_rust-tracing-subscriber+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+std-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+std-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+std-devel.sha256sum] = "6aa4c829ac549aaf2b6361498cc857994e9efbf94f41719f02058b9121765621"

URI_aarch64_rust-tracing-subscriber+thread_local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+thread_local-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+thread_local-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+thread_local-devel.sha256sum] = "d0ed43833af0ccc239174eb7fbb64d63402ef04a8e1ac8713f4f7384fec39b92"

URI_aarch64_rust-tracing-subscriber+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+time-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+time-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+time-devel.sha256sum] = "95733d688829d022974c68f9d93af0ff323432b8c57efde22c4a4a71917a32ff"

URI_aarch64_rust-tracing-subscriber+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+tracing-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+tracing-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+tracing-devel.sha256sum] = "2537fb87a470736b7eb85d8ec57b65ac5c6af2b35f2c69043a19a3f4b99a31f1"

URI_aarch64_rust-tracing-subscriber+tracing-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+tracing-log-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+tracing-log-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+tracing-log-devel.sha256sum] = "d6b6137c38aeca2998c1d39d09860177744d157af3db6885eea050fd85e6ce0e"

URI_aarch64_rust-tracing-subscriber+tracing-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber+tracing-serde-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber+tracing-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber+tracing-serde-devel}"
SRC_URI[aarch64_rust-tracing-subscriber+tracing-serde-devel.sha256sum] = "c66dc170f1f18eea1d46ec627da32bf47da745674d9e89a015bfae2273f3513d"

URI_aarch64_rust-tracing-subscriber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-subscriber-devel-0.3.20-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-subscriber-devel}"
SRC_URI[aarch64_rust-tracing-subscriber-devel.sha256sum] = "9533ef87d726e5bb4dfed9c4e56ed042180f039cf58daa02bf351120df790ffc"

RDEPENDS:rust-tracing-subscriber+alloc-devel = " \
 cargo \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+ansi-devel = " \
 cargo \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+nu-ansi-term-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+default-devel = " \
 cargo \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+smallvec-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+tracing-log-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+env-filter-devel = " \
 cargo \
 rust-regex-automata+std-devel \
 rust-regex-automata-devel \
 rust-tracing-subscriber+matchers-devel \
 rust-tracing-subscriber+once_cell-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+thread_local-devel \
 rust-tracing-subscriber+tracing-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+fmt-devel = " \
 cargo \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+json-devel = " \
 cargo \
 rust-tracing-subscriber+serde-devel \
 rust-tracing-subscriber+serde_json-devel \
 rust-tracing-subscriber+tracing-serde-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+local-time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+matchers-devel = " \
 cargo \
 rust-matchers+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+nu-ansi-term-devel = " \
 cargo \
 rust-nu-ansi-term+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+regex-devel = " \
 cargo \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+registry-devel = " \
 cargo \
 rust-tracing-subscriber+sharded-slab-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber+thread_local-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+sharded-slab-devel = " \
 cargo \
 rust-sharded-slab+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+smallvec-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+std-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-subscriber+alloc-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+thread_local-devel = " \
 cargo \
 rust-thread_local+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+tracing-log-devel = " \
 cargo \
 rust-tracing-log+log-tracer-devel \
 rust-tracing-log+std-devel \
 rust-tracing-log-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber+tracing-serde-devel = " \
 cargo \
 rust-tracing-serde+default-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-tracing-subscriber-devel = " \
 cargo \
 rust \
 rust-tracing-core-devel \
 "
