# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "neochat"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 neochat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/neochat-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8607b857b61f56da8495b739986eea27511882ffc231d90faf75ebd66664aa16"

URI_x86_64_v2_neochat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neochat-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neochat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_neochat}"
SRC_URI[x86_64_v2_neochat.sha256sum] = "8705827e1fdfaf240185395c5e687f66dbd85f20a8b0aea4b0ffb3f388c63102"

URI_aarch64_neochat = "${EPEL_MIRROR}/aarch64/Packages/n/neochat-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_neochat;unpack=0"
SRC_URI:append = " ${URI_aarch64_neochat}"
SRC_URI[aarch64_neochat.sha256sum] = "7294ddb1d906bbfee616ee34ebe115d8fd48417ee5d1072ffdb26e05cfb4280b"

RDEPENDS:neochat = " \
 breeze-icon-theme \
 cmark-lib \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kquickcharts \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kquickimageeditor-qt6 \
 kunifiedpush \
 libicu \
 libquotient-qt6 \
 libstdc++ \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtspeech \
 qt6-qtwebview \
 qtkeychain-qt6 \
 "
