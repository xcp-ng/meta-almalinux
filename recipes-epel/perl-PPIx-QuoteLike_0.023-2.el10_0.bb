# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PPIx-QuoteLike"
PV = "0.023"
PR = "2.el10_0"
PACKAGES = " \
 perl-PPIx-QuoteLike \
 perl-PPIx-QuoteLike-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-PPIx-QuoteLike-0.023-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb1089dc5fd2907b65f66e25d3d7e9d978ad6594ab6aafd63d5b88bd7addf57a"

URI_x86_64_v2_perl-PPIx-QuoteLike = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PPIx-QuoteLike-0.023-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PPIx-QuoteLike;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PPIx-QuoteLike}"
SRC_URI[x86_64_v2_perl-PPIx-QuoteLike.sha256sum] = "6da2fc0609a062bcb189772dfd6590ebab6b977053db8af2f52dc428ed8de31d"

URI_x86_64_v2_perl-PPIx-QuoteLike-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PPIx-QuoteLike-tests-0.023-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-PPIx-QuoteLike-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PPIx-QuoteLike-tests}"
SRC_URI[x86_64_v2_perl-PPIx-QuoteLike-tests.sha256sum] = "6eeca1cb0459ecfaf257734ab571b05064a115285d6ba6d71a6f4fd63331b4cc"

URI_aarch64_perl-PPIx-QuoteLike = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PPIx-QuoteLike-0.023-2.el10_0.noarch.rpm;name=aarch64_perl-PPIx-QuoteLike;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PPIx-QuoteLike}"
SRC_URI[aarch64_perl-PPIx-QuoteLike.sha256sum] = "33bc588a3898b48fa5eb698ca1780fc0fc2c9f6bc4aee90069615f1729304025"

URI_aarch64_perl-PPIx-QuoteLike-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-PPIx-QuoteLike-tests-0.023-2.el10_0.noarch.rpm;name=aarch64_perl-PPIx-QuoteLike-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PPIx-QuoteLike-tests}"
SRC_URI[aarch64_perl-PPIx-QuoteLike-tests.sha256sum] = "465368996ca317d215f7a55075f6175446a6eac5f26b0198e9d3f1c1395fe58a"

RDEPENDS:perl-PPIx-QuoteLike = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-PPI \
 perl-PPIx-QuoteLike \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-base \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-PPIx-QuoteLike-tests = " \
 bash \
 perl-PPI \
 perl-PPIx-QuoteLike \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-open \
 "
