# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nextcloud"
PV = "34.0.2"
PR = "1.el10_2"
PACKAGES = " \
 nextcloud \
 nextcloud-httpd \
 nextcloud-mysql \
 nextcloud-nginx \
 nextcloud-postgresql \
 nextcloud-sqlite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nextcloud-34.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3be79a4bfb68b7d3d2e04c4c1bb286010be9bfa1d4bd5a5403f8524b0476a706"

URI_x86_64_v2_nextcloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-34.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud}"
SRC_URI[x86_64_v2_nextcloud.sha256sum] = "90c246b4b9b63a6b9c10613dbb42f80bdfeda0a13200fbd255fee95954bb90c7"

URI_x86_64_v2_nextcloud-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-httpd-34.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-httpd}"
SRC_URI[x86_64_v2_nextcloud-httpd.sha256sum] = "59cfa0ef939acc59418e5a6d2765aea8786fe1dff97f8cb27a24e4dd71f6b26c"
RPROVIDES:nextcloud-httpd:x86_64_v2 = "virtual/nextcloud-webserver_eq_34.0.2-1.el10_2.alma_altarch"

URI_x86_64_v2_nextcloud-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-mysql-34.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-mysql}"
SRC_URI[x86_64_v2_nextcloud-mysql.sha256sum] = "92c332bc14c631998c8bd583e969ef31affd61964a5b7521f4b04d3a650ecdac"
RPROVIDES:nextcloud-mysql:x86_64_v2 = "virtual/nextcloud-database_eq_34.0.2-1.el10_2.alma_altarch"

URI_x86_64_v2_nextcloud-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-nginx-34.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-nginx}"
SRC_URI[x86_64_v2_nextcloud-nginx.sha256sum] = "0c5f8b6a2281bcf856ed4d2796c9deeefd0eaccd2acb6ba4f94d9c5fd2f74eb2"
RPROVIDES:nextcloud-nginx:x86_64_v2 = "virtual/nextcloud-webserver_eq_34.0.2-1.el10_2.alma_altarch"

URI_x86_64_v2_nextcloud-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-postgresql-34.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-postgresql}"
SRC_URI[x86_64_v2_nextcloud-postgresql.sha256sum] = "654f7444830ea883413fb6ee3242831d2a8512ca01947fa8b31b01438e4d0c86"
RPROVIDES:nextcloud-postgresql:x86_64_v2 = "virtual/nextcloud-database_eq_34.0.2-1.el10_2.alma_altarch"

URI_x86_64_v2_nextcloud-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-sqlite-34.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nextcloud-sqlite}"
SRC_URI[x86_64_v2_nextcloud-sqlite.sha256sum] = "676b6500b8348b305bd33e41af992d4a027ae418cc3efb817c2954fa0b623598"
RPROVIDES:nextcloud-sqlite:x86_64_v2 = "virtual/nextcloud-database_eq_34.0.2-1.el10_2.alma_altarch"

URI_aarch64_nextcloud = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-34.0.2-1.el10_2.noarch.rpm;name=aarch64_nextcloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud}"
SRC_URI[aarch64_nextcloud.sha256sum] = "c8f0ef471c8faa79da2976968d133333fd767c9b00d6ceb1c89ae9da0f8876d0"

URI_aarch64_nextcloud-httpd = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-httpd-34.0.2-1.el10_2.noarch.rpm;name=aarch64_nextcloud-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-httpd}"
SRC_URI[aarch64_nextcloud-httpd.sha256sum] = "928c36849534e10af45cefcdcec4c58cfac3456219279d94f2fd25f4cd380e12"
RPROVIDES:nextcloud-httpd:aarch64 = "virtual/nextcloud-webserver_eq_34.0.2-1.el10_2"

URI_aarch64_nextcloud-mysql = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-mysql-34.0.2-1.el10_2.noarch.rpm;name=aarch64_nextcloud-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-mysql}"
SRC_URI[aarch64_nextcloud-mysql.sha256sum] = "baf04ff89303ce888726b1ca260b1bc8e7010ca38b92a00ae2640fa8838af95c"
RPROVIDES:nextcloud-mysql:aarch64 = "virtual/nextcloud-database_eq_34.0.2-1.el10_2"

URI_aarch64_nextcloud-nginx = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-nginx-34.0.2-1.el10_2.noarch.rpm;name=aarch64_nextcloud-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-nginx}"
SRC_URI[aarch64_nextcloud-nginx.sha256sum] = "13b07f5311e750e0ab8e0153b9b13aa8466516ed63c0da967f4f7b439d87c953"
RPROVIDES:nextcloud-nginx:aarch64 = "virtual/nextcloud-webserver_eq_34.0.2-1.el10_2"

URI_aarch64_nextcloud-postgresql = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-postgresql-34.0.2-1.el10_2.noarch.rpm;name=aarch64_nextcloud-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-postgresql}"
SRC_URI[aarch64_nextcloud-postgresql.sha256sum] = "69ba8a0e9dbaf643e8bab2d8d881bfb1f83f6912cc6cd8781e313999a9082184"
RPROVIDES:nextcloud-postgresql:aarch64 = "virtual/nextcloud-database_eq_34.0.2-1.el10_2"

URI_aarch64_nextcloud-sqlite = "${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-sqlite-34.0.2-1.el10_2.noarch.rpm;name=aarch64_nextcloud-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_nextcloud-sqlite}"
SRC_URI[aarch64_nextcloud-sqlite.sha256sum] = "4e68b38f8a27c0a285ab820863dd3e1c9f3c4631d5700ab36ba8fa4bb1119e01"
RPROVIDES:nextcloud-sqlite:aarch64 = "virtual/nextcloud-database_eq_34.0.2-1.el10_2"

RDEPENDS:nextcloud:x86_64_v2 = " \
 bash \
 ca-certificates \
 php-pecl-imagick \
 php-pecl-memcached \
 php-smbclient \
 systemd \
 virtual//usr/bin/php \
 virtual/nextcloud-database_eq_34.0.2-1.el10_2.alma_altarch \
 virtual/nextcloud-webserver_eq_34.0.2-1.el10_2.alma_altarch \
 virtual/php-bcmath \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gmp \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-opcache \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-pecl-apcu \
 virtual/php-pecl-redis6_or_php-pecl-redis5 \
 virtual/php-process \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-spl \
 virtual/php-xmlwriter \
 virtual/php-zip \
"
RDEPENDS:nextcloud:aarch64 = " \
 bash \
 ca-certificates \
 php-pecl-imagick \
 php-pecl-memcached \
 php-smbclient \
 systemd \
 virtual//usr/bin/php \
 virtual/nextcloud-database_eq_34.0.2-1.el10_2 \
 virtual/nextcloud-webserver_eq_34.0.2-1.el10_2 \
 virtual/php-bcmath \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gmp \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-opcache \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-pecl-apcu \
 virtual/php-pecl-redis6_or_php-pecl-redis5 \
 virtual/php-process \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-spl \
 virtual/php-xmlwriter \
 virtual/php-zip \
"
RDEPENDS:nextcloud-httpd = " \
 bash \
 httpd \
 nextcloud \
 virtual/php-fpm \
 "
RDEPENDS:nextcloud-mysql = " \
 nextcloud \
 virtual/php-mysqlnd \
 "
RDEPENDS:nextcloud-nginx = " \
 bash \
 nextcloud \
 nginx \
 virtual/php-fpm \
 "
RDEPENDS:nextcloud-postgresql = " \
 nextcloud \
 virtual/php-pgsql \
 "
RDEPENDS:nextcloud-sqlite = " \
 nextcloud \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/nextcloud-database_eq_34.0.2-1.el10_2.alma_altarch rpm/virtual/nextcloud-webserver_eq_34.0.2-1.el10_2.alma_altarch"

PROVIDES:append:aarch64 = " rpm/virtual/nextcloud-database_eq_34.0.2-1.el10_2 rpm/virtual/nextcloud-webserver_eq_34.0.2-1.el10_2"
