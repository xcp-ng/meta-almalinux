# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyfakefs"
PV = "5.7.4"
PR = "1.el10_1"
PACKAGES = " \
 python3-pyfakefs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyfakefs-5.7.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b096d12cd13bfef7926031a3002943063e91a99cf68188130f446394a4bd9365"

URI_x86_64_v2_python3-pyfakefs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyfakefs-5.7.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyfakefs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyfakefs}"
SRC_URI[x86_64_v2_python3-pyfakefs.sha256sum] = "c301c62d6a46deba7e074dd19ff337ed7881f66fb59ee6fee9f3694ed54fd859"

URI_aarch64_python3-pyfakefs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyfakefs-5.7.4-1.el10_1.noarch.rpm;name=aarch64_python3-pyfakefs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyfakefs}"
SRC_URI[aarch64_python3-pyfakefs.sha256sum] = "ac7bd3667030fa6a9c6ea097b90324ab9cf69942d57c971de742a897b2a41fc8"

RDEPENDS:python3-pyfakefs = " \
 python3 \
 python3-pytest \
 "
