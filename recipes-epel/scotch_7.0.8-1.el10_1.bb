# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scotch"
PV = "7.0.8"
PR = "1.el10_1"
PACKAGES = " \
 ptscotch-mpich \
 ptscotch-mpich-devel \
 ptscotch-mpich-devel-parmetis \
 ptscotch-openmpi \
 ptscotch-openmpi-devel \
 ptscotch-openmpi-devel-parmetis \
 scotch \
 scotch-devel \
 scotch-devel-metis \
 scotch-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scotch-7.0.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeb0a88facf861fb83803c4162f36751f294df0ba62d27243abf58f479b70c66"

URI_x86_64_v2_ptscotch-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-mpich-7.0.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-mpich}"
SRC_URI[x86_64_v2_ptscotch-mpich.sha256sum] = "5c7d150ffa4b038dc790f3cb6be024dac064279a6b0744e8eff9d57c76c4ca50"

URI_x86_64_v2_ptscotch-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-mpich-devel-7.0.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-mpich-devel}"
SRC_URI[x86_64_v2_ptscotch-mpich-devel.sha256sum] = "0e7963ed0fc2bd322585737b8152c6df53249f3fd94233d7a71d605496c54b89"

URI_x86_64_v2_ptscotch-mpich-devel-parmetis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-mpich-devel-parmetis-7.0.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-mpich-devel-parmetis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-mpich-devel-parmetis}"
SRC_URI[x86_64_v2_ptscotch-mpich-devel-parmetis.sha256sum] = "d41e742595ac761bf7b835ddc4b29088eda9318e1e6910d6657f44770a28a791"

URI_x86_64_v2_ptscotch-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-openmpi-7.0.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-openmpi}"
SRC_URI[x86_64_v2_ptscotch-openmpi.sha256sum] = "7f3432ddbaad1209f17107d1cf6486304ba7bc424f4d3dac5b1d4dd394c2dc01"

URI_x86_64_v2_ptscotch-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-openmpi-devel-7.0.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-openmpi-devel}"
SRC_URI[x86_64_v2_ptscotch-openmpi-devel.sha256sum] = "f0779b16854d63b7964cb71588a4187b371da0c2a93c48702c07100fff90b962"

URI_x86_64_v2_ptscotch-openmpi-devel-parmetis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ptscotch-openmpi-devel-parmetis-7.0.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ptscotch-openmpi-devel-parmetis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptscotch-openmpi-devel-parmetis}"
SRC_URI[x86_64_v2_ptscotch-openmpi-devel-parmetis.sha256sum] = "a38856b237e4995ef51a4abd7d55d9f38e93bf8374a8ce9df99121af6c015070"

URI_x86_64_v2_scotch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scotch-7.0.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scotch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scotch}"
SRC_URI[x86_64_v2_scotch.sha256sum] = "ab98be7d93ec29e2c46f9ea3261c0eecf57c48e11b36a72a4716a2de7967e2c9"

URI_x86_64_v2_scotch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scotch-devel-7.0.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scotch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scotch-devel}"
SRC_URI[x86_64_v2_scotch-devel.sha256sum] = "7cdeef0addd3a4296606f7f20af17daf4f8e9b73d39ffc09d4b4ce377373c8fe"

URI_x86_64_v2_scotch-devel-metis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scotch-devel-metis-7.0.8-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scotch-devel-metis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scotch-devel-metis}"
SRC_URI[x86_64_v2_scotch-devel-metis.sha256sum] = "8d849b2633677f911aff01a6a10453b4095027606cdbb15aaa04105d50189a37"

URI_x86_64_v2_scotch-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scotch-doc-7.0.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_scotch-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scotch-doc}"
SRC_URI[x86_64_v2_scotch-doc.sha256sum] = "1330b1824710772da301ce3f3840e419eb087db275da2822560ec03b076c0edf"

URI_aarch64_ptscotch-mpich = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-mpich-7.0.8-1.el10_1.aarch64.rpm;name=aarch64_ptscotch-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-mpich}"
SRC_URI[aarch64_ptscotch-mpich.sha256sum] = "02db684fdd57c5c3ae6791f6deb1709ba8ad91ed58d38b6831d3f18be9c80d3a"

URI_aarch64_ptscotch-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-mpich-devel-7.0.8-1.el10_1.aarch64.rpm;name=aarch64_ptscotch-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-mpich-devel}"
SRC_URI[aarch64_ptscotch-mpich-devel.sha256sum] = "3181db0c0026e4393f045f36e211fb97730430e1cdaef547c90ebb0375dcd325"

URI_aarch64_ptscotch-mpich-devel-parmetis = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-mpich-devel-parmetis-7.0.8-1.el10_1.aarch64.rpm;name=aarch64_ptscotch-mpich-devel-parmetis;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-mpich-devel-parmetis}"
SRC_URI[aarch64_ptscotch-mpich-devel-parmetis.sha256sum] = "0ab3ecf3ddfe46af6cc5defa5b2e6b7a6ac4ca6a1fbb497cfdfd2e2d1d4eecc7"

URI_aarch64_ptscotch-openmpi = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-openmpi-7.0.8-1.el10_1.aarch64.rpm;name=aarch64_ptscotch-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-openmpi}"
SRC_URI[aarch64_ptscotch-openmpi.sha256sum] = "0aa72eb61ecffd3ec5e90d63856dcb4e3a27e7526d32aefc2f43a7dc248602b3"

URI_aarch64_ptscotch-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-openmpi-devel-7.0.8-1.el10_1.aarch64.rpm;name=aarch64_ptscotch-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-openmpi-devel}"
SRC_URI[aarch64_ptscotch-openmpi-devel.sha256sum] = "892107a1877fa306283fbb59c8a046d3edc3e1c6f89664b591df54b9a5d080a9"

URI_aarch64_ptscotch-openmpi-devel-parmetis = "${EPEL_MIRROR}/aarch64/Packages/p/ptscotch-openmpi-devel-parmetis-7.0.8-1.el10_1.aarch64.rpm;name=aarch64_ptscotch-openmpi-devel-parmetis;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptscotch-openmpi-devel-parmetis}"
SRC_URI[aarch64_ptscotch-openmpi-devel-parmetis.sha256sum] = "1af360ebd3eeab1f3ac5a3ebd223aab631dc48a5f9bd0947a6bb9baebb66485c"

URI_aarch64_scotch = "${EPEL_MIRROR}/aarch64/Packages/s/scotch-7.0.8-1.el10_1.aarch64.rpm;name=aarch64_scotch;unpack=0"
SRC_URI:append = " ${URI_aarch64_scotch}"
SRC_URI[aarch64_scotch.sha256sum] = "31175156d32ac74685baa380db3b9e3375fd7e739ace6264456a8385144fc8bd"

URI_aarch64_scotch-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scotch-devel-7.0.8-1.el10_1.aarch64.rpm;name=aarch64_scotch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scotch-devel}"
SRC_URI[aarch64_scotch-devel.sha256sum] = "9c43a6482dcfa187700661111ce254160a20129bb01117ca6b9b2c23e3bba192"

URI_aarch64_scotch-devel-metis = "${EPEL_MIRROR}/aarch64/Packages/s/scotch-devel-metis-7.0.8-1.el10_1.aarch64.rpm;name=aarch64_scotch-devel-metis;unpack=0"
SRC_URI:append = " ${URI_aarch64_scotch-devel-metis}"
SRC_URI[aarch64_scotch-devel-metis.sha256sum] = "0477bb37cea43d8ae73351224c788a0cd1e095b7d7f82d7d208ba6b5c25e9ad1"

URI_aarch64_scotch-doc = "${EPEL_MIRROR}/aarch64/Packages/s/scotch-doc-7.0.8-1.el10_1.noarch.rpm;name=aarch64_scotch-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scotch-doc}"
SRC_URI[aarch64_scotch-doc.sha256sum] = "5b0171cc23aa5f9b5d27eacc96b0ef779cbd50cf59c1084010fbb0ded48d17f2"

RDEPENDS:ptscotch-mpich = " \
 bzip2-libs \
 glibc \
 mpich \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:ptscotch-mpich-devel = " \
 ptscotch-mpich \
 "
RDEPENDS:ptscotch-mpich-devel-parmetis = " \
 ptscotch-mpich-devel \
 "
RDEPENDS:ptscotch-openmpi = " \
 bzip2-libs \
 glibc \
 openmpi \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:ptscotch-openmpi-devel = " \
 ptscotch-openmpi \
 "
RDEPENDS:ptscotch-openmpi-devel-parmetis = " \
 ptscotch-openmpi-devel \
 "
RDEPENDS:scotch = " \
 bzip2-libs \
 glibc \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:scotch-devel = " \
 cmake-filesystem \
 scotch \
 "
RDEPENDS:scotch-devel-metis = " \
 scotch-devel \
 "
RDEPENDS:scotch-doc = " \
 "
