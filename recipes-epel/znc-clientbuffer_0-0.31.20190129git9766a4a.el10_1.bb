# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "znc-clientbuffer"
PV = "0"
PR = "0.31.20190129git9766a4a.el10_1"
PACKAGES = " \
 znc-clientbuffer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/znc-clientbuffer-0-0.31.20190129git9766a4a.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63184b2fb64f63b7de4ab4ca1bcd7a016bb8c126a738786ce8d4b06ece7be4a7"

URI_aarch64_znc-clientbuffer = "${EPEL_MIRROR}/aarch64/Packages/z/znc-clientbuffer-0-0.31.20190129git9766a4a.el10_1.aarch64.rpm;name=aarch64_znc-clientbuffer;unpack=0"
SRC_URI:append = " ${URI_aarch64_znc-clientbuffer}"
SRC_URI[aarch64_znc-clientbuffer.sha256sum] = "d385de7229d4540bd044b8e7413df218389c10b301fbcd4986e8783f8d5b44d8"

RDEPENDS:znc-clientbuffer = " \
 glibc \
 libgcc \
 libstdc++ \
 znc \
 "
