# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-conv"
PV = "0.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-num-conv+default-devel \
 rust-num-conv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-conv-0.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "574da855399fb9f9f61eb87ac3eaacb0768f6ae8865680a58d24190b170d7997"

URI_x86_64_v2_rust-num-conv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-conv+default-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-conv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-conv+default-devel}"
SRC_URI[x86_64_v2_rust-num-conv+default-devel.sha256sum] = "cfed233ff58b8df44d589fb05387444837bf6d0d362de9d0bb6303a4ef22dbf9"

URI_x86_64_v2_rust-num-conv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-conv-devel-0.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-conv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-conv-devel}"
SRC_URI[x86_64_v2_rust-num-conv-devel.sha256sum] = "b2ab3f5ea5d515a19479ce15b16dec10d5c15a137e5637f8f30ede006278f284"

URI_aarch64_rust-num-conv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-conv+default-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-num-conv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-conv+default-devel}"
SRC_URI[aarch64_rust-num-conv+default-devel.sha256sum] = "2c26e3562b9e513b754815657f603a1dfe3b824634e30ecd2ddd3daa641601f0"

URI_aarch64_rust-num-conv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-conv-devel-0.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-num-conv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-conv-devel}"
SRC_URI[aarch64_rust-num-conv-devel.sha256sum] = "e02147ad037d4d29ec0d9698b99b99d50256f4c9a4a99908f95a4503388aabd5"

RDEPENDS:rust-num-conv+default-devel = " \
 cargo \
 rust-num-conv-devel \
 "
RDEPENDS:rust-num-conv-devel = " \
 cargo \
 rust \
 "
