# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lilv"
PV = "0.26.4"
PR = "1.el10_3"
PACKAGES = " \
 lilv \
 lilv-devel \
 lilv-libs \
 python3-lilv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lilv-0.26.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d99309a65df10e3a92c8f6a1b4e76e5ed15ff00640b694ac41d57e53a0fd27d"

URI_x86_64_v2_lilv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lilv-0.26.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lilv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lilv}"
SRC_URI[x86_64_v2_lilv.sha256sum] = "eac502dbb567a667878e7c668482371c9669459d0e350eea7d7663585d14ccb6"

URI_x86_64_v2_lilv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lilv-devel-0.26.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lilv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lilv-devel}"
SRC_URI[x86_64_v2_lilv-devel.sha256sum] = "f0da74c7ab4229ce066dd77030b8b472be78dad16bdee3781d213b4b123a5ef1"

URI_x86_64_v2_lilv-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lilv-libs-0.26.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lilv-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lilv-libs}"
SRC_URI[x86_64_v2_lilv-libs.sha256sum] = "974e30a9ae0e8e19c451c67fa46cb356322225fbd6ea7e3956ce712262f08cf5"

URI_x86_64_v2_python3-lilv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lilv-0.26.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lilv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lilv}"
SRC_URI[x86_64_v2_python3-lilv.sha256sum] = "f6c55bbf87568a2eef0c8397026755b8659c4103f280c4adfe6130827b63b69e"

URI_aarch64_lilv = "${EPEL_MIRROR}/aarch64/Packages/l/lilv-0.26.4-1.el10_3.aarch64.rpm;name=aarch64_lilv;unpack=0"
SRC_URI:append = " ${URI_aarch64_lilv}"
SRC_URI[aarch64_lilv.sha256sum] = "b0aee1636d33d97dc1c8cbcb1aa4cd8001f7790a7f86dea2063c5deb6968d2b9"

URI_aarch64_lilv-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lilv-devel-0.26.4-1.el10_3.aarch64.rpm;name=aarch64_lilv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lilv-devel}"
SRC_URI[aarch64_lilv-devel.sha256sum] = "4569ab1ca4390763ec7162f3ef1716016f4680c1e8babd8e20d4d3b09e3deaae"

URI_aarch64_lilv-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lilv-libs-0.26.4-1.el10_3.aarch64.rpm;name=aarch64_lilv-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lilv-libs}"
SRC_URI[aarch64_lilv-libs.sha256sum] = "9a70cd6acc8ba189dc43fc39cd8486b1802460ec96d9c394f7411678c2c0cd5d"

URI_aarch64_python3-lilv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lilv-0.26.4-1.el10_3.aarch64.rpm;name=aarch64_python3-lilv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lilv}"
SRC_URI[aarch64_python3-lilv.sha256sum] = "69c5ef6a269fcc2e4bed21aa37f77215880c38999dd77c97045385b11bc7a660"

RDEPENDS:lilv = " \
 glibc \
 libsndfile \
 lilv-libs \
 lv2 \
 "
RDEPENDS:lilv-devel = " \
 lilv-libs \
 lv2-devel \
 pkgconf-pkg-config \
 serd-devel \
 sord-devel \
 sratom-devel \
 zix-devel \
 "
RDEPENDS:lilv-libs = " \
 glibc \
 serd \
 sord \
 sratom \
 zix \
 "
RDEPENDS:python3-lilv = " \
 lilv-libs \
 python3 \
 "
