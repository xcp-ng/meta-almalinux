# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossterm0.25"
PV = "0.25.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-crossterm0.25+bracketed-paste-devel \
 rust-crossterm0.25+default-devel \
 rust-crossterm0.25+event-stream-devel \
 rust-crossterm0.25+futures-core-devel \
 rust-crossterm0.25+serde-devel \
 rust-crossterm0.25-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossterm0.25-0.25.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d8fec40430f2a9d718088600626073902acb87d9d69bab49fdbdc30128cd0d0"

URI_x86_64_v2_rust-crossterm0.25+bracketed-paste-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+bracketed-paste-devel-0.25.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+bracketed-paste-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+bracketed-paste-devel.sha256sum] = "7cd9d4ac8ec5511f79284db8002fc6b1b393397463289f241f9c239474734c39"

URI_x86_64_v2_rust-crossterm0.25+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+default-devel-0.25.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+default-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+default-devel.sha256sum] = "9431b591b305a43ee81484943cf9033c2f9d745b1bf055956d5a047b33462e97"

URI_x86_64_v2_rust-crossterm0.25+event-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+event-stream-devel-0.25.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+event-stream-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+event-stream-devel.sha256sum] = "6115a49d8c1a7a9c7516720bffabb07f24a9c56ac9af4e30c55acc175ef617da"

URI_x86_64_v2_rust-crossterm0.25+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+futures-core-devel-0.25.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+futures-core-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+futures-core-devel.sha256sum] = "8af605e15382582ef768a2f76368fbc3bb530e817447eb12082e29009e8d4dab"

URI_x86_64_v2_rust-crossterm0.25+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25+serde-devel-0.25.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25+serde-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25+serde-devel.sha256sum] = "6f18d1df9b74fad265f949c56264db1e813eb99364b786f93e013622768c09a4"

URI_x86_64_v2_rust-crossterm0.25-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossterm0.25-devel-0.25.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossterm0.25-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossterm0.25-devel}"
SRC_URI[x86_64_v2_rust-crossterm0.25-devel.sha256sum] = "a2807004b9f4cacf3d3e4485939f0c75ada3c4f3ff80b6f6cc1574844b476646"

URI_aarch64_rust-crossterm0.25+bracketed-paste-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+bracketed-paste-devel-0.25.0-5.el10_0.noarch.rpm;name=aarch64_rust-crossterm0.25+bracketed-paste-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+bracketed-paste-devel}"
SRC_URI[aarch64_rust-crossterm0.25+bracketed-paste-devel.sha256sum] = "d3f363e55dc268675de657427592056e938b5c50ad78df6e8f0b867e55abf80c"

URI_aarch64_rust-crossterm0.25+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+default-devel-0.25.0-5.el10_0.noarch.rpm;name=aarch64_rust-crossterm0.25+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+default-devel}"
SRC_URI[aarch64_rust-crossterm0.25+default-devel.sha256sum] = "cab348cdbf58c769e815ab5f52b4ceb61c3f61dc6a5bdee8ef5a14f90eed8a0e"

URI_aarch64_rust-crossterm0.25+event-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+event-stream-devel-0.25.0-5.el10_0.noarch.rpm;name=aarch64_rust-crossterm0.25+event-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+event-stream-devel}"
SRC_URI[aarch64_rust-crossterm0.25+event-stream-devel.sha256sum] = "8d67c5f26a2435a0427249591fd230cd1a1e643f311c5f05ebe32569ce6c04a5"

URI_aarch64_rust-crossterm0.25+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+futures-core-devel-0.25.0-5.el10_0.noarch.rpm;name=aarch64_rust-crossterm0.25+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+futures-core-devel}"
SRC_URI[aarch64_rust-crossterm0.25+futures-core-devel.sha256sum] = "a13d2c7b07880aba722503bc2c41f49c8d58f866b4ebd519212efb7289f5bfaf"

URI_aarch64_rust-crossterm0.25+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25+serde-devel-0.25.0-5.el10_0.noarch.rpm;name=aarch64_rust-crossterm0.25+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25+serde-devel}"
SRC_URI[aarch64_rust-crossterm0.25+serde-devel.sha256sum] = "be49f28b9dc4c6935235d31d6eb4953cc17282b24a299f50b689302c414e1eb5"

URI_aarch64_rust-crossterm0.25-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossterm0.25-devel-0.25.0-5.el10_0.noarch.rpm;name=aarch64_rust-crossterm0.25-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossterm0.25-devel}"
SRC_URI[aarch64_rust-crossterm0.25-devel.sha256sum] = "7e07997c470e676287c5a4c2da7379696e54ee9eb38fc8fde4b9e0e133363397"

RDEPENDS:rust-crossterm0.25+bracketed-paste-devel = " \
 cargo \
 rust-crossterm0.25-devel \
 "
RDEPENDS:rust-crossterm0.25+default-devel = " \
 cargo \
 rust-crossterm0.25+bracketed-paste-devel \
 rust-crossterm0.25-devel \
 "
RDEPENDS:rust-crossterm0.25+event-stream-devel = " \
 cargo \
 rust-crossterm0.25+futures-core-devel \
 rust-crossterm0.25-devel \
 "
RDEPENDS:rust-crossterm0.25+futures-core-devel = " \
 cargo \
 rust-crossterm0.25-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-crossterm0.25+serde-devel = " \
 cargo \
 rust-crossterm0.25-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-crossterm0.25-devel = " \
 cargo \
 rust-bitflags1+default-devel \
 rust-libc+default-devel \
 rust-mio0.8+default-devel \
 rust-mio0.8+os-poll-devel \
 rust-parking_lot+default-devel \
 rust-signal-hook+default-devel \
 rust-signal-hook-mio+default-devel \
 rust-signal-hook-mio+support-v0_8-devel \
 "
