# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "btrfs-efi"
PV = "20230328^git20240824.496ae85"
PR = "2.el10_0"
PACKAGES:x86_64_v2 = " \
 btrfs-efi-unsigned-x64 \
"
PACKAGES:aarch64 = " \
 btrfs-efi-unsigned-aa64 \
 btrfs-efi-unsigned-x64 \
"

URI_src = "${EPELSRC_MIRROR}/Packages/b/btrfs-efi-20230328^git20240824.496ae85-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc0bf7b8217bc88e0407f411b6687fbd948571e63c95ebd68818eee299dadfea"

URI_x86_64_v2_btrfs-efi-unsigned-x64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/btrfs-efi-unsigned-x64-20230328^git20240824.496ae85-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_btrfs-efi-unsigned-x64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_btrfs-efi-unsigned-x64}"
SRC_URI[x86_64_v2_btrfs-efi-unsigned-x64.sha256sum] = "3594c87122df75bd1f99de31a0f4eaa28f3eb6ceaa0cc1e7493bc9099bdf96ef"

URI_aarch64_btrfs-efi-unsigned-aa64 = "${EPEL_MIRROR}/aarch64/Packages/b/btrfs-efi-unsigned-aa64-20230328^git20240824.496ae85-2.el10_0.noarch.rpm;name=aarch64_btrfs-efi-unsigned-aa64;unpack=0"
SRC_URI:append = " ${URI_aarch64_btrfs-efi-unsigned-aa64}"
SRC_URI[aarch64_btrfs-efi-unsigned-aa64.sha256sum] = "42a681e1ee6449e8c8d7a03944914c7ff7bf5f8fef2298ead7d634523ba1b25a"

URI_aarch64_btrfs-efi-unsigned-x64 = "${EPEL_MIRROR}/aarch64/Packages/b/btrfs-efi-unsigned-x64-20230328^git20240824.496ae85-2.el10_0.noarch.rpm;name=aarch64_btrfs-efi-unsigned-x64;unpack=0"
SRC_URI:append = " ${URI_aarch64_btrfs-efi-unsigned-x64}"
SRC_URI[aarch64_btrfs-efi-unsigned-x64.sha256sum] = "d9f8505fb80c69d2da11d3a9eaeb69cd73f840df4ecd960dc51d3319cd3d7689"

RDEPENDS:btrfs-efi-unsigned-x64 = " \
 efi-filesystem \
 "
RDEPENDS:btrfs-efi-unsigned-aa64 = " \
 efi-filesystem \
 "
