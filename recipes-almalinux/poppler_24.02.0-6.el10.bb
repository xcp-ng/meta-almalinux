# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poppler"
PV = "24.02.0"
PR = "6.el10"
PACKAGES = " \
 poppler \
 poppler-cpp \
 poppler-cpp-devel \
 poppler-devel \
 poppler-glib \
 poppler-glib-devel \
 poppler-glib-doc \
 poppler-qt6 \
 poppler-qt6-devel \
 poppler-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/poppler-24.02.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c48323fb56270b83fceef24ef8debd3c6459c7b4a062b4c0a4aeb3d28bfead78"

URI_x86_64_v2_poppler = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-24.02.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_poppler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler}"
SRC_URI[x86_64_v2_poppler.sha256sum] = "8a1e3b6598abdc0ddac9afc51a95ee3d8eed9030590627feb23b7ffa5ca17c7e"

URI_x86_64_v2_poppler-cpp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-cpp-24.02.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_poppler-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-cpp}"
SRC_URI[x86_64_v2_poppler-cpp.sha256sum] = "29a6b27444f7ad9492a0bc9c5601f4712255d507a55c71305708aefbd4e2ddd4"

URI_x86_64_v2_poppler-cpp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-cpp-devel-24.02.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_poppler-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-cpp-devel}"
SRC_URI[x86_64_v2_poppler-cpp-devel.sha256sum] = "d01366b70af9bfa45b429be55936cb2bb5a15c9edc36f40798ce0d789e789ba1"

URI_x86_64_v2_poppler-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-devel-24.02.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_poppler-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-devel}"
SRC_URI[x86_64_v2_poppler-devel.sha256sum] = "d1e1383d1f5eddcde297b488e9f958b5f02eb52ddafe4a0d2c7f0c2a626f8c86"

URI_x86_64_v2_poppler-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-glib-24.02.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_poppler-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-glib}"
SRC_URI[x86_64_v2_poppler-glib.sha256sum] = "f130d370bf624de844690c32c5dc5649417eebfa0455c49d715dfa1c9f79e2d0"

URI_x86_64_v2_poppler-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-glib-devel-24.02.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_poppler-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-glib-devel}"
SRC_URI[x86_64_v2_poppler-glib-devel.sha256sum] = "d09a3e36d6e4505d2a0d2c14ed3d26c66abaea5eb14e8f4f7a9e5ac13c02c85f"

URI_x86_64_v2_poppler-glib-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-glib-doc-24.02.0-6.el10.noarch.rpm;name=x86_64_v2_poppler-glib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-glib-doc}"
SRC_URI[x86_64_v2_poppler-glib-doc.sha256sum] = "0a3179808da40b578432439ecc36ad82ae1f8e12209d49cbb9e85b44b65b29a8"

URI_x86_64_v2_poppler-qt6 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-qt6-24.02.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_poppler-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-qt6}"
SRC_URI[x86_64_v2_poppler-qt6.sha256sum] = "326c32bb98fb08273d188963e9326fae53a811e3dcdc0f643d57d00147ab0d5c"

URI_x86_64_v2_poppler-qt6-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/poppler-qt6-devel-24.02.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_poppler-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-qt6-devel}"
SRC_URI[x86_64_v2_poppler-qt6-devel.sha256sum] = "5f7fa7b26c1cacc94a96c82f1370f74afb72cbb30bd928f0035f061a1d8772ba"

URI_x86_64_v2_poppler-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/poppler-utils-24.02.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_poppler-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poppler-utils}"
SRC_URI[x86_64_v2_poppler-utils.sha256sum] = "9de91101f9cf7d489929ad6bfebacd90a429167a1e8a70e7c4f6f731a814ddf8"

URI_aarch64_poppler = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-24.02.0-6.el10.aarch64.rpm;name=aarch64_poppler;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler}"
SRC_URI[aarch64_poppler.sha256sum] = "2da15588f08fa00808ffc3b114753b4ef87e24575df1f8d5b197071773833dd2"

URI_aarch64_poppler-cpp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-cpp-24.02.0-6.el10.aarch64.rpm;name=aarch64_poppler-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-cpp}"
SRC_URI[aarch64_poppler-cpp.sha256sum] = "b86b5f7c13cc2631c6bc61bdfb253b6f41255cb8532bc33f38df8d8e84550b63"

URI_aarch64_poppler-cpp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-cpp-devel-24.02.0-6.el10.aarch64.rpm;name=aarch64_poppler-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-cpp-devel}"
SRC_URI[aarch64_poppler-cpp-devel.sha256sum] = "7872c33cdee4a8a79ed89c1fba6d80e5692c37aa0b2cffa81064b15388451748"

URI_aarch64_poppler-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-devel-24.02.0-6.el10.aarch64.rpm;name=aarch64_poppler-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-devel}"
SRC_URI[aarch64_poppler-devel.sha256sum] = "f4681e45a097f28117e1117a2258f6a9707d0fa1c0458e1176cfc3ca8dd7e074"

URI_aarch64_poppler-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-glib-24.02.0-6.el10.aarch64.rpm;name=aarch64_poppler-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-glib}"
SRC_URI[aarch64_poppler-glib.sha256sum] = "7e799e822dad22d9d72657c1c6297a062ee534a8c92972d11719ba4fc5e958f5"

URI_aarch64_poppler-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-glib-devel-24.02.0-6.el10.aarch64.rpm;name=aarch64_poppler-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-glib-devel}"
SRC_URI[aarch64_poppler-glib-devel.sha256sum] = "1d6fa40e19f8309c03708b8ddc51116a1b35b3bf62a739b8242cccd09fe92fd2"

URI_aarch64_poppler-glib-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-glib-doc-24.02.0-6.el10.noarch.rpm;name=aarch64_poppler-glib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-glib-doc}"
SRC_URI[aarch64_poppler-glib-doc.sha256sum] = "0a3179808da40b578432439ecc36ad82ae1f8e12209d49cbb9e85b44b65b29a8"

URI_aarch64_poppler-qt6 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-qt6-24.02.0-6.el10.aarch64.rpm;name=aarch64_poppler-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-qt6}"
SRC_URI[aarch64_poppler-qt6.sha256sum] = "673cc407444bf9b7de2800fcbe328c51c709d47a16053a4e1c51042fae5ba0d2"

URI_aarch64_poppler-qt6-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/poppler-qt6-devel-24.02.0-6.el10.aarch64.rpm;name=aarch64_poppler-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-qt6-devel}"
SRC_URI[aarch64_poppler-qt6-devel.sha256sum] = "df5fb8e9575dfd7ca584524803853741259d3e3b90d6af2039b38a685e8e0489"

URI_aarch64_poppler-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/poppler-utils-24.02.0-6.el10.aarch64.rpm;name=aarch64_poppler-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_poppler-utils}"
SRC_URI[aarch64_poppler-utils.sha256sum] = "082940abf4513751673ddc1b5204e98531a40e2d17b4d14eab0d11c344d7682e"

RDEPENDS:poppler = " \
 fontconfig \
 freetype \
 glibc \
 gpgmepp \
 lcms2 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 nspr \
 nss \
 openjpeg2 \
 poppler-data \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:poppler-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 poppler \
 "
RDEPENDS:poppler-cpp-devel = " \
 pkgconf-pkg-config \
 poppler-cpp \
 poppler-devel \
 "
RDEPENDS:poppler-devel = " \
 pkgconf-pkg-config \
 poppler \
 "
RDEPENDS:poppler-glib = " \
 cairo \
 freetype \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 poppler \
 "
RDEPENDS:poppler-glib-devel = " \
 cairo-devel \
 glib2-devel \
 pkgconf-pkg-config \
 poppler-devel \
 poppler-glib \
 "
RDEPENDS:poppler-glib-doc = " \
 "
RDEPENDS:poppler-qt6 = " \
 freetype \
 glibc \
 lcms2 \
 libgcc \
 libstdc++ \
 poppler \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:poppler-qt6-devel = " \
 pkgconf-pkg-config \
 poppler-devel \
 poppler-qt6 \
 qt6-qtbase-devel \
 "
RDEPENDS:poppler-utils = " \
 cairo \
 freetype \
 glibc \
 lcms2 \
 libgcc \
 libstdc++ \
 poppler \
 "
