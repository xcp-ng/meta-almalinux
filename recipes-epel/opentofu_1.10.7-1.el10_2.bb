# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opentofu"
PV = "1.10.7"
PR = "1.el10_2"
PACKAGES = " \
 opentofu \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opentofu-1.10.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9d7c2111e1926441ed50e1e23b6f6423353b490bccfbc4f42670163e43cb6de"

URI_x86_64_v2_opentofu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opentofu-1.10.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opentofu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opentofu}"
SRC_URI[x86_64_v2_opentofu.sha256sum] = "45908a72cf09e08bfd4941e0dcead3291ccb91ce7e220e623c95e47526fa9139"

URI_aarch64_opentofu = "${EPEL_MIRROR}/aarch64/Packages/o/opentofu-1.10.7-1.el10_2.aarch64.rpm;name=aarch64_opentofu;unpack=0"
SRC_URI:append = " ${URI_aarch64_opentofu}"
SRC_URI[aarch64_opentofu.sha256sum] = "959f7f9b3c9c645577b73918392f414751de9654704150c715b580d8219c886c"

RDEPENDS:opentofu = " \
 glibc \
 "
