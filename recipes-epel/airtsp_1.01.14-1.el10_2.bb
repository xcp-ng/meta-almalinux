# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "airtsp"
PV = "1.01.14"
PR = "1.el10_2"
PACKAGES = " \
 airtsp \
 airtsp-devel \
 airtsp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/airtsp-1.01.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e446f8c1a621d9664a56fc4d13b90b847739870b8b8f659699663f5f6815bba7"

URI_x86_64_v2_airtsp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/airtsp-1.01.14-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_airtsp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_airtsp}"
SRC_URI[x86_64_v2_airtsp.sha256sum] = "e918c0ffc0939f2a1e31907a267e2f6311d88c8ced2eff3e6af3bd24d6a714b1"

URI_x86_64_v2_airtsp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/airtsp-devel-1.01.14-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_airtsp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_airtsp-devel}"
SRC_URI[x86_64_v2_airtsp-devel.sha256sum] = "2388c3f6396c4bbeb64f888951c4090bd1f77735cd5388c6a991141ddfe8d92a"

URI_x86_64_v2_airtsp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/airtsp-doc-1.01.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_airtsp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_airtsp-doc}"
SRC_URI[x86_64_v2_airtsp-doc.sha256sum] = "62bd4892e0c88ab237f8e50e2620eb4fa9e3b88affc95287f43b951422cbefbb"

URI_aarch64_airtsp = "${EPEL_MIRROR}/aarch64/Packages/a/airtsp-1.01.14-1.el10_2.aarch64.rpm;name=aarch64_airtsp;unpack=0"
SRC_URI:append = " ${URI_aarch64_airtsp}"
SRC_URI[aarch64_airtsp.sha256sum] = "e9ea10a59207d14da9e0d0ba4fc354188ee647f6ab0858891c6ff516c56e74f0"

URI_aarch64_airtsp-devel = "${EPEL_MIRROR}/aarch64/Packages/a/airtsp-devel-1.01.14-1.el10_2.aarch64.rpm;name=aarch64_airtsp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_airtsp-devel}"
SRC_URI[aarch64_airtsp-devel.sha256sum] = "5c3a42b06683d123c61c42d72eacf92c0a896bbfec322a6177d7a08541f505a3"

URI_aarch64_airtsp-doc = "${EPEL_MIRROR}/aarch64/Packages/a/airtsp-doc-1.01.14-1.el10_2.noarch.rpm;name=aarch64_airtsp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_airtsp-doc}"
SRC_URI[aarch64_airtsp-doc.sha256sum] = "bbe9442267c0803e03b2c8dfc5cc6d7a7f6abcd97938aa8f597fb02c7de413e9"

RDEPENDS:airtsp = " \
 boost-program-options \
 boost-serialization \
 glibc \
 libgcc \
 libstdc++ \
 stdair \
 "
RDEPENDS:airtsp-devel = " \
 airtsp \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:airtsp-doc = " \
 "
