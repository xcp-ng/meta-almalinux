# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argfile"
PV = "1.0.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-argfile+default-devel \
 rust-argfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argfile-1.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b25f068f9b2474a5834de0165fb870c5312108ae0992d2659945313d241534d2"

URI_x86_64_v2_rust-argfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argfile+default-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argfile+default-devel}"
SRC_URI[x86_64_v2_rust-argfile+default-devel.sha256sum] = "4185d0f154ff2a5911d5e8cefaa7eb1e266e80296a7751a9c9aab32cc09998fa"

URI_x86_64_v2_rust-argfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argfile-devel-1.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argfile-devel}"
SRC_URI[x86_64_v2_rust-argfile-devel.sha256sum] = "19775360240b721bfd897a6d536217ea7331dd2626637a0f5778a3bdbb5047a8"

URI_aarch64_rust-argfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argfile+default-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-argfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argfile+default-devel}"
SRC_URI[aarch64_rust-argfile+default-devel.sha256sum] = "f5ec03e5a40a8300dcbaa86565708fff97fb3c42d31bed7f852143442e886fa2"

URI_aarch64_rust-argfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argfile-devel-1.0.0-1.el10_2.noarch.rpm;name=aarch64_rust-argfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argfile-devel}"
SRC_URI[aarch64_rust-argfile-devel.sha256sum] = "d5822ba3dbd8973077a4f6162b45c80a1e69e74503c1c4d35b783fe21a61e5e1"

RDEPENDS:rust-argfile+default-devel = " \
 cargo \
 rust-argfile-devel \
 "
RDEPENDS:rust-argfile-devel = " \
 cargo \
 rust \
 rust-fs-err+default-devel \
 rust-os_str_bytes+default-devel \
 "
