# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-lint"
PV = "1.0.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-sphinx-lint \
 python3-sphinx-lint+tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-lint-1.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab7b3fd415e69b5c11e26f4041b6371149cda6630db15169cc02e6959d6c28fc"

URI_x86_64_v2_python3-sphinx-lint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-lint-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-lint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-lint}"
SRC_URI[x86_64_v2_python3-sphinx-lint.sha256sum] = "713765bb275f6d2a1b0505c5ef5ab6a721d188963571acdde743611fc1c5c8cd"

URI_x86_64_v2_python3-sphinx-lint+tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-lint+tests-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-lint+tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-lint+tests}"
SRC_URI[x86_64_v2_python3-sphinx-lint+tests.sha256sum] = "2c02fa31b7bf816f69d228124aa7aa4c1d333f38eb1722de79fccfdbc7bd1e1d"

URI_aarch64_python3-sphinx-lint = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-lint-1.0.2-1.el10_2.noarch.rpm;name=aarch64_python3-sphinx-lint;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-lint}"
SRC_URI[aarch64_python3-sphinx-lint.sha256sum] = "a655b3c88d193159b2a522029dd00c20b40e829dec3ddd7a74134c0c121bbc28"

URI_aarch64_python3-sphinx-lint+tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-lint+tests-1.0.2-1.el10_2.noarch.rpm;name=aarch64_python3-sphinx-lint+tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-lint+tests}"
SRC_URI[aarch64_python3-sphinx-lint+tests.sha256sum] = "5aa0224691fd1a1d8155b8dd668ec4a671ac031bb2b9c61fdfe5809b07e37757"

RDEPENDS:python3-sphinx-lint = " \
 python3 \
 python3-polib \
 python3-regex \
 "
RDEPENDS:python3-sphinx-lint+tests = " \
 python3 \
 python3-pytest \
 python3-pytest-cov \
 python3-sphinx-lint \
 "
