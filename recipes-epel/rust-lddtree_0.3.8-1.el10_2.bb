# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lddtree"
PV = "0.3.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-lddtree+default-devel \
 rust-lddtree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lddtree-0.3.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf79158e3702aff5b8b7f2c21403e9f80d2a0ed8e7d6bd34777d799970741ffc"

URI_x86_64_v2_rust-lddtree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lddtree+default-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lddtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lddtree+default-devel}"
SRC_URI[x86_64_v2_rust-lddtree+default-devel.sha256sum] = "d652970903612c7a9f989cd8f76fee2c538763035863124e8802fc85b65f3012"

URI_x86_64_v2_rust-lddtree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lddtree-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lddtree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lddtree-devel}"
SRC_URI[x86_64_v2_rust-lddtree-devel.sha256sum] = "50686bdae030895ee8ae0622c3f98c31cf44c4deed9e339ff655ccb638a322a8"

URI_aarch64_rust-lddtree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lddtree+default-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-lddtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lddtree+default-devel}"
SRC_URI[aarch64_rust-lddtree+default-devel.sha256sum] = "b0c2bccf1109764aa3cf62d239acf99aa276e9b7c618a565e80c3d92b4462417"

URI_aarch64_rust-lddtree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lddtree-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-lddtree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lddtree-devel}"
SRC_URI[aarch64_rust-lddtree-devel.sha256sum] = "cdad24cea12b4d604caf9d6f9fe949c314ea9c98355d3236f5366956bc816f88"

RDEPENDS:rust-lddtree+default-devel = " \
 cargo \
 rust-lddtree-devel \
 "
RDEPENDS:rust-lddtree-devel = " \
 cargo \
 rust-fs-err+default-devel \
 rust-glob+default-devel \
 rust-goblin+default-devel \
 "
