# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-opencontainers-runtime-spec"
PV = "1.2.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-opencontainers-runtime-spec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-opencontainers-runtime-spec-1.2.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c774e51e1df8c874885f0f48d1adc9ab23e5ff29b6be6e4650dafd43956aae90"

URI_x86_64_v2_golang-github-opencontainers-runtime-spec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-opencontainers-runtime-spec-devel-1.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-opencontainers-runtime-spec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-opencontainers-runtime-spec-devel}"
SRC_URI[x86_64_v2_golang-github-opencontainers-runtime-spec-devel.sha256sum] = "ffb1ed748c663599647b968d640426b01a0537328125babb941e3766f8959e39"

URI_aarch64_golang-github-opencontainers-runtime-spec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-opencontainers-runtime-spec-devel-1.2.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-opencontainers-runtime-spec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-opencontainers-runtime-spec-devel}"
SRC_URI[aarch64_golang-github-opencontainers-runtime-spec-devel.sha256sum] = "26fe2686abad004dfcb01cf11897b892bf7fd71b6d8d7caa1b7e50ee68d931bb"

RDEPENDS:golang-github-opencontainers-runtime-spec-devel = " \
 go-filesystem \
 golang-github-xeipuuv-gojsonschema-devel \
 "
