# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "FP16"
PV = "1.0^git20240619.98b0a46"
PR = "5.el10_1"
PACKAGES = " \
 FP16-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/FP16-1.0^git20240619.98b0a46-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c23976d9f89c6ee06ba3e97c86a8ff53072721f577c3b96493f047d43d2ee44b"

URI_x86_64_v2_FP16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/FP16-devel-1.0^git20240619.98b0a46-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_FP16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_FP16-devel}"
SRC_URI[x86_64_v2_FP16-devel.sha256sum] = "af31a137cfcf50f9b5ff356c12587e46a26df7c33a925c10e6f648dc42451460"

URI_aarch64_FP16-devel = "${EPEL_MIRROR}/aarch64/Packages/f/FP16-devel-1.0^git20240619.98b0a46-5.el10_1.noarch.rpm;name=aarch64_FP16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_FP16-devel}"
SRC_URI[aarch64_FP16-devel.sha256sum] = "acb7e18d20355f802498315f35437893390a45095f3ff2ab8516e3f08501fabd"

RDEPENDS:FP16-devel = " \
 python3 \
 python3-peachpy \
 "
