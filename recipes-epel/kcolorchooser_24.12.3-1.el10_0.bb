# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcolorchooser"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kcolorchooser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcolorchooser-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b0f5069ded41e1f6aa0e1da84550ba080ef3e9cbc19c4912ffa9d4fc8742d32"

URI_x86_64_v2_kcolorchooser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcolorchooser-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcolorchooser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcolorchooser}"
SRC_URI[x86_64_v2_kcolorchooser.sha256sum] = "0156455c008204bd0d61148d4f3417fbd7966c07671eb2bc58aa1d8fc56bbc12"

URI_aarch64_kcolorchooser = "${EPEL_MIRROR}/aarch64/Packages/k/kcolorchooser-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kcolorchooser;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcolorchooser}"
SRC_URI[aarch64_kcolorchooser.sha256sum] = "fce683b3d68eb750dd213494fcdf41c25813cb4c6444f8a07180f5f4763807f8"

RDEPENDS:kcolorchooser = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
