# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dconf-editor"
PV = "45.0.1"
PR = "6.el10"
PACKAGES = " \
 dconf-editor \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dconf-editor-45.0.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3367f6eaaf7f02f0db712ac7d01f943a7003e6133d6f297aef46b3de7ed92c9f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dconf-editor-45.0.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_dconf-editor;unpack=0"
SRC_URI[x86_64_v2_dconf-editor.sha256sum] = "36bb1e36ae7cf6b2cf203143d6263754f8af6ca3c5d73feba7478ccdca0e7b93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dconf-editor-45.0.1-6.el10.aarch64.rpm;name=aarch64_dconf-editor;unpack=0"
SRC_URI[aarch64_dconf-editor.sha256sum] = "0781ca5262df5e048578cde5af1aff4b10f36a1954dc001b8b25dcbf4fc766d7"

RDEPENDS:dconf-editor = " \
 dconf \
 glib2 \
 glibc \
 gtk3 \
 libhandy \
 "
