# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-krunner"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-krunner \
 kf6-krunner-devel \
 kf6-krunner-doc \
 kf6-krunner-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-krunner-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "499eb986db16888743b66596e13c902e2b33b09e098516027675215b1a797589"

URI_x86_64_v2_kf6-krunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner}"
SRC_URI[x86_64_v2_kf6-krunner.sha256sum] = "918654ffce780ef07343354e30c30738f508fa0786daa26ece7fb0f9ebd92409"

URI_x86_64_v2_kf6-krunner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-devel}"
SRC_URI[x86_64_v2_kf6-krunner-devel.sha256sum] = "88a533e76aa21ce1600e7551b9f87d1c508e55c3eaf18e6ffa381dda90522c4b"

URI_x86_64_v2_kf6-krunner-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-krunner-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-doc}"
SRC_URI[x86_64_v2_kf6-krunner-doc.sha256sum] = "681f9bf2f1e09673e75d791f54c9c490ac12f057404ace1521efe9dd9f7b2a4b"

URI_x86_64_v2_kf6-krunner-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-krunner-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-krunner-html}"
SRC_URI[x86_64_v2_kf6-krunner-html.sha256sum] = "3beb758bfd3c39530a65567bcf3ab04b3c7f651077f447d6665b66189deae927"

URI_aarch64_kf6-krunner = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-krunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner}"
SRC_URI[aarch64_kf6-krunner.sha256sum] = "37d0b13e398a2b301f5bd7281fdc1486404f87e6878047d6cdb30f58e5ef67bd"

URI_aarch64_kf6-krunner-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-krunner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-devel}"
SRC_URI[aarch64_kf6-krunner-devel.sha256sum] = "730fef1109bccd0e3eef79d1cc35f8eb5b68e02b66c545ce26fabf006db79d13"

URI_aarch64_kf6-krunner-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-krunner-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-doc}"
SRC_URI[aarch64_kf6-krunner-doc.sha256sum] = "5b13d68622ce818f83c7a0332a6dce33beb1d3abb890290767c6f3493cd4ecfb"

URI_aarch64_kf6-krunner-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-krunner-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-krunner-html}"
SRC_URI[aarch64_kf6-krunner-html.sha256sum] = "fe2bce91c59cf8fe980eb57e30c58ba6a20ce9cc17999abef38eb21b12091aba"

RDEPENDS:kf6-krunner = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-krunner-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-krunner \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-krunner-doc = " \
 "
RDEPENDS:kf6-krunner-html = " \
 "
