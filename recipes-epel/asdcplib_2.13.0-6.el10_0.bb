# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "asdcplib"
PV = "2.13.0"
PR = "6.el10_0"
PACKAGES = " \
 asdcplib \
 asdcplib-devel \
 asdcplib-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/asdcplib-2.13.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dba5e14adac3cda7d576c3350aeb5109a2942c93ec083dcdaf6d827329c20f9"

URI_x86_64_v2_asdcplib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-2.13.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asdcplib}"
SRC_URI[x86_64_v2_asdcplib.sha256sum] = "5d8b3f7486b4c9a4e87d3cfffb2ace66aab629e9d605488cba2b437fcf851e24"

URI_x86_64_v2_asdcplib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-devel-2.13.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asdcplib-devel}"
SRC_URI[x86_64_v2_asdcplib-devel.sha256sum] = "c6e9c8192bc5b4d9e9c03b1958b0d9128712bfef5d166ba35726a9e4c993d223"

URI_x86_64_v2_asdcplib-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-tools-2.13.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asdcplib-tools}"
SRC_URI[x86_64_v2_asdcplib-tools.sha256sum] = "35d4ac343a1817625bab09c645ddb610ae5926c4b698d619a5a59ba9c5502862"

URI_aarch64_asdcplib = "${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-2.13.0-6.el10_0.aarch64.rpm;name=aarch64_asdcplib;unpack=0"
SRC_URI:append = " ${URI_aarch64_asdcplib}"
SRC_URI[aarch64_asdcplib.sha256sum] = "419990d34c501ff419aed6ea5268fc40da8c1952e7816c1cf96682405dab972c"

URI_aarch64_asdcplib-devel = "${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-devel-2.13.0-6.el10_0.aarch64.rpm;name=aarch64_asdcplib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_asdcplib-devel}"
SRC_URI[aarch64_asdcplib-devel.sha256sum] = "786dcf5b13b856be4c6f57c12fdf0dbe27a639e4df2159e13749628fa35c80df"

URI_aarch64_asdcplib-tools = "${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-tools-2.13.0-6.el10_0.aarch64.rpm;name=aarch64_asdcplib-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_asdcplib-tools}"
SRC_URI[aarch64_asdcplib-tools.sha256sum] = "319d3dfe9a94d53eceb479647b6bcefb64cb5c00c76a697f1e054d6cb68d3583"

RDEPENDS:asdcplib = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 xerces-c \
 "
RDEPENDS:asdcplib-devel = " \
 asdcplib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:asdcplib-tools = " \
 asdcplib \
 glibc \
 libgcc \
 libstdc++ \
 "
