# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-rustls"
PV = "0.26.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio-rustls+brotli-devel \
 rust-tokio-rustls+default-devel \
 rust-tokio-rustls+early-data-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls+zlib-devel \
 rust-tokio-rustls-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-rustls-0.26.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8072e975c8363cde4cd52cb38c4fd0e15a4d6b0e8a12d9375c28a75eb400cdb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+brotli-devel-0.26.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+brotli-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+brotli-devel.sha256sum] = "ae49dcc97d9cd890fd3197845d693af64e7c1e29f50922e8bfc76be81db5b6da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+default-devel-0.26.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+default-devel.sha256sum] = "02e0b68ffca97425bf8ab63e7d25fae329cec6db28a30c9642cd03728c83b759"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+early-data-devel-0.26.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+early-data-devel.sha256sum] = "98ed3ee81864de84bd555ee8452c4c275ffe5516a0f546703ed255a99fc8805e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+logging-devel-0.26.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+logging-devel.sha256sum] = "48e6ea03ceaa6b09320763b00ee987177e8cf237bec325a50e0a85021ee1fbe1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+ring-devel-0.26.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+ring-devel.sha256sum] = "ae463fac86d7ab2d9526a128fa39fd2effc85fa8d258e1693e0de3606b4dc7fe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+tls12-devel-0.26.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+tls12-devel.sha256sum] = "e5bb774a0a402ba8c22d3d07f41e61e8c6ce7ca9da73c557b6376b62fdc79ade"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+zlib-devel-0.26.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+zlib-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls+zlib-devel.sha256sum] = "ec1b2af7c383301a5894693bfb732ecde5de41582001d9a02085e2dba739bd44"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls-devel-0.26.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-rustls-devel.sha256sum] = "2430f8778995cafd36f9614295da9a33e7960c75fd8a2479ab8909bb1847b78e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+brotli-devel-0.26.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+brotli-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+brotli-devel.sha256sum] = "4db4985c398a3b6d270b218693665d031375fbce24c906920904181396878cf3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+default-devel-0.26.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+default-devel.sha256sum] = "3fab506cee5d433956ee06c432c89a89bbddd94b2a4df623fe241ec074e34dd0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+early-data-devel-0.26.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+early-data-devel.sha256sum] = "10430e9eb2985c9c68e586682321a08adb7eb1e7d1f2802dab7e2a043c4750d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+logging-devel-0.26.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+logging-devel.sha256sum] = "ba5e64a0831cb45620fa44c6dfc7f45b8c9eaad252d7fffa335fb56aabbbe22c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+ring-devel-0.26.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+ring-devel.sha256sum] = "4d1fa34a277ef2c577265a03d2547f46e8e9bd2701908f4449967eb6f35533e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+tls12-devel-0.26.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+tls12-devel.sha256sum] = "6e8c4fdfa3676f5bdf34650a0c79108c9ea4a509d2b741b7d38542409e24db59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+zlib-devel-0.26.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+zlib-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls+zlib-devel.sha256sum] = "43cbd85d331d983ec39809d86b103b9957b837076f2df112d9fbc2d2a665eabd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls-devel-0.26.6-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-rustls-devel.sha256sum] = "e527e707102fa949bc6a427c9877e06f8375fdb37d9be8071b5a721fe51d4085"

RDEPENDS:rust-tokio-rustls+brotli-devel = " \
 cargo \
 rust-rustls+brotli-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+default-devel = " \
 cargo \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+early-data-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+logging-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+ring-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+tls12-devel = " \
 cargo \
 rust-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+zlib-devel = " \
 cargo \
 rust-rustls+zlib-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls-devel = " \
 cargo \
 rust \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tokio+default-devel \
 "
