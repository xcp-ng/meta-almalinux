# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rlottie"
PV = "0.2"
PR = "17.el10_2"
PACKAGES = " \
 rlottie \
 rlottie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rlottie-0.2-17.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "971222162a1f12b05a529f559aa3e057d4d9d141568d20d991f950c4ab9c1280"

URI_x86_64_v2_rlottie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rlottie-0.2-17.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rlottie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rlottie}"
SRC_URI[x86_64_v2_rlottie.sha256sum] = "a5fc97f0708936047fc467d23dd4acd7328048720ffeeba2d1645c9d3f711df1"

URI_x86_64_v2_rlottie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rlottie-devel-0.2-17.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rlottie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rlottie-devel}"
SRC_URI[x86_64_v2_rlottie-devel.sha256sum] = "a4b84ff0e134cd6992304edb678fd2a2da3e797f82c3a41efc239e686b3c92b1"

URI_aarch64_rlottie = "${EPEL_MIRROR}/aarch64/Packages/r/rlottie-0.2-17.el10_2.aarch64.rpm;name=aarch64_rlottie;unpack=0"
SRC_URI:append = " ${URI_aarch64_rlottie}"
SRC_URI[aarch64_rlottie.sha256sum] = "77551ef0f202c918e0c8d17f3930f22a07c9b6f336a6404f9222820d5e05b538"

URI_aarch64_rlottie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rlottie-devel-0.2-17.el10_2.aarch64.rpm;name=aarch64_rlottie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rlottie-devel}"
SRC_URI[aarch64_rlottie-devel.sha256sum] = "1f8c6932e5ed47dde97dbe873613a2ac50c6fc7b3fea8d0e4c6b310dc9462a9a"

RDEPENDS:rlottie = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:rlottie-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 rlottie \
 "
