# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-Prompter"
PV = "0.005004"
PR = "1.el10_2"
PACKAGES = " \
 perl-IO-Prompter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-Prompter-0.005004-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ec15dd3041bd17de3e1fdeeeaea23d872790966e34e9c216c4da9045260c815"

URI_x86_64_v2_perl-IO-Prompter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-Prompter-0.005004-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-Prompter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-Prompter}"
SRC_URI[x86_64_v2_perl-IO-Prompter.sha256sum] = "369aff0b6da3da790f3bd32590ce316d6c91c0c5cbb00624b0945832ff00bfb1"

URI_aarch64_perl-IO-Prompter = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-Prompter-0.005004-1.el10_2.noarch.rpm;name=aarch64_perl-IO-Prompter;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-Prompter}"
SRC_URI[aarch64_perl-IO-Prompter.sha256sum] = "46c67b9215957f8260e4e251bbda07ef2f381d7321b8b0c5dc80c1a14265f792"

RDEPENDS:perl-IO-Prompter = " \
 perl-Carp \
 perl-Contextual-Return \
 perl-Scalar-List-Utils \
 perl-Symbol \
 perl-libs \
 perl-match-simple \
 "
