# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pymongo"
PV = "4.8.0"
PR = "1.el10_0"
PACKAGES = " \
 python-pymongo-doc \
 python3-bson \
 python3-pymongo \
 python3-pymongo+ocsp \
 python3-pymongo+snappy \
 python3-pymongo+zstd \
 python3-pymongo-gridfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pymongo-4.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "640431b0b1bde55bb9f433982b3d3ec60d195cb1b08ef64f1a103dcf8cf2a6f1"

URI_x86_64_v2_python-pymongo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pymongo-doc-4.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-pymongo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pymongo-doc}"
SRC_URI[x86_64_v2_python-pymongo-doc.sha256sum] = "df1125c6fadc3138a554c35f95eee6f8298f30590709e68aa615dc0f247b70a3"

URI_x86_64_v2_python3-bson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bson-4.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-bson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bson}"
SRC_URI[x86_64_v2_python3-bson.sha256sum] = "fd697279ce42676530a11e0276221eb55457d8db918b57f3c43aca7ea7b98ae6"

URI_x86_64_v2_python3-pymongo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo-4.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo}"
SRC_URI[x86_64_v2_python3-pymongo.sha256sum] = "bfc16ca029f11f16abb3f23159e642d205926fd5852d74096e22c80e2dfd656e"

URI_x86_64_v2_python3-pymongo+ocsp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo+ocsp-4.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo+ocsp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo+ocsp}"
SRC_URI[x86_64_v2_python3-pymongo+ocsp.sha256sum] = "10f6870265800dc0d06c172aa57c8e5f06fd2616208c85c39460772bbd93792f"

URI_x86_64_v2_python3-pymongo+snappy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo+snappy-4.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo+snappy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo+snappy}"
SRC_URI[x86_64_v2_python3-pymongo+snappy.sha256sum] = "14a6214d3f19d8fd7db68d47936777d505e999c004139a09b1c1b4b1f3a6e3ea"

URI_x86_64_v2_python3-pymongo+zstd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo+zstd-4.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo+zstd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo+zstd}"
SRC_URI[x86_64_v2_python3-pymongo+zstd.sha256sum] = "cfe7c63593ae801256d07f76817d4063635c157067479b25b8f4082ae69bdaa5"

URI_x86_64_v2_python3-pymongo-gridfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymongo-gridfs-4.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymongo-gridfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pymongo-gridfs}"
SRC_URI[x86_64_v2_python3-pymongo-gridfs.sha256sum] = "9ff60c6044761dfebef143e4990ddd680ce01fbbd2c6f9ef068cdfee1e218a82"

URI_aarch64_python-pymongo-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pymongo-doc-4.8.0-1.el10_0.noarch.rpm;name=aarch64_python-pymongo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pymongo-doc}"
SRC_URI[aarch64_python-pymongo-doc.sha256sum] = "e033e99c7b8a4cfe45a03c3767762168f090e4528f6c796239f97ff47e339241"

URI_aarch64_python3-bson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bson-4.8.0-1.el10_0.aarch64.rpm;name=aarch64_python3-bson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bson}"
SRC_URI[aarch64_python3-bson.sha256sum] = "49f7e1f59adccdc675768c9e209cf7a7bc238c4c04ccc27b1903d0ce6b675477"

URI_aarch64_python3-pymongo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo-4.8.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pymongo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo}"
SRC_URI[aarch64_python3-pymongo.sha256sum] = "72d592e368737b5a80f7bc89ec3c40b5ccb93167d09356c982155843165d1a7c"

URI_aarch64_python3-pymongo+ocsp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo+ocsp-4.8.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pymongo+ocsp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo+ocsp}"
SRC_URI[aarch64_python3-pymongo+ocsp.sha256sum] = "5a6e3beebba1b7674f49185bfbddeb5d1c9413323d37bf907149147d5ffc6e1e"

URI_aarch64_python3-pymongo+snappy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo+snappy-4.8.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pymongo+snappy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo+snappy}"
SRC_URI[aarch64_python3-pymongo+snappy.sha256sum] = "2860442fe4953d6d1455dc8562a7e9c0e7cb3a0841830ffd1c89b5d2dfe1d639"

URI_aarch64_python3-pymongo+zstd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo+zstd-4.8.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pymongo+zstd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo+zstd}"
SRC_URI[aarch64_python3-pymongo+zstd.sha256sum] = "87bf45a546f73ecc4ae3962a142b857bb243f82236aa45de15d03d6ce18963ec"

URI_aarch64_python3-pymongo-gridfs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pymongo-gridfs-4.8.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pymongo-gridfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pymongo-gridfs}"
SRC_URI[aarch64_python3-pymongo-gridfs.sha256sum] = "fd0ea06c711637cc88bd76f0a22f1fdd662bb30d1a5dafff633c7da391d35ea7"

RDEPENDS:python-pymongo-doc = " \
 "
RDEPENDS:python3-bson = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-pymongo = " \
 glibc \
 python3 \
 python3-bson \
 python3-dns \
 "
RDEPENDS:python3-pymongo+ocsp = " \
 python3 \
 python3-cryptography \
 python3-pyOpenSSL \
 python3-pymongo \
 python3-requests \
 python3-service-identity \
 "
RDEPENDS:python3-pymongo+snappy = " \
 python3 \
 python3-pymongo \
 python3-snappy \
 "
RDEPENDS:python3-pymongo+zstd = " \
 python3 \
 python3-pymongo \
 python3-zstandard \
 "
RDEPENDS:python3-pymongo-gridfs = " \
 python3 \
 python3-pymongo \
 "
