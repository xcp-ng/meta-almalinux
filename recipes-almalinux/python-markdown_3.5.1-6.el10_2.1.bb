# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-markdown"
PV = "3.5.1"
PR = "6.el10_2.1"
PACKAGES = " \
 python3-markdown \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-markdown-3.5.1-6.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "26715672b95a65f34c0d405c3189036d270785bd5285a3a76a38bb9462592b2f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-markdown-3.5.1-6.el10_2.1.noarch.rpm;name=x86_64_v2_python3-markdown;unpack=0"
SRC_URI[x86_64_v2_python3-markdown.sha256sum] = "e992c7bf853699dca698a1d9174722cf887d7dc2d654e47c3ffcf20cb889e87e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-markdown-3.5.1-6.el10_2.1.noarch.rpm;name=aarch64_python3-markdown;unpack=0"
SRC_URI[aarch64_python3-markdown.sha256sum] = "e992c7bf853699dca698a1d9174722cf887d7dc2d654e47c3ffcf20cb889e87e"

RDEPENDS:python3-markdown = " \
 python3 \
 "
