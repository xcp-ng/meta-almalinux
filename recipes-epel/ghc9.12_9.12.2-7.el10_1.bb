# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.12"
PV = "9.12.2"
PR = "7.el10_1"
PACKAGES:x86_64_v2 = " \
 ghc9.12 \
 ghc9.12-Cabal \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-doc \
 ghc9.12-Cabal-syntax \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-Cabal-syntax-doc \
 ghc9.12-array \
 ghc9.12-array-devel \
 ghc9.12-array-doc \
 ghc9.12-base \
 ghc9.12-base-devel \
 ghc9.12-base-doc \
 ghc9.12-binary \
 ghc9.12-binary-devel \
 ghc9.12-binary-doc \
 ghc9.12-bytestring \
 ghc9.12-bytestring-devel \
 ghc9.12-bytestring-doc \
 ghc9.12-compiler \
 ghc9.12-compiler-default \
 ghc9.12-containers \
 ghc9.12-containers-devel \
 ghc9.12-containers-doc \
 ghc9.12-deepseq \
 ghc9.12-deepseq-devel \
 ghc9.12-deepseq-doc \
 ghc9.12-devel \
 ghc9.12-directory \
 ghc9.12-directory-devel \
 ghc9.12-directory-doc \
 ghc9.12-doc \
 ghc9.12-doc-index \
 ghc9.12-exceptions \
 ghc9.12-exceptions-devel \
 ghc9.12-exceptions-doc \
 ghc9.12-file-io \
 ghc9.12-file-io-devel \
 ghc9.12-file-io-doc \
 ghc9.12-filepath \
 ghc9.12-filepath-devel \
 ghc9.12-filepath-doc \
 ghc9.12-filesystem \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-bignum-devel \
 ghc9.12-ghc-bignum-doc \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-doc \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-boot-th-doc \
 ghc9.12-ghc-compact \
 ghc9.12-ghc-compact-devel \
 ghc9.12-ghc-compact-doc \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-doc \
 ghc9.12-ghc-experimental \
 ghc9.12-ghc-experimental-devel \
 ghc9.12-ghc-experimental-doc \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghc-heap-doc \
 ghc9.12-ghc-platform \
 ghc9.12-ghc-platform-devel \
 ghc9.12-ghc-platform-doc \
 ghc9.12-ghc-toolchain \
 ghc9.12-ghc-toolchain-devel \
 ghc9.12-ghc-toolchain-doc \
 ghc9.12-ghci \
 ghc9.12-ghci-devel \
 ghc9.12-ghci-doc \
 ghc9.12-haddock-api \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-api-doc \
 ghc9.12-haddock-library \
 ghc9.12-haddock-library-devel \
 ghc9.12-haddock-library-doc \
 ghc9.12-hadrian \
 ghc9.12-haskeline \
 ghc9.12-haskeline-devel \
 ghc9.12-haskeline-doc \
 ghc9.12-hpc \
 ghc9.12-hpc-devel \
 ghc9.12-hpc-doc \
 ghc9.12-manual \
 ghc9.12-mtl \
 ghc9.12-mtl-devel \
 ghc9.12-mtl-doc \
 ghc9.12-os-string \
 ghc9.12-os-string-devel \
 ghc9.12-os-string-doc \
 ghc9.12-parsec \
 ghc9.12-parsec-devel \
 ghc9.12-parsec-doc \
 ghc9.12-pretty \
 ghc9.12-pretty-devel \
 ghc9.12-pretty-doc \
 ghc9.12-process \
 ghc9.12-process-devel \
 ghc9.12-process-doc \
 ghc9.12-semaphore-compat \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-semaphore-compat-doc \
 ghc9.12-stm \
 ghc9.12-stm-devel \
 ghc9.12-stm-doc \
 ghc9.12-template-haskell \
 ghc9.12-template-haskell-devel \
 ghc9.12-template-haskell-doc \
 ghc9.12-terminfo \
 ghc9.12-terminfo-devel \
 ghc9.12-terminfo-doc \
 ghc9.12-text \
 ghc9.12-text-devel \
 ghc9.12-text-doc \
 ghc9.12-time \
 ghc9.12-time-devel \
 ghc9.12-time-doc \
 ghc9.12-transformers \
 ghc9.12-transformers-devel \
 ghc9.12-transformers-doc \
 ghc9.12-unix \
 ghc9.12-unix-devel \
 ghc9.12-unix-doc \
 ghc9.12-xhtml \
 ghc9.12-xhtml-devel \
 ghc9.12-xhtml-doc \
"
PACKAGES:aarch64 = " \
 ghc9.12 \
 ghc9.12-Cabal \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-doc \
 ghc9.12-Cabal-prof \
 ghc9.12-Cabal-syntax \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-Cabal-syntax-doc \
 ghc9.12-Cabal-syntax-prof \
 ghc9.12-array \
 ghc9.12-array-devel \
 ghc9.12-array-doc \
 ghc9.12-array-prof \
 ghc9.12-base \
 ghc9.12-base-devel \
 ghc9.12-base-doc \
 ghc9.12-base-prof \
 ghc9.12-binary \
 ghc9.12-binary-devel \
 ghc9.12-binary-doc \
 ghc9.12-binary-prof \
 ghc9.12-bytestring \
 ghc9.12-bytestring-devel \
 ghc9.12-bytestring-doc \
 ghc9.12-bytestring-prof \
 ghc9.12-compiler \
 ghc9.12-compiler-default \
 ghc9.12-containers \
 ghc9.12-containers-devel \
 ghc9.12-containers-doc \
 ghc9.12-containers-prof \
 ghc9.12-deepseq \
 ghc9.12-deepseq-devel \
 ghc9.12-deepseq-doc \
 ghc9.12-deepseq-prof \
 ghc9.12-devel \
 ghc9.12-directory \
 ghc9.12-directory-devel \
 ghc9.12-directory-doc \
 ghc9.12-directory-prof \
 ghc9.12-doc \
 ghc9.12-doc-index \
 ghc9.12-exceptions \
 ghc9.12-exceptions-devel \
 ghc9.12-exceptions-doc \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io \
 ghc9.12-file-io-devel \
 ghc9.12-file-io-doc \
 ghc9.12-file-io-prof \
 ghc9.12-filepath \
 ghc9.12-filepath-devel \
 ghc9.12-filepath-doc \
 ghc9.12-filepath-prof \
 ghc9.12-filesystem \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-bignum-devel \
 ghc9.12-ghc-bignum-doc \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-doc \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-boot-th-doc \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-compact \
 ghc9.12-ghc-compact-devel \
 ghc9.12-ghc-compact-doc \
 ghc9.12-ghc-compact-prof \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-doc \
 ghc9.12-ghc-experimental \
 ghc9.12-ghc-experimental-devel \
 ghc9.12-ghc-experimental-doc \
 ghc9.12-ghc-experimental-prof \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghc-heap-doc \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform \
 ghc9.12-ghc-platform-devel \
 ghc9.12-ghc-platform-doc \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghc-prof \
 ghc9.12-ghc-toolchain \
 ghc9.12-ghc-toolchain-devel \
 ghc9.12-ghc-toolchain-doc \
 ghc9.12-ghc-toolchain-prof \
 ghc9.12-ghci \
 ghc9.12-ghci-devel \
 ghc9.12-ghci-doc \
 ghc9.12-ghci-prof \
 ghc9.12-haddock-api \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-api-doc \
 ghc9.12-haddock-api-prof \
 ghc9.12-haddock-library \
 ghc9.12-haddock-library-devel \
 ghc9.12-haddock-library-doc \
 ghc9.12-haddock-library-prof \
 ghc9.12-hadrian \
 ghc9.12-haskeline \
 ghc9.12-haskeline-devel \
 ghc9.12-haskeline-doc \
 ghc9.12-haskeline-prof \
 ghc9.12-hpc \
 ghc9.12-hpc-devel \
 ghc9.12-hpc-doc \
 ghc9.12-hpc-prof \
 ghc9.12-manual \
 ghc9.12-mtl \
 ghc9.12-mtl-devel \
 ghc9.12-mtl-doc \
 ghc9.12-mtl-prof \
 ghc9.12-os-string \
 ghc9.12-os-string-devel \
 ghc9.12-os-string-doc \
 ghc9.12-os-string-prof \
 ghc9.12-parsec \
 ghc9.12-parsec-devel \
 ghc9.12-parsec-doc \
 ghc9.12-parsec-prof \
 ghc9.12-pretty \
 ghc9.12-pretty-devel \
 ghc9.12-pretty-doc \
 ghc9.12-pretty-prof \
 ghc9.12-process \
 ghc9.12-process-devel \
 ghc9.12-process-doc \
 ghc9.12-process-prof \
 ghc9.12-prof \
 ghc9.12-semaphore-compat \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-semaphore-compat-doc \
 ghc9.12-semaphore-compat-prof \
 ghc9.12-stm \
 ghc9.12-stm-devel \
 ghc9.12-stm-doc \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell \
 ghc9.12-template-haskell-devel \
 ghc9.12-template-haskell-doc \
 ghc9.12-template-haskell-prof \
 ghc9.12-terminfo \
 ghc9.12-terminfo-devel \
 ghc9.12-terminfo-doc \
 ghc9.12-terminfo-prof \
 ghc9.12-text \
 ghc9.12-text-devel \
 ghc9.12-text-doc \
 ghc9.12-text-prof \
 ghc9.12-time \
 ghc9.12-time-devel \
 ghc9.12-time-doc \
 ghc9.12-time-prof \
 ghc9.12-transformers \
 ghc9.12-transformers-devel \
 ghc9.12-transformers-doc \
 ghc9.12-transformers-prof \
 ghc9.12-unix \
 ghc9.12-unix-devel \
 ghc9.12-unix-doc \
 ghc9.12-unix-prof \
 ghc9.12-xhtml \
 ghc9.12-xhtml-devel \
 ghc9.12-xhtml-doc \
 ghc9.12-xhtml-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.12-9.12.2-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbf2f98d5bd1aef815e8837dd19755b3f1034a595a26ddd1ec64ade12b33f63a"

URI_x86_64_v2_ghc9.12 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12}"
SRC_URI[x86_64_v2_ghc9.12.sha256sum] = "9c340105a6f3e5d0c3b2ff849d6830759c14deeae7208d34ae3144d51c7929e4"

URI_x86_64_v2_ghc9.12-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-3.14.1.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal}"
SRC_URI[x86_64_v2_ghc9.12-Cabal.sha256sum] = "de8fc6813e75a5c37b147df4e537d541f42c42488bb0939dde0501aa1e69d3c6"

URI_x86_64_v2_ghc9.12-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-devel-3.14.1.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-devel.sha256sum] = "6308da43e105fe642e1efd9ffac361747ce086130be66d2ceb6804dfd79bfea9"

URI_x86_64_v2_ghc9.12-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-doc-3.14.1.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-doc.sha256sum] = "ab9c3dc154ca26e423fd4953956016f22db0e6170ab20b2b661d5837a2184b57"

URI_x86_64_v2_ghc9.12-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-syntax-3.14.1.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-syntax.sha256sum] = "91ab2481818c07db325bada0bdb0bb268047a419870830272f3943f2d2773cfb"

URI_x86_64_v2_ghc9.12-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-syntax-devel-3.14.1.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-syntax-devel.sha256sum] = "47c1b90b9ea7130607f4bf5d0fafa45ab915f518923694035ef4cab7707c08d5"

URI_x86_64_v2_ghc9.12-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-Cabal-syntax-doc-3.14.1.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc9.12-Cabal-syntax-doc.sha256sum] = "ba27725878d25881fe5008cc28dde86f66540444b9d937e5d41e9c24fd460bf9"

URI_x86_64_v2_ghc9.12-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-array-0.5.8.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-array}"
SRC_URI[x86_64_v2_ghc9.12-array.sha256sum] = "cc1a433efb0a316e36235c21eb9e7da2d4428a3c0e7f7afb3c92780b0f00bf17"

URI_x86_64_v2_ghc9.12-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-array-devel-0.5.8.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-array-devel}"
SRC_URI[x86_64_v2_ghc9.12-array-devel.sha256sum] = "f741095a820cb67fc94e4520199efa7d2a3b225a48972119363b2c79571c5325"

URI_x86_64_v2_ghc9.12-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-array-doc-0.5.8.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-array-doc}"
SRC_URI[x86_64_v2_ghc9.12-array-doc.sha256sum] = "64e4ad56071a9a92098598936649be13f85d37adccaf687d96d721c7cccc137d"

URI_x86_64_v2_ghc9.12-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-base-4.21.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-base}"
SRC_URI[x86_64_v2_ghc9.12-base.sha256sum] = "291f55fbfb2e021c18a76807ec725abe4e6a146fab328fcdab2b055c55f9c5d2"

URI_x86_64_v2_ghc9.12-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-base-devel-4.21.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-base-devel}"
SRC_URI[x86_64_v2_ghc9.12-base-devel.sha256sum] = "62fd3b9fcc29b62133b0dcc6e54dd01e20924218ee7fad91856e0660f8bf9353"

URI_x86_64_v2_ghc9.12-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-base-doc-4.21.0.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-base-doc}"
SRC_URI[x86_64_v2_ghc9.12-base-doc.sha256sum] = "2343eb081b22dcdab552c72f3bac9f8d1716a226b7a1811ae0da11bcd1ef4041"

URI_x86_64_v2_ghc9.12-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-binary-0.8.9.3-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-binary}"
SRC_URI[x86_64_v2_ghc9.12-binary.sha256sum] = "cc24c5ce3726e79a3eef2d39e6adad989aca2a94021a9d1bdd8fbea9e603f4ad"

URI_x86_64_v2_ghc9.12-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-binary-devel-0.8.9.3-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-binary-devel}"
SRC_URI[x86_64_v2_ghc9.12-binary-devel.sha256sum] = "a10034575e8db99153a91f2ebc6c4420475df66b04c5b9fe5ef3658ebe9a081d"

URI_x86_64_v2_ghc9.12-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-binary-doc-0.8.9.3-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-binary-doc}"
SRC_URI[x86_64_v2_ghc9.12-binary-doc.sha256sum] = "628fa9483b65f7dd76c0c0dd0c20f90f501e8fb318d968ee4113315d5234db7c"

URI_x86_64_v2_ghc9.12-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-bytestring-0.12.2.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-bytestring}"
SRC_URI[x86_64_v2_ghc9.12-bytestring.sha256sum] = "b645ae80eb23388e3b77aa05eace93888e7fc508e181f44ed5e167bcddd18605"

URI_x86_64_v2_ghc9.12-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-bytestring-devel-0.12.2.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.12-bytestring-devel.sha256sum] = "c521429706c0643dc12ccdb79991524c0a15ba75ac6290af21c32a9df358d367"

URI_x86_64_v2_ghc9.12-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-bytestring-doc-0.12.2.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.12-bytestring-doc.sha256sum] = "93cebe39957770d5bdbfe7f527c3b880e64e9f3ce08b3561252f957b5e610ac2"

URI_x86_64_v2_ghc9.12-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-compiler-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-compiler}"
SRC_URI[x86_64_v2_ghc9.12-compiler.sha256sum] = "94ae76b4e70830db184559d062b5358ed5beb3b7c6ce043b86ca21a2d2ff46ea"

URI_x86_64_v2_ghc9.12-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-compiler-default-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-compiler-default}"
SRC_URI[x86_64_v2_ghc9.12-compiler-default.sha256sum] = "8bea2666e1aa26850cf3c9aa2d97e0ed00581b4a62c1c9ffd6a4cb9fef50a0a5"

URI_x86_64_v2_ghc9.12-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-containers-0.7-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-containers}"
SRC_URI[x86_64_v2_ghc9.12-containers.sha256sum] = "04d0f838ee5117f9e6f1e92cbe523292df8e1a8f4f57d4edb9b232b723f17a84"

URI_x86_64_v2_ghc9.12-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-containers-devel-0.7-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-containers-devel}"
SRC_URI[x86_64_v2_ghc9.12-containers-devel.sha256sum] = "a2a6371d06009c9e12bc5ae97393c955d8882083a1aac07dfa9dd144aef04bf9"

URI_x86_64_v2_ghc9.12-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-containers-doc-0.7-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-containers-doc}"
SRC_URI[x86_64_v2_ghc9.12-containers-doc.sha256sum] = "7e03d1a123448fe84dced33c07dbd23cc1bdc2c41a51566b4fe047d2b2872c90"

URI_x86_64_v2_ghc9.12-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-deepseq-1.5.1.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-deepseq}"
SRC_URI[x86_64_v2_ghc9.12-deepseq.sha256sum] = "6c9c5b69bc4f4ae215f34304d5433b9dcd2594ed384052a5c664c4bed3213c7b"

URI_x86_64_v2_ghc9.12-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-deepseq-devel-1.5.1.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.12-deepseq-devel.sha256sum] = "7b86156ebbc325f7ec0bdefa9d0bb875a2fdeaf4e35b410ed51f0866a9449081"

URI_x86_64_v2_ghc9.12-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-deepseq-doc-1.5.1.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.12-deepseq-doc.sha256sum] = "3eb202b9e8917e129d9fad028d95cca6d2e65376273e185ffbcd80994272f3b5"

URI_x86_64_v2_ghc9.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-devel-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-devel}"
SRC_URI[x86_64_v2_ghc9.12-devel.sha256sum] = "8cd86c3804a6b1ac6168b1ca3d822f75306a30a4e3d0277ee7d7bf9d0278dbf3"

URI_x86_64_v2_ghc9.12-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-directory-1.3.9.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-directory}"
SRC_URI[x86_64_v2_ghc9.12-directory.sha256sum] = "d7e9b80ebd8f27d31b74bbb2cf49068de6eea7ccfee6561bcfc8c848d7af16ec"

URI_x86_64_v2_ghc9.12-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-directory-devel-1.3.9.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-directory-devel}"
SRC_URI[x86_64_v2_ghc9.12-directory-devel.sha256sum] = "2db3320360a6bbcecc261815a16f8ee830ec1dde00f41c6e680cd5608a4a44f7"

URI_x86_64_v2_ghc9.12-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-directory-doc-1.3.9.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-directory-doc}"
SRC_URI[x86_64_v2_ghc9.12-directory-doc.sha256sum] = "8bbb96f02e45ad2b629f2c29c30cbe2b3cd0f7bea1ddd6e08602c8d6bf51edf4"

URI_x86_64_v2_ghc9.12-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-doc-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-doc}"
SRC_URI[x86_64_v2_ghc9.12-doc.sha256sum] = "2a7357d35e035a2b6730e54fd32d59fe86e6759cb2e6c5141295533fd38d17c5"

URI_x86_64_v2_ghc9.12-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-doc-index-9.12.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-doc-index}"
SRC_URI[x86_64_v2_ghc9.12-doc-index.sha256sum] = "8b254fedbac1dbd5e3c94eea039832ee35b15d2f21f2034d1b3729ec0308bcd1"

URI_x86_64_v2_ghc9.12-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-exceptions-0.10.9-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-exceptions}"
SRC_URI[x86_64_v2_ghc9.12-exceptions.sha256sum] = "17396c79454e178452e62ca673b42eae9f9c4d2cccdfe4e9e879eebfa6ef6738"

URI_x86_64_v2_ghc9.12-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-exceptions-devel-0.10.9-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.12-exceptions-devel.sha256sum] = "bc185f2c173ff0f926960172d5935d88fbbe9d0da737f8a5eacc5364efdccdb2"

URI_x86_64_v2_ghc9.12-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-exceptions-doc-0.10.9-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.12-exceptions-doc.sha256sum] = "c3d7d840260b950d9abf2c4894176046c7165bdf1d40c3f0b92f65122023ad1b"

URI_x86_64_v2_ghc9.12-file-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-file-io-0.1.5-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-file-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-file-io}"
SRC_URI[x86_64_v2_ghc9.12-file-io.sha256sum] = "845f397097c4403ed7293bc10e18edb18448f630deb370f32e858323d7d58215"

URI_x86_64_v2_ghc9.12-file-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-file-io-devel-0.1.5-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-file-io-devel}"
SRC_URI[x86_64_v2_ghc9.12-file-io-devel.sha256sum] = "742df0e71d7e68e0c73ee5e6ebd3e7afb64004b3914c4aaae5ab14eec5ebd1a6"

URI_x86_64_v2_ghc9.12-file-io-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-file-io-doc-0.1.5-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-file-io-doc}"
SRC_URI[x86_64_v2_ghc9.12-file-io-doc.sha256sum] = "5f1478dfe578fa54f52db9bcb3352fa0771aa4b4f1b4c30cf448a12e9c593196"

URI_x86_64_v2_ghc9.12-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filepath-1.5.4.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filepath}"
SRC_URI[x86_64_v2_ghc9.12-filepath.sha256sum] = "6f1b6048befe1b981c4adaa74df917fadeb07211b73428f5f1371947d8215a4a"

URI_x86_64_v2_ghc9.12-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filepath-devel-1.5.4.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.12-filepath-devel.sha256sum] = "e2df202b51bd013832cce2726767a912b5363fceba28408a832507531574eb49"

URI_x86_64_v2_ghc9.12-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filepath-doc-1.5.4.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.12-filepath-doc.sha256sum] = "10d040b42c1cdf5aed067a3e3c4f34db58180371cd5bae341709b53fbbac392d"

URI_x86_64_v2_ghc9.12-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-filesystem-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-filesystem}"
SRC_URI[x86_64_v2_ghc9.12-filesystem.sha256sum] = "dcbae2b1a66d9bfb94a2ffdd677e748387988f8c614c67e7532a0e50ef8f1d3f"

URI_x86_64_v2_ghc9.12-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc}"
SRC_URI[x86_64_v2_ghc9.12-ghc.sha256sum] = "162be587814fe90c373ea8e485968c45350491586beffcf1cee923114dc5a563"

URI_x86_64_v2_ghc9.12-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-bignum-1.3-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.12-ghc-bignum.sha256sum] = "ff3b01279ee089cdbf1410a122639e03b3b92413e4d0f018f4c60b33d728c19d"

URI_x86_64_v2_ghc9.12-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-bignum-devel-1.3-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-bignum-devel.sha256sum] = "889886e16e0d63da326969c80fb16e06fa4464b28ca0b3ad0a34456094de9441"

URI_x86_64_v2_ghc9.12-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-bignum-doc-1.3-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-bignum-doc.sha256sum] = "c4c451e3390772b840545407f822356a623ff4530a4146bf9e99f7cdd1e55e16"

URI_x86_64_v2_ghc9.12-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot.sha256sum] = "b99f1dcca3650e723c29eba4349388e0e260f904a4a30ea6c127f3b901336532"

URI_x86_64_v2_ghc9.12-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-devel-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-devel.sha256sum] = "cf7b37957bb0d092e96271a02fa1f0cd0ff0c119ec192608de6149a00b677b85"

URI_x86_64_v2_ghc9.12-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-doc-9.12.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-doc.sha256sum] = "bea3977434af641273dbf101c3dd295d429542732ae505c71e8012672cbbe8b7"

URI_x86_64_v2_ghc9.12-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-th-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-th.sha256sum] = "c66634cd06aa4e0d325b6d56c2c0f7fce4d38d9919eb70dd2476fb1c507e4573"

URI_x86_64_v2_ghc9.12-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-th-devel-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-th-devel.sha256sum] = "d5fe10bc994acb9301c1b791282f39af981e0e3c415faa2dd308a6afdffa5f4c"

URI_x86_64_v2_ghc9.12-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-boot-th-doc-9.12.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-boot-th-doc.sha256sum] = "163dd6b000039c4cd7f480ec4bc611929bb7b465f9807f0e9debc8032667f842"

URI_x86_64_v2_ghc9.12-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-compact-0.1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.12-ghc-compact.sha256sum] = "de8d851f474cf83826ccf62fcab595d1b7b19ee3e2f01a1d463b5ba3b2279d3a"

URI_x86_64_v2_ghc9.12-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-compact-devel-0.1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-compact-devel.sha256sum] = "7ab6516a179df9b2434636ce20ddef095050a93a0ab68614e1570b90a3aebe20"

URI_x86_64_v2_ghc9.12-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-compact-doc-0.1.0.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-compact-doc.sha256sum] = "ebd067b890b48967fbe66b478574a1c19d9482844638be7a51abecd070d73b2d"

URI_x86_64_v2_ghc9.12-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-devel-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-devel.sha256sum] = "5a980c881b91fa0d4f18ba8d937c504bc8b23fd52671e890ea4a002646315e99"

URI_x86_64_v2_ghc9.12-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-doc-9.12.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-doc.sha256sum] = "67deccc4b53144b329b63449d388b6f3ef93cdd5af18489c676bb4b09daec474"

URI_x86_64_v2_ghc9.12-ghc-experimental = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-experimental-9.1202.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-experimental}"
SRC_URI[x86_64_v2_ghc9.12-ghc-experimental.sha256sum] = "3053ca1cd78cef7ae90e79c34363c14ff8014f11ea9178b0d3935cc734eae6cb"

URI_x86_64_v2_ghc9.12-ghc-experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-experimental-devel-9.1202.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-experimental-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-experimental-devel.sha256sum] = "05838d9dd43df5ec478543f981bf1d98f582893284fda739efd935b4b69d38eb"

URI_x86_64_v2_ghc9.12-ghc-experimental-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-experimental-doc-9.1202.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-experimental-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-experimental-doc.sha256sum] = "30627fe190d2ee7f01dba64acfb7b9279aacfbbd0eeebc7384f299c64c34f6c6"

URI_x86_64_v2_ghc9.12-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-heap-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.12-ghc-heap.sha256sum] = "a99d608b286d19d8a4229b5d143f5ab44becf32df9f82ec8ba2a999f17db5d31"

URI_x86_64_v2_ghc9.12-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-heap-devel-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-heap-devel.sha256sum] = "3228240b5f87ab240e51c5327ae0d4704335e401609a68b5bc33b084a7fb7fbc"

URI_x86_64_v2_ghc9.12-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-heap-doc-9.12.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-heap-doc.sha256sum] = "486e1ef0026f6caff7d0d04a3ba95e2beabcf8e7b55d979406fc77f8bc0e7ce9"

URI_x86_64_v2_ghc9.12-ghc-platform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-platform-0.1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-platform}"
SRC_URI[x86_64_v2_ghc9.12-ghc-platform.sha256sum] = "b3dc16154e428c916b5a6e892773a117e9cd072caffee0205bfcb3bc0ba9fa26"

URI_x86_64_v2_ghc9.12-ghc-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-platform-devel-0.1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-platform-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-platform-devel.sha256sum] = "caf45dbd62c4ef37e81132b54a81b52fcc2a1568d9d4228dd38537b8c1794f13"

URI_x86_64_v2_ghc9.12-ghc-platform-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-platform-doc-0.1.0.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-platform-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-platform-doc.sha256sum] = "1712c1a79121cf7bcc25dd9123f9385c16e883aa070e6bdc6ec8fab8cb7adca7"

URI_x86_64_v2_ghc9.12-ghc-toolchain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-toolchain-0.1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-toolchain}"
SRC_URI[x86_64_v2_ghc9.12-ghc-toolchain.sha256sum] = "f5f417e8d83f2c6adc39ae2535a44d934f4082b9486a759188fcc07093247958"

URI_x86_64_v2_ghc9.12-ghc-toolchain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-toolchain-devel-0.1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-toolchain-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghc-toolchain-devel.sha256sum] = "b64f206a6ac03a197256675b681a8b67c01fb6a881207b5f9cde445fb205090e"

URI_x86_64_v2_ghc9.12-ghc-toolchain-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghc-toolchain-doc-0.1.0.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghc-toolchain-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghc-toolchain-doc.sha256sum] = "0b2288ebd96cabf8badfd3062efa3e75eb34c35b4463c9afe318c8c060b681a2"

URI_x86_64_v2_ghc9.12-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghci-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghci}"
SRC_URI[x86_64_v2_ghc9.12-ghci.sha256sum] = "f31d004efba11eef7d6176e5ab985401838534f2028acd1839f92c411ad0f408"

URI_x86_64_v2_ghc9.12-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghci-devel-9.12.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.12-ghci-devel.sha256sum] = "6e7ce6e04b8314f3ef87b9b7e05af657246d81e8c4eb54f9eccfda48de40c2db"

URI_x86_64_v2_ghc9.12-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-ghci-doc-9.12.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.12-ghci-doc.sha256sum] = "57d708eda9e9623d77cfc8fec0d2429558db456586a226e441b53af5ef4ed9ba"

URI_x86_64_v2_ghc9.12-haddock-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-api-2.30.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-api}"
SRC_URI[x86_64_v2_ghc9.12-haddock-api.sha256sum] = "64facbcf931db02c82c4d5b814ace3cf17c9ea0100971c25a0c95f93367a9a57"

URI_x86_64_v2_ghc9.12-haddock-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-api-devel-2.30.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-api-devel}"
SRC_URI[x86_64_v2_ghc9.12-haddock-api-devel.sha256sum] = "fd2195a61ccf7ca0c728000a55a567b36b4a56cca762ccb380e8a18f1e705aac"

URI_x86_64_v2_ghc9.12-haddock-api-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-api-doc-2.30.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-haddock-api-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-api-doc}"
SRC_URI[x86_64_v2_ghc9.12-haddock-api-doc.sha256sum] = "29ab128279fa813f6c4f1cfaf331638bfbdb0c9361b66a05893f02da9be59dbe"

URI_x86_64_v2_ghc9.12-haddock-library = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-library-1.11.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-library;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-library}"
SRC_URI[x86_64_v2_ghc9.12-haddock-library.sha256sum] = "f68eb7c400512bc9e388b64bd99872c4f999eea539e91c2067846204fe051219"

URI_x86_64_v2_ghc9.12-haddock-library-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-library-devel-1.11.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-library-devel}"
SRC_URI[x86_64_v2_ghc9.12-haddock-library-devel.sha256sum] = "9e0965d00ce143c813e43580436b3e2ab70368b500cf3b2f319d77f68a03e770"

URI_x86_64_v2_ghc9.12-haddock-library-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haddock-library-doc-1.11.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haddock-library-doc}"
SRC_URI[x86_64_v2_ghc9.12-haddock-library-doc.sha256sum] = "e990c63f3fc02ca7d31b3e8cf455c30269e27eb7ef80749eff1c3ba0899976a4"

URI_x86_64_v2_ghc9.12-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hadrian-0.1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hadrian}"
SRC_URI[x86_64_v2_ghc9.12-hadrian.sha256sum] = "11e30802e55760273c9e7e1b40770cc145923b6ad372bee235fc07baa5827f8c"

URI_x86_64_v2_ghc9.12-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haskeline-0.8.2.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haskeline}"
SRC_URI[x86_64_v2_ghc9.12-haskeline.sha256sum] = "f8fc99a410765bb193dc8d3ad1b8af57b928ec00d4b874b58bd15d61c5aa562a"

URI_x86_64_v2_ghc9.12-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haskeline-devel-0.8.2.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.12-haskeline-devel.sha256sum] = "ca573b45a8e3b013019cd07023c17b4f1e5dd595cc49dba0995ce40b5573377b"

URI_x86_64_v2_ghc9.12-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-haskeline-doc-0.8.2.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.12-haskeline-doc.sha256sum] = "e2949ef6a7ee1594ee2de72a41badc80776fffa15d69ff20158185f9551a717d"

URI_x86_64_v2_ghc9.12-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hpc-0.7.0.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hpc}"
SRC_URI[x86_64_v2_ghc9.12-hpc.sha256sum] = "414ba4e39864b63d3f4bdfcb3100872bd3b6a7408c93ae12c655a8f1a97b94c8"

URI_x86_64_v2_ghc9.12-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hpc-devel-0.7.0.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.12-hpc-devel.sha256sum] = "97d7fd23161a04904514642a069ccf2ccb180e33b6c09b8086eeb68e4b791b43"

URI_x86_64_v2_ghc9.12-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-hpc-doc-0.7.0.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.12-hpc-doc.sha256sum] = "72e4a1912ac8e2fd68d37336a6eb16c1779110d8a3685a310c8bdfb807991e65"

URI_x86_64_v2_ghc9.12-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-manual-9.12.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-manual}"
SRC_URI[x86_64_v2_ghc9.12-manual.sha256sum] = "e3726b07e6f5fe549fa1608021671b3be019a21bc5d29f002d722c4edab2422e"

URI_x86_64_v2_ghc9.12-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-mtl-2.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-mtl}"
SRC_URI[x86_64_v2_ghc9.12-mtl.sha256sum] = "200f425849c004b0c8fb76b8b02c3f47db645f9567970f654e6a72f07dcf692e"

URI_x86_64_v2_ghc9.12-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-mtl-devel-2.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.12-mtl-devel.sha256sum] = "1c14d01c12c28510f58ca231439f217408e326be212db4a2758fd298b2803904"

URI_x86_64_v2_ghc9.12-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-mtl-doc-2.3.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.12-mtl-doc.sha256sum] = "1905b4c6687b10b7a99680d04d1368580b98b050b9a255348301e6ea8b4c162d"

URI_x86_64_v2_ghc9.12-os-string = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-os-string-2.0.7-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-os-string;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-os-string}"
SRC_URI[x86_64_v2_ghc9.12-os-string.sha256sum] = "df8e169f9fb36a2aaaf839c2bd2346ca7b639e0c1f06374d0243ef9207267596"

URI_x86_64_v2_ghc9.12-os-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-os-string-devel-2.0.7-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-os-string-devel}"
SRC_URI[x86_64_v2_ghc9.12-os-string-devel.sha256sum] = "a414e2bb4dd4da7cb4a76ddc2cfcbeebe9e533fe4bfe56f76011941258e3fe49"

URI_x86_64_v2_ghc9.12-os-string-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-os-string-doc-2.0.7-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-os-string-doc}"
SRC_URI[x86_64_v2_ghc9.12-os-string-doc.sha256sum] = "6d8c3677937f0c176a0341ea333e22119664a2c9b411147e7ed0bfa14405669d"

URI_x86_64_v2_ghc9.12-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-parsec-3.1.18.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-parsec}"
SRC_URI[x86_64_v2_ghc9.12-parsec.sha256sum] = "b53226b21e7046b27eee34745596ca34944cbd4422526d677c8c69fe901c04ca"

URI_x86_64_v2_ghc9.12-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-parsec-devel-3.1.18.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.12-parsec-devel.sha256sum] = "7d74f7e79627c2a769ea48d36a36ef4ea65f932d1070bf7bd55a338b966c41c4"

URI_x86_64_v2_ghc9.12-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-parsec-doc-3.1.18.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.12-parsec-doc.sha256sum] = "4c3dba40655c2f977a5655cac91b2eb72a5cea49aebf520fb59ccfb880c6fdfc"

URI_x86_64_v2_ghc9.12-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-pretty-1.1.3.6-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-pretty}"
SRC_URI[x86_64_v2_ghc9.12-pretty.sha256sum] = "3e22a77d463f31c2ee49ea45835f40f444c9a441760cd6b490caebe781056172"

URI_x86_64_v2_ghc9.12-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-pretty-devel-1.1.3.6-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.12-pretty-devel.sha256sum] = "f02c2150b1d2549019b8cace3e68fb683d0a75d0a7ce97d80daae161fd39ae1a"

URI_x86_64_v2_ghc9.12-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-pretty-doc-1.1.3.6-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.12-pretty-doc.sha256sum] = "fe5baa51fa61448e49a42b4978ddb1b7acd7813b98d425decdc87ffdef2ee2ad"

URI_x86_64_v2_ghc9.12-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-process-1.6.25.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-process}"
SRC_URI[x86_64_v2_ghc9.12-process.sha256sum] = "c5bf2033a00adda2774a32a1448e3a7382feb307ea3ba2fbe111c824069fc1fe"

URI_x86_64_v2_ghc9.12-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-process-devel-1.6.25.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-process-devel}"
SRC_URI[x86_64_v2_ghc9.12-process-devel.sha256sum] = "d0dc59368c4865c40f04ca5619074f45bdfb435ff744cc09d0351b36f722843f"

URI_x86_64_v2_ghc9.12-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-process-doc-1.6.25.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-process-doc}"
SRC_URI[x86_64_v2_ghc9.12-process-doc.sha256sum] = "f87c55d6316c3768388d9cad08d1c6f781f61575903fa04995b90d0674ef35ed"

URI_x86_64_v2_ghc9.12-semaphore-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-semaphore-compat-1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-semaphore-compat}"
SRC_URI[x86_64_v2_ghc9.12-semaphore-compat.sha256sum] = "fa9aa8140047e8330855376bf03128c08c713e950ec292b39aea7e61a6d7db3c"

URI_x86_64_v2_ghc9.12-semaphore-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-semaphore-compat-devel-1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-semaphore-compat-devel}"
SRC_URI[x86_64_v2_ghc9.12-semaphore-compat-devel.sha256sum] = "b5d7ac597dfe1cdf31fe73ed37c7faa284ac81da582197ef2f4750405b61eeb7"

URI_x86_64_v2_ghc9.12-semaphore-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-semaphore-compat-doc-1.0.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-semaphore-compat-doc}"
SRC_URI[x86_64_v2_ghc9.12-semaphore-compat-doc.sha256sum] = "bdb9497ff9ec9274b5e381c0813f23f472cf475c1e132e73e33b32bf0dc0ea9c"

URI_x86_64_v2_ghc9.12-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-stm-2.5.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-stm}"
SRC_URI[x86_64_v2_ghc9.12-stm.sha256sum] = "01e81ff52c528f4f53094105c79f3a8b5eccb2d655321dfc791b9180f5cc7afc"

URI_x86_64_v2_ghc9.12-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-stm-devel-2.5.3.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-stm-devel}"
SRC_URI[x86_64_v2_ghc9.12-stm-devel.sha256sum] = "19bff739e4741a7798e5fa04aeb6fa2ef5a6dc2d3dd21458ba5f6fbd4ffb0ddf"

URI_x86_64_v2_ghc9.12-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-stm-doc-2.5.3.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-stm-doc}"
SRC_URI[x86_64_v2_ghc9.12-stm-doc.sha256sum] = "e7f6667e9edc7d1badf292457963d0e196ea47f35a1de9813f53b6f838c99461"

URI_x86_64_v2_ghc9.12-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-template-haskell-2.23.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-template-haskell}"
SRC_URI[x86_64_v2_ghc9.12-template-haskell.sha256sum] = "3dd92d1f0f7d5527fe92589901b4d35e61131ca0dd59b2ae4dbe1212f241c22c"

URI_x86_64_v2_ghc9.12-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-template-haskell-devel-2.23.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.12-template-haskell-devel.sha256sum] = "0a2a3e68acec3a9d3abfd777a2cb6dfbace4be761f353d0930cb8d6f144ea1d1"

URI_x86_64_v2_ghc9.12-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-template-haskell-doc-2.23.0.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.12-template-haskell-doc.sha256sum] = "677aeee5943517ee8219a02df9fb9309a601634d033b52414998e03908646c7e"

URI_x86_64_v2_ghc9.12-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-terminfo-0.4.1.7-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-terminfo}"
SRC_URI[x86_64_v2_ghc9.12-terminfo.sha256sum] = "225598d164c180844e7f5f070a92efee06d2ffe177b47796ffaa2ae66db7c271"

URI_x86_64_v2_ghc9.12-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-terminfo-devel-0.4.1.7-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.12-terminfo-devel.sha256sum] = "bacb67db10b17d5d65b6191aa10039439bc85ece6995ab064e67ae86897a6c28"

URI_x86_64_v2_ghc9.12-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-terminfo-doc-0.4.1.7-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.12-terminfo-doc.sha256sum] = "5d89eb441c78ba2051aba2345357ffae04b2519aa53d2e3d6c868998165a40e1"

URI_x86_64_v2_ghc9.12-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-text-2.1.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-text}"
SRC_URI[x86_64_v2_ghc9.12-text.sha256sum] = "08a992f84156cbbd1e510b95ea0880a547b65615f3224ed04dc8b0a58c859501"

URI_x86_64_v2_ghc9.12-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-text-devel-2.1.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-text-devel}"
SRC_URI[x86_64_v2_ghc9.12-text-devel.sha256sum] = "5ae0f797bee28f690c2539183f52098bdd32e5133162f8d0b6785c9887ce7e25"

URI_x86_64_v2_ghc9.12-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-text-doc-2.1.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-text-doc}"
SRC_URI[x86_64_v2_ghc9.12-text-doc.sha256sum] = "68858b291a4ba64ec8653b8cf3fc0aae42286b1c89bafa6571e226b6e1eb91ed"

URI_x86_64_v2_ghc9.12-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-time-1.14-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-time}"
SRC_URI[x86_64_v2_ghc9.12-time.sha256sum] = "83e1768908094075cf4cedc8e0fcc5c6f09ac13f4120224d899e141c1b703fb1"

URI_x86_64_v2_ghc9.12-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-time-devel-1.14-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-time-devel}"
SRC_URI[x86_64_v2_ghc9.12-time-devel.sha256sum] = "ae35819cdcb9a0a89a50606c4740e8349c24ed5cdbaeca675d76d616105dee81"

URI_x86_64_v2_ghc9.12-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-time-doc-1.14-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-time-doc}"
SRC_URI[x86_64_v2_ghc9.12-time-doc.sha256sum] = "e11a209d77b6425cc96a11d253235a6c815ebfac36499f6e36db79590029cf83"

URI_x86_64_v2_ghc9.12-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-transformers-0.6.1.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-transformers}"
SRC_URI[x86_64_v2_ghc9.12-transformers.sha256sum] = "f10875beecaa18683381c1aba9e4b04789d37c9d246b6fc286422a238a08a804"

URI_x86_64_v2_ghc9.12-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-transformers-devel-0.6.1.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.12-transformers-devel.sha256sum] = "e6d88ea044e30bb83018d80190688fffc8294c49bddae9db4ea11eac56f46616"

URI_x86_64_v2_ghc9.12-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-transformers-doc-0.6.1.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.12-transformers-doc.sha256sum] = "4ae69f89fe3f17b24b7621974aa3a685a479956fc8065daf11f3a9e2c44a8cfe"

URI_x86_64_v2_ghc9.12-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-unix-2.8.6.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-unix}"
SRC_URI[x86_64_v2_ghc9.12-unix.sha256sum] = "7613247968847921b6b162e49d03e4b8bcd48e84dcbaa5aa8474b06af1045794"

URI_x86_64_v2_ghc9.12-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-unix-devel-2.8.6.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-unix-devel}"
SRC_URI[x86_64_v2_ghc9.12-unix-devel.sha256sum] = "65ceae418d7edf80494dc7de967e7b13135cc5ad92a172f84c49f418a7122834"

URI_x86_64_v2_ghc9.12-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-unix-doc-2.8.6.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-unix-doc}"
SRC_URI[x86_64_v2_ghc9.12-unix-doc.sha256sum] = "90c54b43f30f04768dc8f5873d3aac71945f664bc659da7318893bc86b82ec21"

URI_x86_64_v2_ghc9.12-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-xhtml-3000.2.2.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-xhtml}"
SRC_URI[x86_64_v2_ghc9.12-xhtml.sha256sum] = "8010c9c3f16cd6e3395629f336ecc59db8fef7c6d2c4e4349fc92e7f88dfba01"

URI_x86_64_v2_ghc9.12-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-xhtml-devel-3000.2.2.1-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.12-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.12-xhtml-devel.sha256sum] = "3c8b25300fae10e5dc2a66899b7d4523fddf8115129657333a2fa39f3de1b051"

URI_x86_64_v2_ghc9.12-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.12-xhtml-doc-3000.2.2.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.12-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.12-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.12-xhtml-doc.sha256sum] = "95a347c3c11cb8d1ba678d6910d615e226d5d777d8d7c172eab0d9127fd54ecd"

URI_aarch64_ghc9.12 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12}"
SRC_URI[aarch64_ghc9.12.sha256sum] = "caaa4820ba2f82b05ad0df93cc37da2d90ecfbb1b4294dde7e19cbda95a13a8c"

URI_aarch64_ghc9.12-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-3.14.1.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal}"
SRC_URI[aarch64_ghc9.12-Cabal.sha256sum] = "96f18b3c97ca67773444f169be6510cff3c951bb7b6380983b265d7e671da15f"

URI_aarch64_ghc9.12-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-devel-3.14.1.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-devel}"
SRC_URI[aarch64_ghc9.12-Cabal-devel.sha256sum] = "b551d171e2e7ce546eb548db9e7fefe83c9b2827cd5b6e5dc11a8089b881ae6c"

URI_aarch64_ghc9.12-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-doc-3.14.1.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-doc}"
SRC_URI[aarch64_ghc9.12-Cabal-doc.sha256sum] = "74d6a71c7c44fd4b21e2501ad37bf25f9a883c5b30e57d48efd62b7d53eb3f31"

URI_aarch64_ghc9.12-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-prof-3.14.1.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-prof}"
SRC_URI[aarch64_ghc9.12-Cabal-prof.sha256sum] = "2c6a12edb4e35004ed639636bca667015d03732134f6e91d45e22584b729f4ce"

URI_aarch64_ghc9.12-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-3.14.1.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax.sha256sum] = "0b7b9314a1e2616b4e828db20383b2e8c440fc64c4d8174aae0f36ecdea20710"

URI_aarch64_ghc9.12-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-devel-3.14.1.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax-devel.sha256sum] = "3010a64c7d3bcd62a703663fc27ba83b7e91df1e923dc635395222b6fbb5e70a"

URI_aarch64_ghc9.12-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-doc-3.14.1.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax-doc.sha256sum] = "5f81f7111ad4e399b3c0810654f165ec3312096e83e3ae17322d2b9330be285d"

URI_aarch64_ghc9.12-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-Cabal-syntax-prof-3.14.1.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc9.12-Cabal-syntax-prof.sha256sum] = "b0de9c30c20ed9954a72b424cd6e01e860fae290f9326fad4d61add6262cc70a"

URI_aarch64_ghc9.12-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-0.5.8.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array}"
SRC_URI[aarch64_ghc9.12-array.sha256sum] = "1311029cbf9c009cccaf6886a49f3affcae57c58907e306d8fc0ee4e07ffc041"

URI_aarch64_ghc9.12-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-devel-0.5.8.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array-devel}"
SRC_URI[aarch64_ghc9.12-array-devel.sha256sum] = "e1ed5656a1fc82fdf5514770fd41e4793b8c45fb9ddfba9f435553583d0dd0eb"

URI_aarch64_ghc9.12-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-doc-0.5.8.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array-doc}"
SRC_URI[aarch64_ghc9.12-array-doc.sha256sum] = "861b28ebe088189041b5a6d16e4ef6fdc7d8ea3642543815ac44e29f15a9e87b"

URI_aarch64_ghc9.12-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-array-prof-0.5.8.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-array-prof}"
SRC_URI[aarch64_ghc9.12-array-prof.sha256sum] = "779bf227fdbdcc8b067be6bbb8f78b24f45c756935a93635bbd3446f9510db6a"

URI_aarch64_ghc9.12-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-4.21.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base}"
SRC_URI[aarch64_ghc9.12-base.sha256sum] = "b978cf40eb3dab1bc33f529c76ab7354247fd7800b119837d93c0756dc616715"

URI_aarch64_ghc9.12-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-devel-4.21.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base-devel}"
SRC_URI[aarch64_ghc9.12-base-devel.sha256sum] = "21e62b9fb7fac177c61b1b3105f10e1454d8b04d168626e8e764772f6510bc49"

URI_aarch64_ghc9.12-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-doc-4.21.0.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base-doc}"
SRC_URI[aarch64_ghc9.12-base-doc.sha256sum] = "2c6196ad995967d0654ebe716c59a378c892f05f4cce080b36f2765ce506b2f4"

URI_aarch64_ghc9.12-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-base-prof-4.21.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-base-prof}"
SRC_URI[aarch64_ghc9.12-base-prof.sha256sum] = "436b0e5ee36ea2845f70f22d03fa78c97eb773ba9832d1dd8da2f7f4442779ab"

URI_aarch64_ghc9.12-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-0.8.9.3-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary}"
SRC_URI[aarch64_ghc9.12-binary.sha256sum] = "e6399e5959b88d3b070f47038e977cb812166767775f28a6f223711e69cb7ef5"

URI_aarch64_ghc9.12-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-devel-0.8.9.3-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary-devel}"
SRC_URI[aarch64_ghc9.12-binary-devel.sha256sum] = "2bb5a0e68b397c095c42a3efbee4c051cab4839a824ac59da065352d49e43fea"

URI_aarch64_ghc9.12-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-doc-0.8.9.3-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary-doc}"
SRC_URI[aarch64_ghc9.12-binary-doc.sha256sum] = "896216130e0e8b013d78dc5dc9ad18f111dac56fa84e68f752f43f0962f50ce7"

URI_aarch64_ghc9.12-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-binary-prof-0.8.9.3-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-binary-prof}"
SRC_URI[aarch64_ghc9.12-binary-prof.sha256sum] = "3ecc298502a863d02e015efb57d481b605f4e0c66a02e050026086ce17dd532e"

URI_aarch64_ghc9.12-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-0.12.2.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring}"
SRC_URI[aarch64_ghc9.12-bytestring.sha256sum] = "c6b68376bc6d9d1dbbbda092d1328b38296178cdcf1449c7ea8db3112aae3368"

URI_aarch64_ghc9.12-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-devel-0.12.2.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring-devel}"
SRC_URI[aarch64_ghc9.12-bytestring-devel.sha256sum] = "7450509fcb0f39880e619a199e849fbc480401261b2d9945c9abe22a1fd69fe5"

URI_aarch64_ghc9.12-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-doc-0.12.2.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring-doc}"
SRC_URI[aarch64_ghc9.12-bytestring-doc.sha256sum] = "40c02e77da8d2cd43db54c375d9b4b1578e83e50a7036c6fa88e9b7c7e5f8fd5"

URI_aarch64_ghc9.12-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-bytestring-prof-0.12.2.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-bytestring-prof}"
SRC_URI[aarch64_ghc9.12-bytestring-prof.sha256sum] = "23f26163d7370d1058f4e7e7379d148fdef27cfb0f385d8649b160a90e3e2fc5"

URI_aarch64_ghc9.12-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-compiler-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-compiler}"
SRC_URI[aarch64_ghc9.12-compiler.sha256sum] = "c892a1f22ff60bd5ffa51e726f2ad63f201a61690c45f62d95fb353b8a6f90bc"

URI_aarch64_ghc9.12-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-compiler-default-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-compiler-default}"
SRC_URI[aarch64_ghc9.12-compiler-default.sha256sum] = "e3ad3d3756fb39c6ec633f61059c2933950e78901045c1408ebfe372de507def"

URI_aarch64_ghc9.12-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-0.7-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers}"
SRC_URI[aarch64_ghc9.12-containers.sha256sum] = "fb868921642995dff0edd1713b5d34f105f0f189f6a431cd627cd242992b2edf"

URI_aarch64_ghc9.12-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-devel-0.7-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers-devel}"
SRC_URI[aarch64_ghc9.12-containers-devel.sha256sum] = "d1644a11b16c974d44e3ac06201f2fcf02d538de3bd6c3eac304fd4b161e6861"

URI_aarch64_ghc9.12-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-doc-0.7-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers-doc}"
SRC_URI[aarch64_ghc9.12-containers-doc.sha256sum] = "36686e3aec8e8eba38c2a51fbd3df7fe5e25d9b154b68a31fe5839e4a23a0393"

URI_aarch64_ghc9.12-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-containers-prof-0.7-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-containers-prof}"
SRC_URI[aarch64_ghc9.12-containers-prof.sha256sum] = "dde15866d29b897bd05c81b0bc9dd877d116b66a049cc3455837b69dcfe00609"

URI_aarch64_ghc9.12-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-1.5.1.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq}"
SRC_URI[aarch64_ghc9.12-deepseq.sha256sum] = "edb9fedefeee1f433e9fd2222db3ee9b7078d7c3ca8e440aa28aa261b456f98c"

URI_aarch64_ghc9.12-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-devel-1.5.1.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq-devel}"
SRC_URI[aarch64_ghc9.12-deepseq-devel.sha256sum] = "a42b673a464142834f25ae87a9b9eb0b39258ab628ea8ec114037dcdf1ed87e3"

URI_aarch64_ghc9.12-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-doc-1.5.1.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq-doc}"
SRC_URI[aarch64_ghc9.12-deepseq-doc.sha256sum] = "baad3979f973aec5cf9b8a18fea5541180b0bad604d8efb6636b0a4c3c1bcb87"

URI_aarch64_ghc9.12-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-deepseq-prof-1.5.1.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-deepseq-prof}"
SRC_URI[aarch64_ghc9.12-deepseq-prof.sha256sum] = "51537134af2210d5e1c5e7a37232a4073371f53730e4e270ef11148565805d31"

URI_aarch64_ghc9.12-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-devel-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-devel}"
SRC_URI[aarch64_ghc9.12-devel.sha256sum] = "e41b6a45fa7f5a1fc43a266b08beb3c58561ebad4dc4931f8a2ab7b039327a3d"

URI_aarch64_ghc9.12-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-1.3.9.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory}"
SRC_URI[aarch64_ghc9.12-directory.sha256sum] = "d004c281d1706329f2b1027c7c8fbe1ba249079ce27ff0aafe47726c402e6dde"

URI_aarch64_ghc9.12-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-devel-1.3.9.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory-devel}"
SRC_URI[aarch64_ghc9.12-directory-devel.sha256sum] = "2923894dd27d694a8bee731b6ed6df01e422745534bdb324aee63d104eedc832"

URI_aarch64_ghc9.12-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-doc-1.3.9.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory-doc}"
SRC_URI[aarch64_ghc9.12-directory-doc.sha256sum] = "79bf7d7aa5024fa6e3558c205c14d010a24b303dc8e6c8327bfacbb535cf6303"

URI_aarch64_ghc9.12-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-directory-prof-1.3.9.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-directory-prof}"
SRC_URI[aarch64_ghc9.12-directory-prof.sha256sum] = "ec6050e3620b8937f8f85600ca84e7c2fbcb4baf18c4c68f90e43006c8a62eb8"

URI_aarch64_ghc9.12-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-doc-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-doc}"
SRC_URI[aarch64_ghc9.12-doc.sha256sum] = "8bfc938270787c1f9804054b389ba37dec86457632bdca3dfa5cb0fecfbba4df"

URI_aarch64_ghc9.12-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-doc-index-9.12.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-doc-index}"
SRC_URI[aarch64_ghc9.12-doc-index.sha256sum] = "2df06b6640abfba9012cebfe98d54965ad80ea70f016d80310c8cb07c1ea7a05"

URI_aarch64_ghc9.12-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-0.10.9-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions}"
SRC_URI[aarch64_ghc9.12-exceptions.sha256sum] = "f52b59f817a6eadef2fc124b32ad831c3c7edf39249ad2d1a731300cb8e6ec8b"

URI_aarch64_ghc9.12-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-devel-0.10.9-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions-devel}"
SRC_URI[aarch64_ghc9.12-exceptions-devel.sha256sum] = "bc5fef5740d3f945dfeda6405a1a435df0fd36f14a86ba0ea234afec0139cd93"

URI_aarch64_ghc9.12-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-doc-0.10.9-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions-doc}"
SRC_URI[aarch64_ghc9.12-exceptions-doc.sha256sum] = "cd4fe05a87fc56d5c7e095335250b105d96f2683b404124ca79d38429660948a"

URI_aarch64_ghc9.12-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-exceptions-prof-0.10.9-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-exceptions-prof}"
SRC_URI[aarch64_ghc9.12-exceptions-prof.sha256sum] = "5f93845ea9197dcff75c11a2adc24687b01eac7e63c3109cc76ce7e1ce583f42"

URI_aarch64_ghc9.12-file-io = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-0.1.5-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-file-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io}"
SRC_URI[aarch64_ghc9.12-file-io.sha256sum] = "da9915b884870f591a13b874b727cd788a820d118d9a28bd544e956a421cbd28"

URI_aarch64_ghc9.12-file-io-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-devel-0.1.5-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-file-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io-devel}"
SRC_URI[aarch64_ghc9.12-file-io-devel.sha256sum] = "acccac64e45a791640470bbbef3f5169bad758cd3860245ec75c5261a55c024a"

URI_aarch64_ghc9.12-file-io-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-doc-0.1.5-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-file-io-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io-doc}"
SRC_URI[aarch64_ghc9.12-file-io-doc.sha256sum] = "0ef11271c75047bb6007870da7173f690a393a0f373136cd7d4c2b76aff64fa7"

URI_aarch64_ghc9.12-file-io-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-file-io-prof-0.1.5-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-file-io-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-file-io-prof}"
SRC_URI[aarch64_ghc9.12-file-io-prof.sha256sum] = "c4ee230f1190188fb4be893db4622ebe4b9c0364f1881c0f7d2f6f4ae8b2b1a4"

URI_aarch64_ghc9.12-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-1.5.4.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath}"
SRC_URI[aarch64_ghc9.12-filepath.sha256sum] = "997e97322a01279d29749c60b42e749eabe2deab73f497f84a762aed48c84315"

URI_aarch64_ghc9.12-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-devel-1.5.4.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath-devel}"
SRC_URI[aarch64_ghc9.12-filepath-devel.sha256sum] = "3212e51041ebdc707fe62299e36d580d547e3cb49183b8da406e6f3ab28ecdc5"

URI_aarch64_ghc9.12-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-doc-1.5.4.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath-doc}"
SRC_URI[aarch64_ghc9.12-filepath-doc.sha256sum] = "e6e77617d99edc88ae48c8faf21593ccc8cccd0bb72f07365cd726859a57a976"

URI_aarch64_ghc9.12-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filepath-prof-1.5.4.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filepath-prof}"
SRC_URI[aarch64_ghc9.12-filepath-prof.sha256sum] = "8f1c21862f9c883f7f529100cca4281c4068704f4fbca69e2a3c25004e086865"

URI_aarch64_ghc9.12-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-filesystem-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-filesystem}"
SRC_URI[aarch64_ghc9.12-filesystem.sha256sum] = "a875495109f41ae385bcc6227f5b008d67e80cd6ad77c6935e380695c76c15df"

URI_aarch64_ghc9.12-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc}"
SRC_URI[aarch64_ghc9.12-ghc.sha256sum] = "85146b6483ee28e42775bcb0c7653ae3287f1cb269d0d8accd5e42cee74d4919"

URI_aarch64_ghc9.12-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-1.3-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum}"
SRC_URI[aarch64_ghc9.12-ghc-bignum.sha256sum] = "2bfa9c625bb766828186ad51c8daf41d0ac3f75c349b9113ae3fe95a4ae3c5df"

URI_aarch64_ghc9.12-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-devel-1.3-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.12-ghc-bignum-devel.sha256sum] = "3d2537d76fc2c94fdc5d17f2b2b0c2a0e42c58ee5690e8725174035f553e3eb6"

URI_aarch64_ghc9.12-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-doc-1.3-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.12-ghc-bignum-doc.sha256sum] = "ecb8abfb64c82fe118351049f2aa9fae4907e830a1eb0fefe02c9c584d2619ab"

URI_aarch64_ghc9.12-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-bignum-prof-1.3-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.12-ghc-bignum-prof.sha256sum] = "f2c00e160edaccfc81cd914594782f4dfa2efec89b56515c54ebfbdfeeb7378f"

URI_aarch64_ghc9.12-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot}"
SRC_URI[aarch64_ghc9.12-ghc-boot.sha256sum] = "be686d10aa409de7d8d55c48e91847e5562553894009fd452ea9286ee3dbc1dc"

URI_aarch64_ghc9.12-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-devel-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.12-ghc-boot-devel.sha256sum] = "85925a70c110082c936d474ed64ce5b3130e526b46e9f5ab1a1582f87e249208"

URI_aarch64_ghc9.12-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-doc-9.12.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.12-ghc-boot-doc.sha256sum] = "1eee252901077af85cea3c840bd756b27cff21be3dbb1efcc4ca9e8543d25995"

URI_aarch64_ghc9.12-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-prof-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.12-ghc-boot-prof.sha256sum] = "4e627e6d126f28906afb7b8a0567f12955311b1ab770cb6065fb54573810a440"

URI_aarch64_ghc9.12-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th.sha256sum] = "e37c37787731874d0fae58a6cfe79928446d068300aafd0881333cb84c341cfc"

URI_aarch64_ghc9.12-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-devel-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th-devel.sha256sum] = "6d5debf307de733f5554f24a0ec120116a2b83e1c5fa5f7f2d9441901259b67a"

URI_aarch64_ghc9.12-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-doc-9.12.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th-doc.sha256sum] = "d477419b6074e83a583de52d407382e8e2fa2e105d3df3868920e459c152b51a"

URI_aarch64_ghc9.12-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-boot-th-prof-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.12-ghc-boot-th-prof.sha256sum] = "a6da3c7399bece8f776e3fc6dc79d92e9f2b68d136a873c87ef024b32eaf4116"

URI_aarch64_ghc9.12-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact}"
SRC_URI[aarch64_ghc9.12-ghc-compact.sha256sum] = "a769eff663a21939990ac6c0d17babf76871017fc4b67d8d5b98fcbe74b1603f"

URI_aarch64_ghc9.12-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-devel-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.12-ghc-compact-devel.sha256sum] = "c6ac4782f37d7f528e406285c5f3633c27f58634392b1345beabce59fd522d69"

URI_aarch64_ghc9.12-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-doc-0.1.0.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.12-ghc-compact-doc.sha256sum] = "fa8cf5cd5e9774324d87ed1dd3cbcc273782b7d9aee39222bcf9ecdedb4f52f0"

URI_aarch64_ghc9.12-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-compact-prof-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.12-ghc-compact-prof.sha256sum] = "4cd25224a45ee1d063612e68505dcd20301decde44d878f2a455cea666afee1e"

URI_aarch64_ghc9.12-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-devel-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-devel}"
SRC_URI[aarch64_ghc9.12-ghc-devel.sha256sum] = "b77c0a83b212558ebe5686e26fb724cc46a16f43341bcd6520ceb3b95cea20b5"

URI_aarch64_ghc9.12-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-doc-9.12.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-doc}"
SRC_URI[aarch64_ghc9.12-ghc-doc.sha256sum] = "6e49d8469689b39718faaaa704377d2d3761fa37050b1be6d244fc030fce828e"

URI_aarch64_ghc9.12-ghc-experimental = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-9.1202.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental}"
SRC_URI[aarch64_ghc9.12-ghc-experimental.sha256sum] = "0a7ab58bbd775cf471b7245cbf62b805cb78b4329eca61da4b45146634369696"

URI_aarch64_ghc9.12-ghc-experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-devel-9.1202.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental-devel}"
SRC_URI[aarch64_ghc9.12-ghc-experimental-devel.sha256sum] = "89e705270a178825c023cc22c419d308e3b8a0d6f360665e0ed0ac18e2673052"

URI_aarch64_ghc9.12-ghc-experimental-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-doc-9.1202.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental-doc}"
SRC_URI[aarch64_ghc9.12-ghc-experimental-doc.sha256sum] = "5cee6718a2229688ed02aebf4a9eb91499e7f4994f3c0a7f60a1487575db1d25"

URI_aarch64_ghc9.12-ghc-experimental-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-experimental-prof-9.1202.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-experimental-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-experimental-prof}"
SRC_URI[aarch64_ghc9.12-ghc-experimental-prof.sha256sum] = "2e6e0a71e8f3f9a1398fe00b8e1055ca39dfb960ef339f8d559fd5fab2d27cea"

URI_aarch64_ghc9.12-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap}"
SRC_URI[aarch64_ghc9.12-ghc-heap.sha256sum] = "7d705c231eb6520e91746c9e4cef2e103d9c2f13e8fd30d03337ec758675afc4"

URI_aarch64_ghc9.12-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-devel-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.12-ghc-heap-devel.sha256sum] = "c9c8f22599d87439119631acbb212233adf56277bacf36daf2ae193b6fd17df1"

URI_aarch64_ghc9.12-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-doc-9.12.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.12-ghc-heap-doc.sha256sum] = "4188344d9de87126d2a77831d6aeb157552928401ee01e489a127d97f113e248"

URI_aarch64_ghc9.12-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-heap-prof-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.12-ghc-heap-prof.sha256sum] = "18e04e34092327a0f41ba07019a314bb388f66cb50bbadce381a50fb755b1a2d"

URI_aarch64_ghc9.12-ghc-platform = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform}"
SRC_URI[aarch64_ghc9.12-ghc-platform.sha256sum] = "dc53d2a0fc8beea7004d5924f0d530a64e17663fab6d42f3e1dba83a190b6ecb"

URI_aarch64_ghc9.12-ghc-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-devel-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform-devel}"
SRC_URI[aarch64_ghc9.12-ghc-platform-devel.sha256sum] = "1efb62986fee010e2dc4b6c77164e3d62b81fe5721bdb4e7ce926b3de197bf29"

URI_aarch64_ghc9.12-ghc-platform-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-doc-0.1.0.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform-doc}"
SRC_URI[aarch64_ghc9.12-ghc-platform-doc.sha256sum] = "602b8b884dce10726a8a44f245813267766928c3b35c9d505a0ac458f9e3427c"

URI_aarch64_ghc9.12-ghc-platform-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-platform-prof-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-platform-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-platform-prof}"
SRC_URI[aarch64_ghc9.12-ghc-platform-prof.sha256sum] = "f3343526a9f672f2b94beb46b2d7f8693cea79eeb02ebf5f4d8092e4de0ee488"

URI_aarch64_ghc9.12-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-prof-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-prof}"
SRC_URI[aarch64_ghc9.12-ghc-prof.sha256sum] = "81355ced841615f6dbc57c700cdb01ee9f431014bb347761fa8584ef008dc401"

URI_aarch64_ghc9.12-ghc-toolchain = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain.sha256sum] = "9904316e64f37ac3664834bb2648e91c8b43d680e88f7bfad7490bdc544025cf"

URI_aarch64_ghc9.12-ghc-toolchain-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-devel-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain-devel}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain-devel.sha256sum] = "569eb8d8a904cd7dadbc883c882d28363e9e68449584aa8e442b7c8a74b1a347"

URI_aarch64_ghc9.12-ghc-toolchain-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-doc-0.1.0.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain-doc}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain-doc.sha256sum] = "f63f830ea155eac93cd0b7cc7abd69ceffe3caf9e1a2fd2e9c65ce6bde5052c4"

URI_aarch64_ghc9.12-ghc-toolchain-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghc-toolchain-prof-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghc-toolchain-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghc-toolchain-prof}"
SRC_URI[aarch64_ghc9.12-ghc-toolchain-prof.sha256sum] = "f88d33aaa92d5e0ab02821e6aef19c51cd0caa11a741dce110cae47610147b36"

URI_aarch64_ghc9.12-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci}"
SRC_URI[aarch64_ghc9.12-ghci.sha256sum] = "7c9a36ee19283822bb8683cde8e74f4253c707bbff532f7bb79bc9d6ca7b642e"

URI_aarch64_ghc9.12-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-devel-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci-devel}"
SRC_URI[aarch64_ghc9.12-ghci-devel.sha256sum] = "7a33180f9b78910f7d78f483aae9521e5943baefc78b575782cb40d233dfa64a"

URI_aarch64_ghc9.12-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-doc-9.12.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci-doc}"
SRC_URI[aarch64_ghc9.12-ghci-doc.sha256sum] = "bd516c09b6fce979cc16337a3ab5c61253ee3df030022e5d86e2c7f5adc82f2d"

URI_aarch64_ghc9.12-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-ghci-prof-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-ghci-prof}"
SRC_URI[aarch64_ghc9.12-ghci-prof.sha256sum] = "b1dfddeee7dc93322e89a950d85af0cffe2032b1b3b278f6f91b2a0f16731c40"

URI_aarch64_ghc9.12-haddock-api = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-2.30.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-haddock-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api}"
SRC_URI[aarch64_ghc9.12-haddock-api.sha256sum] = "66a61246a789325f9a44fb82310f14e05db1d8a5d9f4a95c119d2960847dea5b"

URI_aarch64_ghc9.12-haddock-api-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-devel-2.30.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-haddock-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api-devel}"
SRC_URI[aarch64_ghc9.12-haddock-api-devel.sha256sum] = "1c267e6056f72804001e8895488a31da525c5ed71d200f48ae0dc9c15373d3de"

URI_aarch64_ghc9.12-haddock-api-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-doc-2.30.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-haddock-api-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api-doc}"
SRC_URI[aarch64_ghc9.12-haddock-api-doc.sha256sum] = "6dc6539ed713785cd2a4656a586bd1265db1f6d767815adf6d363ccf3ee6b4e9"

URI_aarch64_ghc9.12-haddock-api-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-api-prof-2.30.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-haddock-api-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-api-prof}"
SRC_URI[aarch64_ghc9.12-haddock-api-prof.sha256sum] = "bbcd1d333ec0f31bd437ceaacdd0754ffa1e69e5fef4727454fd7511e0511bfc"

URI_aarch64_ghc9.12-haddock-library = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-1.11.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-haddock-library;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library}"
SRC_URI[aarch64_ghc9.12-haddock-library.sha256sum] = "6a2f99a33e8f58090f95cf5d588c7d0302c47f10096d249a657fc3fa104ba1dc"

URI_aarch64_ghc9.12-haddock-library-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-devel-1.11.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library-devel}"
SRC_URI[aarch64_ghc9.12-haddock-library-devel.sha256sum] = "744e51705010d71cfdf4c0aa9769763fd6f6defb9b6b36b553617d8b03c2e44d"

URI_aarch64_ghc9.12-haddock-library-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-doc-1.11.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library-doc}"
SRC_URI[aarch64_ghc9.12-haddock-library-doc.sha256sum] = "e6a62dafffbf8f2e5171a429bddc7ea545cf7dcad098656d50536923613e1791"

URI_aarch64_ghc9.12-haddock-library-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haddock-library-prof-1.11.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-haddock-library-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haddock-library-prof}"
SRC_URI[aarch64_ghc9.12-haddock-library-prof.sha256sum] = "0429e6842f12f6e545bd5e688ba89166dd51184e00b2b87b412dde2d7fa5686c"

URI_aarch64_ghc9.12-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hadrian-0.1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hadrian}"
SRC_URI[aarch64_ghc9.12-hadrian.sha256sum] = "7d2dcab3146246ec7481f8784e18821668c11a3c9c2ab2e0608971b2c4c0be6d"

URI_aarch64_ghc9.12-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-0.8.2.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline}"
SRC_URI[aarch64_ghc9.12-haskeline.sha256sum] = "8a98d5b9248570249a42ac81fd44be74a5fceea8aefed9cab07816913282b8a3"

URI_aarch64_ghc9.12-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-devel-0.8.2.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline-devel}"
SRC_URI[aarch64_ghc9.12-haskeline-devel.sha256sum] = "cc8952d9544d6df242bf92503458deee1161c75621733b6596f5df3eb808d33a"

URI_aarch64_ghc9.12-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-doc-0.8.2.1-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline-doc}"
SRC_URI[aarch64_ghc9.12-haskeline-doc.sha256sum] = "f9f4421e76626ec6dc3b8421f4b91cf68bba025ff25744fe104702161ba3eba9"

URI_aarch64_ghc9.12-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-haskeline-prof-0.8.2.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-haskeline-prof}"
SRC_URI[aarch64_ghc9.12-haskeline-prof.sha256sum] = "5a1b4b85107e151ce55b0eac3c5db1dc2c0fd9425a9a2cba72956e13a757e50f"

URI_aarch64_ghc9.12-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-0.7.0.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc}"
SRC_URI[aarch64_ghc9.12-hpc.sha256sum] = "dd8ad0c34f56ca43094a4661557013c12962a4aa6119af65dc0f49d85d8c74f8"

URI_aarch64_ghc9.12-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-devel-0.7.0.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc-devel}"
SRC_URI[aarch64_ghc9.12-hpc-devel.sha256sum] = "e879fd54f98dc7e6521f29db0573261142d415e77d4639d1cf8aa7a4aa38814c"

URI_aarch64_ghc9.12-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-doc-0.7.0.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc-doc}"
SRC_URI[aarch64_ghc9.12-hpc-doc.sha256sum] = "37531b7aed10697c18e96674368e491eb2a3bbca7705571009938768beea2655"

URI_aarch64_ghc9.12-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-hpc-prof-0.7.0.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-hpc-prof}"
SRC_URI[aarch64_ghc9.12-hpc-prof.sha256sum] = "ad6f91e5f320ebe2e95ac3a5e347f9796d59f7350e0fe7fb9f0bf2b2eb819b25"

URI_aarch64_ghc9.12-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-manual-9.12.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-manual}"
SRC_URI[aarch64_ghc9.12-manual.sha256sum] = "878bfa1a42d20e187c04fba9079dc726cfa5786b6a44edf626ff289091ae9b8c"

URI_aarch64_ghc9.12-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-2.3.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl}"
SRC_URI[aarch64_ghc9.12-mtl.sha256sum] = "3d7c7f85416429076e30f6fdf0f45e1eb0e20c4ed1a39f9197be688a8a0255ad"

URI_aarch64_ghc9.12-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-devel-2.3.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl-devel}"
SRC_URI[aarch64_ghc9.12-mtl-devel.sha256sum] = "abeeee659f1571bd60a3c2091c7d27c4eeb3fa207628069809b094a87327fc78"

URI_aarch64_ghc9.12-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-doc-2.3.1-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl-doc}"
SRC_URI[aarch64_ghc9.12-mtl-doc.sha256sum] = "1c61dce14370ab00d8c39d2b3aa60fdc49d854acd6d0c3c552dcac9fb14c9bc6"

URI_aarch64_ghc9.12-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-mtl-prof-2.3.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-mtl-prof}"
SRC_URI[aarch64_ghc9.12-mtl-prof.sha256sum] = "ce7fda455a758be7cb62e7a135bba1d4886903e5b26c5b35e661f3aadb78fd7c"

URI_aarch64_ghc9.12-os-string = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-2.0.7-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-os-string;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string}"
SRC_URI[aarch64_ghc9.12-os-string.sha256sum] = "07cf6ff9180d22c6f959d363f196df754d95355f4c5faa4a3ad975d62524665b"

URI_aarch64_ghc9.12-os-string-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-devel-2.0.7-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string-devel}"
SRC_URI[aarch64_ghc9.12-os-string-devel.sha256sum] = "6885b71415ddb56b6874320184a9d08988b0571dcbd56a5eabb9b1d6518d263c"

URI_aarch64_ghc9.12-os-string-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-doc-2.0.7-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string-doc}"
SRC_URI[aarch64_ghc9.12-os-string-doc.sha256sum] = "df0a4f8959a30fedfed830985725d0e54ffedeb47a3513aea65a66c9c0a15b2e"

URI_aarch64_ghc9.12-os-string-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-os-string-prof-2.0.7-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-os-string-prof}"
SRC_URI[aarch64_ghc9.12-os-string-prof.sha256sum] = "a745288376deb323aa3389646b133abc08d7d7c0763f4b1caa68559e0d6f8a63"

URI_aarch64_ghc9.12-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-3.1.18.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec}"
SRC_URI[aarch64_ghc9.12-parsec.sha256sum] = "8c61e8eebbf916e2037e403c731da9ad5db8acdfee57e024301516fdbf3f7dd3"

URI_aarch64_ghc9.12-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-devel-3.1.18.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec-devel}"
SRC_URI[aarch64_ghc9.12-parsec-devel.sha256sum] = "9d32d0c785c2b79707857c3099212cb26d2ade84792da12d38918758c615051d"

URI_aarch64_ghc9.12-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-doc-3.1.18.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec-doc}"
SRC_URI[aarch64_ghc9.12-parsec-doc.sha256sum] = "14d7b31ebf798f55c58ed82d1c3e34c0fc717397f2d975ebefc78d98b3e035ca"

URI_aarch64_ghc9.12-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-parsec-prof-3.1.18.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-parsec-prof}"
SRC_URI[aarch64_ghc9.12-parsec-prof.sha256sum] = "d8e9faf12a8ecafd9d3e72852b6182a45be226b61261cca6e63bb6cebb2c5552"

URI_aarch64_ghc9.12-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-1.1.3.6-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty}"
SRC_URI[aarch64_ghc9.12-pretty.sha256sum] = "8a26fe7a2831844ff3570c39db423d7ee13ce90ba944924a44309039caaf8c5c"

URI_aarch64_ghc9.12-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-devel-1.1.3.6-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty-devel}"
SRC_URI[aarch64_ghc9.12-pretty-devel.sha256sum] = "c240b1baa4084755dcbb521398dca0117467812fc91bc8fb2aff3e8cac50c462"

URI_aarch64_ghc9.12-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-doc-1.1.3.6-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty-doc}"
SRC_URI[aarch64_ghc9.12-pretty-doc.sha256sum] = "c8c2a18b42ec5c406443b14e8a8b1248125de85a75e80536a2b7092cbc0804fe"

URI_aarch64_ghc9.12-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-pretty-prof-1.1.3.6-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-pretty-prof}"
SRC_URI[aarch64_ghc9.12-pretty-prof.sha256sum] = "2fd43826426f1e6f20a89334b5369719add3f24b2cfe32c6e3cfdb758815f906"

URI_aarch64_ghc9.12-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-1.6.25.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process}"
SRC_URI[aarch64_ghc9.12-process.sha256sum] = "0eccf9d830b147fa470d826156888fa7c4ed14d6ddacfb18faf42a3533582489"

URI_aarch64_ghc9.12-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-devel-1.6.25.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process-devel}"
SRC_URI[aarch64_ghc9.12-process-devel.sha256sum] = "6a308777bf1b39739374af9592dcb509deb19027e32649686a25e39fee1ae6ec"

URI_aarch64_ghc9.12-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-doc-1.6.25.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process-doc}"
SRC_URI[aarch64_ghc9.12-process-doc.sha256sum] = "8e75b5b773a1ed198b38a4a68bd262f7683e6d9a12cbc8b846b2410105140249"

URI_aarch64_ghc9.12-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-process-prof-1.6.25.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-process-prof}"
SRC_URI[aarch64_ghc9.12-process-prof.sha256sum] = "c86068fb1f79766041f829874373724d2efd67e17ab62b140c19969b7409779d"

URI_aarch64_ghc9.12-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-prof-9.12.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-prof}"
SRC_URI[aarch64_ghc9.12-prof.sha256sum] = "2443db9190e1eef9cdd203649b273ede156e6883413fa7d1811e0a13527dade1"

URI_aarch64_ghc9.12-semaphore-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat}"
SRC_URI[aarch64_ghc9.12-semaphore-compat.sha256sum] = "740dc27e89bc09e5e11731d58753156fff4f6762fb1c31a836b129fe24bdeb6c"

URI_aarch64_ghc9.12-semaphore-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-devel-1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat-devel}"
SRC_URI[aarch64_ghc9.12-semaphore-compat-devel.sha256sum] = "8faa21ad4030dfdc8d9cf25ecdaa5d435391b36219e07049cd2da8988ae81c08"

URI_aarch64_ghc9.12-semaphore-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-doc-1.0.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat-doc}"
SRC_URI[aarch64_ghc9.12-semaphore-compat-doc.sha256sum] = "fbd5599a73438b8719926b1532adf3ffd8eab20131647bd0f54b24aa2200f3a8"

URI_aarch64_ghc9.12-semaphore-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-semaphore-compat-prof-1.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-semaphore-compat-prof}"
SRC_URI[aarch64_ghc9.12-semaphore-compat-prof.sha256sum] = "378268a1d182842017d43b3415ca3f65a1079f9cabaf20754f0aed82d72cca22"

URI_aarch64_ghc9.12-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-2.5.3.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm}"
SRC_URI[aarch64_ghc9.12-stm.sha256sum] = "ed199dde0e696c462a8c3e2c3bc7627d8c6b5f42cb9973ae2fb8372cd99716f1"

URI_aarch64_ghc9.12-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-devel-2.5.3.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm-devel}"
SRC_URI[aarch64_ghc9.12-stm-devel.sha256sum] = "6e5aee8d24ae883b034c6239e20539487c503fab1593725b300ce65a409e05b9"

URI_aarch64_ghc9.12-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-doc-2.5.3.1-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm-doc}"
SRC_URI[aarch64_ghc9.12-stm-doc.sha256sum] = "0fa1f7c56a86b7248ded85d5f3864eaa7e797b6371392ac3a8cd4c5cc1d14b7e"

URI_aarch64_ghc9.12-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-stm-prof-2.5.3.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-stm-prof}"
SRC_URI[aarch64_ghc9.12-stm-prof.sha256sum] = "b45402d58d71e90a640c38d0a2aa22eb8c1efda0415c350b38535ce668fdc3d7"

URI_aarch64_ghc9.12-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-2.23.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell}"
SRC_URI[aarch64_ghc9.12-template-haskell.sha256sum] = "97e3120c166889f359020cb62ba7a736f7007a7a4ceeba6a292b5a96a1c6dc6c"

URI_aarch64_ghc9.12-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-devel-2.23.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell-devel}"
SRC_URI[aarch64_ghc9.12-template-haskell-devel.sha256sum] = "18a22ae87b2fa6f4a5f32ecf1515c012a7fca21207031bac7ac475a160591771"

URI_aarch64_ghc9.12-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-doc-2.23.0.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell-doc}"
SRC_URI[aarch64_ghc9.12-template-haskell-doc.sha256sum] = "150df1b8cd91293a9c7e82dd9e0e053cab32cc3da011f5564cdf3177f51f6b4d"

URI_aarch64_ghc9.12-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-template-haskell-prof-2.23.0.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-template-haskell-prof}"
SRC_URI[aarch64_ghc9.12-template-haskell-prof.sha256sum] = "b292e7c3b1a7f5346ab342bea10a5abfebb36c03402443682441ee38b72a53fb"

URI_aarch64_ghc9.12-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-0.4.1.7-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo}"
SRC_URI[aarch64_ghc9.12-terminfo.sha256sum] = "cfcca7c7603441c666e1b79fcf159f1418f54a86163359a043e1d3a020a41a1e"

URI_aarch64_ghc9.12-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-devel-0.4.1.7-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo-devel}"
SRC_URI[aarch64_ghc9.12-terminfo-devel.sha256sum] = "b5ad768929875c0c8bc679920c80c0a88f35110285b4c95a8fd662cd1bbfc364"

URI_aarch64_ghc9.12-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-doc-0.4.1.7-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo-doc}"
SRC_URI[aarch64_ghc9.12-terminfo-doc.sha256sum] = "9b775aa517ed6282a20f6c238c6d29ab2e514d48254b8b24dcfe878ced25cc13"

URI_aarch64_ghc9.12-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-terminfo-prof-0.4.1.7-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-terminfo-prof}"
SRC_URI[aarch64_ghc9.12-terminfo-prof.sha256sum] = "9931fbc2c3ba8fd62d6e456b4f46e8d03aee303c08350359106096a12c5ef75e"

URI_aarch64_ghc9.12-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-2.1.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text}"
SRC_URI[aarch64_ghc9.12-text.sha256sum] = "ec27cc3ef5a561fc8a4df0b1ffdd86cd60d98f2f52a532601e9ecdb0f0486135"

URI_aarch64_ghc9.12-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-devel-2.1.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text-devel}"
SRC_URI[aarch64_ghc9.12-text-devel.sha256sum] = "18d227655a25e5520f77252eaaac66fdc9b8a0df013a43d43662b83ce752907b"

URI_aarch64_ghc9.12-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-doc-2.1.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text-doc}"
SRC_URI[aarch64_ghc9.12-text-doc.sha256sum] = "bf82073699363e518dda9ff5660d487bc208ebdf50f240d948a0d7f5fb107e22"

URI_aarch64_ghc9.12-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-text-prof-2.1.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-text-prof}"
SRC_URI[aarch64_ghc9.12-text-prof.sha256sum] = "e4641ac7023906ba8a21ea16d827394c19c7a78084f12986bbf66540a1906315"

URI_aarch64_ghc9.12-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-1.14-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time}"
SRC_URI[aarch64_ghc9.12-time.sha256sum] = "f6174d603fa78ad569738ca1f5ddfa57ffff275909e5452fcfdc5877a1611ff9"

URI_aarch64_ghc9.12-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-devel-1.14-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time-devel}"
SRC_URI[aarch64_ghc9.12-time-devel.sha256sum] = "f8205634992a560cf642baf7b40705f748ea486a5140cee5bd9e40a0e6c4dd97"

URI_aarch64_ghc9.12-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-doc-1.14-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time-doc}"
SRC_URI[aarch64_ghc9.12-time-doc.sha256sum] = "9925f2f7d531fc9b05f5e75bb0b12986fe43385aedfe14e5f60baed276ab7eb8"

URI_aarch64_ghc9.12-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-time-prof-1.14-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-time-prof}"
SRC_URI[aarch64_ghc9.12-time-prof.sha256sum] = "8115fde60061326182c401918c91553894c1e755e999036257591b54a2902d4a"

URI_aarch64_ghc9.12-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-0.6.1.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers}"
SRC_URI[aarch64_ghc9.12-transformers.sha256sum] = "0dac4e5309fe052023c2c54c9f82dc39d24f496d07d2b498e2b5b81241ab0604"

URI_aarch64_ghc9.12-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-devel-0.6.1.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers-devel}"
SRC_URI[aarch64_ghc9.12-transformers-devel.sha256sum] = "a37ac6c3876de4d5a64ff792a64212401137edf322324e2c9d36f8059f814676"

URI_aarch64_ghc9.12-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-doc-0.6.1.2-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers-doc}"
SRC_URI[aarch64_ghc9.12-transformers-doc.sha256sum] = "faf4c5a5a63a02fb9319b89a5255a1e983acbc34bca6f44b4e295dc38773c971"

URI_aarch64_ghc9.12-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-transformers-prof-0.6.1.2-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-transformers-prof}"
SRC_URI[aarch64_ghc9.12-transformers-prof.sha256sum] = "8f0aa9039953fa09ea7dba319f0f6c75b84c996bc7542e0ec0ca3e016acf723d"

URI_aarch64_ghc9.12-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-2.8.6.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix}"
SRC_URI[aarch64_ghc9.12-unix.sha256sum] = "50dd6fb9fd6d90550b5cfae82eaf9f0c7a06a540446585c676baf86b9123d10a"

URI_aarch64_ghc9.12-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-devel-2.8.6.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix-devel}"
SRC_URI[aarch64_ghc9.12-unix-devel.sha256sum] = "bf92b651b02edec23becef951be0b10dda22d13076768a2e6c060f570bb3d212"

URI_aarch64_ghc9.12-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-doc-2.8.6.0-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix-doc}"
SRC_URI[aarch64_ghc9.12-unix-doc.sha256sum] = "b7d1122d2bed538862fda569951602c8ba77c3e063c8e28b6ca4109a0e855ca0"

URI_aarch64_ghc9.12-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-unix-prof-2.8.6.0-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-unix-prof}"
SRC_URI[aarch64_ghc9.12-unix-prof.sha256sum] = "11338e5dd154d11d7e280569fd44f6314a92132092ccc5c39f5ad53a222731db"

URI_aarch64_ghc9.12-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-3000.2.2.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml}"
SRC_URI[aarch64_ghc9.12-xhtml.sha256sum] = "d20e532dccf246982457ba41053aee6ee28de0cfa3751c79d0d6251fd952af29"

URI_aarch64_ghc9.12-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-devel-3000.2.2.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml-devel}"
SRC_URI[aarch64_ghc9.12-xhtml-devel.sha256sum] = "4b7626f7365345cfe4a785cc14c636fb4f0fec0906a14d65315e9957a598b34d"

URI_aarch64_ghc9.12-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-doc-3000.2.2.1-7.el10_1.noarch.rpm;name=aarch64_ghc9.12-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml-doc}"
SRC_URI[aarch64_ghc9.12-xhtml-doc.sha256sum] = "507f3b3d3dc09b05b65e4c43c8ce7ea7848e7d3aa8543c46b69cec98931b1b7c"

URI_aarch64_ghc9.12-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.12-xhtml-prof-3000.2.2.1-7.el10_1.aarch64.rpm;name=aarch64_ghc9.12-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.12-xhtml-prof}"
SRC_URI[aarch64_ghc9.12-xhtml-prof.sha256sum] = "67218b659908518d2431959680f57fffaa066793ae7ede3d78ace4415b701ca1"

RDEPENDS:ghc9.12 = " \
 ghc9.12-compiler \
 ghc9.12-devel \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-compact-devel \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghci-devel \
 ghc9.12-hpc-devel \
 "
RDEPENDS:ghc9.12-Cabal = " \
 ghc9.12-Cabal-syntax \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-Cabal-devel = " \
 ghc9.12-Cabal \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-mtl-devel \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-devel \
 ghc9.12-process-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-Cabal-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-Cabal-syntax = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-Cabal-syntax-devel = " \
 ghc9.12-Cabal-syntax \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-mtl-devel \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-devel \
 ghc9.12-text-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-Cabal-syntax-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-array = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-array-devel = " \
 ghc9.12-array \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-array-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-base = " \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.12-base-devel = " \
 ghc9.12-base \
 ghc9.12-compiler \
 ghc9.12-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 numactl-devel \
 "
RDEPENDS:ghc9.12-base-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-binary = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-binary-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 "
RDEPENDS:ghc9.12-binary-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-bytestring = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-bytestring-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-bytestring-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.12-Cabal \
 ghc9.12-Cabal-syntax \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-base-devel \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-filesystem \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-ghc-toolchain \
 ghc9.12-ghci \
 ghc9.12-haddock-api \
 ghc9.12-haddock-library \
 ghc9.12-haskeline \
 ghc9.12-hpc \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-semaphore-compat \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-terminfo \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 ghc9.12-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 numactl-libs \
 "
RDEPENDS:ghc9.12-compiler-default = " \
 bash \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-containers = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-containers-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-containers-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-deepseq = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-deepseq-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq \
 "
RDEPENDS:ghc9.12-deepseq-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-devel = " \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-file-io-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-library-devel \
 ghc9.12-haskeline-devel \
 ghc9.12-mtl-devel \
 ghc9.12-os-string-devel \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-devel \
 ghc9.12-process-devel \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-stm-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-terminfo-devel \
 ghc9.12-text-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 ghc9.12-xhtml-devel \
 "
RDEPENDS:ghc9.12-directory = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-directory-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-directory \
 ghc9.12-file-io-devel \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-time-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-directory-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-doc = " \
 "
RDEPENDS:ghc9.12-doc-index = " \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-exceptions = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-exceptions-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-exceptions \
 ghc9.12-mtl-devel \
 ghc9.12-stm-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-exceptions-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-file-io = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-file-io-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-file-io \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-file-io-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-filepath = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-filepath-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath \
 ghc9.12-os-string-devel \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-filepath-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-filesystem = " \
 "
RDEPENDS:ghc9.12-ghc = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-ghci \
 ghc9.12-hpc \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-semaphore-compat \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-bignum = " \
 ghc9.12-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-bignum-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-bignum \
 "
RDEPENDS:ghc9.12-ghc-bignum-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-boot = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-platform \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-devel = " \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-platform-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-ghc-boot-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-boot-th = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-th-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty-devel \
 "
RDEPENDS:ghc9.12-ghc-boot-th-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-compact = " \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-compact-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-compact \
 "
RDEPENDS:ghc9.12-ghc-compact-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghci-devel \
 ghc9.12-hpc-devel \
 ghc9.12-os-string-devel \
 ghc9.12-process-devel \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-stm-devel \
 ghc9.12-time-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-ghc-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-experimental = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-experimental-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-experimental \
 "
RDEPENDS:ghc9.12-ghc-experimental-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-heap = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-heap-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-ghc-heap \
 "
RDEPENDS:ghc9.12-ghc-heap-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-platform = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-platform-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-platform \
 "
RDEPENDS:ghc9.12-ghc-platform-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghc-toolchain = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-platform \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-toolchain-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-platform-devel \
 ghc9.12-ghc-toolchain \
 ghc9.12-process-devel \
 ghc9.12-text-devel \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-ghc-toolchain-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-ghci = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghci-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-ghc-heap-devel \
 ghc9.12-ghci \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-ghci-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-haddock-api = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot \
 ghc9.12-ghc-boot-th \
 ghc9.12-ghc-heap \
 ghc9.12-ghc-platform \
 ghc9.12-ghci \
 ghc9.12-haddock-library \
 ghc9.12-hpc \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-semaphore-compat \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 ghc9.12-xhtml \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-api-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-devel \
 ghc9.12-haddock-api \
 ghc9.12-haddock-library-devel \
 ghc9.12-mtl-devel \
 ghc9.12-parsec-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 ghc9.12-xhtml-devel \
 "
RDEPENDS:ghc9.12-haddock-api-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-haddock-library = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-parsec \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-library-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-haddock-library \
 ghc9.12-parsec-devel \
 ghc9.12-text-devel \
 "
RDEPENDS:ghc9.12-haddock-library-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.12-haskeline = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-process \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-terminfo \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-haskeline-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-filepath-devel \
 ghc9.12-haskeline \
 ghc9.12-process-devel \
 ghc9.12-stm-devel \
 ghc9.12-terminfo-devel \
 ghc9.12-transformers-devel \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-haskeline-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-hpc = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-hpc-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-hpc \
 ghc9.12-time-devel \
 "
RDEPENDS:ghc9.12-hpc-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-manual = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-mtl = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-mtl-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-mtl \
 ghc9.12-transformers-devel \
 "
RDEPENDS:ghc9.12-mtl-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-os-string = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-os-string-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-exceptions-devel \
 ghc9.12-os-string \
 ghc9.12-template-haskell-devel \
 "
RDEPENDS:ghc9.12-os-string-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-parsec = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 ghc9.12-text \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-parsec-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-mtl-devel \
 ghc9.12-parsec \
 ghc9.12-text-devel \
 "
RDEPENDS:ghc9.12-parsec-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-pretty = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-pretty-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-pretty \
 "
RDEPENDS:ghc9.12-pretty-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-process = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-directory \
 ghc9.12-exceptions \
 ghc9.12-file-io \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-process-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-directory-devel \
 ghc9.12-filepath-devel \
 ghc9.12-process \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-process-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-semaphore-compat = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 ghc9.12-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-semaphore-compat-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-exceptions-devel \
 ghc9.12-semaphore-compat \
 ghc9.12-unix-devel \
 "
RDEPENDS:ghc9.12-semaphore-compat-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-stm = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-stm-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-stm \
 "
RDEPENDS:ghc9.12-stm-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-template-haskell = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-template-haskell-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-template-haskell \
 "
RDEPENDS:ghc9.12-template-haskell-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-terminfo = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-terminfo-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.12-terminfo-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-text = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-binary \
 ghc9.12-bytestring \
 ghc9.12-containers \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-text-devel = " \
 ghc9.12-array-devel \
 ghc9.12-base-devel \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-text \
 "
RDEPENDS:ghc9.12-text-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-time = " \
 ghc9.12-base \
 ghc9.12-deepseq \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-pretty \
 ghc9.12-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-time-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-deepseq-devel \
 ghc9.12-template-haskell-devel \
 ghc9.12-time \
 "
RDEPENDS:ghc9.12-time-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-transformers = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-transformers-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-transformers \
 "
RDEPENDS:ghc9.12-transformers-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-unix = " \
 ghc9.12-array \
 ghc9.12-base \
 ghc9.12-bytestring \
 ghc9.12-deepseq \
 ghc9.12-exceptions \
 ghc9.12-filepath \
 ghc9.12-ghc-bignum \
 ghc9.12-ghc-boot-th \
 ghc9.12-mtl \
 ghc9.12-os-string \
 ghc9.12-pretty \
 ghc9.12-stm \
 ghc9.12-template-haskell \
 ghc9.12-time \
 ghc9.12-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-unix-devel = " \
 ghc9.12-base-devel \
 ghc9.12-bytestring-devel \
 ghc9.12-compiler \
 ghc9.12-filepath-devel \
 ghc9.12-os-string-devel \
 ghc9.12-time-devel \
 ghc9.12-unix \
 "
RDEPENDS:ghc9.12-unix-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-xhtml = " \
 ghc9.12-base \
 ghc9.12-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-xhtml-devel = " \
 ghc9.12-base-devel \
 ghc9.12-compiler \
 ghc9.12-xhtml \
 "
RDEPENDS:ghc9.12-xhtml-doc = " \
 ghc9.12-filesystem \
 "
RDEPENDS:ghc9.12-Cabal-prof = " \
 ghc9.12-Cabal-devel \
 ghc9.12-Cabal-syntax-prof \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-Cabal-syntax-prof = " \
 ghc9.12-Cabal-syntax-devel \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-array-prof = " \
 ghc9.12-array-devel \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-base-prof = " \
 ghc9.12-base-devel \
 ghc9.12-ghc-bignum-prof \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.12-binary-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-devel \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-bytestring-prof = " \
 ghc9.12-base-prof \
 ghc9.12-bytestring-devel \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-containers-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-containers-devel \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-deepseq-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-devel \
 ghc9.12-ghc-bignum-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-directory-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-devel \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-exceptions-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-devel \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-file-io-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-devel \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-filepath-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-filepath-devel \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-bignum-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-devel \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-boot-th-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-devel \
 ghc9.12-pretty-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-compact-prof = " \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-compact-devel \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-experimental-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-experimental-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-heap-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-heap-devel \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-platform-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-platform-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-devel \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghci-prof \
 ghc9.12-hpc-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-semaphore-compat-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghc-toolchain-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghc-toolchain-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-ghci-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghci-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-api-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-ghc-heap-prof \
 ghc9.12-ghc-platform-prof \
 ghc9.12-ghc-prof \
 ghc9.12-ghci-prof \
 ghc9.12-haddock-api-devel \
 ghc9.12-haddock-library-prof \
 ghc9.12-hpc-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-semaphore-compat-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 ghc9.12-xhtml-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haddock-library-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-haddock-library-devel \
 ghc9.12-mtl-prof \
 ghc9.12-parsec-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-haskeline-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-haskeline-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-terminfo-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-hpc-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-hpc-devel \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-mtl-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-mtl-devel \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-os-string-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-devel \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-parsec-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-parsec-devel \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-prof \
 ghc9.12-transformers-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-pretty-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-pretty-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-process-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-directory-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-file-io-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-process-devel \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-prof = " \
 ghc9.12-compiler \
 "
RDEPENDS:ghc9.12-semaphore-compat-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-semaphore-compat-devel \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-prof \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-stm-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-stm-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-template-haskell-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-terminfo-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-terminfo-devel \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.12-text-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-binary-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-containers-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-text-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-time-prof = " \
 ghc9.12-base-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-pretty-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-transformers-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-transformers-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-unix-prof = " \
 ghc9.12-array-prof \
 ghc9.12-base-prof \
 ghc9.12-bytestring-prof \
 ghc9.12-deepseq-prof \
 ghc9.12-exceptions-prof \
 ghc9.12-filepath-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-ghc-boot-th-prof \
 ghc9.12-mtl-prof \
 ghc9.12-os-string-prof \
 ghc9.12-pretty-prof \
 ghc9.12-stm-prof \
 ghc9.12-template-haskell-prof \
 ghc9.12-time-prof \
 ghc9.12-transformers-prof \
 ghc9.12-unix-devel \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.12-xhtml-prof = " \
 ghc9.12-base-prof \
 ghc9.12-ghc-bignum-prof \
 ghc9.12-xhtml-devel \
 glibc \
 gmp \
 "
