# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-common"
PV = "0.12.2"
PR = "2.el10_1"
PACKAGES = " \
 aws-c-common \
 aws-c-common-devel \
 aws-c-common-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-common-0.12.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18b90683eff139f57e361fcb757d6f6a2abcd7a1480a9ba20557ffc9c28b80f6"

URI_x86_64_v2_aws-c-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-common-0.12.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-common}"
SRC_URI[x86_64_v2_aws-c-common.sha256sum] = "175a5d19d937e13a448db8588ba0353a74fcf8d1b5bb40ef90d2d3f9e5bfb0b3"

URI_x86_64_v2_aws-c-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-common-devel-0.12.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-common-devel}"
SRC_URI[x86_64_v2_aws-c-common-devel.sha256sum] = "821d5625e6aaeb880b39610a34043fca02e37f37dc1e2c9b11ca7a2645443828"

URI_x86_64_v2_aws-c-common-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-common-libs-0.12.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-common-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-common-libs}"
SRC_URI[x86_64_v2_aws-c-common-libs.sha256sum] = "774d071ad821dcc717e7f562f66e3b434c8ae02b8ae867a4402a0da4cf69c4b7"

URI_aarch64_aws-c-common = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-common-0.12.2-2.el10_1.aarch64.rpm;name=aarch64_aws-c-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-common}"
SRC_URI[aarch64_aws-c-common.sha256sum] = "a37123853ede08fe11ae9fb7d8cbe11633f212f6e71c22be89753aa7a28a4355"

URI_aarch64_aws-c-common-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-common-devel-0.12.2-2.el10_1.aarch64.rpm;name=aarch64_aws-c-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-common-devel}"
SRC_URI[aarch64_aws-c-common-devel.sha256sum] = "2b6f946f433fa9ea9b0bd08c4fbb89a5821ae52ee920398ca6d82263513b5303"

URI_aarch64_aws-c-common-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-common-libs-0.12.2-2.el10_1.aarch64.rpm;name=aarch64_aws-c-common-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-common-libs}"
SRC_URI[aarch64_aws-c-common-libs.sha256sum] = "6362a80e0385dad9e6e1810b0bf8c1cfdbac93653a1a0ee8a4453577dabb5db4"

RDEPENDS:aws-c-common = " \
 aws-c-common-libs \
 "
RDEPENDS:aws-c-common-devel = " \
 aws-c-common-libs \
 cmake-filesystem \
 "
RDEPENDS:aws-c-common-libs = " \
 aws-c-common \
 glibc \
 "
