# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-parse-float"
PV = "1.0.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-lexical-parse-float+compact-devel \
 rust-lexical-parse-float+default-devel \
 rust-lexical-parse-float+f128-devel \
 rust-lexical-parse-float+f16-devel \
 rust-lexical-parse-float+format-devel \
 rust-lexical-parse-float+lint-devel \
 rust-lexical-parse-float+power-of-two-devel \
 rust-lexical-parse-float+radix-devel \
 rust-lexical-parse-float+std-devel \
 rust-lexical-parse-float-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-parse-float-1.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e36d25230d18641d60a0b78a03fc815b77add0ac91e378421837f903c1bbf3c"

URI_x86_64_v2_rust-lexical-parse-float+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+compact-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+compact-devel.sha256sum] = "2733f0d196770e0c3b42386403c4ebbd1ea85fc8b2cd0af9e19529d69b47151c"

URI_x86_64_v2_rust-lexical-parse-float+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+default-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+default-devel.sha256sum] = "fef8d2f8d74dfdb8ad43dd85e96b1a390aa8eff65b4e00c07b5d498017e07cc5"

URI_x86_64_v2_rust-lexical-parse-float+f128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+f128-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+f128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+f128-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+f128-devel.sha256sum] = "857a3d27a4f3f19e79ede26391845abf2fd2a89ee4646558d2cc272e61084894"

URI_x86_64_v2_rust-lexical-parse-float+f16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+f16-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+f16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+f16-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+f16-devel.sha256sum] = "90a5313d8012c423cee6f11a611c5e6f226f18312d8912083ea973b0dbd7b42e"

URI_x86_64_v2_rust-lexical-parse-float+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+format-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+format-devel.sha256sum] = "c5ffdfeb93c1cecd24391238dfd429df23313d819d693d9901230f9413e795ac"

URI_x86_64_v2_rust-lexical-parse-float+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+lint-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+lint-devel.sha256sum] = "e4bb5b1c8b001e4b8aec66785235de08c75fa7230f526a3a714cc95cef7ae0c7"

URI_x86_64_v2_rust-lexical-parse-float+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+power-of-two-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+power-of-two-devel.sha256sum] = "1f0489f320fb3df5e884379556feb2a1d1f597aa5df5648e05ed398cd1add341"

URI_x86_64_v2_rust-lexical-parse-float+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+radix-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+radix-devel.sha256sum] = "6df36797d28e0706226876434a4933aad6a5d4445e50a12aa40682d838200304"

URI_x86_64_v2_rust-lexical-parse-float+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float+std-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float+std-devel.sha256sum] = "780c5d6ef7d6e989619b9466dd9d2f1c6430576eeefad61064d10b83cd48ef14"

URI_x86_64_v2_rust-lexical-parse-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-float-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-float-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-float-devel.sha256sum] = "7bccb1a19f6ca25ff9ff03127d33379d2a9d84b14c9adbee843d0f9ed6d4a5a1"

URI_aarch64_rust-lexical-parse-float+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+compact-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+compact-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+compact-devel.sha256sum] = "61c42556bcd9cc2abd0a16c46f21da46e756bcb37b213965979c9ff1b3bc4d8b"

URI_aarch64_rust-lexical-parse-float+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+default-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+default-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+default-devel.sha256sum] = "676beff1f055bb9ad59cd26e04aea8301c7673b0d33402b122ca4d41fb5f0932"

URI_aarch64_rust-lexical-parse-float+f128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+f128-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float+f128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+f128-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+f128-devel.sha256sum] = "aad1b43b79acfa4436113855248346134f89a0c4fca342baae560c1561956441"

URI_aarch64_rust-lexical-parse-float+f16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+f16-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float+f16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+f16-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+f16-devel.sha256sum] = "400a3d3c600313a190510f1bbb7a3bf64773a633229d67ae06e35f0365c0f9ac"

URI_aarch64_rust-lexical-parse-float+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+format-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+format-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+format-devel.sha256sum] = "94acc4e1c2519d7cf2c2740521e39bbcc487ca88190379e5a46eecc8dcf459ed"

URI_aarch64_rust-lexical-parse-float+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+lint-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+lint-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+lint-devel.sha256sum] = "8966d1a24c708fa51c941776f926a3924146301b71d28ddb921a27e87f7eb5c0"

URI_aarch64_rust-lexical-parse-float+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+power-of-two-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+power-of-two-devel.sha256sum] = "3a7ffb10bb39a958d362753b83106e880e7597baab24989598b58815bddd03c0"

URI_aarch64_rust-lexical-parse-float+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+radix-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+radix-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+radix-devel.sha256sum] = "dbca10a485b3ea930935e2e572df17c877f706c93826b4a69256b944a66180a5"

URI_aarch64_rust-lexical-parse-float+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float+std-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float+std-devel}"
SRC_URI[aarch64_rust-lexical-parse-float+std-devel.sha256sum] = "7431f5a9cf5a9a67947eef83f99c0d3aa8c965952f48b1242936361017a8a2a7"

URI_aarch64_rust-lexical-parse-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-float-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-float-devel}"
SRC_URI[aarch64_rust-lexical-parse-float-devel.sha256sum] = "2f91f81ea15c054ebddbbf2a2b3ceedb015b71d567b2d3fcdca60bb04c9457aa"

RDEPENDS:rust-lexical-parse-float+compact-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+compact-devel \
 rust-lexical-util+compact-devel \
 "
RDEPENDS:rust-lexical-parse-float+default-devel = " \
 cargo \
 rust-lexical-parse-float+std-devel \
 rust-lexical-parse-float-devel \
 "
RDEPENDS:rust-lexical-parse-float+f128-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-util+f128-devel \
 "
RDEPENDS:rust-lexical-parse-float+f16-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-util+f16-devel \
 "
RDEPENDS:rust-lexical-parse-float+format-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+format-devel \
 rust-lexical-util+format-devel \
 "
RDEPENDS:rust-lexical-parse-float+lint-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+lint-devel \
 rust-lexical-util+lint-devel \
 "
RDEPENDS:rust-lexical-parse-float+power-of-two-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-util+power-of-two-devel \
 "
RDEPENDS:rust-lexical-parse-float+radix-devel = " \
 cargo \
 rust-lexical-parse-float+power-of-two-devel \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+radix-devel \
 rust-lexical-util+radix-devel \
 "
RDEPENDS:rust-lexical-parse-float+std-devel = " \
 cargo \
 rust-lexical-parse-float-devel \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-util+std-devel \
 "
RDEPENDS:rust-lexical-parse-float-devel = " \
 cargo \
 rust \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+parse-floats-devel \
 rust-lexical-util-devel \
 "
