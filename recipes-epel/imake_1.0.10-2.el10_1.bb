# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "imake"
PV = "1.0.10"
PR = "2.el10_1"
PACKAGES = " \
 imake \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/imake-1.0.10-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a344809b5542dbc40a52c8fdda3c75262f231bfa1ab11ed2d547b2827f8e5936"

URI_x86_64_v2_imake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imake-1.0.10-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_imake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imake}"
SRC_URI[x86_64_v2_imake.sha256sum] = "94b5a38950cfa6cb4c9cfd3f2efeb6f7bf1a5c7b2e3b0e1a2d6305f282e65640"

URI_aarch64_imake = "${EPEL_MIRROR}/aarch64/Packages/i/imake-1.0.10-2.el10_1.aarch64.rpm;name=aarch64_imake;unpack=0"
SRC_URI:append = " ${URI_aarch64_imake}"
SRC_URI[aarch64_imake.sha256sum] = "1379a918a7039074d72b5116dff3e70c509fdd024d9019ebc587f17977f460b0"

RDEPENDS:imake = " \
 bash \
 gcc \
 glibc \
 perl-interpreter \
 "
