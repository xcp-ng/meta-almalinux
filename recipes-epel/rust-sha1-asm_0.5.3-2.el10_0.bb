# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha1-asm"
PV = "0.5.3"
PR = "2.el10_0"
PACKAGES = " \
 rust-sha1-asm+default-devel \
 rust-sha1-asm-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-sha1-asm-0.5.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2400abc0a165b0b60568fc0ce1b30f8935a1440402b29e0dfd3791cd1064bffb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-asm+default-devel-0.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-asm+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sha1-asm+default-devel.sha256sum] = "43393f812fdefa4fd2256ae1cc7ba6d73e40c285b2f25e6b64c4c7da46d085bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-asm-devel-0.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-asm-devel;unpack=0"
SRC_URI[x86_64_v2_rust-sha1-asm-devel.sha256sum] = "1900a113d77404507060c6c468463dd01d3b98bec476d396d553b8524a0b317f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-asm+default-devel-0.5.3-2.el10_0.noarch.rpm;name=aarch64_rust-sha1-asm+default-devel;unpack=0"
SRC_URI[aarch64_rust-sha1-asm+default-devel.sha256sum] = "887a6384ab18e76cff5439ab5a28adc93c1c6d7d7abcdbb664247870bdb5a6ab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-asm-devel-0.5.3-2.el10_0.noarch.rpm;name=aarch64_rust-sha1-asm-devel;unpack=0"
SRC_URI[aarch64_rust-sha1-asm-devel.sha256sum] = "08e527ba70017ef5746428c8d7d50bd99c6ad387fd7f3d29ebd2459e16c04eb2"

RDEPENDS:rust-sha1-asm+default-devel = " \
 cargo \
 rust-sha1-asm-devel \
 "
RDEPENDS:rust-sha1-asm-devel = " \
 cargo \
 rust-cc+default-devel \
 "
