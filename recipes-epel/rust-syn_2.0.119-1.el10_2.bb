# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syn"
PV = "2.0.119"
PR = "1.el10_2"
PACKAGES = " \
 rust-syn+clone-impls-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+test-devel \
 rust-syn+visit-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syn-2.0.119-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e49b6be98ec0f909b9f6e06e2619bdc9c9ef1d52a45a83993462ae9a1c18b324"

URI_x86_64_v2_rust-syn+clone-impls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+clone-impls-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+clone-impls-devel}"
SRC_URI[x86_64_v2_rust-syn+clone-impls-devel.sha256sum] = "f0d2ed9bc3844dd08d9dbc2d9db5f8712d9777b2a76252df10d318193c9fd443"

URI_x86_64_v2_rust-syn+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+default-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+default-devel}"
SRC_URI[x86_64_v2_rust-syn+default-devel.sha256sum] = "cfa4d5e437b973575a56483c1aaafe848fc530f46162ae0b78695b72aeea80dc"

URI_x86_64_v2_rust-syn+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+derive-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+derive-devel}"
SRC_URI[x86_64_v2_rust-syn+derive-devel.sha256sum] = "76208474861a2a2670b0f2c53fa1329c756b915d43cc8505a13291ec3e632a11"

URI_x86_64_v2_rust-syn+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+extra-traits-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-syn+extra-traits-devel.sha256sum] = "33a8d1d3d8d8341de1b3bbd0ad659146167c7efa71ec59a19907acaae43e2326"

URI_x86_64_v2_rust-syn+fold-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+fold-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+fold-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+fold-devel}"
SRC_URI[x86_64_v2_rust-syn+fold-devel.sha256sum] = "f2c06d6b710e746f25c96ed84673db47e2450735c18bdf2426c8a206b9e7e2a5"

URI_x86_64_v2_rust-syn+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+full-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+full-devel}"
SRC_URI[x86_64_v2_rust-syn+full-devel.sha256sum] = "d4f82a998efcd940e46a8d3e3d95bdca22fded0492083815202fb909a0afbaa1"

URI_x86_64_v2_rust-syn+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+parsing-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+parsing-devel}"
SRC_URI[x86_64_v2_rust-syn+parsing-devel.sha256sum] = "a5750063fc0e90966cf6d15786a68cd7b556408c9d9f20eb544c91092a2652c1"

URI_x86_64_v2_rust-syn+printing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+printing-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+printing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+printing-devel}"
SRC_URI[x86_64_v2_rust-syn+printing-devel.sha256sum] = "f967f11d54d80b6e78c0afd787269017229a92a7b00d44791c800744d344db28"

URI_x86_64_v2_rust-syn+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+proc-macro-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-syn+proc-macro-devel.sha256sum] = "050c8edc43b6e35a31b2566a2d17b7401817d0ebc5406f3ae58adba65646a6d6"

URI_x86_64_v2_rust-syn+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+test-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+test-devel}"
SRC_URI[x86_64_v2_rust-syn+test-devel.sha256sum] = "54602a82abedc893923e189cc8ba3654887943ae9d30a8035ad87e95d6c8f52e"

URI_x86_64_v2_rust-syn+visit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+visit-devel}"
SRC_URI[x86_64_v2_rust-syn+visit-devel.sha256sum] = "ac183c91c5966bd86c83dd57b162c8eccbabb0b3ee5834c90d2c117f6badbc24"

URI_x86_64_v2_rust-syn+visit-mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn+visit-mut-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn+visit-mut-devel}"
SRC_URI[x86_64_v2_rust-syn+visit-mut-devel.sha256sum] = "1723a454f64662c2124b42bc4c5b7e636bde3593a239ae3aa713b81997c72434"

URI_x86_64_v2_rust-syn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syn-devel-2.0.119-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syn-devel}"
SRC_URI[x86_64_v2_rust-syn-devel.sha256sum] = "f8b6f3079be31ad48e5e6907af25f36f2a9650f5b5519431d8df7d1d5a4913c9"

URI_aarch64_rust-syn+clone-impls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+clone-impls-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+clone-impls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+clone-impls-devel}"
SRC_URI[aarch64_rust-syn+clone-impls-devel.sha256sum] = "ccae184eafe934b6b99fc6e25ce50e4b6af43a6ac85b8c09a276cdfe66ae8c63"

URI_aarch64_rust-syn+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+default-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+default-devel}"
SRC_URI[aarch64_rust-syn+default-devel.sha256sum] = "8b3218c56920a5d665bc8c05a3a81c9491ffac54bc4674a963d295316dd23422"

URI_aarch64_rust-syn+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+derive-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+derive-devel}"
SRC_URI[aarch64_rust-syn+derive-devel.sha256sum] = "2b032f9539b2be31a00fe19965210a77b73bb9f15204f8173db808b02330ff8d"

URI_aarch64_rust-syn+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+extra-traits-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+extra-traits-devel}"
SRC_URI[aarch64_rust-syn+extra-traits-devel.sha256sum] = "545dbc273d93b044b27bca216bb3eba02b78d3cbede63ce696bc6286a81c208f"

URI_aarch64_rust-syn+fold-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+fold-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+fold-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+fold-devel}"
SRC_URI[aarch64_rust-syn+fold-devel.sha256sum] = "78244b46d983d78fc1b756c9b8c28d8fcfa3b10502e56a2a6bbd4bbaa46744e5"

URI_aarch64_rust-syn+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+full-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+full-devel}"
SRC_URI[aarch64_rust-syn+full-devel.sha256sum] = "e432c03695c368e0771a136a02e8cf4e5accd4198d521ac62013599108a9f664"

URI_aarch64_rust-syn+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+parsing-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+parsing-devel}"
SRC_URI[aarch64_rust-syn+parsing-devel.sha256sum] = "71aac14c361e6d62f9a630b0c7c1156d5cd26c182ea7968b0d592fb6549f2ae8"

URI_aarch64_rust-syn+printing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+printing-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+printing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+printing-devel}"
SRC_URI[aarch64_rust-syn+printing-devel.sha256sum] = "0c233dc4bdcc9f59fb0f2de2a96334bcd4ab7c81c963bff14ff0432b9bd9afb6"

URI_aarch64_rust-syn+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+proc-macro-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+proc-macro-devel}"
SRC_URI[aarch64_rust-syn+proc-macro-devel.sha256sum] = "70541e03f39fa1de3d6b7d7c568fc2a9cf9a7a1abc4a3809f4c47b5867f4d507"

URI_aarch64_rust-syn+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+test-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+test-devel}"
SRC_URI[aarch64_rust-syn+test-devel.sha256sum] = "beea3fc0123581d0e9e5bd52a50c061b91c57ef5d4e02be1a3b418290a94460e"

URI_aarch64_rust-syn+visit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+visit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+visit-devel}"
SRC_URI[aarch64_rust-syn+visit-devel.sha256sum] = "80a67738311cf812288e581f3d5adbf03d67b567308e8e139544b96c8ad4c8c3"

URI_aarch64_rust-syn+visit-mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn+visit-mut-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn+visit-mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn+visit-mut-devel}"
SRC_URI[aarch64_rust-syn+visit-mut-devel.sha256sum] = "51abca52628869e90a3671798d226b6014d1c44265f0975f4aaae774e24009e6"

URI_aarch64_rust-syn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syn-devel-2.0.119-1.el10_2.noarch.rpm;name=aarch64_rust-syn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syn-devel}"
SRC_URI[aarch64_rust-syn-devel.sha256sum] = "b915b15f05ead7b92b92cb7ca96d1339ad036dbb839e995b4f0c67a931f0219d"

RDEPENDS:rust-syn+clone-impls-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+default-devel = " \
 cargo \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+derive-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+extra-traits-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+fold-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+full-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+parsing-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+printing-devel = " \
 cargo \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+test-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn+visit-mut-devel = " \
 cargo \
 rust-syn-devel \
 "
RDEPENDS:rust-syn-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-unicode-ident+default-devel \
 "
