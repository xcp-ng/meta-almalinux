# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dumpet"
PV = "2.1"
PR = "33.el10_0"
PACKAGES = " \
 dumpet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dumpet-2.1-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5ecdb73b9c527c48b1d5d6c8d627c7056323591a671db34ab64651f53b67697"

URI_x86_64_v2_dumpet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dumpet-2.1-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dumpet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dumpet}"
SRC_URI[x86_64_v2_dumpet.sha256sum] = "ce4d2b9b08dfd46652056b2efd5010d7b8a2aac606ebefe282ae27a0be169702"

URI_aarch64_dumpet = "${EPEL_MIRROR}/aarch64/Packages/d/dumpet-2.1-33.el10_0.aarch64.rpm;name=aarch64_dumpet;unpack=0"
SRC_URI:append = " ${URI_aarch64_dumpet}"
SRC_URI[aarch64_dumpet.sha256sum] = "0a571a26dd46ded9085ebe82463f7c4e8b4300422ceaf6f89c16c7f7a1e91b61"

RDEPENDS:dumpet = " \
 glibc \
 libxml2 \
 popt \
 "
