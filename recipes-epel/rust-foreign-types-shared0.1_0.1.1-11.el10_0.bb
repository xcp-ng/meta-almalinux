# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foreign-types-shared0.1"
PV = "0.1.1"
PR = "11.el10_0"
PACKAGES = " \
 rust-foreign-types-shared0.1+default-devel \
 rust-foreign-types-shared0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foreign-types-shared0.1-0.1.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed9aea81c14e18bc5590979e223326a44719ddc980217e7b04c1db41dc600b63"

URI_x86_64_v2_rust-foreign-types-shared0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types-shared0.1+default-devel-0.1.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types-shared0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types-shared0.1+default-devel}"
SRC_URI[x86_64_v2_rust-foreign-types-shared0.1+default-devel.sha256sum] = "1d1191ce8c1a127a1ff81a187ceb47c062b8648741484f96ff4cc3b2fa188d09"

URI_x86_64_v2_rust-foreign-types-shared0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types-shared0.1-devel-0.1.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types-shared0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types-shared0.1-devel}"
SRC_URI[x86_64_v2_rust-foreign-types-shared0.1-devel.sha256sum] = "d67d6558336e6258a306935a87703ef71655ced9b75d3bb80385a4d4e28bc498"

URI_aarch64_rust-foreign-types-shared0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types-shared0.1+default-devel-0.1.1-11.el10_0.noarch.rpm;name=aarch64_rust-foreign-types-shared0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types-shared0.1+default-devel}"
SRC_URI[aarch64_rust-foreign-types-shared0.1+default-devel.sha256sum] = "816e9f025334ab4a4a227f3b4e1e4da6fbb2fd3ef7c3401a9adb36418f5e7605"

URI_aarch64_rust-foreign-types-shared0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types-shared0.1-devel-0.1.1-11.el10_0.noarch.rpm;name=aarch64_rust-foreign-types-shared0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types-shared0.1-devel}"
SRC_URI[aarch64_rust-foreign-types-shared0.1-devel.sha256sum] = "5c0c34dcfa43b83cda1f8ac13d84816a2191e7f2810d73453b6d56b798333967"

RDEPENDS:rust-foreign-types-shared0.1+default-devel = " \
 cargo \
 rust-foreign-types-shared0.1-devel \
 "
RDEPENDS:rust-foreign-types-shared0.1-devel = " \
 cargo \
 "
