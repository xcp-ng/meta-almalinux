# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qt5compat"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qt5compat \
 qt6-qt5compat-devel \
 qt6-qt5compat-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qt5compat-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65610df0505f77cca384d16e871a1bf65b4a4ca3af7d36c168f6159257a41458"

URI_x86_64_v2_qt6-qt5compat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt5compat-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt5compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt5compat}"
SRC_URI[x86_64_v2_qt6-qt5compat.sha256sum] = "d29792d7c2d442107fc294a3786eb3a0962983ebafc4520b2c6791d343cc3ea0"

URI_x86_64_v2_qt6-qt5compat-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt5compat-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt5compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt5compat-devel}"
SRC_URI[x86_64_v2_qt6-qt5compat-devel.sha256sum] = "877bae5724e5f6abca6e815d2b400fbc2478bc7a51314bb392f4dc7b4e430ef7"

URI_x86_64_v2_qt6-qt5compat-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qt5compat-examples-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt5compat-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt5compat-examples}"
SRC_URI[x86_64_v2_qt6-qt5compat-examples.sha256sum] = "c124fcf8461fa440fc23bc98b65a332cdc6b348de5ceb8301dace7ec2e33ce9a"

URI_aarch64_qt6-qt5compat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt5compat-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qt5compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt5compat}"
SRC_URI[aarch64_qt6-qt5compat.sha256sum] = "06cf4a65092e40d26de77e08f4ae83eed42373b5260e4422b0387efad001e0de"

URI_aarch64_qt6-qt5compat-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt5compat-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qt5compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt5compat-devel}"
SRC_URI[aarch64_qt6-qt5compat-devel.sha256sum] = "7c2f8189851f138b9d5f35a4a0a2999f0183959490dd561e818dadf1295cf779"

URI_aarch64_qt6-qt5compat-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qt5compat-examples-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qt5compat-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt5compat-examples}"
SRC_URI[aarch64_qt6-qt5compat-examples.sha256sum] = "1f8aa7f48b39b225f556afb63f2289f27acbe2c561d4b72016fffba567f20bf9"

RDEPENDS:qt6-qt5compat = " \
 glibc \
 libicu \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtshadertools \
 "
RDEPENDS:qt6-qt5compat-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qt5compat \
 qt6-qtbase-devel \
 "
RDEPENDS:qt6-qt5compat-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
