# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-executor"
PV = "1.14.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-async-executor+default-devel \
 rust-async-executor+static-devel \
 rust-async-executor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-executor-1.14.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4908e131457bfef10040db7bc6690bb9498d61897ebf1216e34e9c76bfb766e6"

URI_x86_64_v2_rust-async-executor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-executor+default-devel-1.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-executor+default-devel}"
SRC_URI[x86_64_v2_rust-async-executor+default-devel.sha256sum] = "4db89c7b1395111d91f7f38221af6f838a430b804e46a9e441609c09c0542239"

URI_x86_64_v2_rust-async-executor+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-executor+static-devel-1.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-executor+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-executor+static-devel}"
SRC_URI[x86_64_v2_rust-async-executor+static-devel.sha256sum] = "3a59bc14a826e14a1ff541f55630ece5ed1f448eed37208c356d00bd31cc96d8"

URI_x86_64_v2_rust-async-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-executor-devel-1.14.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-executor-devel}"
SRC_URI[x86_64_v2_rust-async-executor-devel.sha256sum] = "45a1c6f38cd8fedfbc21782d07117078de26057c6774631e5d8239f3be076e61"

URI_aarch64_rust-async-executor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-executor+default-devel-1.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-async-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-executor+default-devel}"
SRC_URI[aarch64_rust-async-executor+default-devel.sha256sum] = "a86fe801b5d85cecf322477c88599ab52f30d17c83968b355448ddc94c60ad45"

URI_aarch64_rust-async-executor+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-executor+static-devel-1.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-async-executor+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-executor+static-devel}"
SRC_URI[aarch64_rust-async-executor+static-devel.sha256sum] = "d40a5ba0365c013edcec77d2b1e93eb275a6713254c230013398a6b412e65da5"

URI_aarch64_rust-async-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-executor-devel-1.14.0-1.el10_2.noarch.rpm;name=aarch64_rust-async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-executor-devel}"
SRC_URI[aarch64_rust-async-executor-devel.sha256sum] = "85a4e9a500c476acbdb430b8f532b2427130e950ad4f1ad1358ee49bda9b9010"

RDEPENDS:rust-async-executor+default-devel = " \
 cargo \
 rust-async-executor-devel \
 "
RDEPENDS:rust-async-executor+static-devel = " \
 cargo \
 rust-async-executor-devel \
 "
RDEPENDS:rust-async-executor-devel = " \
 cargo \
 rust \
 rust-async-task+default-devel \
 rust-concurrent-queue+default-devel \
 rust-fastrand+default-devel \
 rust-futures-lite-devel \
 rust-pin-project-lite+default-devel \
 rust-slab+default-devel \
 "
