# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-proxy-core"
PV = "9.9"
PR = "1.el10_2"
PACKAGES = " \
 globus-gsi-proxy-core \
 globus-gsi-proxy-core-devel \
 globus-gsi-proxy-core-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-proxy-core-9.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c35472411bd4c2206176d103b6218f018f914f87964be8ab3cde651870d16b65"

URI_x86_64_v2_globus-gsi-proxy-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-core-9.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-core}"
SRC_URI[x86_64_v2_globus-gsi-proxy-core.sha256sum] = "1c303b1b35dbecc0084cf965b99386d75bf14a024c7ca2124dd3bffd1a9ab8f8"

URI_x86_64_v2_globus-gsi-proxy-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-core-devel-9.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-proxy-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-core-devel}"
SRC_URI[x86_64_v2_globus-gsi-proxy-core-devel.sha256sum] = "40164a44cc149a98ef8b9427db28270ef3d3881bca7e4f6f908195c5d88951c8"

URI_x86_64_v2_globus-gsi-proxy-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-proxy-core-doc-9.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-proxy-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gsi-proxy-core-doc}"
SRC_URI[x86_64_v2_globus-gsi-proxy-core-doc.sha256sum] = "b6fc00e42d60843b1f9b2221e48cde6053a6178ea3b636cec52cc937f55d07f3"

URI_aarch64_globus-gsi-proxy-core = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-core-9.9-1.el10_2.aarch64.rpm;name=aarch64_globus-gsi-proxy-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-core}"
SRC_URI[aarch64_globus-gsi-proxy-core.sha256sum] = "ad78a8e76d286a0dc37297ce6e723af9035301e5898dcb32e02c6e17e6948b42"

URI_aarch64_globus-gsi-proxy-core-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-core-devel-9.9-1.el10_2.aarch64.rpm;name=aarch64_globus-gsi-proxy-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-core-devel}"
SRC_URI[aarch64_globus-gsi-proxy-core-devel.sha256sum] = "70aa61d19c4b65694e7e9d539321aa3b941d64f4e1f7dabe2cd90845c4b88f46"

URI_aarch64_globus-gsi-proxy-core-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-proxy-core-doc-9.9-1.el10_2.noarch.rpm;name=aarch64_globus-gsi-proxy-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gsi-proxy-core-doc}"
SRC_URI[aarch64_globus-gsi-proxy-core-doc.sha256sum] = "163f887ee7b3c71bca55c6965fee6f54831db01def18215c0e35c09202d46b3f"

RDEPENDS:globus-gsi-proxy-core = " \
 glibc \
 globus-common \
 globus-gsi-credential \
 globus-gsi-openssl-error \
 globus-gsi-proxy-ssl \
 globus-openssl-module \
 openssl-libs \
 "
RDEPENDS:globus-gsi-proxy-core-devel = " \
 globus-common-devel \
 globus-gsi-cert-utils-devel \
 globus-gsi-credential-devel \
 globus-gsi-openssl-error-devel \
 globus-gsi-proxy-core \
 globus-gsi-proxy-ssl-devel \
 globus-gsi-sysconfig-devel \
 globus-openssl-module-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-proxy-core-doc = " \
 "
