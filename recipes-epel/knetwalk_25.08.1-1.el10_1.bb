# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knetwalk"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 knetwalk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knetwalk-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a53f517bb02b8101a225a71408f25443ddb3bc3fdd8666fe20c90c6867f70805"

URI_x86_64_v2_knetwalk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knetwalk-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knetwalk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knetwalk}"
SRC_URI[x86_64_v2_knetwalk.sha256sum] = "d185b4d55d06ada2c79719f02c1ec0c70669456ce1c43b6318ec614f9f6697c1"

URI_aarch64_knetwalk = "${EPEL_MIRROR}/aarch64/Packages/k/knetwalk-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_knetwalk;unpack=0"
SRC_URI:append = " ${URI_aarch64_knetwalk}"
SRC_URI[aarch64_knetwalk.sha256sum] = "c0e26ab87a4577e9b5c2aa8b80b26adbf009ef542b6f7fd43b50b8cf1fab3a66"

RDEPENDS:knetwalk = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
