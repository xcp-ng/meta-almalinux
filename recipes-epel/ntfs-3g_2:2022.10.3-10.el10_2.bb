# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntfs-3g"
PE = "2"
PV = "2022.10.3"
PR = "10.el10_2"
PACKAGES = " \
 ntfs-3g \
 ntfs-3g-devel \
 ntfs-3g-libs \
 ntfsprogs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntfs-3g-2022.10.3-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2d888013b623c3d4182095df4fc565426561dbb7005cdfc9a625917c031b0ff"

URI_x86_64_v2_ntfs-3g = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-2022.10.3-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g}"
SRC_URI[x86_64_v2_ntfs-3g.sha256sum] = "422fa9e1d1fb49097da04581818d84447965393061bef3642d8dde28f126e614"

URI_x86_64_v2_ntfs-3g-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-devel-2022.10.3-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-devel}"
SRC_URI[x86_64_v2_ntfs-3g-devel.sha256sum] = "65969d9d7c5ab49bf8b69985d441f1262675545d77301885160f91b0cdbfc3d8"

URI_x86_64_v2_ntfs-3g-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-libs-2022.10.3-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-libs}"
SRC_URI[x86_64_v2_ntfs-3g-libs.sha256sum] = "724f921d6827580f6023b49bcfb33775bcf26307ccc807d75d5e7e8ccfe5deed"

URI_x86_64_v2_ntfsprogs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfsprogs-2022.10.3-10.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfsprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfsprogs}"
SRC_URI[x86_64_v2_ntfsprogs.sha256sum] = "78544c2da9ed9c91015d9bf07cf1946a6282ccd3b7a5b7840fb9ef4d3142d9f6"

URI_aarch64_ntfs-3g = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-2022.10.3-10.el10_2.aarch64.rpm;name=aarch64_ntfs-3g;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g}"
SRC_URI[aarch64_ntfs-3g.sha256sum] = "eebbd899e7e3148d894917d54655c414d1f369a618299894c1414120f8838000"

URI_aarch64_ntfs-3g-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-devel-2022.10.3-10.el10_2.aarch64.rpm;name=aarch64_ntfs-3g-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-devel}"
SRC_URI[aarch64_ntfs-3g-devel.sha256sum] = "2f0c646bddd3b72316130990ec1b0049823a64d3ebbfad61c5a648b8b907d0e2"

URI_aarch64_ntfs-3g-libs = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-libs-2022.10.3-10.el10_2.aarch64.rpm;name=aarch64_ntfs-3g-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-libs}"
SRC_URI[aarch64_ntfs-3g-libs.sha256sum] = "580c4e88efdc89486ee37f3be07bb8d5c608a4ae4218d2578bb29c6147789883"

URI_aarch64_ntfsprogs = "${EPEL_MIRROR}/aarch64/Packages/n/ntfsprogs-2022.10.3-10.el10_2.aarch64.rpm;name=aarch64_ntfsprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfsprogs}"
SRC_URI[aarch64_ntfsprogs.sha256sum] = "b19a2eb029e50147cf0e7cea778d13eaa6af8f0e2b549f953926461d7ae65477"

RDEPENDS:ntfs-3g = " \
 glibc \
 ntfs-3g-libs \
 "
RDEPENDS:ntfs-3g-devel = " \
 ntfs-3g-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ntfs-3g-libs = " \
 glibc \
 "
RDEPENDS:ntfsprogs = " \
 glibc \
 gnutls \
 libgcrypt \
 libuuid \
 ntfs-3g-libs \
 "
