# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-HUnit"
PV = "1.6.2.0"
PR = "11.el10_0"
PACKAGES = " \
 ghc-HUnit \
 ghc-HUnit-devel \
 ghc-HUnit-doc \
 ghc-HUnit-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-HUnit-1.6.2.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72e25b247aa437ba7d00827bfc7e979137bd4561d62434471029ce37d93344ef"

URI_x86_64_v2_ghc-HUnit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HUnit-1.6.2.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HUnit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HUnit}"
SRC_URI[x86_64_v2_ghc-HUnit.sha256sum] = "99ff507f5815ce8988446fe91ad5b9053aeb46129e5b4d5c4c65f069ddea4aab"

URI_x86_64_v2_ghc-HUnit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HUnit-devel-1.6.2.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HUnit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HUnit-devel}"
SRC_URI[x86_64_v2_ghc-HUnit-devel.sha256sum] = "1dae656629b6618c65b21416819408b48066d37510b7cd5d49da553c09bd7f34"

URI_x86_64_v2_ghc-HUnit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HUnit-doc-1.6.2.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-HUnit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HUnit-doc}"
SRC_URI[x86_64_v2_ghc-HUnit-doc.sha256sum] = "1f9f19dc78c4967bf75c1b1db9400b4a5dbae4c3ad40dbe71548e9ae35b1d33d"

URI_x86_64_v2_ghc-HUnit-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-HUnit-prof-1.6.2.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-HUnit-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-HUnit-prof}"
SRC_URI[x86_64_v2_ghc-HUnit-prof.sha256sum] = "09d77dccd7792b7d9be4643748b386b42aaf4bd0a37d0c2e94459e5882c8fb33"

URI_aarch64_ghc-HUnit = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HUnit-1.6.2.0-11.el10_0.aarch64.rpm;name=aarch64_ghc-HUnit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HUnit}"
SRC_URI[aarch64_ghc-HUnit.sha256sum] = "bfc5d20457f67cfb8468a5891691ed033b89837966cd049cf16bda23c0420f4c"

URI_aarch64_ghc-HUnit-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HUnit-devel-1.6.2.0-11.el10_0.aarch64.rpm;name=aarch64_ghc-HUnit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HUnit-devel}"
SRC_URI[aarch64_ghc-HUnit-devel.sha256sum] = "ef53c7ccb0e88deba86677d45ec73337427f6be472ddb4843eccae61a57afecc"

URI_aarch64_ghc-HUnit-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HUnit-doc-1.6.2.0-11.el10_0.noarch.rpm;name=aarch64_ghc-HUnit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HUnit-doc}"
SRC_URI[aarch64_ghc-HUnit-doc.sha256sum] = "f51ab3aa5147aa6a9402c71c800b7f69fe5d2a7c4f1217dd75a9ceefead69fb2"

URI_aarch64_ghc-HUnit-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-HUnit-prof-1.6.2.0-11.el10_0.aarch64.rpm;name=aarch64_ghc-HUnit-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-HUnit-prof}"
SRC_URI[aarch64_ghc-HUnit-prof.sha256sum] = "de176563e483b567522bdf1a274c6fc3ff945c3d5964058202e2652815f7f9db"

RDEPENDS:ghc-HUnit = " \
 ghc-array \
 ghc-base \
 ghc-call-stack \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-HUnit-devel = " \
 ghc-HUnit \
 ghc-base-devel \
 ghc-call-stack-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 "
RDEPENDS:ghc-HUnit-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-HUnit-prof = " \
 ghc-HUnit-devel \
 ghc-base-prof \
 ghc-call-stack-prof \
 ghc-deepseq-prof \
 "
