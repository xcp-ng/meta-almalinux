# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec-derive"
PV = "0.11.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-zerovec-derive+default-devel \
 rust-zerovec-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-derive-0.11.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e902605ddd868bc3b694c7304703e38c10a4aba9ff101a59b81a532a7071949"

URI_x86_64_v2_rust-zerovec-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive+default-devel-0.11.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerovec-derive+default-devel.sha256sum] = "6ed1cd759d4996f36ea2ec5781668738fde8966dd68610def36a7be9074a1a36"

URI_x86_64_v2_rust-zerovec-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive-devel-0.11.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-derive-devel}"
SRC_URI[x86_64_v2_rust-zerovec-derive-devel.sha256sum] = "63dc596b5178b1abb5ebeaf9a446c14ab3f5213a95ea7e85b1c1306fabdc1bf3"

URI_aarch64_rust-zerovec-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive+default-devel-0.11.2-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-derive+default-devel}"
SRC_URI[aarch64_rust-zerovec-derive+default-devel.sha256sum] = "1eb3f9466ae9cd552507e116211446794d58b4163d0f76f2ac3410ffe79169c3"

URI_aarch64_rust-zerovec-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive-devel-0.11.2-1.el10_1.noarch.rpm;name=aarch64_rust-zerovec-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-derive-devel}"
SRC_URI[aarch64_rust-zerovec-derive-devel.sha256sum] = "7509c995b175ba6243c388805f5b46c3e27bf909bc5f1057a02cd5222c0892c8"

RDEPENDS:rust-zerovec-derive+default-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 "
RDEPENDS:rust-zerovec-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
