# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liborc"
PV = "2.0.3"
PR = "1.el10_0"
PACKAGES = " \
 liborc-devel \
 liborc2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liborc-2.0.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "204c140cec5ec7f96ab8d05e583eb81d9fc85efc1326f3a1a2436ae2ac74e79b"

URI_x86_64_v2_liborc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liborc-devel-2.0.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liborc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liborc-devel}"
SRC_URI[x86_64_v2_liborc-devel.sha256sum] = "c62feac0fbfc0d733d1eba29db524cdfcac0abfdaccf49b5f170a45b32f1a81b"

URI_x86_64_v2_liborc2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liborc2-2.0.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liborc2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liborc2}"
SRC_URI[x86_64_v2_liborc2.sha256sum] = "36e18c6095665cf4d833d20333be4d3d5e0973c3666d39b1d66a2696a254538b"

URI_aarch64_liborc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liborc-devel-2.0.3-1.el10_0.aarch64.rpm;name=aarch64_liborc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liborc-devel}"
SRC_URI[aarch64_liborc-devel.sha256sum] = "768d27e8f0b1a9ad9958bfad54e752f03b44bdf979e7387210102d929cbd6328"

URI_aarch64_liborc2 = "${EPEL_MIRROR}/aarch64/Packages/l/liborc2-2.0.3-1.el10_0.aarch64.rpm;name=aarch64_liborc2;unpack=0"
SRC_URI:append = " ${URI_aarch64_liborc2}"
SRC_URI[aarch64_liborc2.sha256sum] = "12b4a6e20946431bcd1ea651bd99ced8df70b21991286b7d0609a332fd89e41f"

RDEPENDS:liborc-devel = " \
 liborc2 \
 "
RDEPENDS:liborc2 = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 protobuf \
 snappy \
 zlib-ng-compat \
 "
