# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parallel-Pipes"
PV = "0.201"
PR = "1.el10_1"
PACKAGES = " \
 perl-Parallel-Pipes \
 perl-Parallel-Pipes-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Parallel-Pipes-0.201-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa2d18ff19253d0702696af20d36c2d0afa398c188d5257c3b9325d5db122f18"

URI_x86_64_v2_perl-Parallel-Pipes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parallel-Pipes-0.201-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parallel-Pipes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parallel-Pipes}"
SRC_URI[x86_64_v2_perl-Parallel-Pipes.sha256sum] = "0468767e52c36c1d2200934327c18d7e4a48547a9c4a6a2ace4f008f4dd95f9a"

URI_x86_64_v2_perl-Parallel-Pipes-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parallel-Pipes-tests-0.201-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parallel-Pipes-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parallel-Pipes-tests}"
SRC_URI[x86_64_v2_perl-Parallel-Pipes-tests.sha256sum] = "31fed8c9cedae37c69f47f37c9bfd7232c9c5a2ebb0a35ce5a9b9f7abacb09b3"

URI_aarch64_perl-Parallel-Pipes = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parallel-Pipes-0.201-1.el10_1.noarch.rpm;name=aarch64_perl-Parallel-Pipes;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parallel-Pipes}"
SRC_URI[aarch64_perl-Parallel-Pipes.sha256sum] = "254c719c423050c759ea7be04cb4491948e3f848669a48425ae645f962bf3159"

URI_aarch64_perl-Parallel-Pipes-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parallel-Pipes-tests-0.201-1.el10_1.noarch.rpm;name=aarch64_perl-Parallel-Pipes-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parallel-Pipes-tests}"
SRC_URI[aarch64_perl-Parallel-Pipes-tests.sha256sum] = "3cc86bea100b5b6de59f0a44133e6b3f43160e4d66c49175edea0ae7b994d404"

RDEPENDS:perl-Parallel-Pipes = " \
 perl-Carp \
 perl-IO \
 perl-Parallel-Pipes \
 perl-Storable \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Parallel-Pipes-tests = " \
 bash \
 perl-File-Temp \
 perl-Parallel-Pipes \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 "
