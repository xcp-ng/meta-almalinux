# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sudo"
PV = "1.9.17"
PR = "4.p2.el10_2"
PACKAGES = " \
 sudo \
 sudo-python-plugin \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sudo-1.9.17-4.p2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac6e70b269afea9f4129899a295fbb9c5695fa0c68312741a20517aa99c5405e"

URI_x86_64_v2_sudo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sudo-1.9.17-4.p2.el10_2.x86_64_v2.rpm;name=x86_64_v2_sudo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sudo}"
SRC_URI[x86_64_v2_sudo.sha256sum] = "351ec618dcd425fbff386ca2de28d75dba1e77a3c4f6f5b46b33429f2d6c8a90"

URI_x86_64_v2_sudo-python-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sudo-python-plugin-1.9.17-4.p2.el10_2.x86_64_v2.rpm;name=x86_64_v2_sudo-python-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sudo-python-plugin}"
SRC_URI[x86_64_v2_sudo-python-plugin.sha256sum] = "0abb22dcf96ee2b8b611f5fadcbcea46256f8ee359cc50ce4faf885c585cbe47"

URI_aarch64_sudo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sudo-1.9.17-4.p2.el10_2.aarch64.rpm;name=aarch64_sudo;unpack=0"
SRC_URI:append = " ${URI_aarch64_sudo}"
SRC_URI[aarch64_sudo.sha256sum] = "fe5801d4fe9f5408e3799794ffd0d69bf1e4d89684b79f62a69cc167fb089941"

URI_aarch64_sudo-python-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sudo-python-plugin-1.9.17-4.p2.el10_2.aarch64.rpm;name=aarch64_sudo-python-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_sudo-python-plugin}"
SRC_URI[aarch64_sudo-python-plugin.sha256sum] = "fe347d6b8ac6d4aa078e52a03e73ef6b6a01b44f3b6518fe78a66f45291ad47c"

RDEPENDS:sudo = " \
 audit-libs \
 glibc \
 libselinux \
 openldap \
 pam \
 pam-libs \
 zlib-ng-compat \
 "
RDEPENDS:sudo-python-plugin = " \
 glibc \
 python3-libs \
 sudo \
 "
