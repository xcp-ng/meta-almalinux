# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osbuild"
PV = "158"
PR = "1.el10"
PACKAGES = " \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 osbuild-selinux \
 python3-osbuild \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/osbuild-158-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14a5343491d0a7b8b1dc77fbd3fe69beab26d65b8cba0a7296d195e68bdd445e"

URI_x86_64_v2_osbuild = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-158-1.el10.noarch.rpm;name=x86_64_v2_osbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild}"
SRC_URI[x86_64_v2_osbuild.sha256sum] = "db136b9f708ebba2495af803bb4676fcd4c2f8b656b9d0bde0db6daf484a7933"

URI_x86_64_v2_osbuild-depsolve-dnf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-depsolve-dnf-158-1.el10.noarch.rpm;name=x86_64_v2_osbuild-depsolve-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-depsolve-dnf}"
SRC_URI[x86_64_v2_osbuild-depsolve-dnf.sha256sum] = "9feba72f74e530322b9cea2bf3d009ba88f05480c688abeb50e4fb16ee14c522"

URI_x86_64_v2_osbuild-luks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-luks2-158-1.el10.noarch.rpm;name=x86_64_v2_osbuild-luks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-luks2}"
SRC_URI[x86_64_v2_osbuild-luks2.sha256sum] = "69fd855ded51d8d69681f1485adff21e3697721d0c6bd6e4e3c903300ca439da"

URI_x86_64_v2_osbuild-lvm2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-lvm2-158-1.el10.noarch.rpm;name=x86_64_v2_osbuild-lvm2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-lvm2}"
SRC_URI[x86_64_v2_osbuild-lvm2.sha256sum] = "e02739cfdd82c6b12a2d618495f8b80318db3661a739f0216e42457e49d61d40"

URI_x86_64_v2_osbuild-ostree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-ostree-158-1.el10.noarch.rpm;name=x86_64_v2_osbuild-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-ostree}"
SRC_URI[x86_64_v2_osbuild-ostree.sha256sum] = "3fb920dc2a434d3338a4773505c9727b1a6ae715e73ecb36ddad16334d094c5b"

URI_x86_64_v2_osbuild-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/osbuild-selinux-158-1.el10.noarch.rpm;name=x86_64_v2_osbuild-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osbuild-selinux}"
SRC_URI[x86_64_v2_osbuild-selinux.sha256sum] = "2c41c5c116f9da573a077ecfb5bdd5f7f2f978dbb7d9c3c1f841d07e71c8befb"

URI_x86_64_v2_python3-osbuild = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-osbuild-158-1.el10.noarch.rpm;name=x86_64_v2_python3-osbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-osbuild}"
SRC_URI[x86_64_v2_python3-osbuild.sha256sum] = "395e70acee46b8e5b6aca3389e4904f803001b589b59ad27c72b527186d050fb"

URI_aarch64_osbuild = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-158-1.el10.noarch.rpm;name=aarch64_osbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild}"
SRC_URI[aarch64_osbuild.sha256sum] = "db136b9f708ebba2495af803bb4676fcd4c2f8b656b9d0bde0db6daf484a7933"

URI_aarch64_osbuild-depsolve-dnf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-depsolve-dnf-158-1.el10.noarch.rpm;name=aarch64_osbuild-depsolve-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-depsolve-dnf}"
SRC_URI[aarch64_osbuild-depsolve-dnf.sha256sum] = "9feba72f74e530322b9cea2bf3d009ba88f05480c688abeb50e4fb16ee14c522"

URI_aarch64_osbuild-luks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-luks2-158-1.el10.noarch.rpm;name=aarch64_osbuild-luks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-luks2}"
SRC_URI[aarch64_osbuild-luks2.sha256sum] = "69fd855ded51d8d69681f1485adff21e3697721d0c6bd6e4e3c903300ca439da"

URI_aarch64_osbuild-lvm2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-lvm2-158-1.el10.noarch.rpm;name=aarch64_osbuild-lvm2;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-lvm2}"
SRC_URI[aarch64_osbuild-lvm2.sha256sum] = "e02739cfdd82c6b12a2d618495f8b80318db3661a739f0216e42457e49d61d40"

URI_aarch64_osbuild-ostree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-ostree-158-1.el10.noarch.rpm;name=aarch64_osbuild-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-ostree}"
SRC_URI[aarch64_osbuild-ostree.sha256sum] = "3fb920dc2a434d3338a4773505c9727b1a6ae715e73ecb36ddad16334d094c5b"

URI_aarch64_osbuild-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/osbuild-selinux-158-1.el10.noarch.rpm;name=aarch64_osbuild-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_osbuild-selinux}"
SRC_URI[aarch64_osbuild-selinux.sha256sum] = "2c41c5c116f9da573a077ecfb5bdd5f7f2f978dbb7d9c3c1f841d07e71c8befb"

URI_aarch64_python3-osbuild = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-osbuild-158-1.el10.noarch.rpm;name=aarch64_python3-osbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-osbuild}"
SRC_URI[aarch64_python3-osbuild.sha256sum] = "395e70acee46b8e5b6aca3389e4904f803001b589b59ad27c72b527186d050fb"

RDEPENDS:osbuild = " \
 bash \
 bubblewrap \
 curl \
 e2fsprogs \
 glibc \
 osbuild-selinux \
 policycoreutils \
 python3 \
 python3-librepo \
 python3-osbuild \
 qemu-img \
 skopeo \
 systemd \
 tar \
 util-linux \
 virtual/coreutils \
 "
RDEPENDS:osbuild-depsolve-dnf = " \
 osbuild \
 python3 \
 python3-dnf \
 "
RDEPENDS:osbuild-luks2 = " \
 cryptsetup \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-lvm2 = " \
 lvm2 \
 osbuild \
 python3 \
 "
RDEPENDS:osbuild-ostree = " \
 osbuild \
 ostree \
 python3 \
 rpm-ostree \
 "
RDEPENDS:osbuild-selinux = " \
 bash \
 libselinux-utils \
 osbuild \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:python3-osbuild = " \
 python3 \
 python3-jsonschema \
 "
