# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pie"
PV = "1.5.0"
PR = "1.el10_3"
PACKAGES = " \
 pie \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pie-1.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "41fd11d55d210ddadcfccdd463d7cdf25d64e90b15160b55010921a7de214783"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pie-1.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pie;unpack=0"
SRC_URI[x86_64_v2_pie.sha256sum] = "d6eb57e50dd6717ce39f46c0f86a1874b9b4dee7db29cb3a6000cad5d59b1043"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pie-1.5.0-1.el10_3.noarch.rpm;name=aarch64_pie;unpack=0"
SRC_URI[aarch64_pie.sha256sum] = "1b24ec075004dec4f17f32e0accf3b3591d0bbf4ad5ebd48d5dee05cc74d732b"

RDEPENDS:pie = " \
 bash \
 ca-certificates \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-mbstring \
 virtual/php-phar \
 virtual/php-posix \
 virtual/php-zip \
 virtual/php_language__ge_8.1 \
 "
