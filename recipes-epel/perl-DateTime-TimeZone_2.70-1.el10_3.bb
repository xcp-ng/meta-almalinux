# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-TimeZone"
PV = "2.70"
PR = "1.el10_3"
PACKAGES = " \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-TimeZone-2.70-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5dfac626272710b1e67f4fd2ec34165a51d7a5675d57f79cba560f88fb273def"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-2.70-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone;unpack=0"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone.sha256sum] = "9f9e78fce92c30a07d901a78d71ce4b0a945c50a8d02575f0806ac9133582fbf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-tests-2.70-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone-tests.sha256sum] = "810d56f4d1536d2792cb01f74b926d4b723670672d5a323bee57cb1282220515"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-2.70-1.el10_3.noarch.rpm;name=aarch64_perl-DateTime-TimeZone;unpack=0"
SRC_URI[aarch64_perl-DateTime-TimeZone.sha256sum] = "5869e9cabeace49d849d8a238aee09f13cc07c7e6243e41f823720dadfc1a3bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-tests-2.70-1.el10_3.noarch.rpm;name=aarch64_perl-DateTime-TimeZone-tests;unpack=0"
SRC_URI[aarch64_perl-DateTime-TimeZone-tests.sha256sum] = "3a58e8d3f66bbeb2cc8a2ce62e089115a380019e0cda424b24e82e0bb88356bd"

RDEPENDS:perl-DateTime-TimeZone = " \
 perl-Class-Singleton \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-DateTime-TimeZone-Tzfile \
 perl-File-Basename \
 perl-File-Compare \
 perl-File-Find \
 perl-Module-Runtime \
 perl-Params-ValidationCompiler \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Specio \
 perl-Try-Tiny \
 perl-constant \
 perl-libs \
 perl-namespace-autoclean \
 perl-parent \
 "
RDEPENDS:perl-DateTime-TimeZone-tests = " \
 bash \
 perl-DateTime \
 perl-DateTime-TimeZone \
 perl-ExtUtils-MakeMaker \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Output \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-Test-Taint \
 perl-Try-Tiny \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
