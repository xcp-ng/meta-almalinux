# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdisplay-info-epel"
PV = "0.2.0"
PR = "3.el10_1"
PACKAGES = " \
 libdisplay-info-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdisplay-info-epel-0.2.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c79e73ea7d348f46b828804d6d9cec47bb7768d85347287aeb4c73a664cfeec"

URI_x86_64_v2_libdisplay-info-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdisplay-info-tools-0.2.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdisplay-info-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdisplay-info-tools}"
SRC_URI[x86_64_v2_libdisplay-info-tools.sha256sum] = "c2105859113d09c21dc50f686482995475371be5b2d723f1d8e1b06962e8741a"

URI_aarch64_libdisplay-info-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libdisplay-info-tools-0.2.0-3.el10_1.aarch64.rpm;name=aarch64_libdisplay-info-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdisplay-info-tools}"
SRC_URI[aarch64_libdisplay-info-tools.sha256sum] = "bed6c58b4138a3f6b222c4febd4f963ec6d1d8c460cf8382df763100bd2ae69d"

RDEPENDS:libdisplay-info-tools = " \
 glibc \
 libdisplay-info \
 "
