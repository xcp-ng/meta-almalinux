# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-oid-registry"
PV = "0.7.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-oid-registry+crypto-devel \
 rust-oid-registry+default-devel \
 rust-oid-registry+kdf-devel \
 rust-oid-registry+ms_spc-devel \
 rust-oid-registry+nist_algs-devel \
 rust-oid-registry+pkcs1-devel \
 rust-oid-registry+pkcs12-devel \
 rust-oid-registry+pkcs7-devel \
 rust-oid-registry+pkcs9-devel \
 rust-oid-registry+registry-devel \
 rust-oid-registry+x500-devel \
 rust-oid-registry+x509-devel \
 rust-oid-registry+x962-devel \
 rust-oid-registry-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-oid-registry-0.7.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "babada4f73b21d822a4061b237f3134beb434a1410557084c7530007042f9f8e"

URI_x86_64_v2_rust-oid-registry+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+crypto-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+crypto-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+crypto-devel.sha256sum] = "23e55bdd2ddc5500d99e75fbe459eef45abefb511610ccd91dcd50e56ae0bad8"

URI_x86_64_v2_rust-oid-registry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+default-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+default-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+default-devel.sha256sum] = "d33c2eb23701716983d16405c1ad336adecb86d3c4fb191b01b222fc6fe69e0b"

URI_x86_64_v2_rust-oid-registry+kdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+kdf-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+kdf-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+kdf-devel.sha256sum] = "8192015bed8f1682b72270d600c7bf3604905a1650c8ddb1c5916571dfa3aa4f"

URI_x86_64_v2_rust-oid-registry+ms_spc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+ms_spc-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+ms_spc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+ms_spc-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+ms_spc-devel.sha256sum] = "de60c462d4adc102df4961cd8b7be68c483ce78506677b411c4a5b280c3455bc"

URI_x86_64_v2_rust-oid-registry+nist_algs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+nist_algs-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+nist_algs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+nist_algs-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+nist_algs-devel.sha256sum] = "da2ad6ec23d59c7e58eed8cbef51cf1d190c6d05ee7d2186857b636cd2500c7a"

URI_x86_64_v2_rust-oid-registry+pkcs1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs1-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs1-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs1-devel.sha256sum] = "05fe9db639b23a2aeb1597f2bf67285a700ff82369dca94c09723051ef199289"

URI_x86_64_v2_rust-oid-registry+pkcs12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs12-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs12-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs12-devel.sha256sum] = "ca5a42ae2d6901dd3efbfcc718ea1da3802a7b7e23d6ceca74d676258e04d216"

URI_x86_64_v2_rust-oid-registry+pkcs7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs7-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs7-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs7-devel.sha256sum] = "008091fe562e1a82897c65e68f41cfe570f19987aa5db1050496827fb574a730"

URI_x86_64_v2_rust-oid-registry+pkcs9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+pkcs9-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+pkcs9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+pkcs9-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+pkcs9-devel.sha256sum] = "8e023be408557b283b89cd32e242be3d01c5030a2f464d716ac22a77c99cff7e"

URI_x86_64_v2_rust-oid-registry+registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+registry-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+registry-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+registry-devel.sha256sum] = "5cf13dd31a5051e4894d753dc3c67c20847c62990beb694f4d61e20c19291191"

URI_x86_64_v2_rust-oid-registry+x500-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+x500-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+x500-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+x500-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+x500-devel.sha256sum] = "087c687892318f9fdbf2d08079201b3eda4262bb4d6d2319d536814c29bdf8c2"

URI_x86_64_v2_rust-oid-registry+x509-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+x509-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+x509-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+x509-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+x509-devel.sha256sum] = "fd840604e5488e1e8cbf5c4a48cfe1fe3dc5f3a4b0d28510621d5fb976404503"

URI_x86_64_v2_rust-oid-registry+x962-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry+x962-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry+x962-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry+x962-devel}"
SRC_URI[x86_64_v2_rust-oid-registry+x962-devel.sha256sum] = "30e578beaae8d1d5cc0b97aca617bed8a16b99358a27e354ed75cbd13713831c"

URI_x86_64_v2_rust-oid-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-oid-registry-devel-0.7.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-oid-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-oid-registry-devel}"
SRC_URI[x86_64_v2_rust-oid-registry-devel.sha256sum] = "39db885feb6e4b449baf9ba6bb1a5896ea4fb44fa1d1ee6395b95080bc734da3"

URI_aarch64_rust-oid-registry+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+crypto-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+crypto-devel}"
SRC_URI[aarch64_rust-oid-registry+crypto-devel.sha256sum] = "fdf3121334e63ed8459cdc5548aa8ba882cffeaca33e73b108208c2ec5109a20"

URI_aarch64_rust-oid-registry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+default-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+default-devel}"
SRC_URI[aarch64_rust-oid-registry+default-devel.sha256sum] = "2d3661eb82884765fbc8e57d96ec42dfe0a0b38270d9f8b268bfd817ae0d9dfd"

URI_aarch64_rust-oid-registry+kdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+kdf-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+kdf-devel}"
SRC_URI[aarch64_rust-oid-registry+kdf-devel.sha256sum] = "e3effff83383cd51f6630e6ea5dbe67b9bf79736feb82d5d8cf14f23615dfb3b"

URI_aarch64_rust-oid-registry+ms_spc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+ms_spc-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+ms_spc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+ms_spc-devel}"
SRC_URI[aarch64_rust-oid-registry+ms_spc-devel.sha256sum] = "c723dfc0d3685a8af6cad63eccc28c228936388c2a0a50e4a3e9365503e7f686"

URI_aarch64_rust-oid-registry+nist_algs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+nist_algs-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+nist_algs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+nist_algs-devel}"
SRC_URI[aarch64_rust-oid-registry+nist_algs-devel.sha256sum] = "eab0548df53882d66925dfaccecd06a984c598344e786bbe81ab46c54ce9a356"

URI_aarch64_rust-oid-registry+pkcs1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs1-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs1-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs1-devel.sha256sum] = "4c9d927efcea5ee21df4352cbdd2ea68ff320fa577bff8d0c8313d166ed55cb4"

URI_aarch64_rust-oid-registry+pkcs12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs12-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+pkcs12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs12-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs12-devel.sha256sum] = "321d8393e6a6a66b0dbf828adb68b753d1d49196fc0dad89b2be4804cd332434"

URI_aarch64_rust-oid-registry+pkcs7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs7-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+pkcs7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs7-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs7-devel.sha256sum] = "53f8e9aef76cc90d43a12e43e737261863baf84a9f398a973de54f2046bb21d0"

URI_aarch64_rust-oid-registry+pkcs9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+pkcs9-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+pkcs9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+pkcs9-devel}"
SRC_URI[aarch64_rust-oid-registry+pkcs9-devel.sha256sum] = "72971f6b40e509f42d0f6739eccb29c7801d452f43b4b6ede766d80d24b3163e"

URI_aarch64_rust-oid-registry+registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+registry-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+registry-devel}"
SRC_URI[aarch64_rust-oid-registry+registry-devel.sha256sum] = "36697ddd84a740415ee097f1e8b906c1473dd05a90a72b47085e65635f173e0b"

URI_aarch64_rust-oid-registry+x500-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+x500-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+x500-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+x500-devel}"
SRC_URI[aarch64_rust-oid-registry+x500-devel.sha256sum] = "60af5bfbc2edb278dbc3c3f3bb95cd9d7460df27652685869b0d1ea6ec920bd9"

URI_aarch64_rust-oid-registry+x509-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+x509-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+x509-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+x509-devel}"
SRC_URI[aarch64_rust-oid-registry+x509-devel.sha256sum] = "a1f426d3e2fe99129fd9f90d0bfd149d0fdbaf87368a7963d4ecb2507317a481"

URI_aarch64_rust-oid-registry+x962-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry+x962-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry+x962-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry+x962-devel}"
SRC_URI[aarch64_rust-oid-registry+x962-devel.sha256sum] = "462a171a764e9b6c80fc01ad69e2a842802c8fe8a0e84e99744d630d3c40cc4b"

URI_aarch64_rust-oid-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-oid-registry-devel-0.7.1-3.el10_1.noarch.rpm;name=aarch64_rust-oid-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-oid-registry-devel}"
SRC_URI[aarch64_rust-oid-registry-devel.sha256sum] = "c5781b1778c4251dc62d8563a0dd47794adb1b66f2a95442fc826c0019127fc0"

RDEPENDS:rust-oid-registry+crypto-devel = " \
 cargo \
 rust-oid-registry+kdf-devel \
 rust-oid-registry+nist_algs-devel \
 rust-oid-registry+pkcs1-devel \
 rust-oid-registry+pkcs12-devel \
 rust-oid-registry+pkcs7-devel \
 rust-oid-registry+pkcs9-devel \
 rust-oid-registry+x962-devel \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+default-devel = " \
 cargo \
 rust-oid-registry+registry-devel \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+kdf-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+ms_spc-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+nist_algs-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs1-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs12-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs7-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+pkcs9-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+registry-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+x500-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+x509-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry+x962-devel = " \
 cargo \
 rust-oid-registry-devel \
 "
RDEPENDS:rust-oid-registry-devel = " \
 cargo \
 rust \
 rust-asn1-rs+default-devel \
 "
