# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shadow-utils"
PE = "2"
PV = "4.15.0"
PR = "10.el10_1"
PACKAGES = " \
 shadow-utils \
 shadow-utils-subid \
 shadow-utils-subid-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/shadow-utils-4.15.0-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a20109097d8ecc1520d2764f9fbab7083a00890bd53f9b2d9d2a2d0d312892a8"

URI_x86_64_v2_shadow-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shadow-utils-4.15.0-10.el10_1.x86_64_v2.rpm;name=x86_64_v2_shadow-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shadow-utils}"
SRC_URI[x86_64_v2_shadow-utils.sha256sum] = "3aa717c7a3b2d9e17df6bed620fec42a3834299d7dcb2ae9918f676de1e2b7bf"

URI_x86_64_v2_shadow-utils-subid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shadow-utils-subid-4.15.0-10.el10_1.x86_64_v2.rpm;name=x86_64_v2_shadow-utils-subid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shadow-utils-subid}"
SRC_URI[x86_64_v2_shadow-utils-subid.sha256sum] = "a9a45d0906fd8cac999ca81c878e28ead9bd9a3ecfd59103794848553ae11e99"

URI_x86_64_v2_shadow-utils-subid-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/shadow-utils-subid-devel-4.15.0-10.el10_1.x86_64_v2.rpm;name=x86_64_v2_shadow-utils-subid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shadow-utils-subid-devel}"
SRC_URI[x86_64_v2_shadow-utils-subid-devel.sha256sum] = "f74be8bbf5eff768bcfe08832da4c50070d6f6b66fb24d5a5208a5ed26c261d5"

URI_aarch64_shadow-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shadow-utils-4.15.0-10.el10_1.aarch64.rpm;name=aarch64_shadow-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_shadow-utils}"
SRC_URI[aarch64_shadow-utils.sha256sum] = "a8d2b9640213624c000217f4b6060d762813bb7d3b3dfaa9d004314473b95f49"

URI_aarch64_shadow-utils-subid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shadow-utils-subid-4.15.0-10.el10_1.aarch64.rpm;name=aarch64_shadow-utils-subid;unpack=0"
SRC_URI:append = " ${URI_aarch64_shadow-utils-subid}"
SRC_URI[aarch64_shadow-utils-subid.sha256sum] = "ab15bdc6dc578d59423cecc37b39baf0483436c654e360e2170973765d0fb395"

URI_aarch64_shadow-utils-subid-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/shadow-utils-subid-devel-4.15.0-10.el10_1.aarch64.rpm;name=aarch64_shadow-utils-subid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_shadow-utils-subid-devel}"
SRC_URI[aarch64_shadow-utils-subid-devel.sha256sum] = "d37a854bae16411d7010bfb711b85a35978f074b15b304d5dc3dc587ffeb62fc"

RDEPENDS:shadow-utils = " \
 audit-libs \
 glibc \
 libacl \
 libattr \
 libeconf \
 libselinux \
 libsemanage \
 libxcrypt \
 pam-libs \
 setup \
 "
RDEPENDS:shadow-utils-subid = " \
 audit-libs \
 glibc \
 libacl \
 libattr \
 libeconf \
 libselinux \
 libsemanage \
 libxcrypt \
 pam-libs \
 "
RDEPENDS:shadow-utils-subid-devel = " \
 shadow-utils-subid \
 "
