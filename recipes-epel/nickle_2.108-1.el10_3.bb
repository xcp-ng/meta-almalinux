# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nickle"
PV = "2.108"
PR = "1.el10_3"
PACKAGES = " \
 nickle \
 nickle-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nickle-2.108-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1dff6879009b5879c1c14ae6da2bd7fe9f59d1bf6b1ca5e012d095fcf992b28a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nickle-2.108-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nickle;unpack=0"
SRC_URI[x86_64_v2_nickle.sha256sum] = "2f4e025f30c9a0d566a2f1773ba30190a9f70b9dfd73578c4d41c04c704ac619"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nickle-devel-2.108-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nickle-devel;unpack=0"
SRC_URI[x86_64_v2_nickle-devel.sha256sum] = "9eabd6afe501a4766ef47f045efd9617c856a6686013205eb7c1029495fef102"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nickle-2.108-1.el10_3.aarch64.rpm;name=aarch64_nickle;unpack=0"
SRC_URI[aarch64_nickle.sha256sum] = "6c61a4f552f9b9f20ae6cc5425c57bf8032bd39ba56b06cebf139cafa68ebdd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nickle-devel-2.108-1.el10_3.aarch64.rpm;name=aarch64_nickle-devel;unpack=0"
SRC_URI[aarch64_nickle-devel.sha256sum] = "4df1e09d6d2bf24a98a3b2ff6fd02c6719c99c826e98a4d63c004c439397c937"

RDEPENDS:nickle = " \
 glibc \
 readline \
 "
RDEPENDS:nickle-devel = " \
 nickle \
 "
