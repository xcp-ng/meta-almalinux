# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libcst"
PV = "1.8.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-libcst+default-devel \
 rust-libcst+trace-devel \
 rust-libcst-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libcst-1.8.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbb0c3263efe03f035e6aa55f3a359aefcc2f730d71645fb3df8deeef4eac28e"

URI_x86_64_v2_rust-libcst+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst+default-devel-1.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcst+default-devel}"
SRC_URI[x86_64_v2_rust-libcst+default-devel.sha256sum] = "02754db03679408feccc884381e20c241a3a33b8ef67218e7511a6e28f51684e"

URI_x86_64_v2_rust-libcst+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst+trace-devel-1.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcst+trace-devel}"
SRC_URI[x86_64_v2_rust-libcst+trace-devel.sha256sum] = "f0c316d0cdcb15371ee084d0775ab1abe6a7a4fd5b6875c934c2238c5dc3c5cb"

URI_x86_64_v2_rust-libcst-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst-devel-1.8.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcst-devel}"
SRC_URI[x86_64_v2_rust-libcst-devel.sha256sum] = "a7666084989fac896deaf7e33236fdabc25619674a6964e5639556eb4bb55a55"

URI_aarch64_rust-libcst+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst+default-devel-1.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-libcst+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcst+default-devel}"
SRC_URI[aarch64_rust-libcst+default-devel.sha256sum] = "3df9fcb144617a6640e3046f5a7f20b4b1eaaf459090a3b481bfa3a58f2294b1"

URI_aarch64_rust-libcst+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst+trace-devel-1.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-libcst+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcst+trace-devel}"
SRC_URI[aarch64_rust-libcst+trace-devel.sha256sum] = "ed325ca4d1756da5cffa9af6c003af78a37542735b56cfbf21131e0cc178f90e"

URI_aarch64_rust-libcst-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst-devel-1.8.6-1.el10_1.noarch.rpm;name=aarch64_rust-libcst-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcst-devel}"
SRC_URI[aarch64_rust-libcst-devel.sha256sum] = "376a2b0229e8c5a334feb89a1e25dc751522874fa092ad1f5ec660d0bd375381"

RDEPENDS:rust-libcst+default-devel = " \
 cargo \
 rust-libcst-devel \
 "
RDEPENDS:rust-libcst+trace-devel = " \
 cargo \
 rust-libcst-devel \
 rust-peg+trace-devel \
 "
RDEPENDS:rust-libcst-devel = " \
 cargo \
 rust \
 rust-annotate-snippets+default-devel \
 rust-libcst_derive+default-devel \
 rust-memchr+default-devel \
 rust-paste+default-devel \
 rust-peg+default-devel \
 rust-regex+default-devel \
 rust-thiserror+default-devel \
 "
