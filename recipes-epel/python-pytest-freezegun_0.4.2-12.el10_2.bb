# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-freezegun"
PV = "0.4.2"
PR = "12.el10_2"
PACKAGES = " \
 python3-pytest-freezegun \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-freezegun-0.4.2-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5864276c24cd01c1dbe597d63b56c23ac83752ec829894a76d490417f18e0d15"

URI_x86_64_v2_python3-pytest-freezegun = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-freezegun-0.4.2-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-freezegun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-freezegun}"
SRC_URI[x86_64_v2_python3-pytest-freezegun.sha256sum] = "bf62b6081a68521ac70ae1780049f7c653bc54f6d87508dfcdb69a3ff575e4a3"

URI_aarch64_python3-pytest-freezegun = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-freezegun-0.4.2-12.el10_2.noarch.rpm;name=aarch64_python3-pytest-freezegun;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-freezegun}"
SRC_URI[aarch64_python3-pytest-freezegun.sha256sum] = "26393a72d1e2f9b9284ed0336d1a05d409b05758b4df59fc21d4bf8dc234ba8e"

RDEPENDS:python3-pytest-freezegun = " \
 python3 \
 python3-freezegun \
 python3-pytest \
 "
