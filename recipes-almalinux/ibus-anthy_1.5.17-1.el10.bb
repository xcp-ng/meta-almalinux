# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-anthy"
PV = "1.5.17"
PR = "1.el10"
PACKAGES = " \
 ibus-anthy \
 ibus-anthy-python \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-anthy-1.5.17-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "745e259a25d1d3b38be70f73cc4371a5e7e0f81ba05442e3f38e3053746c6aea"

URI_x86_64_v2_ibus-anthy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-anthy-1.5.17-1.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-anthy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-anthy}"
SRC_URI[x86_64_v2_ibus-anthy.sha256sum] = "fdc0513650dce6fa368dbf93c9760357cecbb130f197894a0a97ca7ab4f059ca"

URI_x86_64_v2_ibus-anthy-python = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-anthy-python-1.5.17-1.el10.noarch.rpm;name=x86_64_v2_ibus-anthy-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-anthy-python}"
SRC_URI[x86_64_v2_ibus-anthy-python.sha256sum] = "42672e961862259d583d829e0ae9f78fd77491efa44faf5fa099ef5bcb49377e"

URI_aarch64_ibus-anthy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-anthy-1.5.17-1.el10.aarch64.rpm;name=aarch64_ibus-anthy;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-anthy}"
SRC_URI[aarch64_ibus-anthy.sha256sum] = "0ce1bfc2493f5180388ecad1f167245100f0733e780e0d123c80cdae4ca044b5"

URI_aarch64_ibus-anthy-python = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-anthy-python-1.5.17-1.el10.noarch.rpm;name=aarch64_ibus-anthy-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-anthy-python}"
SRC_URI[aarch64_ibus-anthy-python.sha256sum] = "42672e961862259d583d829e0ae9f78fd77491efa44faf5fa099ef5bcb49377e"

RDEPENDS:ibus-anthy = " \
 anthy-unicode \
 glib2 \
 glibc \
 ibus \
 ibus-anthy-python \
 kasumi-unicode \
 "
RDEPENDS:ibus-anthy-python = " \
 bash \
 gtk3 \
 ibus-anthy \
 python3-cairo \
 python3-gobject \
 "
