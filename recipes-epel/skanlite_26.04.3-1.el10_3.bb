# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skanlite"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 skanlite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skanlite-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae67753931463c35e51d348f1be6df481b6964bceef4094cb500f6fb93a25baf"

URI_x86_64_v2_skanlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skanlite-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skanlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skanlite}"
SRC_URI[x86_64_v2_skanlite.sha256sum] = "107c6f214b04b5eaaf0bbddcf6e2e59d939b343f817eb3d5b799d2a15073cfd0"

URI_aarch64_skanlite = "${EPEL_MIRROR}/aarch64/Packages/s/skanlite-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_skanlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_skanlite}"
SRC_URI[aarch64_skanlite.sha256sum] = "3fd49ae659e6b4426784f612c187d5da63f18260ca98494a937c64fa8992ec5c"

RDEPENDS:skanlite = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
