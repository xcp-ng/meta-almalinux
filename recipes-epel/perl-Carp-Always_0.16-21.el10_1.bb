# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Carp-Always"
PV = "0.16"
PR = "21.el10_1"
PACKAGES = " \
 perl-Carp-Always \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Carp-Always-0.16-21.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37092fd7ab2dbe9d81d465a27e4db7c3ffb7507cf85614fe7fb2fe112a5ca27d"

URI_x86_64_v2_perl-Carp-Always = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Carp-Always-0.16-21.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Carp-Always;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Carp-Always}"
SRC_URI[x86_64_v2_perl-Carp-Always.sha256sum] = "a69c810a1b5ad861f9e740c9fa66e1276087a8063a4c3629af5beb1b0f764b08"

URI_aarch64_perl-Carp-Always = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Carp-Always-0.16-21.el10_1.noarch.rpm;name=aarch64_perl-Carp-Always;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Carp-Always}"
SRC_URI[aarch64_perl-Carp-Always.sha256sum] = "75d9285d1d8d49229baee74183f417d0560852b5acf106964a9bf49fbecee207"

RDEPENDS:perl-Carp-Always = " \
 perl-Carp \
 perl-constant \
 perl-if \
 perl-libs \
 "
