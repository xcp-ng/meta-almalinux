# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nagios-plugins"
PV = "2.4.12"
PR = "1.el10_0"
PACKAGES = " \
 nagios-plugins \
 nagios-plugins-all \
 nagios-plugins-apt \
 nagios-plugins-breeze \
 nagios-plugins-by_ssh \
 nagios-plugins-cluster \
 nagios-plugins-dhcp \
 nagios-plugins-dig \
 nagios-plugins-disk \
 nagios-plugins-disk_smb \
 nagios-plugins-dns \
 nagios-plugins-dummy \
 nagios-plugins-file_age \
 nagios-plugins-flexlm \
 nagios-plugins-fping \
 nagios-plugins-game \
 nagios-plugins-hpjd \
 nagios-plugins-http \
 nagios-plugins-icmp \
 nagios-plugins-ide_smart \
 nagios-plugins-ifoperstatus \
 nagios-plugins-ifstatus \
 nagios-plugins-ircd \
 nagios-plugins-ldap \
 nagios-plugins-load \
 nagios-plugins-log \
 nagios-plugins-mailq \
 nagios-plugins-mrtg \
 nagios-plugins-mrtgtraf \
 nagios-plugins-mysql \
 nagios-plugins-nagios \
 nagios-plugins-nt \
 nagios-plugins-ntp \
 nagios-plugins-nwstat \
 nagios-plugins-oracle \
 nagios-plugins-overcr \
 nagios-plugins-perl \
 nagios-plugins-pgsql \
 nagios-plugins-ping \
 nagios-plugins-procs \
 nagios-plugins-real \
 nagios-plugins-remove_perfdata \
 nagios-plugins-rpc \
 nagios-plugins-sensors \
 nagios-plugins-smtp \
 nagios-plugins-snmp \
 nagios-plugins-ssh \
 nagios-plugins-ssl_validity \
 nagios-plugins-swap \
 nagios-plugins-tcp \
 nagios-plugins-time \
 nagios-plugins-ups \
 nagios-plugins-uptime \
 nagios-plugins-users \
 nagios-plugins-wave \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nagios-plugins-2.4.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8cd8af1ce4cfedfdba96c7351640ab0fd2d96ff1f1955eb85976105e71e7e38"

URI_x86_64_v2_nagios-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins}"
SRC_URI[x86_64_v2_nagios-plugins.sha256sum] = "3596589a12ba90bc10754a68cc0fbed6ab2605681df9338c74ed66ff005c69ea"

URI_x86_64_v2_nagios-plugins-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-all-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-all}"
SRC_URI[x86_64_v2_nagios-plugins-all.sha256sum] = "c9ac5592f8c58bfb76d41e62b66e13d3d204d81ca33b62aa819c653cbf57850f"

URI_x86_64_v2_nagios-plugins-apt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-apt-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-apt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-apt}"
SRC_URI[x86_64_v2_nagios-plugins-apt.sha256sum] = "7d7075024e4f623f14103950fceb8706eebc97c47c20923204cbfa4c6034b431"

URI_x86_64_v2_nagios-plugins-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-breeze-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-breeze}"
SRC_URI[x86_64_v2_nagios-plugins-breeze.sha256sum] = "25769415d6b55ce276a0e0b69e27a688be9c1fe31e5a153519c14cfe77c5d942"

URI_x86_64_v2_nagios-plugins-by_ssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-by_ssh-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-by_ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-by_ssh}"
SRC_URI[x86_64_v2_nagios-plugins-by_ssh.sha256sum] = "e8ab8a5e9016348cc07c85d5015a48fe4ff9ec3e75a98a0e72f1ebb0474db79e"

URI_x86_64_v2_nagios-plugins-cluster = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-cluster-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-cluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-cluster}"
SRC_URI[x86_64_v2_nagios-plugins-cluster.sha256sum] = "3625249739a901393a18a6ba107d96ee3c7119ffd510a20c2d8403ce47334b74"

URI_x86_64_v2_nagios-plugins-dhcp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-dhcp-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-dhcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-dhcp}"
SRC_URI[x86_64_v2_nagios-plugins-dhcp.sha256sum] = "c5371333f187102b92fb4cbba25221b1f7d864171faf544c9d47041986fbc387"

URI_x86_64_v2_nagios-plugins-dig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-dig-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-dig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-dig}"
SRC_URI[x86_64_v2_nagios-plugins-dig.sha256sum] = "fad176850f5c14a0062862da01999353c7e7e137b4f8d07f21657f5f90e852c9"

URI_x86_64_v2_nagios-plugins-disk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-disk-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-disk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-disk}"
SRC_URI[x86_64_v2_nagios-plugins-disk.sha256sum] = "a5d70a942e669721ab7e90da6a48f1373d3f737d5bff12167ed5bf8e89bead74"

URI_x86_64_v2_nagios-plugins-disk_smb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-disk_smb-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-disk_smb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-disk_smb}"
SRC_URI[x86_64_v2_nagios-plugins-disk_smb.sha256sum] = "61e58f5a261e6077c8e5432dd2e8ce3d80e962430c8e93de652ef8e77e2e3371"

URI_x86_64_v2_nagios-plugins-dns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-dns-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-dns}"
SRC_URI[x86_64_v2_nagios-plugins-dns.sha256sum] = "efe233da7690a327749e08e786c80802d690ae12b670b3bb9b5da4cbdde99d3f"

URI_x86_64_v2_nagios-plugins-dummy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-dummy-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-dummy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-dummy}"
SRC_URI[x86_64_v2_nagios-plugins-dummy.sha256sum] = "074d2f3cc1397a5df7a1f2d013b4310993357703512b98dc73641ec5946c99ab"

URI_x86_64_v2_nagios-plugins-file_age = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-file_age-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-file_age;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-file_age}"
SRC_URI[x86_64_v2_nagios-plugins-file_age.sha256sum] = "e2a34a2c4fe0f23461b1508d7a6e56c3c001314d76443a4d937075d7c8e72a00"

URI_x86_64_v2_nagios-plugins-flexlm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-flexlm-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-flexlm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-flexlm}"
SRC_URI[x86_64_v2_nagios-plugins-flexlm.sha256sum] = "afbd231e9677bf54203892034dcf3496230da1e0a6da832ae50379b8af60b86e"

URI_x86_64_v2_nagios-plugins-fping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-fping-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-fping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-fping}"
SRC_URI[x86_64_v2_nagios-plugins-fping.sha256sum] = "261f149adef8be155dd287bade840ea894cdc3c0fb6cc2bc53793b441ad71da6"

URI_x86_64_v2_nagios-plugins-game = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-game-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-game;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-game}"
SRC_URI[x86_64_v2_nagios-plugins-game.sha256sum] = "398236f5a3fe4894cd850e8a1137a3c3047c4a63425d31351b15b2e55af067b7"

URI_x86_64_v2_nagios-plugins-hpjd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-hpjd-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-hpjd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-hpjd}"
SRC_URI[x86_64_v2_nagios-plugins-hpjd.sha256sum] = "baa645af583035d886427555d90d74851b7425a0c8556ffaff30e0347f204463"

URI_x86_64_v2_nagios-plugins-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-http-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-http}"
SRC_URI[x86_64_v2_nagios-plugins-http.sha256sum] = "76a7c15f70f9064038ed7a3795d26867f15f8d4dc4617996470cbf0786b76ad1"

URI_x86_64_v2_nagios-plugins-icmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-icmp-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-icmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-icmp}"
SRC_URI[x86_64_v2_nagios-plugins-icmp.sha256sum] = "ae1ad0a6f24dffee4ac94922dae8a5fc2378eaf6398d494d417caf14f65e211f"

URI_x86_64_v2_nagios-plugins-ide_smart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ide_smart-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ide_smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ide_smart}"
SRC_URI[x86_64_v2_nagios-plugins-ide_smart.sha256sum] = "3175b632bf8f770d061818e8269f54ff0927c7d023a610ecddf1f4310cf87635"

URI_x86_64_v2_nagios-plugins-ifoperstatus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ifoperstatus-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ifoperstatus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ifoperstatus}"
SRC_URI[x86_64_v2_nagios-plugins-ifoperstatus.sha256sum] = "3b90052a8e208584df8cb0b2afb26a1e18c35b3dea4279bcb9c4692acbda725a"

URI_x86_64_v2_nagios-plugins-ifstatus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ifstatus-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ifstatus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ifstatus}"
SRC_URI[x86_64_v2_nagios-plugins-ifstatus.sha256sum] = "a59b2e36d19da5c4846d4cc2a46b80ba4081410c8525a4346f1e741f6cc0c4ae"

URI_x86_64_v2_nagios-plugins-ircd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ircd-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ircd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ircd}"
SRC_URI[x86_64_v2_nagios-plugins-ircd.sha256sum] = "0d321917d26a54923950ffa73add7d0383dd3a954b3252419798a91f6527bb50"

URI_x86_64_v2_nagios-plugins-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ldap-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ldap}"
SRC_URI[x86_64_v2_nagios-plugins-ldap.sha256sum] = "4f9a9ee6d369789e45642b149db0e26a011b2296aea1cfbb619d078ac2d16301"

URI_x86_64_v2_nagios-plugins-load = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-load-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-load;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-load}"
SRC_URI[x86_64_v2_nagios-plugins-load.sha256sum] = "f7d0bb7cd81a0a408839ddc97692ab2c3cf86129b38852e76154c3e403a88fcb"

URI_x86_64_v2_nagios-plugins-log = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-log-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-log}"
SRC_URI[x86_64_v2_nagios-plugins-log.sha256sum] = "63946691bfc1c4bac4ee477206ad0d5d3ba9e062671be7aa4c9ac825e8570182"

URI_x86_64_v2_nagios-plugins-mailq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-mailq-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-mailq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-mailq}"
SRC_URI[x86_64_v2_nagios-plugins-mailq.sha256sum] = "cfedd7c52fac332fc315c34811357574490db2ea6297942724184ac5198f1cef"

URI_x86_64_v2_nagios-plugins-mrtg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-mrtg-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-mrtg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-mrtg}"
SRC_URI[x86_64_v2_nagios-plugins-mrtg.sha256sum] = "2ea5a483e31e8bdb079368161efb72a2fb0cc9173f25d1105df773fdb47ad1dc"

URI_x86_64_v2_nagios-plugins-mrtgtraf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-mrtgtraf-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-mrtgtraf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-mrtgtraf}"
SRC_URI[x86_64_v2_nagios-plugins-mrtgtraf.sha256sum] = "7dbba8d0d4341fc45d66bf7a957a576a9d57615265d2cef528d181bd412fcb4e"

URI_x86_64_v2_nagios-plugins-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-mysql-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-mysql}"
SRC_URI[x86_64_v2_nagios-plugins-mysql.sha256sum] = "f465154b52277ebedaba378f69d034f73287ab547ab57f3f075dadb918c86d5d"

URI_x86_64_v2_nagios-plugins-nagios = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-nagios-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-nagios;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-nagios}"
SRC_URI[x86_64_v2_nagios-plugins-nagios.sha256sum] = "9811bc7ed0caeca23734280bec832f897baa12e6a2edf144cb2001daa75c28ff"

URI_x86_64_v2_nagios-plugins-nt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-nt-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-nt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-nt}"
SRC_URI[x86_64_v2_nagios-plugins-nt.sha256sum] = "6fde00dfd568742a8a773ae4c427000e218440b8e508e6a0f3ca93a632dcc050"

URI_x86_64_v2_nagios-plugins-ntp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ntp-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ntp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ntp}"
SRC_URI[x86_64_v2_nagios-plugins-ntp.sha256sum] = "61d4f6751a20c66e51959bfa123188f2f7eb1d5ea1f27c3e3d2c4ca5aad73f54"

URI_x86_64_v2_nagios-plugins-nwstat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-nwstat-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-nwstat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-nwstat}"
SRC_URI[x86_64_v2_nagios-plugins-nwstat.sha256sum] = "d1b433aba7692088e2f5fb3aed7c98d039036faf1d234fe5657410e3ccc3c733"

URI_x86_64_v2_nagios-plugins-oracle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-oracle-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-oracle}"
SRC_URI[x86_64_v2_nagios-plugins-oracle.sha256sum] = "a6d2a6fa5dd4c50f8f7625ec1a41cdb16b4edbf455e979f4ff250b4f599e528b"

URI_x86_64_v2_nagios-plugins-overcr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-overcr-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-overcr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-overcr}"
SRC_URI[x86_64_v2_nagios-plugins-overcr.sha256sum] = "123e27dd26dc804c1b7d64b071e7887506e2964e3d75aa30d773bd225bc4e2ab"

URI_x86_64_v2_nagios-plugins-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-perl-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-perl}"
SRC_URI[x86_64_v2_nagios-plugins-perl.sha256sum] = "56f1e8a3bcb6dd8dedd278adbb2261134ee7c6310b08bd20a7ffbe308c7dd41b"

URI_x86_64_v2_nagios-plugins-pgsql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-pgsql-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-pgsql}"
SRC_URI[x86_64_v2_nagios-plugins-pgsql.sha256sum] = "b8133f66d8fcd855958a8c28995feb74323e4fd7ad6bc5e1553f476e82f5b8b7"

URI_x86_64_v2_nagios-plugins-ping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ping-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ping}"
SRC_URI[x86_64_v2_nagios-plugins-ping.sha256sum] = "08a8368ed38389317b54c5270c2df3d1eabf6e99ed5925bed16bc0bd6ba0fc55"

URI_x86_64_v2_nagios-plugins-procs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-procs-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-procs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-procs}"
SRC_URI[x86_64_v2_nagios-plugins-procs.sha256sum] = "ba68626a040329b3d7ae680063d26c69be716c1d799dc86a241811e26bd7bff9"

URI_x86_64_v2_nagios-plugins-real = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-real-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-real;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-real}"
SRC_URI[x86_64_v2_nagios-plugins-real.sha256sum] = "5dde0d521cf8455fb3bd3e7aeecef2afaf9ea326a23e6ca4ecba9d4ac21fb2a0"

URI_x86_64_v2_nagios-plugins-remove_perfdata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-remove_perfdata-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-remove_perfdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-remove_perfdata}"
SRC_URI[x86_64_v2_nagios-plugins-remove_perfdata.sha256sum] = "dd433b14dd63ca94b1cc1cd39044f348be4c551c3246ae0039506fb7b945ec88"

URI_x86_64_v2_nagios-plugins-rpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-rpc-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-rpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-rpc}"
SRC_URI[x86_64_v2_nagios-plugins-rpc.sha256sum] = "65cb30de2d069adb98329405b0693e467ebd599d7aff586c185755f17a52f8a0"

URI_x86_64_v2_nagios-plugins-sensors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-sensors-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-sensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-sensors}"
SRC_URI[x86_64_v2_nagios-plugins-sensors.sha256sum] = "671bdb798a88a2b4b65f58312d8a450bd7bb915b52ea4c60d517f679781aed4f"

URI_x86_64_v2_nagios-plugins-smtp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-smtp-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-smtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-smtp}"
SRC_URI[x86_64_v2_nagios-plugins-smtp.sha256sum] = "50fde0ebce28c54331c4b2b6eb83e1599de9de6726b48451b044c960c5095f48"

URI_x86_64_v2_nagios-plugins-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-snmp-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-snmp}"
SRC_URI[x86_64_v2_nagios-plugins-snmp.sha256sum] = "d47e04390eabe1f1f6ce39b03bde1cf5b9801e895c462536a754e111fac4fa2e"

URI_x86_64_v2_nagios-plugins-ssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ssh-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ssh}"
SRC_URI[x86_64_v2_nagios-plugins-ssh.sha256sum] = "b1fd9bc933a9d8bde3b11738ed446d55d1b33446d8bbe6dd880b603a12d7bdef"

URI_x86_64_v2_nagios-plugins-ssl_validity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ssl_validity-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ssl_validity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ssl_validity}"
SRC_URI[x86_64_v2_nagios-plugins-ssl_validity.sha256sum] = "0a94c61a47645a4b6e786fbde18a31fbd4510e0d80c9a507b58ca8f8cdc223e3"

URI_x86_64_v2_nagios-plugins-swap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-swap-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-swap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-swap}"
SRC_URI[x86_64_v2_nagios-plugins-swap.sha256sum] = "e3135ee38cb43ec8febde6a4d8f707ad0806ad86124c11b626915528549bec9d"

URI_x86_64_v2_nagios-plugins-tcp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-tcp-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-tcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-tcp}"
SRC_URI[x86_64_v2_nagios-plugins-tcp.sha256sum] = "26dc154bb5cbb160aebbaa66e5ae2db3dcdceaff67469fa557a311483b653ff4"

URI_x86_64_v2_nagios-plugins-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-time-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-time}"
SRC_URI[x86_64_v2_nagios-plugins-time.sha256sum] = "69a2f6affa3410cd6fe127bcc6a45df19f35d5df7768b81a1ed9aaddc5a4fadf"

URI_x86_64_v2_nagios-plugins-ups = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-ups-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-ups;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-ups}"
SRC_URI[x86_64_v2_nagios-plugins-ups.sha256sum] = "091bbbdec5378dbcde383c304992fc6f2d89c85e23ad6b09651ceddb5964981c"

URI_x86_64_v2_nagios-plugins-uptime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-uptime-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-uptime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-uptime}"
SRC_URI[x86_64_v2_nagios-plugins-uptime.sha256sum] = "d85a0c5b98fb3320c89f94003da6230990a97f31d41c139f4c38279c38bf997d"

URI_x86_64_v2_nagios-plugins-users = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-users-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-users;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-users}"
SRC_URI[x86_64_v2_nagios-plugins-users.sha256sum] = "42b42653134575f442c158dca39019b1f2fe6b5e060780a5722d6b28d78b9cb0"

URI_x86_64_v2_nagios-plugins-wave = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nagios-plugins-wave-2.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nagios-plugins-wave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nagios-plugins-wave}"
SRC_URI[x86_64_v2_nagios-plugins-wave.sha256sum] = "5fe0d7f21a0657f9d6e560b20fc4c455df4241c020dfe15b572f1aecc201a739"

URI_aarch64_nagios-plugins = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins}"
SRC_URI[aarch64_nagios-plugins.sha256sum] = "4a220e5cf7ef9e87c67619bf963d96573e7358ce8e1c03f09bf729858ef1f384"

URI_aarch64_nagios-plugins-all = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-all-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-all}"
SRC_URI[aarch64_nagios-plugins-all.sha256sum] = "bb9d6710f8c28f9352cbef61511d6c9b74756d6008812ea69fd6a138bede2119"

URI_aarch64_nagios-plugins-apt = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-apt-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-apt;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-apt}"
SRC_URI[aarch64_nagios-plugins-apt.sha256sum] = "a33b78806a6a0c42beaf7a036d7dcdf2cfedcd207ee66bacbb3cfe5f3614cad0"

URI_aarch64_nagios-plugins-breeze = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-breeze-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-breeze}"
SRC_URI[aarch64_nagios-plugins-breeze.sha256sum] = "29d85553a1626d87dc8466f5c7f2c499b472ea1c6273c07f33392da401815b1c"

URI_aarch64_nagios-plugins-by_ssh = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-by_ssh-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-by_ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-by_ssh}"
SRC_URI[aarch64_nagios-plugins-by_ssh.sha256sum] = "e8e647da1647009abfb36f663edd0fc7584d65958fecd608fc30e3d2da3ad99b"

URI_aarch64_nagios-plugins-cluster = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-cluster-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-cluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-cluster}"
SRC_URI[aarch64_nagios-plugins-cluster.sha256sum] = "8bcfa853e0623c273709b6faf7bddd0b175f5c923b7bf9f1e90105c97181e371"

URI_aarch64_nagios-plugins-dhcp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-dhcp-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-dhcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-dhcp}"
SRC_URI[aarch64_nagios-plugins-dhcp.sha256sum] = "e72810996b009d12cbea4b2c57f38a4c64df3235fa59126f54b46b800433d5d1"

URI_aarch64_nagios-plugins-dig = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-dig-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-dig;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-dig}"
SRC_URI[aarch64_nagios-plugins-dig.sha256sum] = "5fa8459c8c5e3d856bc58891869644f4864543c6c7c31a18ab2e6882c8d08212"

URI_aarch64_nagios-plugins-disk = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-disk-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-disk;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-disk}"
SRC_URI[aarch64_nagios-plugins-disk.sha256sum] = "05694b61d1fec5f9b8ba7bfa3ac1c598957215026a6d19ff7a826a6c3904ef54"

URI_aarch64_nagios-plugins-disk_smb = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-disk_smb-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-disk_smb;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-disk_smb}"
SRC_URI[aarch64_nagios-plugins-disk_smb.sha256sum] = "7fc808f650920971fa1eced7556031a3340b1f01b51fdec555beb9ee8ac57e56"

URI_aarch64_nagios-plugins-dns = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-dns-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-dns}"
SRC_URI[aarch64_nagios-plugins-dns.sha256sum] = "5746ef79668fa074078ecee73b8a244665be866855e10dfdb014bc635532e92e"

URI_aarch64_nagios-plugins-dummy = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-dummy-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-dummy;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-dummy}"
SRC_URI[aarch64_nagios-plugins-dummy.sha256sum] = "b0006ae18e2dddf7874e119c80a1060cea67603af41eb5dc39d80b2885d8c629"

URI_aarch64_nagios-plugins-file_age = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-file_age-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-file_age;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-file_age}"
SRC_URI[aarch64_nagios-plugins-file_age.sha256sum] = "c972516b8e235ee2ba4a257fc509d8ecc0a4dd83d857644e1a4fe9748ad3b682"

URI_aarch64_nagios-plugins-flexlm = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-flexlm-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-flexlm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-flexlm}"
SRC_URI[aarch64_nagios-plugins-flexlm.sha256sum] = "17882f31362d894ea627f0813643d1355432ff7504419a7d14713727e934d93c"

URI_aarch64_nagios-plugins-fping = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-fping-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-fping;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-fping}"
SRC_URI[aarch64_nagios-plugins-fping.sha256sum] = "4b567d7abed4bd96fe6304ac53e342502964de0c3bdd220a8588bd333b9950e0"

URI_aarch64_nagios-plugins-game = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-game-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-game;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-game}"
SRC_URI[aarch64_nagios-plugins-game.sha256sum] = "af23ef18f0442190d5ffae3248e24faaf5bae944cfbf8dad164608a1c5326460"

URI_aarch64_nagios-plugins-hpjd = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-hpjd-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-hpjd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-hpjd}"
SRC_URI[aarch64_nagios-plugins-hpjd.sha256sum] = "d12a6e001c73ae509541e8a9f469822d4286971a3a1bb004c7abe60078a5ddad"

URI_aarch64_nagios-plugins-http = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-http-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-http}"
SRC_URI[aarch64_nagios-plugins-http.sha256sum] = "17d78f1fb90743ed5864097246825e800c58b8e4765908e015c8313c462f71a8"

URI_aarch64_nagios-plugins-icmp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-icmp-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-icmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-icmp}"
SRC_URI[aarch64_nagios-plugins-icmp.sha256sum] = "828eb4b47d5b4cd788668a972193c899389388e81471ed82603a41ec33ba512c"

URI_aarch64_nagios-plugins-ide_smart = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ide_smart-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ide_smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ide_smart}"
SRC_URI[aarch64_nagios-plugins-ide_smart.sha256sum] = "13dabc6a6852bf32e3945f27fc134d86acce940d130a6990fecf5302cdb0795e"

URI_aarch64_nagios-plugins-ifoperstatus = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ifoperstatus-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ifoperstatus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ifoperstatus}"
SRC_URI[aarch64_nagios-plugins-ifoperstatus.sha256sum] = "a635649435d07e29fe6c42fb0ec69cde3c3b161ab81d9027c920e9d4f82a11fc"

URI_aarch64_nagios-plugins-ifstatus = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ifstatus-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ifstatus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ifstatus}"
SRC_URI[aarch64_nagios-plugins-ifstatus.sha256sum] = "c764e0c8f3a1ecd452b51a87c99f13643576e86bd3c5393c436ee6203da7b611"

URI_aarch64_nagios-plugins-ircd = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ircd-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ircd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ircd}"
SRC_URI[aarch64_nagios-plugins-ircd.sha256sum] = "a42a94e3989efac35a0df3b928785993b7336e918795c92b3ab892df6a493488"

URI_aarch64_nagios-plugins-ldap = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ldap-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ldap}"
SRC_URI[aarch64_nagios-plugins-ldap.sha256sum] = "41e77c23b0ca63a0fcffd8461a824122437a74b91bb18ebc9b4d1dddd8836e6b"

URI_aarch64_nagios-plugins-load = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-load-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-load;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-load}"
SRC_URI[aarch64_nagios-plugins-load.sha256sum] = "68739a5321015be6fd46ee05badae327713dac804ddf12dfa35243eaf141b979"

URI_aarch64_nagios-plugins-log = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-log-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-log}"
SRC_URI[aarch64_nagios-plugins-log.sha256sum] = "ef1dbb1ed63dcff06ee5a7847087f74c8061e25e2e2c61ca983b36f17fc1d29b"

URI_aarch64_nagios-plugins-mailq = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-mailq-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-mailq;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-mailq}"
SRC_URI[aarch64_nagios-plugins-mailq.sha256sum] = "d6ad851c273c9cb40ed1c727bf8f097ae6476632346169ed718842cc699a0721"

URI_aarch64_nagios-plugins-mrtg = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-mrtg-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-mrtg;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-mrtg}"
SRC_URI[aarch64_nagios-plugins-mrtg.sha256sum] = "d1ac1346c3b23d1a257aeed9b3914ecd097fecca468e6b6211b9dcb5af0ab9e5"

URI_aarch64_nagios-plugins-mrtgtraf = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-mrtgtraf-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-mrtgtraf;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-mrtgtraf}"
SRC_URI[aarch64_nagios-plugins-mrtgtraf.sha256sum] = "fa16465be148a4c53c9e42f9ce87a0b96ca22b78c387d4d1047f6000e8112601"

URI_aarch64_nagios-plugins-mysql = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-mysql-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-mysql}"
SRC_URI[aarch64_nagios-plugins-mysql.sha256sum] = "cd086ff7b471f660f1ed9081aaa4f8428668d7b3437570d61ca500a3891d38b8"

URI_aarch64_nagios-plugins-nagios = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-nagios-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-nagios;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-nagios}"
SRC_URI[aarch64_nagios-plugins-nagios.sha256sum] = "83bd4dc5b5dd8565eda25cb2d502883900207369d4737ac043685ee80c7ab3fb"

URI_aarch64_nagios-plugins-nt = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-nt-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-nt;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-nt}"
SRC_URI[aarch64_nagios-plugins-nt.sha256sum] = "3bbc63febf6b2461696716d47c67a99c78cefe7550213f387621e3447552bc55"

URI_aarch64_nagios-plugins-ntp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ntp-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ntp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ntp}"
SRC_URI[aarch64_nagios-plugins-ntp.sha256sum] = "5d2be4836656ed1b798e8372400d32e74b83575199a7ffcf6e3251a83989e61a"

URI_aarch64_nagios-plugins-nwstat = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-nwstat-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-nwstat;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-nwstat}"
SRC_URI[aarch64_nagios-plugins-nwstat.sha256sum] = "0752c201ce236b48edddcbdda71b640008886bba5c3fb2e0e60a256f3077ec07"

URI_aarch64_nagios-plugins-oracle = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-oracle-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-oracle}"
SRC_URI[aarch64_nagios-plugins-oracle.sha256sum] = "3c10d9fcf0537c9171034d70b4f73abf91521da65e612d20f45a3f5092bf3d89"

URI_aarch64_nagios-plugins-overcr = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-overcr-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-overcr;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-overcr}"
SRC_URI[aarch64_nagios-plugins-overcr.sha256sum] = "9b6eeafa3989020eaa18e882644c03adcd59d8ef76812c878cd35bdea0fcf4a8"

URI_aarch64_nagios-plugins-perl = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-perl-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-perl}"
SRC_URI[aarch64_nagios-plugins-perl.sha256sum] = "5d8bf8a6fc402978138b5c2f6a263bac71f5e20a0e62c393dd85dde4d579e51a"

URI_aarch64_nagios-plugins-pgsql = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-pgsql-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-pgsql}"
SRC_URI[aarch64_nagios-plugins-pgsql.sha256sum] = "cb23bd2adb7c252986b56ad05603d1ef25cce582f3d0de3c15bbd0055a0d4bf9"

URI_aarch64_nagios-plugins-ping = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ping-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ping}"
SRC_URI[aarch64_nagios-plugins-ping.sha256sum] = "e6dd26a979e6f2c592db1ec414dc268f287300e82d10acd822881310057bb1ff"

URI_aarch64_nagios-plugins-procs = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-procs-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-procs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-procs}"
SRC_URI[aarch64_nagios-plugins-procs.sha256sum] = "60baaff3b95c565edd1d8867d1f2dcb3ca387d78233e502f1674eb77fb6aef51"

URI_aarch64_nagios-plugins-real = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-real-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-real;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-real}"
SRC_URI[aarch64_nagios-plugins-real.sha256sum] = "92dcf8ac83cbccad044097178882412b01affa384501e6aca16bda307036904e"

URI_aarch64_nagios-plugins-remove_perfdata = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-remove_perfdata-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-remove_perfdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-remove_perfdata}"
SRC_URI[aarch64_nagios-plugins-remove_perfdata.sha256sum] = "9d6a95064a62a6aba10f20cc1a4efb34f6adbdb2f67dcc84be72551ad82da0d5"

URI_aarch64_nagios-plugins-rpc = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-rpc-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-rpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-rpc}"
SRC_URI[aarch64_nagios-plugins-rpc.sha256sum] = "2273e8b935c7a92059ce31f054e50cbc2f2517ee1ec9564542506779a045f306"

URI_aarch64_nagios-plugins-sensors = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-sensors-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-sensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-sensors}"
SRC_URI[aarch64_nagios-plugins-sensors.sha256sum] = "fd7f2653892c8911164b1ef4b292b7d3d21e8ec39d6a69911f7b62d2fbb5d005"

URI_aarch64_nagios-plugins-smtp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-smtp-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-smtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-smtp}"
SRC_URI[aarch64_nagios-plugins-smtp.sha256sum] = "628292a44bdc8142c9a8bfec94e6d90e4189d6b7ce4b49b523a85b5eb008e8c7"

URI_aarch64_nagios-plugins-snmp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-snmp-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-snmp}"
SRC_URI[aarch64_nagios-plugins-snmp.sha256sum] = "4c6df4121c241ff2a3fb46d8bd23d2460993b9e012495256ac34c5560e75c277"

URI_aarch64_nagios-plugins-ssh = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ssh-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ssh}"
SRC_URI[aarch64_nagios-plugins-ssh.sha256sum] = "fa9c9c5d2ac63b5e43afbdf0fe05e58faeea5586ea8e1e13f7cff57792d37f08"

URI_aarch64_nagios-plugins-ssl_validity = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ssl_validity-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ssl_validity;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ssl_validity}"
SRC_URI[aarch64_nagios-plugins-ssl_validity.sha256sum] = "d4397cb31367e5ec252977353eda18bcff575ad582b2a8b5714cd16570a412ad"

URI_aarch64_nagios-plugins-swap = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-swap-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-swap;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-swap}"
SRC_URI[aarch64_nagios-plugins-swap.sha256sum] = "30c135ba48c386b4617c418e09281270866f1009368e508790b6bf520f34e5d4"

URI_aarch64_nagios-plugins-tcp = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-tcp-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-tcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-tcp}"
SRC_URI[aarch64_nagios-plugins-tcp.sha256sum] = "85990575b7eafed9ddabe3e37ffb220024188b91efd16cf1c0f1b297ea644412"

URI_aarch64_nagios-plugins-time = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-time-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-time}"
SRC_URI[aarch64_nagios-plugins-time.sha256sum] = "015039b5e1486e8e4a40e825a36abfc412345ee43a7ee048b4ea7de475f8220d"

URI_aarch64_nagios-plugins-ups = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-ups-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-ups;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-ups}"
SRC_URI[aarch64_nagios-plugins-ups.sha256sum] = "fa217574644a7821bcd3502b1ba54ccfbf9847affbf03d584f79b38f3d274766"

URI_aarch64_nagios-plugins-uptime = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-uptime-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-uptime;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-uptime}"
SRC_URI[aarch64_nagios-plugins-uptime.sha256sum] = "0288ebe46a20f8470ade71b2274bb9533267844da9fc31ef5f4b98e48a2c472c"

URI_aarch64_nagios-plugins-users = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-users-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-users;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-users}"
SRC_URI[aarch64_nagios-plugins-users.sha256sum] = "29bd56a500a0797adcda9b11f79662504c3d6c04b2226d058bad6d734bcd05a7"

URI_aarch64_nagios-plugins-wave = "${EPEL_MIRROR}/aarch64/Packages/n/nagios-plugins-wave-2.4.12-1.el10_0.aarch64.rpm;name=aarch64_nagios-plugins-wave;unpack=0"
SRC_URI:append = " ${URI_aarch64_nagios-plugins-wave}"
SRC_URI[aarch64_nagios-plugins-wave.sha256sum] = "cbfc64f8b9e854848f82ddee68f1e35658bb3f28d9bedb04779e4272ecca163f"

RDEPENDS:nagios-plugins = " \
 bash \
 glibc \
 nagios-common \
 "
RDEPENDS:nagios-plugins-all = " \
 nagios-plugins-breeze \
 nagios-plugins-by_ssh \
 nagios-plugins-cluster \
 nagios-plugins-dhcp \
 nagios-plugins-dig \
 nagios-plugins-disk \
 nagios-plugins-disk_smb \
 nagios-plugins-dns \
 nagios-plugins-dummy \
 nagios-plugins-file_age \
 nagios-plugins-flexlm \
 nagios-plugins-fping \
 nagios-plugins-game \
 nagios-plugins-hpjd \
 nagios-plugins-http \
 nagios-plugins-icmp \
 nagios-plugins-ide_smart \
 nagios-plugins-ircd \
 nagios-plugins-ldap \
 nagios-plugins-load \
 nagios-plugins-log \
 nagios-plugins-mailq \
 nagios-plugins-mrtg \
 nagios-plugins-mrtgtraf \
 nagios-plugins-mysql \
 nagios-plugins-nagios \
 nagios-plugins-nt \
 nagios-plugins-ntp \
 nagios-plugins-nwstat \
 nagios-plugins-oracle \
 nagios-plugins-overcr \
 nagios-plugins-pgsql \
 nagios-plugins-ping \
 nagios-plugins-procs \
 nagios-plugins-real \
 nagios-plugins-rpc \
 nagios-plugins-sensors \
 nagios-plugins-smtp \
 nagios-plugins-snmp \
 nagios-plugins-ssh \
 nagios-plugins-ssl_validity \
 nagios-plugins-swap \
 nagios-plugins-tcp \
 nagios-plugins-time \
 nagios-plugins-ups \
 nagios-plugins-users \
 nagios-plugins-wave \
 "
RDEPENDS:nagios-plugins-apt = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-breeze = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
RDEPENDS:nagios-plugins-by_ssh = " \
 glibc \
 nagios-plugins \
 openssh-clients \
 "
RDEPENDS:nagios-plugins-cluster = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-dhcp = " \
 glibc \
 nagios-common \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-dig = " \
 bind-utils \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-disk = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-disk_smb = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-utf8-all \
 perl-vars \
 samba-client \
 "
RDEPENDS:nagios-plugins-dns = " \
 bind-utils \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-dummy = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-file_age = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-English \
 perl-File-Basename \
 perl-File-stat \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
RDEPENDS:nagios-plugins-flexlm = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
RDEPENDS:nagios-plugins-fping = " \
 fping \
 glibc \
 nagios-common \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-game = " \
 glibc \
 nagios-plugins \
 qstat \
 "
RDEPENDS:nagios-plugins-hpjd = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-http = " \
 glibc \
 nagios-plugins \
 openssl \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-icmp = " \
 glibc \
 nagios-common \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ide_smart = " \
 glibc \
 nagios-common \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ifoperstatus = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Net-SNMP \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
RDEPENDS:nagios-plugins-ifstatus = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Net-SNMP \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
RDEPENDS:nagios-plugins-ircd = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Socket \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
RDEPENDS:nagios-plugins-ldap = " \
 glibc \
 nagios-plugins \
 openldap \
 openssl \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-load = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-log = " \
 bash \
 grep \
 nagios-plugins \
 virtual/coreutils \
 "
RDEPENDS:nagios-plugins-mailq = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 virtual//usr/bin/mailq \
 "
RDEPENDS:nagios-plugins-mrtg = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-mrtgtraf = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-mysql = " \
 glibc \
 mariadb-connector-c \
 nagios-plugins \
 openssl \
 "
RDEPENDS:nagios-plugins-nagios = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-nt = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ntp = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-nwstat = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-oracle = " \
 bash \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-overcr = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-perl = " \
 nagios-plugins \
 perl-Exporter \
 "
RDEPENDS:nagios-plugins-pgsql = " \
 glibc \
 libpq \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ping = " \
 glibc \
 iputils \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-procs = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-real = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-remove_perfdata = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-rpc = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 rpcbind \
 "
RDEPENDS:nagios-plugins-sensors = " \
 bash \
 grep \
 lm_sensors \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-smtp = " \
 glibc \
 nagios-plugins \
 openssl \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-snmp = " \
 glibc \
 nagios-plugins \
 net-snmp-utils \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-ssh = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ssl_validity = " \
 nagios-plugins \
 openssl \
 perl-Crypt-X509 \
 perl-Digest-MD5 \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-POSIX \
 perl-Text-Glob \
 perl-TimeDate \
 perl-interpreter \
 perl-libwww-perl \
 "
RDEPENDS:nagios-plugins-swap = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-tcp = " \
 glibc \
 nagios-plugins \
 openssl \
 openssl-libs \
 "
RDEPENDS:nagios-plugins-time = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-ups = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-uptime = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-users = " \
 glibc \
 nagios-plugins \
 "
RDEPENDS:nagios-plugins-wave = " \
 nagios-plugins \
 nagios-plugins-perl \
 perl-FindBin \
 perl-Getopt-Long \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
