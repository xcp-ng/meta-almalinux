# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-browser-integration"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-browser-integration \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-browser-integration-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a258e936cc48f96db968ed4919e2a945fb7d9c2ff8aa8cdef0e0563ff77cdf5"

URI_x86_64_v2_plasma-browser-integration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-browser-integration-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-browser-integration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-browser-integration}"
SRC_URI[x86_64_v2_plasma-browser-integration.sha256sum] = "f441d519677d6fac0b56dfef3864472317238cba3a86acea7dd149624387cd3b"

URI_aarch64_plasma-browser-integration = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-browser-integration-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-browser-integration;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-browser-integration}"
SRC_URI[aarch64_plasma-browser-integration.sha256sum] = "c6f4f6e6bfc7e0d71f1b6bf804c37aa38cef72ba196bf231f8f7e9effe70864d"

RDEPENDS:plasma-browser-integration = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-purpose \
 libstdc++ \
 plasma-activities \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
