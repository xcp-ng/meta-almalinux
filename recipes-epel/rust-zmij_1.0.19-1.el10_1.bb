# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zmij"
PV = "1.0.19"
PR = "1.el10_1"
PACKAGES = " \
 rust-zmij+default-devel \
 rust-zmij+no-panic-devel \
 rust-zmij-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zmij-1.0.19-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d381159562b82069262e650173ab891f7956889b9da517d27f8fcb75be14c50"

URI_x86_64_v2_rust-zmij+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zmij+default-devel-1.0.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zmij+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zmij+default-devel}"
SRC_URI[x86_64_v2_rust-zmij+default-devel.sha256sum] = "520c6573badbb32ff3091b7d5fca8d2b1430113e1a57025cb1c7711706031d44"

URI_x86_64_v2_rust-zmij+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zmij+no-panic-devel-1.0.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zmij+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zmij+no-panic-devel}"
SRC_URI[x86_64_v2_rust-zmij+no-panic-devel.sha256sum] = "eacc61f3639bd74d049f8b093f0c955b03cc1ec8062a9d8856322e341e13d271"

URI_x86_64_v2_rust-zmij-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zmij-devel-1.0.19-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zmij-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zmij-devel}"
SRC_URI[x86_64_v2_rust-zmij-devel.sha256sum] = "fb67261c57412923737769046c76cc5b0b55edb8181028157e9e29737bfd3344"

URI_aarch64_rust-zmij+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zmij+default-devel-1.0.19-1.el10_1.noarch.rpm;name=aarch64_rust-zmij+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zmij+default-devel}"
SRC_URI[aarch64_rust-zmij+default-devel.sha256sum] = "dd0e3646c783a2d6a5a5c379e318f20cd4cde1ec361a5a88628a15ec7b57cc91"

URI_aarch64_rust-zmij+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zmij+no-panic-devel-1.0.19-1.el10_1.noarch.rpm;name=aarch64_rust-zmij+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zmij+no-panic-devel}"
SRC_URI[aarch64_rust-zmij+no-panic-devel.sha256sum] = "2be91cfbfd935bb680e2773886da1b2aa6c42415f336db5db4bbab30dbeee6c6"

URI_aarch64_rust-zmij-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zmij-devel-1.0.19-1.el10_1.noarch.rpm;name=aarch64_rust-zmij-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zmij-devel}"
SRC_URI[aarch64_rust-zmij-devel.sha256sum] = "8cadf17c212d4b60485441439d104e24675138e86b5a51d557d0c483b4beaa42"

RDEPENDS:rust-zmij+default-devel = " \
 cargo \
 rust-zmij-devel \
 "
RDEPENDS:rust-zmij+no-panic-devel = " \
 cargo \
 rust-no-panic+default-devel \
 rust-zmij-devel \
 "
RDEPENDS:rust-zmij-devel = " \
 cargo \
 rust \
 "
