# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono"
PV = "0.4.44"
PR = "1.el10_2"
PACKAGES = " \
 rust-chrono+alloc-devel \
 rust-chrono+arbitrary-devel \
 rust-chrono+clock-devel \
 rust-chrono+core-error-devel \
 rust-chrono+default-devel \
 rust-chrono+iana-time-zone-devel \
 rust-chrono+libc-devel \
 rust-chrono+now-devel \
 rust-chrono+oldtime-devel \
 rust-chrono+pure-rust-locales-devel \
 rust-chrono+rkyv-16-devel \
 rust-chrono+rkyv-32-devel \
 rust-chrono+rkyv-64-devel \
 rust-chrono+rkyv-devel \
 rust-chrono+rkyv-validation-devel \
 rust-chrono+serde-devel \
 rust-chrono+std-devel \
 rust-chrono+unstable-locales-devel \
 rust-chrono-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-0.4.44-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe4e318c0d1e61e251399f2b1a6f547773b60777eb80f44dbe5cc8a197189a81"

URI_x86_64_v2_rust-chrono+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+alloc-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+alloc-devel}"
SRC_URI[x86_64_v2_rust-chrono+alloc-devel.sha256sum] = "18bcb2006491d975d7a6a016d45326fde7fde950214f39b34708cb6c9e1695a1"

URI_x86_64_v2_rust-chrono+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+arbitrary-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-chrono+arbitrary-devel.sha256sum] = "b80aa93b401f1906748ceb41aa1739379325964927acad1c6c9924464ca44618"

URI_x86_64_v2_rust-chrono+clock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+clock-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+clock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+clock-devel}"
SRC_URI[x86_64_v2_rust-chrono+clock-devel.sha256sum] = "20f46981dfbf9033a802d8e21eb4607149caa9f93ef5097616e7cb9a536066f8"

URI_x86_64_v2_rust-chrono+core-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+core-error-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+core-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+core-error-devel}"
SRC_URI[x86_64_v2_rust-chrono+core-error-devel.sha256sum] = "2b2b342b5ba77da157208e607f3861f296d1aa824caa407cb2b0ad427b947a45"

URI_x86_64_v2_rust-chrono+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+default-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+default-devel}"
SRC_URI[x86_64_v2_rust-chrono+default-devel.sha256sum] = "940919adf4515844481a5b61a86befe12a5ac2245ad2bbeeac07d79ee737b5e4"

URI_x86_64_v2_rust-chrono+iana-time-zone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+iana-time-zone-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+iana-time-zone-devel}"
SRC_URI[x86_64_v2_rust-chrono+iana-time-zone-devel.sha256sum] = "1bc3e10fa00f9c365a1aa5131ca1d34166eb23c9a0c8d27712b9a97055d2d9a5"

URI_x86_64_v2_rust-chrono+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+libc-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+libc-devel}"
SRC_URI[x86_64_v2_rust-chrono+libc-devel.sha256sum] = "80e2e0a943d0273199232ee1b4f6ac9a29795b3401fea6b12ec3a2b7c82ece69"

URI_x86_64_v2_rust-chrono+now-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+now-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+now-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+now-devel}"
SRC_URI[x86_64_v2_rust-chrono+now-devel.sha256sum] = "d5b547de9b18a240e42806237d2ae94b172f569f7cab155d16f91a77d5f4e866"

URI_x86_64_v2_rust-chrono+oldtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+oldtime-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+oldtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+oldtime-devel}"
SRC_URI[x86_64_v2_rust-chrono+oldtime-devel.sha256sum] = "df993fd998e0135d418050704a9a1822042535d604610ae721c75289a342f8fc"

URI_x86_64_v2_rust-chrono+pure-rust-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+pure-rust-locales-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+pure-rust-locales-devel}"
SRC_URI[x86_64_v2_rust-chrono+pure-rust-locales-devel.sha256sum] = "44a37574d567f61efab5737861c2e92dffc6e0175e18d4f81aa30fa71cabc409"

URI_x86_64_v2_rust-chrono+rkyv-16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-16-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-16-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-16-devel.sha256sum] = "acfb017025375956cb44cb87b0a4e4a04561db1bd3e79b2ad2c937f26fe1e2d2"

URI_x86_64_v2_rust-chrono+rkyv-32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-32-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-32-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-32-devel.sha256sum] = "6e4d3f3fceea94fd0a08cc4b03242cf4671636f917cf5921642d0a2b2fd741ef"

URI_x86_64_v2_rust-chrono+rkyv-64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-64-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-64-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-64-devel.sha256sum] = "fa20b61d93bb7961997e13cd0f5c6b12abd8276f928a5d1abc7b9c521657ab0a"

URI_x86_64_v2_rust-chrono+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-devel.sha256sum] = "8f01138a1dbf426c031099bc9de69b432eec7772a9c61bbd8e6b78a6cf8d3554"

URI_x86_64_v2_rust-chrono+rkyv-validation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-validation-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-validation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-validation-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-validation-devel.sha256sum] = "565c93d1e0953a38f30c37ce9402bb09b9b111f29bedea84690a3dc45969554f"

URI_x86_64_v2_rust-chrono+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+serde-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+serde-devel}"
SRC_URI[x86_64_v2_rust-chrono+serde-devel.sha256sum] = "31a704f8615fb8a358e72c44a06d21d6bd7864432300aeb1eaede0087219273c"

URI_x86_64_v2_rust-chrono+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+std-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+std-devel}"
SRC_URI[x86_64_v2_rust-chrono+std-devel.sha256sum] = "49df45081f5c4dd5de025d82a80f1cc5da83387efb1acbbfedb7efdc512e52af"

URI_x86_64_v2_rust-chrono+unstable-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+unstable-locales-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+unstable-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+unstable-locales-devel}"
SRC_URI[x86_64_v2_rust-chrono+unstable-locales-devel.sha256sum] = "05a9b8af711a9928dbf1f3a8857bf74d0bc9fd89c4774446f1f1fff2400c72cd"

URI_x86_64_v2_rust-chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-devel-0.4.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-devel}"
SRC_URI[x86_64_v2_rust-chrono-devel.sha256sum] = "68e92f3a3ec12609fc336160d59b22f4a15387cef613a705e3fe6b9c8364ff92"

URI_aarch64_rust-chrono+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+alloc-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+alloc-devel}"
SRC_URI[aarch64_rust-chrono+alloc-devel.sha256sum] = "c6a29f8e0579c040a4e6e2483de13c12ae80501dc97eeb2a0aeb1c6a9a3ac3a2"

URI_aarch64_rust-chrono+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+arbitrary-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+arbitrary-devel}"
SRC_URI[aarch64_rust-chrono+arbitrary-devel.sha256sum] = "a00aaefdfd26f45ca5b72f47764f50761dbd8f96e596d469219250fcde201cc7"

URI_aarch64_rust-chrono+clock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+clock-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+clock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+clock-devel}"
SRC_URI[aarch64_rust-chrono+clock-devel.sha256sum] = "653a68aa88aa2a5065c7e63b9e9a71d05a0808c10bf139e5346768d234425de3"

URI_aarch64_rust-chrono+core-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+core-error-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+core-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+core-error-devel}"
SRC_URI[aarch64_rust-chrono+core-error-devel.sha256sum] = "b60b7c790080a95837056c860e42fd7155ed467ed19936352ceda1b876db2041"

URI_aarch64_rust-chrono+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+default-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+default-devel}"
SRC_URI[aarch64_rust-chrono+default-devel.sha256sum] = "783a0b8cb3c30d6a6b1f9aa5a9041a27f854b6fa7bd23578692fa98bbccb5774"

URI_aarch64_rust-chrono+iana-time-zone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+iana-time-zone-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+iana-time-zone-devel}"
SRC_URI[aarch64_rust-chrono+iana-time-zone-devel.sha256sum] = "09ae5027656fdc94d5c1fea7df502cc584950a75f05a505c42b74b0b3fcce5be"

URI_aarch64_rust-chrono+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+libc-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+libc-devel}"
SRC_URI[aarch64_rust-chrono+libc-devel.sha256sum] = "f25777a15b4159d6eea753d3d164a2254bf8801f65b941bae8ce488092205236"

URI_aarch64_rust-chrono+now-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+now-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+now-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+now-devel}"
SRC_URI[aarch64_rust-chrono+now-devel.sha256sum] = "bfd60531eb9a61c3a8060c2da7cf699a1406ba5e2e152cf9d1b7014caced3f1c"

URI_aarch64_rust-chrono+oldtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+oldtime-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+oldtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+oldtime-devel}"
SRC_URI[aarch64_rust-chrono+oldtime-devel.sha256sum] = "f48ecaaf009064188b0e87d5107997f8cf73cb29ff6ac8bab8ac57de6eca2d3c"

URI_aarch64_rust-chrono+pure-rust-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+pure-rust-locales-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+pure-rust-locales-devel}"
SRC_URI[aarch64_rust-chrono+pure-rust-locales-devel.sha256sum] = "5324cca21df97c802825e979a2502e91110ab7edf198fdace6df91e2a42950d5"

URI_aarch64_rust-chrono+rkyv-16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-16-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+rkyv-16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-16-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-16-devel.sha256sum] = "6913662de16d5b10f5fe9ec90973566f9e09191b0e2dca687bc162c2b762aa77"

URI_aarch64_rust-chrono+rkyv-32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-32-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+rkyv-32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-32-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-32-devel.sha256sum] = "cb0df2d0f1e9c490270386d57f0944b8729ebc0dc4db64e048fcf58df05b915d"

URI_aarch64_rust-chrono+rkyv-64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-64-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+rkyv-64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-64-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-64-devel.sha256sum] = "c5709dff7f6ffbeff2638b519b94fbfdc69a25fe8592150314c9f3a0624fcc1f"

URI_aarch64_rust-chrono+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-devel.sha256sum] = "bfa3361d0fc71e279ed769357467fe6b38eb5233988d8de22148efd8b8601cf1"

URI_aarch64_rust-chrono+rkyv-validation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-validation-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+rkyv-validation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-validation-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-validation-devel.sha256sum] = "4574368ec21de144085a89dcd40ab2292283a6a551d62a476683484c5bfff17d"

URI_aarch64_rust-chrono+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+serde-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+serde-devel}"
SRC_URI[aarch64_rust-chrono+serde-devel.sha256sum] = "6a8316e7721585e69ca8cfedc0b1d33dfc16fb7376956fda38566e938297e590"

URI_aarch64_rust-chrono+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+std-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+std-devel}"
SRC_URI[aarch64_rust-chrono+std-devel.sha256sum] = "47ca8939c0a8c35a9c3a36b0fe979bc26c7d7bff2710b589731e44d322bf1bc3"

URI_aarch64_rust-chrono+unstable-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+unstable-locales-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono+unstable-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+unstable-locales-devel}"
SRC_URI[aarch64_rust-chrono+unstable-locales-devel.sha256sum] = "b287e525a213fceb2b25d10d6868dec66724baa6c870d33590fc20365e3e03e5"

URI_aarch64_rust-chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-devel-0.4.44-1.el10_2.noarch.rpm;name=aarch64_rust-chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-devel}"
SRC_URI[aarch64_rust-chrono-devel.sha256sum] = "d09a9e16cd6a27695c850b8ae17b04258c2f3aaa0aaa320c562591a1f48779fe"

RDEPENDS:rust-chrono+alloc-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+clock-devel = " \
 cargo \
 rust-chrono+iana-time-zone-devel \
 rust-chrono+now-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+core-error-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+default-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+oldtime-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+iana-time-zone-devel = " \
 cargo \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 "
RDEPENDS:rust-chrono+libc-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+now-devel = " \
 cargo \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+oldtime-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+pure-rust-locales-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pure-rust-locales+default-devel \
 "
RDEPENDS:rust-chrono+rkyv-16-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_16-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-32-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-64-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_64-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-validation-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+serde-devel = " \
 cargo \
 rust-chrono-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-chrono+std-devel = " \
 cargo \
 rust-chrono+alloc-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+unstable-locales-devel = " \
 cargo \
 rust-chrono+pure-rust-locales-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
