# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tzdata"
PV = "2026b"
PR = "1.el10.alma.1"
PACKAGES = " \
 tzdata \
 tzdata-java \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tzdata-2026b-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d17b69dea97197457a1d891abdf06841834d587fbb95f2fa85d8f81c74ce5203"

URI_x86_64_v2_tzdata = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tzdata-2026b-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tzdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tzdata}"
SRC_URI[x86_64_v2_tzdata.sha256sum] = "1e7959c30e4c427b3e6ea31062642136a8fbc3c4229c4d18f74d8b5a962993e7"

URI_x86_64_v2_tzdata-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tzdata-java-2026b-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tzdata-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tzdata-java}"
SRC_URI[x86_64_v2_tzdata-java.sha256sum] = "7a75e71d74b54c56064e48c2631a4c4bac96ba640f7f799ca4f35cdcea183e91"

URI_aarch64_tzdata = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tzdata-2026b-1.el10.alma.1.noarch.rpm;name=aarch64_tzdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_tzdata}"
SRC_URI[aarch64_tzdata.sha256sum] = "1e7959c30e4c427b3e6ea31062642136a8fbc3c4229c4d18f74d8b5a962993e7"

URI_aarch64_tzdata-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tzdata-java-2026b-1.el10.alma.1.noarch.rpm;name=aarch64_tzdata-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_tzdata-java}"
SRC_URI[aarch64_tzdata-java.sha256sum] = "7a75e71d74b54c56064e48c2631a4c4bac96ba640f7f799ca4f35cdcea183e91"

RDEPENDS:tzdata = " \
 "
RDEPENDS:tzdata-java = " \
 "
