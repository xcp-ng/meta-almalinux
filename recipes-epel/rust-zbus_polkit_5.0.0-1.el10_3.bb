# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus_polkit"
PV = "5.0.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-zbus_polkit+blocking-api-devel \
 rust-zbus_polkit+default-devel \
 rust-zbus_polkit+tokio-devel \
 rust-zbus_polkit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zbus_polkit-5.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5b1aeea5a6dfe9a3caae93f1bdb96b6f049dc5ff08c1ee3d47a506e87cbfda6"

URI_x86_64_v2_rust-zbus_polkit+blocking-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_polkit+blocking-api-devel-5.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_polkit+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_polkit+blocking-api-devel}"
SRC_URI[x86_64_v2_rust-zbus_polkit+blocking-api-devel.sha256sum] = "30463338ee510d394b2664a454c18ca7b1c2f0571ed93882c141dfc416cd2eeb"

URI_x86_64_v2_rust-zbus_polkit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_polkit+default-devel-5.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_polkit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_polkit+default-devel}"
SRC_URI[x86_64_v2_rust-zbus_polkit+default-devel.sha256sum] = "a1e4c393ba827330b81ddfe98cda122c3726bbcf6611cdad609ba9cf2cd58eca"

URI_x86_64_v2_rust-zbus_polkit+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_polkit+tokio-devel-5.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_polkit+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_polkit+tokio-devel}"
SRC_URI[x86_64_v2_rust-zbus_polkit+tokio-devel.sha256sum] = "9bf10a1cf4b575946454ffaa3650a2eed57fa9b070c48c5fa1d00c82e91eae70"

URI_x86_64_v2_rust-zbus_polkit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_polkit-devel-5.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_polkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_polkit-devel}"
SRC_URI[x86_64_v2_rust-zbus_polkit-devel.sha256sum] = "d2b256fa1b98ec3901f2de0f305549f7af9329dad0921d6ce4296a5aad0afea0"

URI_aarch64_rust-zbus_polkit+blocking-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_polkit+blocking-api-devel-5.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_polkit+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_polkit+blocking-api-devel}"
SRC_URI[aarch64_rust-zbus_polkit+blocking-api-devel.sha256sum] = "b707c754b122a3b2691c4b3e7689068bdeafa284f90cec02591a6cd10171663b"

URI_aarch64_rust-zbus_polkit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_polkit+default-devel-5.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_polkit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_polkit+default-devel}"
SRC_URI[aarch64_rust-zbus_polkit+default-devel.sha256sum] = "f920efe0fc0104f4e82073d4498a40e18a49f6db636b3c4fb9247f9a59cddc67"

URI_aarch64_rust-zbus_polkit+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_polkit+tokio-devel-5.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_polkit+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_polkit+tokio-devel}"
SRC_URI[aarch64_rust-zbus_polkit+tokio-devel.sha256sum] = "9ca6d657976864c99cd59baf18116701da5bf88d329cd7922d4998cd805c1bdf"

URI_aarch64_rust-zbus_polkit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_polkit-devel-5.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus_polkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_polkit-devel}"
SRC_URI[aarch64_rust-zbus_polkit-devel.sha256sum] = "7564397012dc751adb4cee9a0cf81b62da220f0324880226f483bc5219d7001f"

RDEPENDS:rust-zbus_polkit+blocking-api-devel = " \
 cargo \
 rust-zbus+blocking-api-devel \
 rust-zbus_polkit-devel \
 "
RDEPENDS:rust-zbus_polkit+default-devel = " \
 cargo \
 rust-zbus+async-io-devel \
 rust-zbus_polkit+blocking-api-devel \
 rust-zbus_polkit-devel \
 "
RDEPENDS:rust-zbus_polkit+tokio-devel = " \
 cargo \
 rust-zbus+tokio-devel \
 rust-zbus_polkit-devel \
 "
RDEPENDS:rust-zbus_polkit-devel = " \
 cargo \
 rust \
 rust-enumflags2+default-devel \
 rust-enumflags2+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_repr+default-devel \
 rust-static_assertions+default-devel \
 rust-zbus-devel \
 "
