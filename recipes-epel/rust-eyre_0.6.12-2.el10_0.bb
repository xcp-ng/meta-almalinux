# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-eyre"
PV = "0.6.12"
PR = "2.el10_0"
PACKAGES = " \
 rust-eyre+auto-install-devel \
 rust-eyre+default-devel \
 rust-eyre+track-caller-devel \
 rust-eyre-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-eyre-0.6.12-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a453c6205d70cb794cfe148f562caf8505d5831ec653145ab2f7a00f8a06fc67"

URI_x86_64_v2_rust-eyre+auto-install-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre+auto-install-devel-0.6.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre+auto-install-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eyre+auto-install-devel}"
SRC_URI[x86_64_v2_rust-eyre+auto-install-devel.sha256sum] = "082129153c2d5e99fc6b5b2b77f173edebf22b7f1c77d2d06b27572f8d5ce30c"

URI_x86_64_v2_rust-eyre+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre+default-devel-0.6.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eyre+default-devel}"
SRC_URI[x86_64_v2_rust-eyre+default-devel.sha256sum] = "6e035ce141613820744c395d627c24e4fc99cf1155dd91b1988b65eb6bd3eb14"

URI_x86_64_v2_rust-eyre+track-caller-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre+track-caller-devel-0.6.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre+track-caller-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eyre+track-caller-devel}"
SRC_URI[x86_64_v2_rust-eyre+track-caller-devel.sha256sum] = "c94f20bab1b1e4b02ecccac7432ccbda1d1f920430d516cd7e656ff7447bbd76"

URI_x86_64_v2_rust-eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre-devel-0.6.12-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eyre-devel}"
SRC_URI[x86_64_v2_rust-eyre-devel.sha256sum] = "977f02b28c9dc2984e50a3b34e237f8b2302f38f98d7c365ccf6ac45f3ed31e8"

URI_aarch64_rust-eyre+auto-install-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre+auto-install-devel-0.6.12-2.el10_0.noarch.rpm;name=aarch64_rust-eyre+auto-install-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eyre+auto-install-devel}"
SRC_URI[aarch64_rust-eyre+auto-install-devel.sha256sum] = "7b5342c893fbaaec2ff913f4eb8cec914e1c97b9e45e14098798d89b969a1b8a"

URI_aarch64_rust-eyre+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre+default-devel-0.6.12-2.el10_0.noarch.rpm;name=aarch64_rust-eyre+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eyre+default-devel}"
SRC_URI[aarch64_rust-eyre+default-devel.sha256sum] = "8e97b96673d2a14e682a186d2196ce91b36e5b82a119a2217fab8918dc421390"

URI_aarch64_rust-eyre+track-caller-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre+track-caller-devel-0.6.12-2.el10_0.noarch.rpm;name=aarch64_rust-eyre+track-caller-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eyre+track-caller-devel}"
SRC_URI[aarch64_rust-eyre+track-caller-devel.sha256sum] = "7808f212b8fa9d28c63a5f079e1e0f6c438a78ed74aea072854b403c781fc6c9"

URI_aarch64_rust-eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre-devel-0.6.12-2.el10_0.noarch.rpm;name=aarch64_rust-eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eyre-devel}"
SRC_URI[aarch64_rust-eyre-devel.sha256sum] = "9b031c6cc2b158b820725b61670dfcf09453421ec7a21684a04e9e90edfe53a2"

RDEPENDS:rust-eyre+auto-install-devel = " \
 cargo \
 rust-eyre-devel \
 "
RDEPENDS:rust-eyre+default-devel = " \
 cargo \
 rust-eyre+auto-install-devel \
 rust-eyre+track-caller-devel \
 rust-eyre-devel \
 "
RDEPENDS:rust-eyre+track-caller-devel = " \
 cargo \
 rust-eyre-devel \
 "
RDEPENDS:rust-eyre-devel = " \
 cargo \
 rust \
 rust-indenter+default-devel \
 rust-once_cell+default-devel \
 "
