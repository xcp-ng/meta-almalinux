# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam"
PV = "1.6.1"
PR = "8.el10"
PACKAGES = " \
 pam \
 pam-devel \
 pam-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pam-1.6.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5388a4c3f1cb4b88d2c6ba3ff2ce523f6a72565765b2d17c70d8ac5c1bfdaf34"

URI_x86_64_v2_pam = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-1.6.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam}"
SRC_URI[x86_64_v2_pam.sha256sum] = "508d8a6eeeb1dfc0b60e3a1b7f37b9d75af47d9ce6efb769eb2e20ce37f10474"

URI_x86_64_v2_pam-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam-devel-1.6.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_pam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-devel}"
SRC_URI[x86_64_v2_pam-devel.sha256sum] = "cbfdbfc3a122c50e59c825fcbf09bc93a488a216a7d347cc5de5a7b0e562ec8c"

URI_x86_64_v2_pam-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-libs-1.6.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_pam-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-libs}"
SRC_URI[x86_64_v2_pam-libs.sha256sum] = "f191a92ab27133f8c897b58b7dac618507b81fb5e30ba08561ee2fd4cef72674"

URI_aarch64_pam = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-1.6.1-8.el10.aarch64.rpm;name=aarch64_pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam}"
SRC_URI[aarch64_pam.sha256sum] = "95992cd773c03bf46256571815beade5bbb0bca39e41f30928db52e394459f8a"

URI_aarch64_pam-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam-devel-1.6.1-8.el10.aarch64.rpm;name=aarch64_pam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-devel}"
SRC_URI[aarch64_pam-devel.sha256sum] = "1d6bf7e9f836b9f2dc5c652b66837e1fd6cc03fe19c74d16a121e352437d4c91"

URI_aarch64_pam-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-libs-1.6.1-8.el10.aarch64.rpm;name=aarch64_pam-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-libs}"
SRC_URI[aarch64_pam-libs.sha256sum] = "5bcafe006d73f60602c271844fcdad0e33d873d092140054a8511c70d0ef0b63"

RDEPENDS:pam = " \
 audit-libs \
 authselect \
 bash \
 gdbm \
 gdbm-libs \
 glibc \
 libeconf \
 libpwquality \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 setup \
 "
RDEPENDS:pam-devel = " \
 pam-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pam-libs = " \
 audit-libs \
 glibc \
 libeconf \
 "
