# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "copr-cli"
PV = "2.5"
PR = "1.el10_1"
PACKAGES = " \
 copr-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/copr-cli-2.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "269c5cf5f9d6685b96509ca27a0213f77fedee6f494db192d34997d6edcdc5d4"

URI_x86_64_v2_copr-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/copr-cli-2.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_copr-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_copr-cli}"
SRC_URI[x86_64_v2_copr-cli.sha256sum] = "eb39bdc6b462dff286cf0560a42d413ad2d1d57021963521ca21cd9ba6a7ce2e"

URI_aarch64_copr-cli = "${EPEL_MIRROR}/aarch64/Packages/c/copr-cli-2.5-1.el10_1.noarch.rpm;name=aarch64_copr-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_copr-cli}"
SRC_URI[aarch64_copr-cli.sha256sum] = "1040bb579aec2d6b0f3f6b2aaf61af7567a58ea0fa81963ddeb225251f1d7f64"

RDEPENDS:copr-cli = " \
 python3 \
 python3-copr \
 python3-humanize \
 python3-jinja2 \
 python3-koji \
 python3-rich \
 python3-setuptools \
 python3-typing-extensions \
 wget \
 "
