# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-aliyun-oss"
PV = "3.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-aliyun-oss+default-devel \
 rust-reqsign-aliyun-oss-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-aliyun-oss-3.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15e95e2a350159d5fbee608312a00057a70aecb4ebf43252306536fab999c3f7"

URI_x86_64_v2_rust-reqsign-aliyun-oss+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aliyun-oss+default-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aliyun-oss+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aliyun-oss+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aliyun-oss+default-devel.sha256sum] = "536b1b8cb12a9adccbafc1b3d986e4c54f263f49fd0ea6593f4b8674316c364f"

URI_x86_64_v2_rust-reqsign-aliyun-oss-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aliyun-oss-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aliyun-oss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aliyun-oss-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aliyun-oss-devel.sha256sum] = "3c87bf6b968d7deb80608d5ab028dcf6d9e966706cbb9f5256f67593d6b51b4d"

URI_aarch64_rust-reqsign-aliyun-oss+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aliyun-oss+default-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-aliyun-oss+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aliyun-oss+default-devel}"
SRC_URI[aarch64_rust-reqsign-aliyun-oss+default-devel.sha256sum] = "539e551e94a9e7e26ef44b16292bb47b90e15ca440bd85255654f64ce592f265"

URI_aarch64_rust-reqsign-aliyun-oss-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aliyun-oss-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-aliyun-oss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aliyun-oss-devel}"
SRC_URI[aarch64_rust-reqsign-aliyun-oss-devel.sha256sum] = "e803a7bd864234864cbfe02660ec06bdddac2426a5e36b5dca8ca1cf253540e6"

RDEPENDS:rust-reqsign-aliyun-oss+default-devel = " \
 cargo \
 rust-reqsign-aliyun-oss-devel \
 "
RDEPENDS:rust-reqsign-aliyun-oss-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-rust-ini+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
