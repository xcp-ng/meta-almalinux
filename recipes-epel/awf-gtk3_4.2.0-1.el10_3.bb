# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awf-gtk3"
PV = "4.2.0"
PR = "1.el10_3"
PACKAGES = " \
 awf-gtk3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awf-gtk3-4.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86f79a8ac7632f3e357cc08de1b99742267e1731470a0816f025c5297b91d7e1"

URI_x86_64_v2_awf-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awf-gtk3-4.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_awf-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awf-gtk3}"
SRC_URI[x86_64_v2_awf-gtk3.sha256sum] = "be65939cef3c1b9d4b419b26fc63334c6c97ae521c6b79cb6fd744aa7b6a8258"

URI_aarch64_awf-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/a/awf-gtk3-4.2.0-1.el10_3.aarch64.rpm;name=aarch64_awf-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_awf-gtk3}"
SRC_URI[aarch64_awf-gtk3.sha256sum] = "f16560b9405862172f4617c14a3aea3e7b24431952cbcecfe8fb749e1b112ad0"

RDEPENDS:awf-gtk3 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libnotify \
 pango \
 "
