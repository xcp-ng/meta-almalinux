# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyproject-rpm-macros"
PV = "1.23.2"
PR = "1.el10"
PACKAGES = " \
 pyproject-rpm-macros \
 pyproject-srpm-macros \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pyproject-rpm-macros-1.23.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac12dec98e76ccb613302cce4d97b49c9cf44db504c4c1128fbb3a54adf3313c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pyproject-rpm-macros-1.23.2-1.el10.noarch.rpm;name=x86_64_v2_pyproject-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_pyproject-rpm-macros.sha256sum] = "2aa1bd835cb55a47aefda2387df525ccd1f4ae1662a0a762f3bbb17cbbdd9a33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pyproject-srpm-macros-1.23.2-1.el10.noarch.rpm;name=x86_64_v2_pyproject-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_pyproject-srpm-macros.sha256sum] = "2a327d92cfdfc01777296122434f70f12a360856f8bd729c5e286df0b5701ec7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pyproject-rpm-macros-1.23.2-1.el10.noarch.rpm;name=aarch64_pyproject-rpm-macros;unpack=0"
SRC_URI[aarch64_pyproject-rpm-macros.sha256sum] = "2aa1bd835cb55a47aefda2387df525ccd1f4ae1662a0a762f3bbb17cbbdd9a33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pyproject-srpm-macros-1.23.2-1.el10.noarch.rpm;name=aarch64_pyproject-srpm-macros;unpack=0"
SRC_URI[aarch64_pyproject-srpm-macros.sha256sum] = "2a327d92cfdfc01777296122434f70f12a360856f8bd729c5e286df0b5701ec7"

RDEPENDS:pyproject-rpm-macros = " \
 findutils \
 pyproject-srpm-macros \
 python-rpm-macros \
 python-srpm-macros \
 python3-rpm-macros \
 rpm-build \
 sed \
 "
RDEPENDS:pyproject-srpm-macros = " \
 pyproject-rpm-macros \
 rpm-build \
 "
