# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-python-pkginfo"
PV = "0.6.5"
PR = "4.el10_0"
PACKAGES = " \
 rust-python-pkginfo+bzip2-devel \
 rust-python-pkginfo+default-devel \
 rust-python-pkginfo+deprecated-formats-devel \
 rust-python-pkginfo+serde-devel \
 rust-python-pkginfo+xz-devel \
 rust-python-pkginfo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-python-pkginfo-0.6.5-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38186ee499ff5496ec8428f3e7fdaf13ec56664ffa9d10ab82584b8be958db07"

URI_x86_64_v2_rust-python-pkginfo+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+bzip2-devel-0.6.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+bzip2-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+bzip2-devel.sha256sum] = "a903b989c012fa024f9d8632951768803efb2e4868f1f48cb9a543e781dd4d34"

URI_x86_64_v2_rust-python-pkginfo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+default-devel-0.6.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+default-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+default-devel.sha256sum] = "bfbc8618e335e7d002ed283966a1fa021f550e8d4164b22e88184721e0cb3912"

URI_x86_64_v2_rust-python-pkginfo+deprecated-formats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+deprecated-formats-devel-0.6.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+deprecated-formats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+deprecated-formats-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+deprecated-formats-devel.sha256sum] = "dff30c90f92295cafa9240485b854f5643e5db3a147943159545d8ee43be8d88"

URI_x86_64_v2_rust-python-pkginfo+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+serde-devel-0.6.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+serde-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+serde-devel.sha256sum] = "af68bd73491b7b5b8a05193d0f095c8959e9b58931788986d78a7dbb304b5b29"

URI_x86_64_v2_rust-python-pkginfo+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo+xz-devel-0.6.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo+xz-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo+xz-devel.sha256sum] = "605dfe5d2433b38e579f26780f731e6b875c0e051ca8d6e72a530e0007ec6b92"

URI_x86_64_v2_rust-python-pkginfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-python-pkginfo-devel-0.6.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-python-pkginfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-python-pkginfo-devel}"
SRC_URI[x86_64_v2_rust-python-pkginfo-devel.sha256sum] = "2c135842cc09eaa670972e222633290aa67fbfb5da4757a74bdb52928e281775"

URI_aarch64_rust-python-pkginfo+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+bzip2-devel-0.6.5-4.el10_0.noarch.rpm;name=aarch64_rust-python-pkginfo+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+bzip2-devel}"
SRC_URI[aarch64_rust-python-pkginfo+bzip2-devel.sha256sum] = "e17ac5987f877fa25a1296025b0227ce49afb9a145eec9b8fec53d9e8c39edaa"

URI_aarch64_rust-python-pkginfo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+default-devel-0.6.5-4.el10_0.noarch.rpm;name=aarch64_rust-python-pkginfo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+default-devel}"
SRC_URI[aarch64_rust-python-pkginfo+default-devel.sha256sum] = "c7e68a62e1f0122e6480d0acf88335928944d6ecb60573bb9957126d3d139631"

URI_aarch64_rust-python-pkginfo+deprecated-formats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+deprecated-formats-devel-0.6.5-4.el10_0.noarch.rpm;name=aarch64_rust-python-pkginfo+deprecated-formats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+deprecated-formats-devel}"
SRC_URI[aarch64_rust-python-pkginfo+deprecated-formats-devel.sha256sum] = "91031efa8a55edee6f6d3975d0a09e79c0407040ef2672efc9a53340909e715c"

URI_aarch64_rust-python-pkginfo+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+serde-devel-0.6.5-4.el10_0.noarch.rpm;name=aarch64_rust-python-pkginfo+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+serde-devel}"
SRC_URI[aarch64_rust-python-pkginfo+serde-devel.sha256sum] = "5e4a0a5ed841c6178f95573275244c5f82186e82d4e849762121f0b7ac09d1f6"

URI_aarch64_rust-python-pkginfo+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo+xz-devel-0.6.5-4.el10_0.noarch.rpm;name=aarch64_rust-python-pkginfo+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo+xz-devel}"
SRC_URI[aarch64_rust-python-pkginfo+xz-devel.sha256sum] = "5d752e63ecf3acd2b5fc0d7adfe05ef0c9ca94891cf970442241181988a85737"

URI_aarch64_rust-python-pkginfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-python-pkginfo-devel-0.6.5-4.el10_0.noarch.rpm;name=aarch64_rust-python-pkginfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-python-pkginfo-devel}"
SRC_URI[aarch64_rust-python-pkginfo-devel.sha256sum] = "5c5f23a6159d0366362c3ed7060aa4b477cc1e1b9a161eb799281160fd378ce5"

RDEPENDS:rust-python-pkginfo+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-python-pkginfo-devel \
 "
RDEPENDS:rust-python-pkginfo+default-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 "
RDEPENDS:rust-python-pkginfo+deprecated-formats-devel = " \
 cargo \
 rust-python-pkginfo+bzip2-devel \
 rust-python-pkginfo+xz-devel \
 rust-python-pkginfo-devel \
 virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_3.0.0~ \
 "
RDEPENDS:rust-python-pkginfo+serde-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-python-pkginfo+xz-devel = " \
 cargo \
 rust-python-pkginfo-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-python-pkginfo-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-fs-err+default-devel \
 rust-mailparse+default-devel \
 rust-rfc2047-decoder+default-devel \
 rust-tar+default-devel \
 rust-thiserror+default-devel \
 virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_3.0.0~ \
 virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_3.0.0~ \
 "
