# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "guava"
PV = "32.1.3"
PR = "6.el10"
PACKAGES = " \
 guava \
 guava-javadoc \
 guava-testlib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/guava-32.1.3-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "badbb3a87bfc66e87d77c9afbb8bd306a8e72917b295b91aae1f70cc4ba16e02"

URI_x86_64_v2_guava = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/guava-32.1.3-6.el10.noarch.rpm;name=x86_64_v2_guava;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guava}"
SRC_URI[x86_64_v2_guava.sha256sum] = "4aa6bb46a70481359aba12ff75d715210d9affed6082c9aa765c4ce5936c887d"

URI_x86_64_v2_guava-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guava-javadoc-32.1.3-6.el10.noarch.rpm;name=x86_64_v2_guava-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guava-javadoc}"
SRC_URI[x86_64_v2_guava-javadoc.sha256sum] = "5a8bd58d84b2181863608024203c9d875d80fd6817668753a56a556cbb0df9de"

URI_x86_64_v2_guava-testlib = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guava-testlib-32.1.3-6.el10.noarch.rpm;name=x86_64_v2_guava-testlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guava-testlib}"
SRC_URI[x86_64_v2_guava-testlib.sha256sum] = "400d5c041b22b6353cbbde7990126eacae8c5dba2f68d4295171a955c2769c91"

URI_aarch64_guava = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/guava-32.1.3-6.el10.noarch.rpm;name=aarch64_guava;unpack=0"
SRC_URI:append = " ${URI_aarch64_guava}"
SRC_URI[aarch64_guava.sha256sum] = "4aa6bb46a70481359aba12ff75d715210d9affed6082c9aa765c4ce5936c887d"

URI_aarch64_guava-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guava-javadoc-32.1.3-6.el10.noarch.rpm;name=aarch64_guava-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_guava-javadoc}"
SRC_URI[aarch64_guava-javadoc.sha256sum] = "5a8bd58d84b2181863608024203c9d875d80fd6817668753a56a556cbb0df9de"

URI_aarch64_guava-testlib = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guava-testlib-32.1.3-6.el10.noarch.rpm;name=aarch64_guava-testlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_guava-testlib}"
SRC_URI[aarch64_guava-testlib.sha256sum] = "400d5c041b22b6353cbbde7990126eacae8c5dba2f68d4295171a955c2769c91"

RDEPENDS:guava = " \
 javapackages-filesystem \
 jsr-305 \
 "
RDEPENDS:guava-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:guava-testlib = " \
 guava \
 javapackages-filesystem \
 jsr-305 \
 junit \
 "
