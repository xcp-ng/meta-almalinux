# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "HepMC"
PV = "2.06.11"
PR = "19.el10_2"
PACKAGES = " \
 HepMC \
 HepMC-devel \
 HepMC-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/HepMC-2.06.11-19.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1db40494cc361dcf9b2966940d9d116bed20be1c8d11b8872957ea9320bd49b8"

URI_x86_64_v2_HepMC = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC-2.06.11-19.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC}"
SRC_URI[x86_64_v2_HepMC.sha256sum] = "e0ad38b807ce559f0c6a8fa2f84d72a45a6449ecae18b5f0bd8222a77a6b8eaa"

URI_x86_64_v2_HepMC-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC-devel-2.06.11-19.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_HepMC-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC-devel}"
SRC_URI[x86_64_v2_HepMC-devel.sha256sum] = "a519db82081cc63f5b0ac8114e10eabbf8baac9105e772542bbd8054e6759ea2"

URI_x86_64_v2_HepMC-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/HepMC-doc-2.06.11-19.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_HepMC-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_HepMC-doc}"
SRC_URI[x86_64_v2_HepMC-doc.sha256sum] = "49364fd55c593829a9b530a55e45f5f9a2c801da8531baa931d5b66566c8b436"

URI_aarch64_HepMC = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC-2.06.11-19.el10_2.aarch64.rpm;name=aarch64_HepMC;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC}"
SRC_URI[aarch64_HepMC.sha256sum] = "ad8b38f64360aeb280111a1893466d450ea6411bca227f9cde0607b4294d85c7"

URI_aarch64_HepMC-devel = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC-devel-2.06.11-19.el10_2.aarch64.rpm;name=aarch64_HepMC-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC-devel}"
SRC_URI[aarch64_HepMC-devel.sha256sum] = "c56f9775f46ebc258ce3407d0b4b41961d525af1d2244863fabcbbba31c34751"

URI_aarch64_HepMC-doc = "${EPEL_MIRROR}/aarch64/Packages/h/HepMC-doc-2.06.11-19.el10_2.noarch.rpm;name=aarch64_HepMC-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_HepMC-doc}"
SRC_URI[aarch64_HepMC-doc.sha256sum] = "0ddd1e8c0ee7df740166ebde330876deb7f3a0422dd01dc10713e27e88ed9373"

RDEPENDS:HepMC = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:HepMC-devel = " \
 HepMC \
 "
RDEPENDS:HepMC-doc = " \
 "
