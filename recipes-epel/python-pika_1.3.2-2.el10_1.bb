# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pika"
PV = "1.3.2"
PR = "2.el10_1"
PACKAGES = " \
 python-pika-doc \
 python3-pika \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pika-1.3.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "96fe14028253a11f79b71e8e8aff9419e8be5cf9f9a8d4ec129102b4579cb845"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pika-doc-1.3.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-pika-doc;unpack=0"
SRC_URI[x86_64_v2_python-pika-doc.sha256sum] = "21b30b12e4fa96c6a8136bbc7d5ef5db566639e956b0bbd0ab45128d67cb26dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pika-1.3.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pika;unpack=0"
SRC_URI[x86_64_v2_python3-pika.sha256sum] = "d699b102ec408031b55ae4659d0cf786d4257607fe694e99ac27a50f47bb9bd5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-pika-doc-1.3.2-2.el10_1.noarch.rpm;name=aarch64_python-pika-doc;unpack=0"
SRC_URI[aarch64_python-pika-doc.sha256sum] = "bcbea4a89219cb78686e8715311b76494de957d3e4b13895bbf32c565de50a24"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pika-1.3.2-2.el10_1.noarch.rpm;name=aarch64_python3-pika;unpack=0"
SRC_URI[aarch64_python3-pika.sha256sum] = "18f8f24817371367a116edd1c402b9ac68cebeced3c9974a2fd13c03780749a8"

RDEPENDS:python-pika-doc = " \
 "
RDEPENDS:python3-pika = " \
 python3 \
 "
