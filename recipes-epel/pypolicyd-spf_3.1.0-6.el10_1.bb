# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pypolicyd-spf"
PV = "3.1.0"
PR = "6.el10_1"
PACKAGES = " \
 pypolicyd-spf \
 pypolicyd-spf-milter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pypolicyd-spf-3.1.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afb7278a8c62ce9690527eaafe69e6efce599dc6b99de9f8b519024d800314eb"

URI_x86_64_v2_pypolicyd-spf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pypolicyd-spf-3.1.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pypolicyd-spf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pypolicyd-spf}"
SRC_URI[x86_64_v2_pypolicyd-spf.sha256sum] = "9088a7fe02bf356be3240c9a077bd67b12a681a36bbd0e25799900cc6112c6e5"

URI_x86_64_v2_pypolicyd-spf-milter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pypolicyd-spf-milter-3.1.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pypolicyd-spf-milter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pypolicyd-spf-milter}"
SRC_URI[x86_64_v2_pypolicyd-spf-milter.sha256sum] = "7126a5da8422262a1b49c52919980e616bc8d69b33dbab5c41a9d1c2cca22a7c"

URI_aarch64_pypolicyd-spf = "${EPEL_MIRROR}/aarch64/Packages/p/pypolicyd-spf-3.1.0-6.el10_1.noarch.rpm;name=aarch64_pypolicyd-spf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pypolicyd-spf}"
SRC_URI[aarch64_pypolicyd-spf.sha256sum] = "c4a4f813c4d8525f9fb0406a2bac960cfcfc1e3acea72164cce614d58b20295b"

URI_aarch64_pypolicyd-spf-milter = "${EPEL_MIRROR}/aarch64/Packages/p/pypolicyd-spf-milter-3.1.0-6.el10_1.noarch.rpm;name=aarch64_pypolicyd-spf-milter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pypolicyd-spf-milter}"
SRC_URI[aarch64_pypolicyd-spf-milter.sha256sum] = "fbdb30860cdaad67e848492452a6ca8e13b8a387d49737c857553ca912e1408e"

RDEPENDS:pypolicyd-spf = " \
 bash \
 postfix \
 python3 \
 python3-authres \
 python3-pyspf \
 shadow-utils \
 "
RDEPENDS:pypolicyd-spf-milter = " \
 pypolicyd-spf \
 python3 \
 python3-pymilter \
 "
