# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive_builder_macro"
PV = "0.20.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-derive_builder_macro+alloc-devel \
 rust-derive_builder_macro+default-devel \
 rust-derive_builder_macro+lib_has_std-devel \
 rust-derive_builder_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive_builder_macro-0.20.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d67c88ec5f2844232d1a2064599eb8636fb9f9144c005e638ebda81f57cb7b6"

URI_x86_64_v2_rust-derive_builder_macro+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder_macro+alloc-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder_macro+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder_macro+alloc-devel}"
SRC_URI[x86_64_v2_rust-derive_builder_macro+alloc-devel.sha256sum] = "e3f7a585226907c750730b658d43539ca6c359f714fbebe44756648daed094cd"

URI_x86_64_v2_rust-derive_builder_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder_macro+default-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder_macro+default-devel}"
SRC_URI[x86_64_v2_rust-derive_builder_macro+default-devel.sha256sum] = "ea0f2aabe28772a80c5d0cbf7ea7236a9bd57e8b90ac00393ecce59c4a779dd0"

URI_x86_64_v2_rust-derive_builder_macro+lib_has_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder_macro+lib_has_std-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder_macro+lib_has_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder_macro+lib_has_std-devel}"
SRC_URI[x86_64_v2_rust-derive_builder_macro+lib_has_std-devel.sha256sum] = "1ff3fbd48ff61ec546f68d72573dcbd0c4a25486e261320536eb3c412eb29e78"

URI_x86_64_v2_rust-derive_builder_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_builder_macro-devel-0.20.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_builder_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_builder_macro-devel}"
SRC_URI[x86_64_v2_rust-derive_builder_macro-devel.sha256sum] = "7116905ba6a6aef82b0dbe62ec09a11840024916245e1350e26e92449faf6bf8"

URI_aarch64_rust-derive_builder_macro+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder_macro+alloc-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder_macro+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder_macro+alloc-devel}"
SRC_URI[aarch64_rust-derive_builder_macro+alloc-devel.sha256sum] = "dd5a85cff2c0831b1d057be67919c6f71ec6565e636134c60c52f20f0cfe1e41"

URI_aarch64_rust-derive_builder_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder_macro+default-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder_macro+default-devel}"
SRC_URI[aarch64_rust-derive_builder_macro+default-devel.sha256sum] = "8a308a840bf83bd26f87eec3a571c78d4eeefd081ff881ce49b2500580e98812"

URI_aarch64_rust-derive_builder_macro+lib_has_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder_macro+lib_has_std-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder_macro+lib_has_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder_macro+lib_has_std-devel}"
SRC_URI[aarch64_rust-derive_builder_macro+lib_has_std-devel.sha256sum] = "9959306b489257f995c9e2da5ba75d8fd7493c28cfab13bdf63a4d408acf6a73"

URI_aarch64_rust-derive_builder_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_builder_macro-devel-0.20.2-1.el10_0.noarch.rpm;name=aarch64_rust-derive_builder_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_builder_macro-devel}"
SRC_URI[aarch64_rust-derive_builder_macro-devel.sha256sum] = "7f094196a777ec8d3a223b43d7234d6668f739a0d1ebbd5b798fb69cb5738a05"

RDEPENDS:rust-derive_builder_macro+alloc-devel = " \
 cargo \
 rust-derive_builder_core+alloc-devel \
 rust-derive_builder_macro-devel \
 "
RDEPENDS:rust-derive_builder_macro+default-devel = " \
 cargo \
 rust-derive_builder_macro-devel \
 "
RDEPENDS:rust-derive_builder_macro+lib_has_std-devel = " \
 cargo \
 rust-derive_builder_core+lib_has_std-devel \
 rust-derive_builder_macro-devel \
 "
RDEPENDS:rust-derive_builder_macro-devel = " \
 cargo \
 rust-derive_builder_core+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
