# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdecor"
PV = "0.2.2"
PR = "5.el10"
PACKAGES = " \
 libdecor \
 libdecor-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libdecor-0.2.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25ba4155dabf184aab56f3fe659e11e431b3bc1526509f788cca0fa49b025e1b"

URI_x86_64_v2_libdecor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdecor-0.2.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libdecor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdecor}"
SRC_URI[x86_64_v2_libdecor.sha256sum] = "23fa06af0d25c316ece5606f974c6d291bd5d916185fb9d584e5dcd5a2795fef"

URI_x86_64_v2_libdecor-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdecor-devel-0.2.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libdecor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdecor-devel}"
SRC_URI[x86_64_v2_libdecor-devel.sha256sum] = "4f9be00febc3596258087a7ed2ac98bca9966cb7ccccc8b15f8960ec2efd6b9e"

URI_aarch64_libdecor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdecor-0.2.2-5.el10.aarch64.rpm;name=aarch64_libdecor;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdecor}"
SRC_URI[aarch64_libdecor.sha256sum] = "a6a113399f305cb1491537bb8112a3b8eb3dcd5c3e87886cd4a94afce30f8b1f"

URI_aarch64_libdecor-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdecor-devel-0.2.2-5.el10.aarch64.rpm;name=aarch64_libdecor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdecor-devel}"
SRC_URI[aarch64_libdecor-devel.sha256sum] = "9fe630567bf644e3a0b6afbe1cdb55659b4e5288c7a3a4d427fb230d27acb83b"

RDEPENDS:libdecor = " \
 cairo \
 dbus-libs \
 glib2 \
 glibc \
 gtk3 \
 libwayland-client \
 libwayland-cursor \
 pango \
 "
RDEPENDS:libdecor-devel = " \
 libdecor \
 pkgconf-pkg-config \
 wayland-devel \
 "
