# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klickety"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 klickety \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klickety-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c9fb947149b9e41f7a08934d5a07d8e66ca3e4ad59d39350aabdeb795e0ad29"

URI_x86_64_v2_klickety = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klickety-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klickety;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klickety}"
SRC_URI[x86_64_v2_klickety.sha256sum] = "2429e18a69cba5f2483e0b3f03089037c7e4720f57ff587103e2b908aaccca41"

URI_aarch64_klickety = "${EPEL_MIRROR}/aarch64/Packages/k/klickety-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_klickety;unpack=0"
SRC_URI:append = " ${URI_aarch64_klickety}"
SRC_URI[aarch64_klickety.sha256sum] = "9846f9b6dfd2587dd0102f0728bcf76cf2e2645598725f61497575c520a751a4"

RDEPENDS:klickety = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
