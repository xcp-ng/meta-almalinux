# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuptime"
PV = "5.2.6"
PR = "1.el10_2"
PACKAGES = " \
 tuptime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tuptime-5.2.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea7a7fc264b8d76c0f2df6b2086ffccc6ee095c9a0652e3bb830ca0b0798162b"

URI_x86_64_v2_tuptime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tuptime-5.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tuptime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuptime}"
SRC_URI[x86_64_v2_tuptime.sha256sum] = "ba24e114dd8058f6836e7b63758d8b206d9c90924a190e0c15b468357cf18898"

URI_aarch64_tuptime = "${EPEL_MIRROR}/aarch64/Packages/t/tuptime-5.2.6-1.el10_2.noarch.rpm;name=aarch64_tuptime;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuptime}"
SRC_URI[aarch64_tuptime.sha256sum] = "27637f7f9cdf749b9089a233b9fa223185540384d29e71b4353fb339d74c9be9"

RDEPENDS:tuptime = " \
 bash \
 systemd \
 "
