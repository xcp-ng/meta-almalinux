# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gavl"
PV = "1.4.0"
PR = "37.el10_0"
PACKAGES = " \
 gavl \
 gavl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gavl-1.4.0-37.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b65ffb0ba9776847aa5fc07382ce0e0f9f3a7a28ddc37755731cc6ce5b05d8c"

URI_x86_64_v2_gavl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gavl-1.4.0-37.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gavl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gavl}"
SRC_URI[x86_64_v2_gavl.sha256sum] = "be366dda18280e45cea4d29843aed21136705d21314230a1dafbb42ab8b4bd14"

URI_x86_64_v2_gavl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gavl-devel-1.4.0-37.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gavl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gavl-devel}"
SRC_URI[x86_64_v2_gavl-devel.sha256sum] = "b3bd9e7b9ae74c6eb93528d01341d428abf50a8114545ba9ee1948ea7b4b3dd9"

URI_aarch64_gavl = "${EPEL_MIRROR}/aarch64/Packages/g/gavl-1.4.0-37.el10_0.aarch64.rpm;name=aarch64_gavl;unpack=0"
SRC_URI:append = " ${URI_aarch64_gavl}"
SRC_URI[aarch64_gavl.sha256sum] = "fde03c4c7ac142b45ae1f9ca394c0a96a974f4f15e3d1fdb2a31a7c5e99eeff0"

URI_aarch64_gavl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gavl-devel-1.4.0-37.el10_0.aarch64.rpm;name=aarch64_gavl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gavl-devel}"
SRC_URI[aarch64_gavl-devel.sha256sum] = "116a69449ff3134b1b1b73fee1a9cf4195754fa54915a8998c082526ba83b92c"

RDEPENDS:gavl = " \
 glibc \
 libgdither \
 "
RDEPENDS:gavl-devel = " \
 gavl \
 pkgconf-pkg-config \
 "
