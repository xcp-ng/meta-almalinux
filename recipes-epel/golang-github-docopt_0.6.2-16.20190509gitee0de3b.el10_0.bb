# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-docopt"
PV = "0.6.2"
PR = "16.20190509gitee0de3b.el10_0"
PACKAGES = " \
 compat-golang-github-docopt-devel \
 golang-github-docopt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-docopt-0.6.2-16.20190509gitee0de3b.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6b0d70f5800f38c7e535df4a72bcaf1435a45c529fae5c1f1aaf919b2987721"

URI_aarch64_compat-golang-github-docopt-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-docopt-devel-0.6.2-16.20190509gitee0de3b.el10_0.noarch.rpm;name=aarch64_compat-golang-github-docopt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-docopt-devel}"
SRC_URI[aarch64_compat-golang-github-docopt-devel.sha256sum] = "0a6e84eec96ce71eef2444a478c3af70dd5ae9a772d12340605b0b2d33e48697"

URI_aarch64_golang-github-docopt-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-docopt-devel-0.6.2-16.20190509gitee0de3b.el10_0.noarch.rpm;name=aarch64_golang-github-docopt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-docopt-devel}"
SRC_URI[aarch64_golang-github-docopt-devel.sha256sum] = "03689b0fb2a460e1f59782a6ac3d3a4735605c41e34791f00ff3b5a3143f9b89"

RDEPENDS:compat-golang-github-docopt-devel = " \
 go-filesystem \
 golang-github-docopt-devel \
 "
RDEPENDS:golang-github-docopt-devel = " \
 go-filesystem \
 "
