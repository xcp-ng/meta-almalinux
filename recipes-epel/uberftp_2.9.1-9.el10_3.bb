# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uberftp"
PV = "2.9.1"
PR = "9.el10_3"
PACKAGES = " \
 uberftp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uberftp-2.9.1-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f502f5fdc049878739ba7dcf95db8f4f041ae58dc1fa7c667ea519b8cfbfafd5"

URI_x86_64_v2_uberftp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uberftp-2.9.1-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uberftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uberftp}"
SRC_URI[x86_64_v2_uberftp.sha256sum] = "53583254b44e3b8c1dca69dbec3788004ead3aa8e948411dd275a06def0cd769"

URI_aarch64_uberftp = "${EPEL_MIRROR}/aarch64/Packages/u/uberftp-2.9.1-9.el10_3.aarch64.rpm;name=aarch64_uberftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_uberftp}"
SRC_URI[aarch64_uberftp.sha256sum] = "7534b15cd9761d35c9b5ea3851ae00b68491f0bd1760622fcefa749b164d836d"

RDEPENDS:uberftp = " \
 glibc \
 globus-common \
 globus-gssapi-gsi \
 "
