# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-scipy"
PV = "1.16.2"
PR = "4.el10"
PACKAGES = " \
 python3.14-scipy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-scipy-1.16.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26bc9791a60317b64f51473ea5525003abdb5314af145fdcf485c175774eff6e"

URI_x86_64_v2_python3.14-scipy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-scipy-1.16.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-scipy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-scipy}"
SRC_URI[x86_64_v2_python3.14-scipy.sha256sum] = "f50e6091bb72f565717f4dd54c099597e8851a5204748c84e6494a114fa297d5"

URI_aarch64_python3.14-scipy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-scipy-1.16.2-4.el10.aarch64.rpm;name=aarch64_python3.14-scipy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-scipy}"
SRC_URI[aarch64_python3.14-scipy.sha256sum] = "174b9f1567fa5d271a862353a53950f0ad3e88c6cbb25939bab0405c4eb14686"

RDEPENDS:python3.14-scipy = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 libstdc++ \
 python3.14 \
 python3.14-numpy \
 "
