# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tungstenite"
PV = "0.29.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+data-encoding-devel \
 rust-tungstenite+default-devel \
 rust-tungstenite+handshake-devel \
 rust-tungstenite+http-devel \
 rust-tungstenite+httparse-devel \
 rust-tungstenite+native-tls-crate-devel \
 rust-tungstenite+native-tls-devel \
 rust-tungstenite+rustls-devel \
 rust-tungstenite+rustls-native-certs-devel \
 rust-tungstenite+rustls-pki-types-devel \
 rust-tungstenite+rustls-tls-native-roots-devel \
 rust-tungstenite+rustls-tls-webpki-roots-devel \
 rust-tungstenite+sha1-devel \
 rust-tungstenite+url-devel \
 rust-tungstenite+webpki-roots-devel \
 rust-tungstenite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tungstenite-0.29.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79ca2afa46452ce0e7c3d3ed324c5f8f15b9be9c65099275a507ef517d202b4a"

URI_x86_64_v2_rust-tungstenite+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+__rustls-tls-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+__rustls-tls-devel.sha256sum] = "0d4f9185f37f182e54c2ef640018214e3efb0725765bf003c1b63726f0b9e77b"

URI_x86_64_v2_rust-tungstenite+data-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+data-encoding-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+data-encoding-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+data-encoding-devel.sha256sum] = "fe372444fd8eb64bbf34492181ce6ab2078e1d86acbf59a4ea120df602658907"

URI_x86_64_v2_rust-tungstenite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+default-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+default-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+default-devel.sha256sum] = "fafbe826eaf1e8018bbc117694363f359ee2294ad0a4f74a8d0f72f76c8d85bb"

URI_x86_64_v2_rust-tungstenite+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+handshake-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+handshake-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+handshake-devel.sha256sum] = "b8bb8f3a569bed6d4ba9bd5229adfa4c3c58b18dc25b471e094e1a4fc3857948"

URI_x86_64_v2_rust-tungstenite+http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+http-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+http-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+http-devel.sha256sum] = "6754c7c43d111768de771b0170b6b4d6e0aef61bedee6e613c8c535c40139d0c"

URI_x86_64_v2_rust-tungstenite+httparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+httparse-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+httparse-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+httparse-devel.sha256sum] = "21369b80019a287d7877bdf144aa89dc0028a3f7a4c96196b3c52cd77bc83a72"

URI_x86_64_v2_rust-tungstenite+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+native-tls-crate-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+native-tls-crate-devel.sha256sum] = "e74654abcfbceeb42b5204a3ead0bcf34032ed2b92fb190f4e1d9b8fb3db5607"

URI_x86_64_v2_rust-tungstenite+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+native-tls-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+native-tls-devel.sha256sum] = "f79d2f91ac5bfc52718518db379f20dcce154476278114d24d3b1fc1133bc213"

URI_x86_64_v2_rust-tungstenite+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-devel.sha256sum] = "17f393f1948f5f59ae48eb8b35e03cbed0b2901db4cb96385c89efa71506ff3c"

URI_x86_64_v2_rust-tungstenite+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-native-certs-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-native-certs-devel.sha256sum] = "e5368e799b28c17be8fef7c2c3a4ffafdcd55e7dc2d40bd44e757728cc1f709b"

URI_x86_64_v2_rust-tungstenite+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-pki-types-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-pki-types-devel.sha256sum] = "4de74cc7a60b6ca3dad8461643e8c616692162f1d1f5cb5df825069e05a9c274"

URI_x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-tls-native-roots-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "0782d57ed0c230b561c816cab3a5cedd8ab4d8ccd19ad571ffe1636b17fb59e0"

URI_x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-tls-webpki-roots-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "c5916b3d317e374665a6caa28777668b05dad88d86bdea3e7db2ad64b9616cec"

URI_x86_64_v2_rust-tungstenite+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+sha1-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+sha1-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+sha1-devel.sha256sum] = "8fa63b6897e1d7b759df23943288446f256ff7b9bd1f8ad48bec32f3a3223550"

URI_x86_64_v2_rust-tungstenite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+url-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+url-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+url-devel.sha256sum] = "83778d00780cfaf76a6b1975f2762845ed54d01f8e0a12a5e3a569b97dbdf614"

URI_x86_64_v2_rust-tungstenite+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+webpki-roots-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+webpki-roots-devel.sha256sum] = "faee7e70c7c393741f9f8b480f8f2a547495a4268f93f3ccc6f5d13eb243fc9e"

URI_x86_64_v2_rust-tungstenite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite-devel}"
SRC_URI[x86_64_v2_rust-tungstenite-devel.sha256sum] = "49fbc903de8f3478ed3b2c3b36c933fb5a926dc577488613a619991d1d7d4e87"

URI_aarch64_rust-tungstenite+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+__rustls-tls-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tungstenite+__rustls-tls-devel.sha256sum] = "241e534125e818659ffe57ec04edb3d02ef9f420d24f89b891702f77f8b3033c"

URI_aarch64_rust-tungstenite+data-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+data-encoding-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+data-encoding-devel}"
SRC_URI[aarch64_rust-tungstenite+data-encoding-devel.sha256sum] = "4f7e9f206ea99248ba846bb024eb9b3ac2c19cd70a6d495289c1a06f21a0603d"

URI_aarch64_rust-tungstenite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+default-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+default-devel}"
SRC_URI[aarch64_rust-tungstenite+default-devel.sha256sum] = "f185ca5236779e29c9c5a8477a0fe010caa269af4bfa5da57b7bda0409bab8ea"

URI_aarch64_rust-tungstenite+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+handshake-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+handshake-devel}"
SRC_URI[aarch64_rust-tungstenite+handshake-devel.sha256sum] = "66e6cc48c38ddd83d046886c2e77074288a4a6468a8413ad7639b327c4236916"

URI_aarch64_rust-tungstenite+http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+http-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+http-devel}"
SRC_URI[aarch64_rust-tungstenite+http-devel.sha256sum] = "827e62057409ab1df006307441628ac267b6d2b0b995809a099719ab4e1a3a1e"

URI_aarch64_rust-tungstenite+httparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+httparse-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+httparse-devel}"
SRC_URI[aarch64_rust-tungstenite+httparse-devel.sha256sum] = "1895a3275b5869aea0e32c9c44848a9a8dfb987fc9edcc24aaef64f078c266c8"

URI_aarch64_rust-tungstenite+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+native-tls-crate-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tungstenite+native-tls-crate-devel.sha256sum] = "bff3cd0e34f738d5831f02fc522a4e86a4e9e7049dafe86268497ddf4bd5ecc0"

URI_aarch64_rust-tungstenite+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+native-tls-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+native-tls-devel}"
SRC_URI[aarch64_rust-tungstenite+native-tls-devel.sha256sum] = "bde4909b5cb46e0726ff9947f986fd2a36b87d367b3f6617ba59b10f33cc5351"

URI_aarch64_rust-tungstenite+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-devel.sha256sum] = "9903b14ada7d8db2a0156ad8ff95ea5026b85a24c2f859a6222d46a59990cdfc"

URI_aarch64_rust-tungstenite+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-native-certs-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-native-certs-devel.sha256sum] = "a7f4b4392189c0e2eabe503df8da28e851e71f3e8c0ac26159dfcd3212edb691"

URI_aarch64_rust-tungstenite+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-pki-types-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-pki-types-devel.sha256sum] = "10e96785a4a8be6b172d7d390420adaff7009aefc2bc6435efd5ba894acda130"

URI_aarch64_rust-tungstenite+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-tls-native-roots-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "d84cdf5c0f7754c36fd2a7bda60044afee26d01d2a516e888323b3829b7adf89"

URI_aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-tls-webpki-roots-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "3d6590bb9a560dded64006b7fcfe92cf9bc52c3fcd23c06f19116190ea10d31c"

URI_aarch64_rust-tungstenite+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+sha1-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+sha1-devel}"
SRC_URI[aarch64_rust-tungstenite+sha1-devel.sha256sum] = "35c7cae683bdaf4274262bbcb52de351d13ec812d17eb1dff819c5888b8f908c"

URI_aarch64_rust-tungstenite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+url-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+url-devel}"
SRC_URI[aarch64_rust-tungstenite+url-devel.sha256sum] = "a2e777643361159d5ec3ed455470beac9543fd1ad91ca81ff43d3e60a6a0509b"

URI_aarch64_rust-tungstenite+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+webpki-roots-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+webpki-roots-devel.sha256sum] = "5767d318463d8519a7591a2e5cf0a370686133e5d5e7d213cf6c538f785173ac"

URI_aarch64_rust-tungstenite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite-devel}"
SRC_URI[aarch64_rust-tungstenite-devel.sha256sum] = "7c65ca5c6605debc16ce08a4d60cdc3c8c58c3dc409fedc33e592279c7e89e61"

RDEPENDS:rust-tungstenite+__rustls-tls-devel = " \
 cargo \
 rust-tungstenite+rustls-devel \
 rust-tungstenite+rustls-pki-types-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+data-encoding-devel = " \
 cargo \
 rust-data-encoding+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+default-devel = " \
 cargo \
 rust-tungstenite+handshake-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+handshake-devel = " \
 cargo \
 rust-tungstenite+data-encoding-devel \
 rust-tungstenite+http-devel \
 rust-tungstenite+httparse-devel \
 rust-tungstenite+sha1-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+http-devel = " \
 cargo \
 rust-http+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+httparse-devel = " \
 cargo \
 rust-httparse+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+native-tls-devel = " \
 cargo \
 rust-tungstenite+native-tls-crate-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-devel = " \
 cargo \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+rustls-native-certs-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+webpki-roots-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+sha1-devel = " \
 cargo \
 rust-sha1_0.10+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+url-devel = " \
 cargo \
 rust-tungstenite-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-tungstenite+webpki-roots-devel = " \
 cargo \
 rust-tungstenite-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-tungstenite-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-log+default-devel \
 rust-rand0.9+default-devel \
 rust-thiserror+default-devel \
 "
