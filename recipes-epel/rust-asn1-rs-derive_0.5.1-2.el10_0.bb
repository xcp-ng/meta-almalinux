# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1-rs-derive"
PV = "0.5.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-asn1-rs-derive+default-devel \
 rust-asn1-rs-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-rs-derive-0.5.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c67c195375ae8995d27886a59f4cd05c5fcff480f13e0c364216721a02a157d"

URI_x86_64_v2_rust-asn1-rs-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-derive+default-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-derive+default-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-derive+default-devel.sha256sum] = "7d9efe7fc831c824d6cbd07f16b52568ef318c5474bd6df2c77329cfbbb54aac"

URI_x86_64_v2_rust-asn1-rs-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-derive-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-derive-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-derive-devel.sha256sum] = "c9c907702f286c4b2e304fcc562b9c4d419ffab05c75801b4eaf63460a0d1b66"

URI_aarch64_rust-asn1-rs-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-derive+default-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-derive+default-devel}"
SRC_URI[aarch64_rust-asn1-rs-derive+default-devel.sha256sum] = "07b1ca2284b528b87985659d8e7d96bf5790feca7704a0ed7c5a79493a2e489c"

URI_aarch64_rust-asn1-rs-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-derive-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-derive-devel}"
SRC_URI[aarch64_rust-asn1-rs-derive-devel.sha256sum] = "c5cc95a144444601f3d58bf5ec15cc5bcb32c07040113a34f9a00671b77f3708"

RDEPENDS:rust-asn1-rs-derive+default-devel = " \
 cargo \
 rust-asn1-rs-derive-devel \
 "
RDEPENDS:rust-asn1-rs-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 rust-synstructure+default-devel \
 "
