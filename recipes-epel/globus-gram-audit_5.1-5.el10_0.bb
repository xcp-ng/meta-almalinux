# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-audit"
PV = "5.1"
PR = "5.el10_0"
PACKAGES = " \
 globus-gram-audit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-audit-5.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca2accacd475e8f2ad6d21270cef534a3e01fedce83eb35e7bd967bf14b2bd74"

URI_x86_64_v2_globus-gram-audit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-audit-5.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-audit}"
SRC_URI[x86_64_v2_globus-gram-audit.sha256sum] = "6197f6b7e1ca92e3d08d01caa781af3bc43dc30dcf44619b9d62a9224cc1dcd7"

URI_aarch64_globus-gram-audit = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-audit-5.1-5.el10_0.noarch.rpm;name=aarch64_globus-gram-audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-audit}"
SRC_URI[aarch64_globus-gram-audit.sha256sum] = "021a76bb5610c5c7c294ea9c48d63bdb0f0d742758fd590373ce8f72523141f4"

RDEPENDS:globus-gram-audit = " \
 bash \
 crontabs \
 globus-common \
 perl-DBD-SQLite \
 perl-DBI \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Pod-Usage \
 perl-Time-Local \
 perl-interpreter \
 perl-libs \
 "
