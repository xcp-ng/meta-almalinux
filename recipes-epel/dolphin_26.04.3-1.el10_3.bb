# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dolphin"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 dolphin \
 dolphin-devel \
 dolphin-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dolphin-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a490f4f7046e9aab902ac75329d049f425e0250bdf602602987132a09299368"

URI_x86_64_v2_dolphin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin}"
SRC_URI[x86_64_v2_dolphin.sha256sum] = "eb7e56cf90a8df567c65c0339ad5f7c61ec3399e46e6a45aee0cf83e5917e235"

URI_x86_64_v2_dolphin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin-devel}"
SRC_URI[x86_64_v2_dolphin-devel.sha256sum] = "eae60f0a190c9a11a1ded77cfb85b1e8f27e2473a45fcd6806330acb83a17a67"

URI_x86_64_v2_dolphin-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dolphin-libs}"
SRC_URI[x86_64_v2_dolphin-libs.sha256sum] = "0396ae1fad4121368d986407d2b3be9f7edea7b87c6f2cb3d3481e7cd04c90b7"

URI_aarch64_dolphin = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_dolphin;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin}"
SRC_URI[aarch64_dolphin.sha256sum] = "0feadcbd4aa43c595ab8a9e5b56112dc6da8157e2289a7da43f73ce6a73004fe"

URI_aarch64_dolphin-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_dolphin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin-devel}"
SRC_URI[aarch64_dolphin-devel.sha256sum] = "09b1486804de2904981cba68ccbd84079b7e8478f8db242c8f54810eb58f959b"

URI_aarch64_dolphin-libs = "${EPEL_MIRROR}/aarch64/Packages/d/dolphin-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_dolphin-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_dolphin-libs}"
SRC_URI[aarch64_dolphin-libs.sha256sum] = "ccf925ba51fc35643a3b51a1bf8f4b259b50bbdccccc0aa4a1e0fe301804ba85"

RDEPENDS:dolphin = " \
 PackageKit-Qt6 \
 baloo-widgets \
 dolphin-libs \
 glibc \
 kf6-baloo-libs \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kparts \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
RDEPENDS:dolphin-devel = " \
 cmake-filesystem \
 dolphin-libs \
 kf6-kio-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:dolphin-libs = " \
 baloo-widgets \
 glibc \
 kf6-baloo-libs \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
