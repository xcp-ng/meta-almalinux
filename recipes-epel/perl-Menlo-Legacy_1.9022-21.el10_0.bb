# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Menlo-Legacy"
PV = "1.9022"
PR = "21.el10_0"
PACKAGES = " \
 perl-Menlo-Legacy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Menlo-Legacy-1.9022-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04be1b26c8b20c2baae4b9138859e366f71cd7324fd04968426aa133d9465a1a"

URI_x86_64_v2_perl-Menlo-Legacy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Menlo-Legacy-1.9022-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Menlo-Legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Menlo-Legacy}"
SRC_URI[x86_64_v2_perl-Menlo-Legacy.sha256sum] = "777133f2d433b6a8ff44741add37d564f007d261baead7bc19aebefc5b59d41a"

URI_aarch64_perl-Menlo-Legacy = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Menlo-Legacy-1.9022-21.el10_0.noarch.rpm;name=aarch64_perl-Menlo-Legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Menlo-Legacy}"
SRC_URI[aarch64_perl-Menlo-Legacy.sha256sum] = "6d251944cf7d6a5277cce170a2c0aeb15e193ca3509e2abeccdb927c9fe78ac0"

RDEPENDS:perl-Menlo-Legacy = " \
 perl-Archive-Tar \
 perl-Archive-Zip \
 perl-CPAN-Common-Index \
 perl-CPAN-DistnameInfo \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Check \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Capture-Tiny \
 perl-Digest-SHA \
 perl-ExtUtils-Manifest \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-HomeDir \
 perl-File-Path \
 perl-File-Temp \
 perl-File-Which \
 perl-File-pushd \
 perl-Getopt-Long \
 perl-HTTP-Tinyish \
 perl-JSON-PP \
 perl-Menlo \
 perl-Module-CPANfile \
 perl-Module-CoreList \
 perl-Module-Metadata \
 perl-Module-Signature \
 perl-Parse-PMFile \
 perl-PathTools \
 perl-Safe \
 perl-Symbol \
 perl-constant \
 perl-libs \
 perl-local-lib \
 perl-version \
 "
