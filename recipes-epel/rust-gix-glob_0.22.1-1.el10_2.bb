# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-glob"
PV = "0.22.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-glob+default-devel \
 rust-gix-glob+document-features-devel \
 rust-gix-glob+serde-devel \
 rust-gix-glob-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-gix-glob-0.22.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7c90da82bbb5f1705609348e12b6b98913ccb2f8644e02b4bef76f96182ec808"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+default-devel-0.22.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-glob+default-devel.sha256sum] = "8da5165cca6d947b0faaa393297a77d924187843ebff364f38ec8ecc9a36dab0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+document-features-devel-0.22.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+document-features-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-glob+document-features-devel.sha256sum] = "8259c065173106fcb94ebc9fcc291e63d41640f8f1e8c2121c9854787ede9dfe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+serde-devel-0.22.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-glob+serde-devel.sha256sum] = "5d6d61b18af70e793a90b50797da0176b5ff313a158e99995bd522ec22379463"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob-devel-0.22.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gix-glob-devel.sha256sum] = "ee8cb98f11eabf36a430e8ef8f1ad1be9c4df8de9812f7ed6a0762412209dd52"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+default-devel-0.22.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-glob+default-devel;unpack=0"
SRC_URI[aarch64_rust-gix-glob+default-devel.sha256sum] = "80c0e58e25702036f79d6636572f6199b3dd48d4e5076d3e49a72d26e90bd53b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+document-features-devel-0.22.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-glob+document-features-devel;unpack=0"
SRC_URI[aarch64_rust-gix-glob+document-features-devel.sha256sum] = "607d0d11d93391e07ff11ba29ef95352e28d35b07a304104304718a6fe6864b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+serde-devel-0.22.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-glob+serde-devel;unpack=0"
SRC_URI[aarch64_rust-gix-glob+serde-devel.sha256sum] = "f233eeb39f476f3b861f5f2bdefed47e6e016b2e2dcc0250f5fdef76bd1f10bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob-devel-0.22.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-glob-devel;unpack=0"
SRC_URI[aarch64_rust-gix-glob-devel.sha256sum] = "c166183de8d286860aeb25cb6170d7c3ddea969700404b20ea0a37f869e47910"

RDEPENDS:rust-gix-glob+default-devel = " \
 cargo \
 rust-gix-glob-devel \
 "
RDEPENDS:rust-gix-glob+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-glob-devel \
 "
RDEPENDS:rust-gix-glob+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-bstr+serde-devel \
 rust-gix-glob-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-glob-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-path+default-devel \
 "
