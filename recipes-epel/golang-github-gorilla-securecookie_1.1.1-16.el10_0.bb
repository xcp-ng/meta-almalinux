# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gorilla-securecookie"
PV = "1.1.1"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-gorilla-securecookie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gorilla-securecookie-1.1.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a34da2176143e2523d3e811da3737895c49fe89c4e0af34e666b3b305c188c5"

URI_x86_64_v2_golang-github-gorilla-securecookie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gorilla-securecookie-devel-1.1.1-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gorilla-securecookie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gorilla-securecookie-devel}"
SRC_URI[x86_64_v2_golang-github-gorilla-securecookie-devel.sha256sum] = "c0d88ebe98bce6e18eca31a71c980f867a008952b22e9199fd400af3259e683e"

URI_aarch64_golang-github-gorilla-securecookie-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gorilla-securecookie-devel-1.1.1-16.el10_0.noarch.rpm;name=aarch64_golang-github-gorilla-securecookie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gorilla-securecookie-devel}"
SRC_URI[aarch64_golang-github-gorilla-securecookie-devel.sha256sum] = "aa81a62b7bafeb1b697f0c621c72477d85f9c0ad6ff0281f75eaee461149fa53"

RDEPENDS:golang-github-gorilla-securecookie-devel = " \
 go-filesystem \
 "
