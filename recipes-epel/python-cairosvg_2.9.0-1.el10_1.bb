# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cairosvg"
PV = "2.9.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-cairosvg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cairosvg-2.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7b1c25eb7eeba26d05f4736c5aa71b8bcb5e18cb052043784e90fe2f36ee6eb"

URI_x86_64_v2_python3-cairosvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cairosvg-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cairosvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cairosvg}"
SRC_URI[x86_64_v2_python3-cairosvg.sha256sum] = "8f7c2aa74fba6ee4430e657615e4961e112f7cfbc7221b866ac0537a67d846a1"

URI_aarch64_python3-cairosvg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cairosvg-2.9.0-1.el10_1.noarch.rpm;name=aarch64_python3-cairosvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cairosvg}"
SRC_URI[aarch64_python3-cairosvg.sha256sum] = "281b47f80c6e78ebc31c2f7c92719fafe8ea5bab3719ee1924c3dbf7a58f9711"

RDEPENDS:python3-cairosvg = " \
 python3 \
 python3-cairocffi \
 python3-cssselect2 \
 python3-defusedxml \
 python3-pillow \
 python3-tinycss2 \
 "
