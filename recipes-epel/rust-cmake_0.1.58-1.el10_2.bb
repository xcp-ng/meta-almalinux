# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cmake"
PV = "0.1.58"
PR = "1.el10_2"
PACKAGES = " \
 rust-cmake+default-devel \
 rust-cmake-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cmake-0.1.58-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30664c0561f2f5d12163b358a1a5eb89f2c3dea6108fc10146d81f5b74dc57df"

URI_x86_64_v2_rust-cmake+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmake+default-devel-0.1.58-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmake+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmake+default-devel}"
SRC_URI[x86_64_v2_rust-cmake+default-devel.sha256sum] = "6da12573a93838f0853a87bb3c146c3cc1d86f2b008efda05af5b12288066dba"

URI_x86_64_v2_rust-cmake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmake-devel-0.1.58-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmake-devel}"
SRC_URI[x86_64_v2_rust-cmake-devel.sha256sum] = "863d8f69a4baf325dbe9e38ed96f3ef23673c9938f78777504362c349da2ceca"

URI_aarch64_rust-cmake+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmake+default-devel-0.1.58-1.el10_2.noarch.rpm;name=aarch64_rust-cmake+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmake+default-devel}"
SRC_URI[aarch64_rust-cmake+default-devel.sha256sum] = "077aae81e9d2bc65259f2f0d9b3b817d5467eb77ff4a7d15c08a9bdcd5ddf37b"

URI_aarch64_rust-cmake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmake-devel-0.1.58-1.el10_2.noarch.rpm;name=aarch64_rust-cmake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmake-devel}"
SRC_URI[aarch64_rust-cmake-devel.sha256sum] = "1535ff047badba96e16943be9129f099d44a8985dddc86a5121ba3fcf2697f82"

RDEPENDS:rust-cmake+default-devel = " \
 cargo \
 rust-cmake-devel \
 "
RDEPENDS:rust-cmake-devel = " \
 cargo \
 cmake \
 rust \
 rust-cc+default-devel \
 "
