# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "proftpd"
PV = "1.3.9"
PR = "1.el10_0"
PACKAGES = " \
 proftpd \
 proftpd-devel \
 proftpd-ldap \
 proftpd-mysql \
 proftpd-postgresql \
 proftpd-proxy \
 proftpd-sqlite \
 proftpd-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/proftpd-1.3.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d18e102ef2dad7f84c152ad4b035cbe3a77bca2138a0ae717cf845332e5ff395"

URI_x86_64_v2_proftpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-1.3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd}"
SRC_URI[x86_64_v2_proftpd.sha256sum] = "30eb35acc84e6a6f1c00ace01221c099e53c128ca639729798de7e162f73c0cf"

URI_x86_64_v2_proftpd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-devel-1.3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-devel}"
SRC_URI[x86_64_v2_proftpd-devel.sha256sum] = "d5f801cec8e1d9b86f0e531f3acdd51f84b08b0f9649213917cee5853196ede4"

URI_x86_64_v2_proftpd-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-ldap-1.3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-ldap}"
SRC_URI[x86_64_v2_proftpd-ldap.sha256sum] = "ae038058c9d2bfdb10d232c9c59793f890c3a134f5a21157784e548fcb8f9aa6"

URI_x86_64_v2_proftpd-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-mysql-1.3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-mysql}"
SRC_URI[x86_64_v2_proftpd-mysql.sha256sum] = "81f8b6e75b641bc083c7edab2e1f9bbea5b4ebefd417809a9f0c407154f4c30f"

URI_x86_64_v2_proftpd-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-postgresql-1.3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-postgresql}"
SRC_URI[x86_64_v2_proftpd-postgresql.sha256sum] = "b1264b19e1c145153b2c56a754ba23d780bf0141fe1bdd799e26b0a0727c5d47"

URI_x86_64_v2_proftpd-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-proxy-1.3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-proxy}"
SRC_URI[x86_64_v2_proftpd-proxy.sha256sum] = "c083d1cd7a4732831afed01ce6cbb73772886cce3e8cdff1f24aef4341344e57"

URI_x86_64_v2_proftpd-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-sqlite-1.3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-sqlite}"
SRC_URI[x86_64_v2_proftpd-sqlite.sha256sum] = "4d907439ccc9b372c6cbc4de4779dd36010886ba7eb02ddbc52e1f41de23a928"

URI_x86_64_v2_proftpd-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-utils-1.3.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_proftpd-utils}"
SRC_URI[x86_64_v2_proftpd-utils.sha256sum] = "d08265067fa8bc60b4966d895c703daada2a8eda6e0ed4d5c08b8753ba599706"

URI_aarch64_proftpd = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-1.3.9-1.el10_0.aarch64.rpm;name=aarch64_proftpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd}"
SRC_URI[aarch64_proftpd.sha256sum] = "6e3fd7c0b3ec6ec2c647cdbfb1518b308d9650d6854000ff7656dd43ea4d27c9"

URI_aarch64_proftpd-devel = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-devel-1.3.9-1.el10_0.aarch64.rpm;name=aarch64_proftpd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-devel}"
SRC_URI[aarch64_proftpd-devel.sha256sum] = "084650a46487ac757dab96e2645cfd34b5f6c11024810c7fa0221bea194cc65c"

URI_aarch64_proftpd-ldap = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-ldap-1.3.9-1.el10_0.aarch64.rpm;name=aarch64_proftpd-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-ldap}"
SRC_URI[aarch64_proftpd-ldap.sha256sum] = "408f4aafa602b2eda47ca437fc37581cb994bb496db36af06eb1888fe4b445ee"

URI_aarch64_proftpd-mysql = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-mysql-1.3.9-1.el10_0.aarch64.rpm;name=aarch64_proftpd-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-mysql}"
SRC_URI[aarch64_proftpd-mysql.sha256sum] = "eb527c7ca39cf2a0b17df5f9c56c61b97d189c7b2f2210061725916ec3b68e95"

URI_aarch64_proftpd-postgresql = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-postgresql-1.3.9-1.el10_0.aarch64.rpm;name=aarch64_proftpd-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-postgresql}"
SRC_URI[aarch64_proftpd-postgresql.sha256sum] = "645bef602dbb41e0991d57772bec2ac8c6d772409d62b895c4eeeced5dcdfd91"

URI_aarch64_proftpd-proxy = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-proxy-1.3.9-1.el10_0.aarch64.rpm;name=aarch64_proftpd-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-proxy}"
SRC_URI[aarch64_proftpd-proxy.sha256sum] = "cc5f9d0d576c0aadf69f23ce1c6d4c57ca1e9c0fd3d25373826aaf2912d61bd9"

URI_aarch64_proftpd-sqlite = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-sqlite-1.3.9-1.el10_0.aarch64.rpm;name=aarch64_proftpd-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-sqlite}"
SRC_URI[aarch64_proftpd-sqlite.sha256sum] = "c9bee52a52233cddfec95160fb76f207ac0b6e3c3468aab546bcdf2c0e809c22"

URI_aarch64_proftpd-utils = "${EPEL_MIRROR}/aarch64/Packages/p/proftpd-utils-1.3.9-1.el10_0.aarch64.rpm;name=aarch64_proftpd-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_proftpd-utils}"
SRC_URI[aarch64_proftpd-utils.sha256sum] = "bbd119674b0099c9bc930d4ad734f5b7e2984d4f429837b78094c8061767f281"

RDEPENDS:proftpd = " \
 bash \
 findutils \
 glibc \
 libacl \
 libcap \
 libidn2 \
 libmemcached-awesome \
 libsodium \
 libxcrypt \
 logrotate \
 openssl-libs \
 pam-libs \
 pcre2 \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-devel = " \
 gcc \
 libacl-devel \
 libcap-devel \
 libmemcached-awesome-devel \
 libpq-devel \
 libsodium-devel \
 libtool \
 mariadb-connector-c-devel \
 ncurses-devel \
 openldap-devel \
 openssl-devel \
 pam-devel \
 pcre2-devel \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 proftpd \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:proftpd-ldap = " \
 glibc \
 libidn2 \
 libsodium \
 openldap \
 proftpd \
 "
RDEPENDS:proftpd-mysql = " \
 glibc \
 libidn2 \
 libsodium \
 mariadb-connector-c \
 proftpd \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-postgresql = " \
 glibc \
 libidn2 \
 libpq \
 libsodium \
 proftpd \
 "
RDEPENDS:proftpd-proxy = " \
 glibc \
 libidn2 \
 libsodium \
 openssl-libs \
 proftpd \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-sqlite = " \
 glibc \
 libidn2 \
 libsodium \
 proftpd \
 sqlite-libs \
 "
RDEPENDS:proftpd-utils = " \
 glibc \
 ncurses-libs \
 perl-Crypt-Cracklib \
 perl-Fcntl \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-MIME-Base64 \
 perl-Mail-Sendmail \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 proftpd \
 "
