# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alembic"
PV = "1.8.12"
PR = "1.el10_3"
PACKAGES = " \
 alembic \
 alembic-devel \
 alembic-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alembic-1.8.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47e0063b8f8c1c8c0558ef1443db81dfaff198711193ce32187ce04ed377c5e3"

URI_x86_64_v2_alembic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alembic-1.8.12-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alembic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alembic}"
SRC_URI[x86_64_v2_alembic.sha256sum] = "d2c86652f8913e2eecddeefbb77f2f1232d2c2c5a3c2a963f7ee6377a4a7a0d0"

URI_x86_64_v2_alembic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alembic-devel-1.8.12-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alembic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alembic-devel}"
SRC_URI[x86_64_v2_alembic-devel.sha256sum] = "ca2d44d32942d0302d48eed209550ca3b8f60e1609125f2b90625915e0c28592"

URI_x86_64_v2_alembic-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alembic-libs-1.8.12-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alembic-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alembic-libs}"
SRC_URI[x86_64_v2_alembic-libs.sha256sum] = "a29e3d5768e84293e880c83db53dea101e08608d8b17165702753d90e024cc37"

URI_aarch64_alembic = "${EPEL_MIRROR}/aarch64/Packages/a/alembic-1.8.12-1.el10_3.aarch64.rpm;name=aarch64_alembic;unpack=0"
SRC_URI:append = " ${URI_aarch64_alembic}"
SRC_URI[aarch64_alembic.sha256sum] = "51aae86b99a73dbe9b24cd5adfdbb61fe41033bf6a310b4bfd0ffc2e09f19a4b"

URI_aarch64_alembic-devel = "${EPEL_MIRROR}/aarch64/Packages/a/alembic-devel-1.8.12-1.el10_3.aarch64.rpm;name=aarch64_alembic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_alembic-devel}"
SRC_URI[aarch64_alembic-devel.sha256sum] = "f105dba2ac74b8228150eaea912ace63795a90e6baed37f477fb017fd1e70ec8"

URI_aarch64_alembic-libs = "${EPEL_MIRROR}/aarch64/Packages/a/alembic-libs-1.8.12-1.el10_3.aarch64.rpm;name=aarch64_alembic-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_alembic-libs}"
SRC_URI[aarch64_alembic-libs.sha256sum] = "871f53a3cf7796b1e7ff1a94ac294f49008d0d52ff506dde04fb9786cb0735c4"

RDEPENDS:alembic = " \
 alembic-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:alembic-devel = " \
 alembic-libs \
 cmake \
 cmake-filesystem \
 imath-devel \
 "
RDEPENDS:alembic-libs = " \
 glibc \
 hdf5 \
 imath \
 libgcc \
 libstdc++ \
 "
