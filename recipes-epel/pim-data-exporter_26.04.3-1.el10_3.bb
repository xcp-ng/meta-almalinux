# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pim-data-exporter"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 pim-data-exporter \
 pim-data-exporter-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pim-data-exporter-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "886c7c4917e809bad245dd17e5f6e6950255e9752f786b2daa66aed5cf014b35"

URI_x86_64_v2_pim-data-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-data-exporter}"
SRC_URI[x86_64_v2_pim-data-exporter.sha256sum] = "1ce9960dfd1ecb684576fa75ff9da0fd4026e5520d5efad13f39dd46e6a6bf89"

URI_x86_64_v2_pim-data-exporter-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pim-data-exporter-libs}"
SRC_URI[x86_64_v2_pim-data-exporter-libs.sha256sum] = "6c970c7dda53b38604a6fca6422c4e3b819dd984a7b6245ffa4f2ef50fff2386"

URI_aarch64_pim-data-exporter = "${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_pim-data-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-data-exporter}"
SRC_URI[aarch64_pim-data-exporter.sha256sum] = "b5294475c6a57cf7455deeeb4e4c7b19e6344f79fe169273bce269d825615f4f"

URI_aarch64_pim-data-exporter-libs = "${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_pim-data-exporter-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pim-data-exporter-libs}"
SRC_URI[aarch64_pim-data-exporter-libs.sha256sum] = "f53db06c3b5219629b94e74448fbeb942ecc84580a899d12bca0da730d9b8ff5"

RDEPENDS:pim-data-exporter = " \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter-libs \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pim-data-exporter-libs = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
