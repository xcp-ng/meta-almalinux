# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glib2"
PV = "2.80.4"
PR = "13.el10"
PACKAGES = " \
 glib2 \
 glib2-devel \
 glib2-doc \
 glib2-static \
 glib2-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glib2-2.80.4-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2547410074019703a596fabfb77c583dcb53274547c19334e0df162a277a3fb6"

URI_x86_64_v2_glib2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glib2-2.80.4-13.el10.x86_64_v2.rpm;name=x86_64_v2_glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2}"
SRC_URI[x86_64_v2_glib2.sha256sum] = "22b87250973f5a7cf86f2e758fed07ae3899bda99b1cf1dfcbb33d0d4eaa8c01"

URI_x86_64_v2_glib2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-devel-2.80.4-13.el10.x86_64_v2.rpm;name=x86_64_v2_glib2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-devel}"
SRC_URI[x86_64_v2_glib2-devel.sha256sum] = "4c8142a4bd5d4a1758209e68e22dcf271cc8ee91bb900278fc730d12d250d5d0"

URI_x86_64_v2_glib2-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-doc-2.80.4-13.el10.x86_64_v2.rpm;name=x86_64_v2_glib2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-doc}"
SRC_URI[x86_64_v2_glib2-doc.sha256sum] = "3345c375c0a29c84f418d219d01e389945320bf093a67b98e045d20d1fbdc8a9"

URI_x86_64_v2_glib2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-static-2.80.4-13.el10.x86_64_v2.rpm;name=x86_64_v2_glib2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-static}"
SRC_URI[x86_64_v2_glib2-static.sha256sum] = "24966bc32f528c8ef9f7fd1e9bf004b4453943e0ea34e6d770320e7124b8656f"

URI_x86_64_v2_glib2-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-tests-2.80.4-13.el10.x86_64_v2.rpm;name=x86_64_v2_glib2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glib2-tests}"
SRC_URI[x86_64_v2_glib2-tests.sha256sum] = "7637df96f979a66cf43581df673aa668545940dbb97bdc4f6382d4ae0951f02a"

URI_aarch64_glib2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glib2-2.80.4-13.el10.aarch64.rpm;name=aarch64_glib2;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2}"
SRC_URI[aarch64_glib2.sha256sum] = "7636249879cbc292fa51e2ec59304972acd950fbc431db686ce66ba0a2c2a4dc"

URI_aarch64_glib2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-devel-2.80.4-13.el10.aarch64.rpm;name=aarch64_glib2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-devel}"
SRC_URI[aarch64_glib2-devel.sha256sum] = "b06f6eebef90123087753a01b409ff1ad945618b4ad43a18bc2627336ee8ddf5"

URI_aarch64_glib2-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-doc-2.80.4-13.el10.aarch64.rpm;name=aarch64_glib2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-doc}"
SRC_URI[aarch64_glib2-doc.sha256sum] = "ffa2ca7bce07bd3ed1c21e9c13af2ae0c66a116b2f153a61358c0c126a53ca4a"

URI_aarch64_glib2-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-static-2.80.4-13.el10.aarch64.rpm;name=aarch64_glib2-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-static}"
SRC_URI[aarch64_glib2-static.sha256sum] = "4f9868951d750cb14f57dc58b86c4a394b935f3816cc3d6f518f4dd2c59461be"

URI_aarch64_glib2-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-tests-2.80.4-13.el10.aarch64.rpm;name=aarch64_glib2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_glib2-tests}"
SRC_URI[aarch64_glib2-tests.sha256sum] = "5f39008d40bc1efffa9b05c1fa56dce45f7caffcc5b5aff3fcab1d54e5ed2c0e"

RDEPENDS:glib2:x86_64_v2 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2:aarch64 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libgcc \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
"
RDEPENDS:glib2-devel = " \
 bash \
 elfutils-libelf \
 glib2 \
 glib2-devel \
 glibc \
 libffi \
 libffi-devel \
 libmount-devel \
 libselinux-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 python3 \
 python3-packaging \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:glib2-doc = " \
 glib2 \
 "
RDEPENDS:glib2-static = " \
 glib2-devel \
 pcre2-static \
 sysprof-capture-devel \
 "
RDEPENDS:glib2-tests = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 pcre2 \
 python3 \
 "
