# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "musl"
PV = "1.2.5"
PR = "3.el10_0"
PACKAGES = " \
 musl-clang \
 musl-devel \
 musl-filesystem \
 musl-gcc \
 musl-libc \
 musl-libc-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/musl-1.2.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "074986e248b49ca912dcac8b02514db73ec398b37a2d0422a028f5ecb9779946"

URI_x86_64_v2_musl-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-clang-1.2.5-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-clang}"
SRC_URI[x86_64_v2_musl-clang.sha256sum] = "68e49483699da7de7ec920610691e53ed44f6e20f9ba6158e2e695838dd7a4d9"

URI_x86_64_v2_musl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-devel-1.2.5-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-devel}"
SRC_URI[x86_64_v2_musl-devel.sha256sum] = "4b91f8158b6d8127d45288cc115c78be8b2152354e5c19010447af03152d581f"

URI_x86_64_v2_musl-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-filesystem-1.2.5-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-filesystem}"
SRC_URI[x86_64_v2_musl-filesystem.sha256sum] = "4d60b680908eaf01826c70ab7b228de8436e34c15e160a74b355905452844572"

URI_x86_64_v2_musl-gcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-gcc-1.2.5-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-gcc}"
SRC_URI[x86_64_v2_musl-gcc.sha256sum] = "34fbc26331ca67483eb56b65a1605e5e7855573057838dab08047afc66e397e0"

URI_x86_64_v2_musl-libc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-libc-1.2.5-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-libc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-libc}"
SRC_URI[x86_64_v2_musl-libc.sha256sum] = "b026a0141ed74bb9376bb7626c4a282209b8ac96fd982f6e9a4b683b95e3f73b"

URI_x86_64_v2_musl-libc-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/musl-libc-static-1.2.5-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_musl-libc-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_musl-libc-static}"
SRC_URI[x86_64_v2_musl-libc-static.sha256sum] = "6c78e4b72b68a43d3483099b03a43a43ec7d09d4774c3d7fa7ecca51676dde77"

URI_aarch64_musl-clang = "${EPEL_MIRROR}/aarch64/Packages/m/musl-clang-1.2.5-3.el10_0.aarch64.rpm;name=aarch64_musl-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-clang}"
SRC_URI[aarch64_musl-clang.sha256sum] = "e30c2520f87ececa13f4726773c06936b818640c8b65f1e074edf0722422d9e2"

URI_aarch64_musl-devel = "${EPEL_MIRROR}/aarch64/Packages/m/musl-devel-1.2.5-3.el10_0.aarch64.rpm;name=aarch64_musl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-devel}"
SRC_URI[aarch64_musl-devel.sha256sum] = "670f0768c0a9e02c00375acd2b62d3db3ca12d17050484422f74320875a01d42"

URI_aarch64_musl-filesystem = "${EPEL_MIRROR}/aarch64/Packages/m/musl-filesystem-1.2.5-3.el10_0.aarch64.rpm;name=aarch64_musl-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-filesystem}"
SRC_URI[aarch64_musl-filesystem.sha256sum] = "a539b6b1938d2e7cfc9ad12687d86b1674aea2252f73bae924255493055a1e8a"

URI_aarch64_musl-gcc = "${EPEL_MIRROR}/aarch64/Packages/m/musl-gcc-1.2.5-3.el10_0.aarch64.rpm;name=aarch64_musl-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-gcc}"
SRC_URI[aarch64_musl-gcc.sha256sum] = "63d8186e34e16032d32f8ae54a9b54de809b93c3e638b938973b76ab030f04fd"

URI_aarch64_musl-libc = "${EPEL_MIRROR}/aarch64/Packages/m/musl-libc-1.2.5-3.el10_0.aarch64.rpm;name=aarch64_musl-libc;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-libc}"
SRC_URI[aarch64_musl-libc.sha256sum] = "8910f701a60d8a0c4bec6c64b90746e82b3f62983e3b7f29125dc38b95d22766"

URI_aarch64_musl-libc-static = "${EPEL_MIRROR}/aarch64/Packages/m/musl-libc-static-1.2.5-3.el10_0.aarch64.rpm;name=aarch64_musl-libc-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_musl-libc-static}"
SRC_URI[aarch64_musl-libc-static.sha256sum] = "38b2786f8a964f1f262d4efd208b3d1ab91f0d2149c91183b754d6c208e9aaf5"

RDEPENDS:musl-clang = " \
 bash \
 clang \
 musl-devel \
 "
RDEPENDS:musl-devel = " \
 musl-libc \
 "
RDEPENDS:musl-filesystem = " \
 "
RDEPENDS:musl-gcc = " \
 bash \
 gcc \
 musl-devel \
 "
RDEPENDS:musl-libc = " \
 musl-filesystem \
 "
RDEPENDS:musl-libc-static = " \
 musl-devel \
 "
