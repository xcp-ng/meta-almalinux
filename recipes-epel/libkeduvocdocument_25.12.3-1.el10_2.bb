# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkeduvocdocument"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkeduvocdocument \
 libkeduvocdocument-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkeduvocdocument-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b9a9f1935aa2bfc8ecf0af31e52ad2ecd04edbce2247e76eccef769230891e4"

URI_x86_64_v2_libkeduvocdocument = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkeduvocdocument}"
SRC_URI[x86_64_v2_libkeduvocdocument.sha256sum] = "de0cce7026f03f5ec19f58b433796cc447601f5d330c7c60c723a0840a6a4606"

URI_x86_64_v2_libkeduvocdocument-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkeduvocdocument-devel}"
SRC_URI[x86_64_v2_libkeduvocdocument-devel.sha256sum] = "5f8b46f63038da387e83d99720dbcd44a9341e01102c513a4ec837abb97bcf43"

URI_aarch64_libkeduvocdocument = "${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkeduvocdocument;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkeduvocdocument}"
SRC_URI[aarch64_libkeduvocdocument.sha256sum] = "3ca06886d3f24d2d3a2265cd4654dc0e54b38db63a450fcd2edc1e473c590b6b"

URI_aarch64_libkeduvocdocument-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkeduvocdocument-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkeduvocdocument-devel}"
SRC_URI[aarch64_libkeduvocdocument-devel.sha256sum] = "4377b061a1d0df8bc2b740b3eb55e65b8f598d5aa0737e772b275d55c1c78772"

RDEPENDS:libkeduvocdocument = " \
 glibc \
 kdeedu-data \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libkeduvocdocument-devel = " \
 cmake-filesystem \
 libkeduvocdocument \
 "
