# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kparts"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kparts \
 kf6-kparts-devel \
 kf6-kparts-doc \
 kf6-kparts-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kparts-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b883e0ed7ca04a72a8309e90a6f1d9cbb3589ae3a11a2d50e51decdc17d6a839"

URI_x86_64_v2_kf6-kparts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts}"
SRC_URI[x86_64_v2_kf6-kparts.sha256sum] = "52b9c9254b4e8eb50ef4efd4dbd109f0dbf2f0c849b9df7f2a73fa5eed111914"

URI_x86_64_v2_kf6-kparts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-devel}"
SRC_URI[x86_64_v2_kf6-kparts-devel.sha256sum] = "178f07a80a1dd0ab69c0928aee7956e942e78e1a86d30969057a29984f650d00"

URI_x86_64_v2_kf6-kparts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kparts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-doc}"
SRC_URI[x86_64_v2_kf6-kparts-doc.sha256sum] = "4b8e8419cdfc6e655896fda1136b97f54ce225934c52c68e1be6edfc21afaffe"

URI_x86_64_v2_kf6-kparts-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kparts-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-html}"
SRC_URI[x86_64_v2_kf6-kparts-html.sha256sum] = "9e07a8e400b21989a1b0bcbc57d61be7b09d615cdcc5c877670b56dee08cebf2"

URI_aarch64_kf6-kparts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kparts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts}"
SRC_URI[aarch64_kf6-kparts.sha256sum] = "083f71c30707a92eae4535a9a7661ffc4c66a263bd9c25f532e461f4dbaf4561"

URI_aarch64_kf6-kparts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kparts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-devel}"
SRC_URI[aarch64_kf6-kparts-devel.sha256sum] = "3dfc0915bc7053e576595e4d411fe5075300e976a3c25afbcaf8994ed8689aed"

URI_aarch64_kf6-kparts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kparts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-doc}"
SRC_URI[aarch64_kf6-kparts-doc.sha256sum] = "25fea295312d270eec60c6026ea7096a45d4ec4bff0b1eb34249a0caa2447741"

URI_aarch64_kf6-kparts-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kparts-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-html}"
SRC_URI[aarch64_kf6-kparts-html.sha256sum] = "f36272da3f476e5298fe11bcf602d038214a8119a9d0ed64794057b9ece4c4e8"

RDEPENDS:kf6-kparts = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kparts-devel = " \
 cmake-filesystem \
 kf6-kio-devel \
 kf6-kparts \
 kf6-ktextwidgets-devel \
 kf6-kxmlgui-devel \
 "
RDEPENDS:kf6-kparts-doc = " \
 "
RDEPENDS:kf6-kparts-html = " \
 "
