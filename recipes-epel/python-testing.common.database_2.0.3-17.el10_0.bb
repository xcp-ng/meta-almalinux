# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-testing.common.database"
PV = "2.0.3"
PR = "17.el10_0"
PACKAGES = " \
 python3-testing.common.database \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-testing.common.database-2.0.3-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95819067e0da33b8dc447a0a04120f125dc0f87b70e2dfe6df73e027117c6762"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-testing.common.database-2.0.3-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-testing.common.database;unpack=0"
SRC_URI[x86_64_v2_python3-testing.common.database.sha256sum] = "d3fd861ebfe4674e96ea6cfba48467dc4ea869cb4560319e15056eab2aa73c4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-testing.common.database-2.0.3-17.el10_0.noarch.rpm;name=aarch64_python3-testing.common.database;unpack=0"
SRC_URI[aarch64_python3-testing.common.database.sha256sum] = "7f0027e79bb87d3540832261c71f085d54ba7ae489de1a7c8e54653951fe6b8b"

RDEPENDS:python3-testing.common.database = " \
 python3 \
 "
