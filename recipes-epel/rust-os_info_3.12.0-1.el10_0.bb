# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_info"
PV = "3.12.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-os_info+default-devel \
 rust-os_info+serde-devel \
 rust-os_info-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_info-3.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7dd64128ef946150a57c606e5ec25a6d530c0eefb05b0776ff75a90165b64719"

URI_x86_64_v2_rust-os_info+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+default-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+default-devel}"
SRC_URI[x86_64_v2_rust-os_info+default-devel.sha256sum] = "4de4d45e7b79e9992ca09af226d56d3c00638207d0f38ff8cdabc7311ef632ee"

URI_x86_64_v2_rust-os_info+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+serde-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+serde-devel}"
SRC_URI[x86_64_v2_rust-os_info+serde-devel.sha256sum] = "337b3691a16add3d178be62808e0e0d8781aba3c0d527ab430f1fbd0d1635024"

URI_x86_64_v2_rust-os_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info-devel-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info-devel}"
SRC_URI[x86_64_v2_rust-os_info-devel.sha256sum] = "5a34623e24d679c83dee0862c6ae3266c09d68bd62fdc3945e7e933556c87a26"

URI_aarch64_rust-os_info+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+default-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-os_info+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+default-devel}"
SRC_URI[aarch64_rust-os_info+default-devel.sha256sum] = "ef5fa6f357c6798a25606e564e416010f15d29875b1f0a1ca07d886e7b31fbf1"

URI_aarch64_rust-os_info+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+serde-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-os_info+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+serde-devel}"
SRC_URI[aarch64_rust-os_info+serde-devel.sha256sum] = "ed127faf64bc9085a9a871bbb245e92b2342ab2d25051cad637e1d748ce0b30b"

URI_aarch64_rust-os_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info-devel-3.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-os_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info-devel}"
SRC_URI[aarch64_rust-os_info-devel.sha256sum] = "ab6911aae4a72bcd0566ec49883dc65b2f6ed3d1d7404a2303ca51da8b06ec39"

RDEPENDS:rust-os_info+default-devel = " \
 cargo \
 rust-os_info+serde-devel \
 rust-os_info-devel \
 "
RDEPENDS:rust-os_info+serde-devel = " \
 cargo \
 rust-os_info-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-os_info-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 "
