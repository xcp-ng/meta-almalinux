# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Hash-Ordered"
PV = "0.014"
PR = "5.el10_0"
PACKAGES = " \
 perl-Hash-Ordered \
 perl-Hash-Ordered-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Hash-Ordered-0.014-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1e0451c7eb7e469fef03ced548775890a935d3413ebe2ef07cb3d4c75f59746"

URI_x86_64_v2_perl-Hash-Ordered = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Hash-Ordered-0.014-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Hash-Ordered;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Hash-Ordered}"
SRC_URI[x86_64_v2_perl-Hash-Ordered.sha256sum] = "dd4124f3273559efee53c648c9e53570e0b2e74c6cc91e1a9f5cd9618d9f5621"

URI_x86_64_v2_perl-Hash-Ordered-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Hash-Ordered-tests-0.014-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Hash-Ordered-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Hash-Ordered-tests}"
SRC_URI[x86_64_v2_perl-Hash-Ordered-tests.sha256sum] = "87e70a68bbedce0f72c43c6b3fc100bcfa83850e92fd00d1c5b3df3455b35ea9"

URI_aarch64_perl-Hash-Ordered = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Hash-Ordered-0.014-5.el10_0.noarch.rpm;name=aarch64_perl-Hash-Ordered;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Hash-Ordered}"
SRC_URI[aarch64_perl-Hash-Ordered.sha256sum] = "0ca8b7c5a8b4e944f6a8f624f798c1f80cbd2bef5628459ab339bd2510e7a0bf"

URI_aarch64_perl-Hash-Ordered-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Hash-Ordered-tests-0.014-5.el10_0.noarch.rpm;name=aarch64_perl-Hash-Ordered-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Hash-Ordered-tests}"
SRC_URI[aarch64_perl-Hash-Ordered-tests.sha256sum] = "1362c8227e57061f048d6ad3211588f4a907e50b6104fc911d10f4c70600f593"

RDEPENDS:perl-Hash-Ordered = " \
 perl-Carp \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Hash-Ordered-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-Hash-Ordered \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Test-Deep \
 perl-Test-FailWarnings \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
