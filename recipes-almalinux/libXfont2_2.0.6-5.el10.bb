# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXfont2"
PV = "2.0.6"
PR = "5.el10"
PACKAGES = " \
 libXfont2 \
 libXfont2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXfont2-2.0.6-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5233158a86850308985910d7a0bcbe9d3de17c68438ea000aa334d1352be1328"

URI_x86_64_v2_libXfont2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXfont2-2.0.6-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXfont2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXfont2}"
SRC_URI[x86_64_v2_libXfont2.sha256sum] = "4f265abdcfee3e6991d5467cabc46466d5e0b5c58ca3b3a7e75cf6d4f82565f2"

URI_x86_64_v2_libXfont2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libXfont2-devel-2.0.6-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXfont2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXfont2-devel}"
SRC_URI[x86_64_v2_libXfont2-devel.sha256sum] = "dc518e7aba1604cdeec83bf82c008fb0ca746dee5f5dba850c850dec8b363687"

URI_aarch64_libXfont2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXfont2-2.0.6-5.el10.aarch64.rpm;name=aarch64_libXfont2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXfont2}"
SRC_URI[aarch64_libXfont2.sha256sum] = "02d710210078945b628c0b624b6147801a8200e78417cd734cf4db787f2dbe5c"

URI_aarch64_libXfont2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libXfont2-devel-2.0.6-5.el10.aarch64.rpm;name=aarch64_libXfont2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXfont2-devel}"
SRC_URI[aarch64_libXfont2-devel.sha256sum] = "ee1472bd6c7f026b49011c7a6c73bc05b5977faaba03be5cea9fc73bb3aaf260"

RDEPENDS:libXfont2 = " \
 freetype \
 glibc \
 libfontenc \
 zlib-ng-compat \
 "
RDEPENDS:libXfont2-devel = " \
 freetype-devel \
 libXfont2 \
 libfontenc-devel \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 zlib-ng-compat-devel \
 "
