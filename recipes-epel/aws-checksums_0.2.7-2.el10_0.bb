# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-checksums"
PV = "0.2.7"
PR = "2.el10_0"
PACKAGES = " \
 aws-checksums \
 aws-checksums-devel \
 aws-checksums-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-checksums-0.2.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77b6ea4f80f740b2f180f817a2ff6b54be997e2b87927b4d662dd50999fa993a"

URI_x86_64_v2_aws-checksums = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-checksums-0.2.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-checksums;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-checksums}"
SRC_URI[x86_64_v2_aws-checksums.sha256sum] = "c608283d48a1e845d7a6a3d3773fd9731c0e72a49dc3281a842abe820e716fe1"

URI_x86_64_v2_aws-checksums-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-checksums-devel-0.2.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-checksums-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-checksums-devel}"
SRC_URI[x86_64_v2_aws-checksums-devel.sha256sum] = "9bd403fe6e1da2dcabb5509a0bc5840c783acbd4149bbffca4454e267ab216da"

URI_x86_64_v2_aws-checksums-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-checksums-libs-0.2.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-checksums-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-checksums-libs}"
SRC_URI[x86_64_v2_aws-checksums-libs.sha256sum] = "ebce0b20cc65f2a22e40950817acb39ae21de39ec355ce434bda386d369a1508"

URI_aarch64_aws-checksums = "${EPEL_MIRROR}/aarch64/Packages/a/aws-checksums-0.2.7-2.el10_0.aarch64.rpm;name=aarch64_aws-checksums;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-checksums}"
SRC_URI[aarch64_aws-checksums.sha256sum] = "2e926c9f36e8bc1f1c07c72f991c5aeac8a8ef98af0e533f8de422b845ba9bd3"

URI_aarch64_aws-checksums-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-checksums-devel-0.2.7-2.el10_0.aarch64.rpm;name=aarch64_aws-checksums-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-checksums-devel}"
SRC_URI[aarch64_aws-checksums-devel.sha256sum] = "7e6b5baa3dc8ab3bb7dd090dcfe7b3fa2b83328732e27cbe8b939df9043657df"

URI_aarch64_aws-checksums-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-checksums-libs-0.2.7-2.el10_0.aarch64.rpm;name=aarch64_aws-checksums-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-checksums-libs}"
SRC_URI[aarch64_aws-checksums-libs.sha256sum] = "673f440d18e507c92019597358eb5c1740defd5d373d41e99ebba22b410dca9d"

RDEPENDS:aws-checksums = " \
 aws-c-common-libs \
 aws-checksums-libs \
 glibc \
 "
RDEPENDS:aws-checksums-devel = " \
 aws-c-common-devel \
 aws-checksums \
 aws-checksums-libs \
 cmake-filesystem \
 "
RDEPENDS:aws-checksums-libs = " \
 aws-c-common-libs \
 aws-checksums \
 glibc \
 "
