# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-test-macro"
PV = "0.2.5"
PR = "3.el10_0"
PACKAGES = " \
 rust-tracing-test-macro+default-devel \
 rust-tracing-test-macro+no-env-filter-devel \
 rust-tracing-test-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-test-macro-0.2.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43d788316d3c82ae15d50680aea4aaffde37c49e50a3bcda923933f298f63843"

URI_x86_64_v2_rust-tracing-test-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-test-macro+default-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-test-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-test-macro+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-test-macro+default-devel.sha256sum] = "399a966cfcdcc073ab64c7c33deea1c37c060a977a8df5d1def2cbdd5e47f8d9"

URI_x86_64_v2_rust-tracing-test-macro+no-env-filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-test-macro+no-env-filter-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-test-macro+no-env-filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-test-macro+no-env-filter-devel}"
SRC_URI[x86_64_v2_rust-tracing-test-macro+no-env-filter-devel.sha256sum] = "a4c0b1b625e912dd92a37e75313aa413f6950af18391a25430111d480468e0c6"

URI_x86_64_v2_rust-tracing-test-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-test-macro-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-test-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-test-macro-devel}"
SRC_URI[x86_64_v2_rust-tracing-test-macro-devel.sha256sum] = "6397647ec9e39f8a295a24df3d1a1bbe87c0289a5d86b19ce6a33600ed7a0df3"

URI_aarch64_rust-tracing-test-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-test-macro+default-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-test-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-test-macro+default-devel}"
SRC_URI[aarch64_rust-tracing-test-macro+default-devel.sha256sum] = "49661fba601352d0826aa5746933f9b47b561c91d6007fdb56eea778241f2424"

URI_aarch64_rust-tracing-test-macro+no-env-filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-test-macro+no-env-filter-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-test-macro+no-env-filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-test-macro+no-env-filter-devel}"
SRC_URI[aarch64_rust-tracing-test-macro+no-env-filter-devel.sha256sum] = "b76aa70bbd8352c34748c65ad0e9e144b5a43ba6eb2dcb1e1e647667dc89042d"

URI_aarch64_rust-tracing-test-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-test-macro-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-test-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-test-macro-devel}"
SRC_URI[aarch64_rust-tracing-test-macro-devel.sha256sum] = "6f12930a3b14a497817426ce7a642d58300353c8d0fc1467167b493b14de49fd"

RDEPENDS:rust-tracing-test-macro+default-devel = " \
 cargo \
 rust-tracing-test-macro-devel \
 "
RDEPENDS:rust-tracing-test-macro+no-env-filter-devel = " \
 cargo \
 rust-tracing-test-macro-devel \
 "
RDEPENDS:rust-tracing-test-macro-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
