# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mailparse"
PV = "3.1.8"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-mailparse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mailparse-3.1.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6475e437856f109594c2945568cd832880dc81b8f3dc2d148c3a033021f4e03"

URI_x86_64_v2_php-pecl-mailparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mailparse-3.1.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mailparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mailparse}"
SRC_URI[x86_64_v2_php-pecl-mailparse.sha256sum] = "7c3120f4fdf047a0b82506e04e822cd5ae70afcb832ff5db68d46be884d080e9"

URI_aarch64_php-pecl-mailparse = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mailparse-3.1.8-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-mailparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mailparse}"
SRC_URI[aarch64_php-pecl-mailparse.sha256sum] = "b8579d15500e411f410f8d8b254e3246acfa58a56bf0a98f75e6fdff89b13fee"

RDEPENDS:php-pecl-mailparse = " \
 glibc \
 php-common \
 php-mbstring \
 "
