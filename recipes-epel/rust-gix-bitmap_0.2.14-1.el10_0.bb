# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-bitmap"
PV = "0.2.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-bitmap+default-devel \
 rust-gix-bitmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-bitmap-0.2.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbd74c20dfdcb1c8b454f3b7afd89d640dd34c0cb3fd9220b6131ef32f496b2e"

URI_x86_64_v2_rust-gix-bitmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-bitmap+default-devel-0.2.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-bitmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-bitmap+default-devel}"
SRC_URI[x86_64_v2_rust-gix-bitmap+default-devel.sha256sum] = "340d3b1430ca73194a59954643f2846a92a3c719ed4080c1a1c53be822a567fa"

URI_x86_64_v2_rust-gix-bitmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-bitmap-devel-0.2.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-bitmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-bitmap-devel}"
SRC_URI[x86_64_v2_rust-gix-bitmap-devel.sha256sum] = "ddc92032801a9e927a97c44e0b810fd85914edf91f73b1a6ac22a0b791a9b602"

URI_aarch64_rust-gix-bitmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-bitmap+default-devel-0.2.14-1.el10_0.noarch.rpm;name=aarch64_rust-gix-bitmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-bitmap+default-devel}"
SRC_URI[aarch64_rust-gix-bitmap+default-devel.sha256sum] = "500d28e42a61df9efcdb63e443099d745c178b407fc896d7eaf29dc8b0aa3472"

URI_aarch64_rust-gix-bitmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-bitmap-devel-0.2.14-1.el10_0.noarch.rpm;name=aarch64_rust-gix-bitmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-bitmap-devel}"
SRC_URI[aarch64_rust-gix-bitmap-devel.sha256sum] = "a364e263a9eb05ab2fe6666ccd2c54552935f6b34d4d8f38244cb4467dd4b4ba"

RDEPENDS:rust-gix-bitmap+default-devel = " \
 cargo \
 rust-gix-bitmap-devel \
 "
RDEPENDS:rust-gix-bitmap-devel = " \
 cargo \
 rust \
 rust-thiserror+default-devel \
 "
