# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-systemsettings"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-systemsettings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-systemsettings-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f1464ec7c1031a5f11f5328772295c93bf5be8f69867ce0e889375c320ac7b0"

URI_x86_64_v2_plasma-systemsettings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-systemsettings-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-systemsettings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-systemsettings}"
SRC_URI[x86_64_v2_plasma-systemsettings.sha256sum] = "e1928aad80dd931dda371d506a7132af65bad2974865cc9509121f4bd68a7133"

URI_aarch64_plasma-systemsettings = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-systemsettings-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-systemsettings;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-systemsettings}"
SRC_URI[aarch64_plasma-systemsettings.sha256sum] = "f97475ab37b2c73424508e4e7ccf1687837a806392172916f06a6c9ce339dbaf"

RDEPENDS:plasma-systemsettings = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-krunner \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
