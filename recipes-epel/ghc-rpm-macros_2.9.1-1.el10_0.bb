# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-rpm-macros"
PV = "2.9.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-rpm-macros \
 ghc-rpm-macros-extra \
 ghc-rpm-macros-quick \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-rpm-macros-2.9.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa6528b5202fa727b88b0d227df36d0441b1774dfb5dafc269f30723b6153d35"

URI_x86_64_v2_ghc-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-macros-2.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-macros}"
SRC_URI[x86_64_v2_ghc-rpm-macros.sha256sum] = "542190a391118859174a574168a01af1ba02d5b38e820ea84aa234123c03647d"

URI_x86_64_v2_ghc-rpm-macros-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-macros-extra-2.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-macros-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-macros-extra}"
SRC_URI[x86_64_v2_ghc-rpm-macros-extra.sha256sum] = "d91ea2c81fefe02e72de3463c19d5ceeba5c179b1e36fc1bcfd8a2ea3a342271"

URI_x86_64_v2_ghc-rpm-macros-quick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpm-macros-quick-2.9.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpm-macros-quick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpm-macros-quick}"
SRC_URI[x86_64_v2_ghc-rpm-macros-quick.sha256sum] = "fafba6643c2d28e1ba1b8c91586078beec4968814e43e6214630c785987804f0"

URI_aarch64_ghc-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-macros-2.9.1-1.el10_0.noarch.rpm;name=aarch64_ghc-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-macros}"
SRC_URI[aarch64_ghc-rpm-macros.sha256sum] = "0e3f4b660e402f88233cc8be2d96e43383d0b76f5165d189340607ad760b5c0a"

URI_aarch64_ghc-rpm-macros-extra = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-macros-extra-2.9.1-1.el10_0.noarch.rpm;name=aarch64_ghc-rpm-macros-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-macros-extra}"
SRC_URI[aarch64_ghc-rpm-macros-extra.sha256sum] = "5664a7897c3fbb552bf699a5b3f7edc22e2569b390633deb263447a5acc9401c"

URI_aarch64_ghc-rpm-macros-quick = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpm-macros-quick-2.9.1-1.el10_0.noarch.rpm;name=aarch64_ghc-rpm-macros-quick;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpm-macros-quick}"
SRC_URI[aarch64_ghc-rpm-macros-quick.sha256sum] = "6189368780f89bc228aa8298cd2c9f291bfd64f9eb8ef0e22b74a91ce9c69188"

RDEPENDS:ghc-rpm-macros = " \
 bash \
 chrpath \
 redhat-rpm-config \
 "
RDEPENDS:ghc-rpm-macros-extra = " \
 ghc-rpm-macros \
 "
RDEPENDS:ghc-rpm-macros-quick = " \
 ghc-rpm-macros \
 "
