# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-l2tp"
PV = "1.20.20"
PR = "5.el10_1"
PACKAGES = " \
 NetworkManager-l2tp \
 NetworkManager-l2tp-gnome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-l2tp-1.20.20-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1edef94973cdff5788707705a52c01b167e8cfaea189fe671d77a580eabe9a23"

URI_x86_64_v2_NetworkManager-l2tp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-1.20.20-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-l2tp}"
SRC_URI[x86_64_v2_NetworkManager-l2tp.sha256sum] = "b35a3f118395156bdf347a35eeaa128d91875b88b0b4bbe9cc5c09c26be08fda"

URI_x86_64_v2_NetworkManager-l2tp-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-gnome-1.20.20-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-l2tp-gnome}"
SRC_URI[x86_64_v2_NetworkManager-l2tp-gnome.sha256sum] = "464b476aabaebc4e7df8ada4612e0aa8dca7d7e80d30aefa0a908e35878ecf86"

URI_aarch64_NetworkManager-l2tp = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-1.20.20-5.el10_1.aarch64.rpm;name=aarch64_NetworkManager-l2tp;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-l2tp}"
SRC_URI[aarch64_NetworkManager-l2tp.sha256sum] = "d752d08be4a3241d698b0d21c2e6b13d941a689edae1dd02ad2c954c7941609c"

URI_aarch64_NetworkManager-l2tp-gnome = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-gnome-1.20.20-5.el10_1.aarch64.rpm;name=aarch64_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-l2tp-gnome}"
SRC_URI[aarch64_NetworkManager-l2tp-gnome.sha256sum] = "57ec77129128fded5717208b606f546ecf9ac49a1ceb1a6915e0e180c5a38e48"

RDEPENDS:NetworkManager-l2tp = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 nspr \
 nss \
 openssl-libs \
 ppp \
 xl2tpd \
 "
RDEPENDS:NetworkManager-l2tp-gnome = " \
 NetworkManager-l2tp \
 NetworkManager-libnm \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 openssl-libs \
 pango \
 vulkan-loader \
 "
