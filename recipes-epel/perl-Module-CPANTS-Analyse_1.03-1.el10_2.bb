# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-CPANTS-Analyse"
PV = "1.03"
PR = "1.el10_2"
PACKAGES = " \
 perl-Module-CPANTS-Analyse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-CPANTS-Analyse-1.03-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3543656296c3cb9037add97c1c4ded7299f108fcbc33b63149c43f98197e593c"

URI_x86_64_v2_perl-Module-CPANTS-Analyse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-CPANTS-Analyse-1.03-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-CPANTS-Analyse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-CPANTS-Analyse}"
SRC_URI[x86_64_v2_perl-Module-CPANTS-Analyse.sha256sum] = "1fccef07677029f20644b8bf9a02581c5c516403b7cedd16ae9abd30d43fb832"

URI_aarch64_perl-Module-CPANTS-Analyse = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-CPANTS-Analyse-1.03-1.el10_2.noarch.rpm;name=aarch64_perl-Module-CPANTS-Analyse;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-CPANTS-Analyse}"
SRC_URI[aarch64_perl-Module-CPANTS-Analyse.sha256sum] = "a2ca033cb1324da50df0c1cecc1ac103bc29b286ded1e7aba5c8785ac3bb1e6c"

RDEPENDS:perl-Module-CPANTS-Analyse = " \
 perl-Archive-Any-Lite \
 perl-Archive-Tar \
 perl-Array-Diff \
 perl-CPAN-Meta \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Accessor \
 perl-Data-Binary \
 perl-Encode \
 perl-Exporter \
 perl-ExtUtils-Manifest \
 perl-File-Copy \
 perl-File-Find-Object \
 perl-File-Temp \
 perl-File-stat \
 perl-JSON-PP \
 perl-Module-CPANfile \
 perl-Module-Find \
 perl-Parse-Distname \
 perl-PathTools \
 perl-Perl-PrereqScanner-NotQuiteLite \
 perl-Scalar-List-Utils \
 perl-Software-License \
 perl-Text-Balanced \
 perl-base \
 perl-libs \
 perl-version \
 "
