# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "superlu_dist"
PE = "1"
PV = "8.2.0"
PR = "10.el10_0"
PACKAGES = " \
 superlu_dist-doc \
 superlu_dist-mpich \
 superlu_dist-mpich-devel \
 superlu_dist-openmpi \
 superlu_dist-openmpi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/superlu_dist-8.2.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c125a1c3af47811fc82831fba94e588ddba505c7be7ec646888d9b24456aa49a"

URI_x86_64_v2_superlu_dist-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-doc-8.2.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_superlu_dist-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-doc}"
SRC_URI[x86_64_v2_superlu_dist-doc.sha256sum] = "a9cd0bbb28953c197fdc961ac38953451fc44a08d29f369adbc2b9fefe65ea0b"

URI_x86_64_v2_superlu_dist-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-mpich-8.2.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-mpich}"
SRC_URI[x86_64_v2_superlu_dist-mpich.sha256sum] = "6f30292551f1fe9e78c4f3ff341825bc49fbac4334687b9de0ad24b54f202ab1"

URI_x86_64_v2_superlu_dist-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-mpich-devel-8.2.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-mpich-devel}"
SRC_URI[x86_64_v2_superlu_dist-mpich-devel.sha256sum] = "4ffef660cb18ed485149d4151756137306ce6d22b4765282e43e37707e426c14"

URI_x86_64_v2_superlu_dist-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-openmpi-8.2.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-openmpi}"
SRC_URI[x86_64_v2_superlu_dist-openmpi.sha256sum] = "713f8a9212e93ae69c072eb1275a0843dbcc83ddbcb9d91d4e85152802802e3e"

URI_x86_64_v2_superlu_dist-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/superlu_dist-openmpi-devel-8.2.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_superlu_dist-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_superlu_dist-openmpi-devel}"
SRC_URI[x86_64_v2_superlu_dist-openmpi-devel.sha256sum] = "f4a13b16b3f4d8d0c107906b79ed2f54038086a61802c4902ced6969692bb5db"

URI_aarch64_superlu_dist-doc = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-doc-8.2.0-10.el10_0.noarch.rpm;name=aarch64_superlu_dist-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-doc}"
SRC_URI[aarch64_superlu_dist-doc.sha256sum] = "99b1c01e336643a063f2a16fe364595ef6d24df9a1df1ad7f4b0c83119e22f23"

URI_aarch64_superlu_dist-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-mpich-8.2.0-10.el10_0.aarch64.rpm;name=aarch64_superlu_dist-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-mpich}"
SRC_URI[aarch64_superlu_dist-mpich.sha256sum] = "132cee9b2b727354fabb8c16642b53e93e8595e350373983101e2d772677406f"

URI_aarch64_superlu_dist-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-mpich-devel-8.2.0-10.el10_0.aarch64.rpm;name=aarch64_superlu_dist-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-mpich-devel}"
SRC_URI[aarch64_superlu_dist-mpich-devel.sha256sum] = "1a39dbb22be42a6de98f22de0272afa6e46ffa05ccdfebd27e8eb6c80bf8609c"

URI_aarch64_superlu_dist-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-openmpi-8.2.0-10.el10_0.aarch64.rpm;name=aarch64_superlu_dist-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-openmpi}"
SRC_URI[aarch64_superlu_dist-openmpi.sha256sum] = "f5e6c79fdf780052ad537ac935999615da3eec4da700a800c6d6d12ae9387438"

URI_aarch64_superlu_dist-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/s/superlu_dist-openmpi-devel-8.2.0-10.el10_0.aarch64.rpm;name=aarch64_superlu_dist-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_superlu_dist-openmpi-devel}"
SRC_URI[aarch64_superlu_dist-openmpi-devel.sha256sum] = "7490086865405d09e4c2a70a9483fbb92dcbdfd31b7caec16287a4dedb442f39"

RDEPENDS:superlu_dist-doc = " \
 "
RDEPENDS:superlu_dist-mpich = " \
 flexiblas-netlib \
 gcc-gfortran \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 metis \
 mpich \
 ptscotch-mpich \
 "
RDEPENDS:superlu_dist-mpich-devel = " \
 mpich-devel \
 ptscotch-mpich-devel \
 ptscotch-mpich-devel-parmetis \
 superlu_dist-mpich \
 "
RDEPENDS:superlu_dist-openmpi = " \
 flexiblas-netlib \
 gcc-gfortran \
 glibc \
 libgcc \
 libgfortran \
 libgomp \
 metis \
 openmpi \
 ptscotch-openmpi \
 "
RDEPENDS:superlu_dist-openmpi-devel = " \
 openmpi-devel \
 superlu_dist-openmpi \
 "
