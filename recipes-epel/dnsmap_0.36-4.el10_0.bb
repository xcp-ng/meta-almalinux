# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsmap"
PV = "0.36"
PR = "4.el10_0"
PACKAGES = " \
 dnsmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnsmap-0.36-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4d437218db67d537d33aa711cd6a802591cce61a4c8d7d9e3202c34ef911f37"

URI_x86_64_v2_dnsmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnsmap-0.36-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnsmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsmap}"
SRC_URI[x86_64_v2_dnsmap.sha256sum] = "35e9b9916cb645042e891fd8a77dbcff127bb57a6bcd80bb2955e9d1d079e3d2"

URI_aarch64_dnsmap = "${EPEL_MIRROR}/aarch64/Packages/d/dnsmap-0.36-4.el10_0.aarch64.rpm;name=aarch64_dnsmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsmap}"
SRC_URI[aarch64_dnsmap.sha256sum] = "cc8e2d95d3ceb9b6ab32015efe9a0c96251108ee550b54982f88846a825a0b53"

RDEPENDS:dnsmap = " \
 bash \
 glibc \
 "
