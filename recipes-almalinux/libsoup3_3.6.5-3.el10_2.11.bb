# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsoup3"
PV = "3.6.5"
PR = "3.el10_2.11"
PACKAGES = " \
 libsoup3 \
 libsoup3-devel \
 libsoup3-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsoup3-3.6.5-3.el10_2.11.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f26437644ae4d0a676943bf2173a69aea2e373060f728d1236299b01ae917e17"

URI_x86_64_v2_libsoup3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsoup3-3.6.5-3.el10_2.11.x86_64_v2.rpm;name=x86_64_v2_libsoup3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsoup3}"
SRC_URI[x86_64_v2_libsoup3.sha256sum] = "51f68826da83aadb59fee2dfde1e436f0f39b894d5ff3cc881b8cb4e98812dc5"

URI_x86_64_v2_libsoup3-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsoup3-devel-3.6.5-3.el10_2.11.x86_64_v2.rpm;name=x86_64_v2_libsoup3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsoup3-devel}"
SRC_URI[x86_64_v2_libsoup3-devel.sha256sum] = "28788897ff445bb5456a22517cb78a388ac21ee0d8101ac3796d25e830d566b6"

URI_x86_64_v2_libsoup3-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsoup3-doc-3.6.5-3.el10_2.11.noarch.rpm;name=x86_64_v2_libsoup3-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsoup3-doc}"
SRC_URI[x86_64_v2_libsoup3-doc.sha256sum] = "e9c9aacec423d69703716502eee70d36997b031b05b8cdd423d46cbd4cf7206c"

URI_aarch64_libsoup3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsoup3-3.6.5-3.el10_2.11.aarch64.rpm;name=aarch64_libsoup3;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsoup3}"
SRC_URI[aarch64_libsoup3.sha256sum] = "fa5bbb6b86369a81fd38e5c62517f82e9bc75e80f11188861e60d99d38e7e7bc"

URI_aarch64_libsoup3-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsoup3-devel-3.6.5-3.el10_2.11.aarch64.rpm;name=aarch64_libsoup3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsoup3-devel}"
SRC_URI[aarch64_libsoup3-devel.sha256sum] = "46359728033ef7db7509616de8fdd1c9db9ac7f54aa114f4b3b40b48a5166551"

URI_aarch64_libsoup3-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsoup3-doc-3.6.5-3.el10_2.11.noarch.rpm;name=aarch64_libsoup3-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsoup3-doc}"
SRC_URI[aarch64_libsoup3-doc.sha256sum] = "e9c9aacec423d69703716502eee70d36997b031b05b8cdd423d46cbd4cf7206c"

RDEPENDS:libsoup3 = " \
 glib2 \
 glibc \
 krb5-libs \
 libbrotli \
 libnghttp2 \
 libpsl \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:libsoup3-devel = " \
 brotli-devel \
 glib2-devel \
 krb5-devel \
 libnghttp2-devel \
 libpsl-devel \
 libsoup3 \
 pkgconf-pkg-config \
 sqlite-devel \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libsoup3-doc = " \
 "
