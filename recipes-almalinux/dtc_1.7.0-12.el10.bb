# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dtc"
PV = "1.7.0"
PR = "12.el10"
PACKAGES = " \
 dtc \
 libfdt \
 libfdt-devel \
 libfdt-static \
 python3-libfdt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dtc-1.7.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66843944e01bd0d55015592f719838165cb2e3ee77ab0d2d484b33cb6b9776ec"

URI_x86_64_v2_dtc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dtc-1.7.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_dtc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dtc}"
SRC_URI[x86_64_v2_dtc.sha256sum] = "2ec668c7959ab63f2de1146bb415a3b48221479ffdec57b604230fabd5ecc488"

URI_x86_64_v2_libfdt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libfdt-1.7.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_libfdt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdt}"
SRC_URI[x86_64_v2_libfdt.sha256sum] = "f0d42dae6b8949e2197e36de267a4e1c8909c00d29f72ed7b2a4099ff2a467fe"

URI_x86_64_v2_libfdt-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfdt-devel-1.7.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_libfdt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdt-devel}"
SRC_URI[x86_64_v2_libfdt-devel.sha256sum] = "709fe5262b416d8414cd01681aca58dee4bcc5718d3f3a4c17c867bcaec65253"

URI_x86_64_v2_libfdt-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfdt-static-1.7.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_libfdt-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdt-static}"
SRC_URI[x86_64_v2_libfdt-static.sha256sum] = "be9b8c0ec5b1d269bcb35689e4757f0179ea5eb21b7edd49d0c5ebef2d93388b"

URI_x86_64_v2_python3-libfdt = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-libfdt-1.7.0-12.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libfdt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libfdt}"
SRC_URI[x86_64_v2_python3-libfdt.sha256sum] = "296b6b399e7bffb19a1b06db269c08c10f3e4db9342b81fe7dd6c534003ced02"

URI_aarch64_dtc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dtc-1.7.0-12.el10.aarch64.rpm;name=aarch64_dtc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dtc}"
SRC_URI[aarch64_dtc.sha256sum] = "6c1df62c713971d25468705c65708e5a49c4b939924642499a1c05691a8764e8"

URI_aarch64_libfdt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libfdt-1.7.0-12.el10.aarch64.rpm;name=aarch64_libfdt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdt}"
SRC_URI[aarch64_libfdt.sha256sum] = "6bef203c3608a30d1e63ff4a7a7a8385c120c299c19151720a80b394009dd826"

URI_aarch64_libfdt-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfdt-devel-1.7.0-12.el10.aarch64.rpm;name=aarch64_libfdt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdt-devel}"
SRC_URI[aarch64_libfdt-devel.sha256sum] = "a19619c54eb5353f12f449210947c79f76061d9bb90192d04d18eaa398a9653d"

URI_aarch64_libfdt-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfdt-static-1.7.0-12.el10.aarch64.rpm;name=aarch64_libfdt-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdt-static}"
SRC_URI[aarch64_libfdt-static.sha256sum] = "c11339b9c9252b32d6d185051d6ab7fb1543b5f35af1fe4173009fd31cc34913"

URI_aarch64_python3-libfdt = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-libfdt-1.7.0-12.el10.aarch64.rpm;name=aarch64_python3-libfdt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libfdt}"
SRC_URI[aarch64_python3-libfdt.sha256sum] = "0d08a098cb11caefad81aee6e22ed8ee5056f0f004a6582527cf6f0334dd4f72"

RDEPENDS:dtc = " \
 bash \
 glibc \
 libfdt \
 "
RDEPENDS:libfdt = " \
 glibc \
 "
RDEPENDS:libfdt-devel = " \
 libfdt \
 "
RDEPENDS:libfdt-static = " \
 libfdt-devel \
 "
RDEPENDS:python3-libfdt = " \
 dtc \
 glibc \
 python3 \
 "
