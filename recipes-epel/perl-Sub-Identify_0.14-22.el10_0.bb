# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sub-Identify"
PV = "0.14"
PR = "22.el10_0"
PACKAGES = " \
 perl-Sub-Identify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sub-Identify-0.14-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f3adef45b52f56c438e6281015e4acfe8a702a564383239dfa8a887c11ad0a0"

URI_x86_64_v2_perl-Sub-Identify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sub-Identify-0.14-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sub-Identify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sub-Identify}"
SRC_URI[x86_64_v2_perl-Sub-Identify.sha256sum] = "aa7f00c60f9dc05de62f531ff2db7442edca3210b315b15a1c72a80949fcfaa3"

URI_aarch64_perl-Sub-Identify = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sub-Identify-0.14-22.el10_0.aarch64.rpm;name=aarch64_perl-Sub-Identify;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sub-Identify}"
SRC_URI[aarch64_perl-Sub-Identify.sha256sum] = "db33230636ba7ad02b52a369402f16c6385a5e4dae197079c4e4950d35eb59bd"

RDEPENDS:perl-Sub-Identify = " \
 glibc \
 perl-B \
 perl-Exporter \
 perl-libs \
 "
