# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-heapsize"
PV = "0.4.2"
PR = "21.el10_0"
PACKAGES = " \
 rust-heapsize+default-devel \
 rust-heapsize+flexible-tests-devel \
 rust-heapsize+unstable-devel \
 rust-heapsize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-heapsize-0.4.2-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f04a7199b8f47cab63f65ef9a6e1111b4375d4dbb666f6fc003e89830827af7"

URI_x86_64_v2_rust-heapsize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapsize+default-devel-0.4.2-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapsize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapsize+default-devel}"
SRC_URI[x86_64_v2_rust-heapsize+default-devel.sha256sum] = "dfd4dc5570898d8bbbf2cdfb512e811146ec4abb0fb1a092762b8a283965d565"

URI_x86_64_v2_rust-heapsize+flexible-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapsize+flexible-tests-devel-0.4.2-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapsize+flexible-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapsize+flexible-tests-devel}"
SRC_URI[x86_64_v2_rust-heapsize+flexible-tests-devel.sha256sum] = "d9f999ca8b28631a7db9291348656a7e52f4c6340adfa771fd010cdc50451866"

URI_x86_64_v2_rust-heapsize+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapsize+unstable-devel-0.4.2-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapsize+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapsize+unstable-devel}"
SRC_URI[x86_64_v2_rust-heapsize+unstable-devel.sha256sum] = "2c3c6d1cd66e0d17fe713776940b690c393d21151bb28a2bcc7407a4037d4080"

URI_x86_64_v2_rust-heapsize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapsize-devel-0.4.2-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapsize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapsize-devel}"
SRC_URI[x86_64_v2_rust-heapsize-devel.sha256sum] = "bd8cc8d9348e28ef9dc47c8ed2646604b23a3092d5b95f4bf69114c708e85790"

URI_aarch64_rust-heapsize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapsize+default-devel-0.4.2-21.el10_0.noarch.rpm;name=aarch64_rust-heapsize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapsize+default-devel}"
SRC_URI[aarch64_rust-heapsize+default-devel.sha256sum] = "2954c808a8b0293729d32d5a3b6e2cec09d430950c4658d9d7507409fe47eea8"

URI_aarch64_rust-heapsize+flexible-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapsize+flexible-tests-devel-0.4.2-21.el10_0.noarch.rpm;name=aarch64_rust-heapsize+flexible-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapsize+flexible-tests-devel}"
SRC_URI[aarch64_rust-heapsize+flexible-tests-devel.sha256sum] = "ec0b0c24d0bc20fcaff3a932310e17ac06ad112f941305e273e0e0a5b46a0e17"

URI_aarch64_rust-heapsize+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapsize+unstable-devel-0.4.2-21.el10_0.noarch.rpm;name=aarch64_rust-heapsize+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapsize+unstable-devel}"
SRC_URI[aarch64_rust-heapsize+unstable-devel.sha256sum] = "f93faab92622a651163dbc9e46d8710fd389e17db88c2a5a9966b5cac6fc0a07"

URI_aarch64_rust-heapsize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapsize-devel-0.4.2-21.el10_0.noarch.rpm;name=aarch64_rust-heapsize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapsize-devel}"
SRC_URI[aarch64_rust-heapsize-devel.sha256sum] = "c6c399667eae4540c7e5e2ab7ad62b5a9e0ea4f481315da746c78c734d9e58dc"

RDEPENDS:rust-heapsize+default-devel = " \
 cargo \
 rust-heapsize-devel \
 "
RDEPENDS:rust-heapsize+flexible-tests-devel = " \
 cargo \
 rust-heapsize-devel \
 "
RDEPENDS:rust-heapsize+unstable-devel = " \
 cargo \
 rust-heapsize-devel \
 "
RDEPENDS:rust-heapsize-devel = " \
 cargo \
 "
