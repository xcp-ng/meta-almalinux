# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerpc-utils"
PV = "1.3.13"
PR = "6.el10"
PACKAGES = " \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/powerpc-utils-1.3.13-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e355ef66fe4a0d468087ac1d0bb5f74a9f5b9f313ce3261dbfc7767006fc0a18"

