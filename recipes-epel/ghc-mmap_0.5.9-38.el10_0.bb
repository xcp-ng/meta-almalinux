# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-mmap"
PV = "0.5.9"
PR = "38.el10_0"
PACKAGES = " \
 ghc-mmap \
 ghc-mmap-devel \
 ghc-mmap-doc \
 ghc-mmap-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-mmap-0.5.9-38.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caa0ac95665e96076f4dc539e4bb6f2e48829466260920b2d341e300e4c0d0aa"

URI_x86_64_v2_ghc-mmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mmap-0.5.9-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mmap}"
SRC_URI[x86_64_v2_ghc-mmap.sha256sum] = "4119beae442903304ee2b540fdb23583a5632468f00d13b722ab306a2ef35a1c"

URI_x86_64_v2_ghc-mmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mmap-devel-0.5.9-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mmap-devel}"
SRC_URI[x86_64_v2_ghc-mmap-devel.sha256sum] = "dfa0168c0e1d05cb16e447543399ee5981b469662441ff11befce7c3352c9fa2"

URI_x86_64_v2_ghc-mmap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mmap-doc-0.5.9-38.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-mmap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mmap-doc}"
SRC_URI[x86_64_v2_ghc-mmap-doc.sha256sum] = "f241c1ef558a60b8b41f44235ab6ef372bebbb37df538850af14f9328a73ed89"

URI_x86_64_v2_ghc-mmap-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-mmap-prof-0.5.9-38.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-mmap-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-mmap-prof}"
SRC_URI[x86_64_v2_ghc-mmap-prof.sha256sum] = "91272a365be72a917765b705b00a2e7067afec4f3e800c4f5a3135023e718a5b"

URI_aarch64_ghc-mmap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mmap-0.5.9-38.el10_0.aarch64.rpm;name=aarch64_ghc-mmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mmap}"
SRC_URI[aarch64_ghc-mmap.sha256sum] = "32be1a579c54fadac7a69d3dcc2c608c4f6a17a6955b700bf0d4228f46fc723e"

URI_aarch64_ghc-mmap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mmap-devel-0.5.9-38.el10_0.aarch64.rpm;name=aarch64_ghc-mmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mmap-devel}"
SRC_URI[aarch64_ghc-mmap-devel.sha256sum] = "2fef38d39645153c828190789d3b6d0645874f32615540cc06934a15692b3a28"

URI_aarch64_ghc-mmap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mmap-doc-0.5.9-38.el10_0.noarch.rpm;name=aarch64_ghc-mmap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mmap-doc}"
SRC_URI[aarch64_ghc-mmap-doc.sha256sum] = "f7ae0718f710df1e3a131e03de7feea6ed17c8b760e04fcc2308b3549f42e2e5"

URI_aarch64_ghc-mmap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-mmap-prof-0.5.9-38.el10_0.aarch64.rpm;name=aarch64_ghc-mmap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-mmap-prof}"
SRC_URI[aarch64_ghc-mmap-prof.sha256sum] = "50fae8ff268a9e9f4b34e3394c5882bb63ee53c2fbdf3f1de5eb5232ea1003b7"

RDEPENDS:ghc-mmap = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-mmap-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-mmap \
 "
RDEPENDS:ghc-mmap-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-mmap-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-mmap-devel \
 "
