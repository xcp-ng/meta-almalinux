# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-url"
PV = "2.5.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-url+default-devel \
 rust-url+expose_internals-devel \
 rust-url+serde-devel \
 rust-url+std-devel \
 rust-url-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-url-2.5.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd5e227c3a35ac08ba1956a7f3cbe300c0a449c7fe8c991789eceea20a6b3c59"

URI_x86_64_v2_rust-url+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+default-devel-2.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+default-devel}"
SRC_URI[x86_64_v2_rust-url+default-devel.sha256sum] = "7050d7c2124d6432f6ec23950dd75b114925aa4f8d1f2886e5d2f442e24ce326"

URI_x86_64_v2_rust-url+expose_internals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+expose_internals-devel-2.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+expose_internals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+expose_internals-devel}"
SRC_URI[x86_64_v2_rust-url+expose_internals-devel.sha256sum] = "c234d156ea81f81d1a41cc2bc9f1a50f4fa53a26bcb40c3a70d1cca65ca94246"

URI_x86_64_v2_rust-url+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+serde-devel-2.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+serde-devel}"
SRC_URI[x86_64_v2_rust-url+serde-devel.sha256sum] = "3f26381c04fbb9ebd3258d70e24decda072b781106af26848aa211ed0fe150d3"

URI_x86_64_v2_rust-url+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url+std-devel-2.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url+std-devel}"
SRC_URI[x86_64_v2_rust-url+std-devel.sha256sum] = "e2163a07e2f95cd357d93006a01b091b9cff57f607d61b0baa250e268bf5dbc4"

URI_x86_64_v2_rust-url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-url-devel-2.5.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-url-devel}"
SRC_URI[x86_64_v2_rust-url-devel.sha256sum] = "8bdb64b66a0e0b84f8c99782d2d32a5e6393ae0908a33ccd2d274e138487c0bf"

URI_aarch64_rust-url+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+default-devel-2.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-url+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+default-devel}"
SRC_URI[aarch64_rust-url+default-devel.sha256sum] = "b58beb1b576af70b1d6397697b12c735e10642441ef1cd5e66108acefd8943fc"

URI_aarch64_rust-url+expose_internals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+expose_internals-devel-2.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-url+expose_internals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+expose_internals-devel}"
SRC_URI[aarch64_rust-url+expose_internals-devel.sha256sum] = "a85d0ecc93ee049b4afb8b8e94e75762b6054b9312148131ae8dc3551697a14e"

URI_aarch64_rust-url+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+serde-devel-2.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-url+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+serde-devel}"
SRC_URI[aarch64_rust-url+serde-devel.sha256sum] = "3d785d53b944e1e45f62707b084f3b3d07861c870d2e96c052aa9bc6f4f06cc6"

URI_aarch64_rust-url+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url+std-devel-2.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-url+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url+std-devel}"
SRC_URI[aarch64_rust-url+std-devel.sha256sum] = "05a393442e74c6312d337ed29d36fec14dab4e23a4a5f20742c49768a0241465"

URI_aarch64_rust-url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-url-devel-2.5.8-1.el10_2.noarch.rpm;name=aarch64_rust-url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-url-devel}"
SRC_URI[aarch64_rust-url-devel.sha256sum] = "997c7c9f823e2a50e7fef2d08c9d4505630560f3dd50a489777b008743d2c21f"

RDEPENDS:rust-url+default-devel = " \
 cargo \
 rust-url+std-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url+expose_internals-devel = " \
 cargo \
 rust-url-devel \
 "
RDEPENDS:rust-url+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-serde_derive-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url+std-devel = " \
 cargo \
 rust-form_urlencoded+std-devel \
 rust-idna+std-devel \
 rust-percent-encoding+std-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-url-devel \
 "
RDEPENDS:rust-url-devel = " \
 cargo \
 rust \
 rust-form_urlencoded+alloc-devel \
 rust-form_urlencoded-devel \
 rust-idna+alloc-devel \
 rust-idna+compiled_data-devel \
 rust-idna-devel \
 rust-percent-encoding+alloc-devel \
 rust-percent-encoding-devel \
 "
