# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-validation-suite"
PV = "7.1.0"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm-validation-suite \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-validation-suite-7.1.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "443c03ffac742352fe7f7a53b98534b3940d42ed660705b3278e9152afcf08ff"

URI_x86_64_v2_rocm-validation-suite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-validation-suite-7.1.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-validation-suite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-validation-suite}"
SRC_URI[x86_64_v2_rocm-validation-suite.sha256sum] = "4d93e3fd85ad4724585308f07cc7ac83a1667431c8c4030fd857d9c5399c1e1a"

RDEPENDS:rocm-validation-suite = " \
 amdsmi \
 glibc \
 hipblaslt \
 hiprand \
 libgcc \
 libstdc++ \
 pciutils-libs \
 rocblas \
 rocm-hip \
 rocm-runtime \
 virtual/libomp.so_VERSION__64bit_ \
 virtual/libomp.so___64bit_ \
 yaml-cpp \
 "
