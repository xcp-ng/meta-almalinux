# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-swift"
PV = "0.7.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-swift+default-devel \
 rust-tree-sitter-swift-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-swift-0.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1f8ae0a426b322477d879b36fa49fa652d7eeeca6efdc355f636505e5922b1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-swift+default-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-swift+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-swift+default-devel.sha256sum] = "17e36437d4d70082e0563a1de619f9c89d09066de0f83cecebe2eb454a9622ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-swift-devel-0.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-swift-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-swift-devel.sha256sum] = "59c10293f4eea1d546f178ff1e4b8dc773f5980023e83acf0310076772b69501"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-swift+default-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-swift+default-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-swift+default-devel.sha256sum] = "448b334c0ad46c9dcb9fbffc592a5ef49af9041b8dd37a2307ed2ef9d23029fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-swift-devel-0.7.3-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-swift-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-swift-devel.sha256sum] = "8d6561e8a5b3818677f66c22e9fac1c2675e835abeabb76be1bce74ec79b5c20"

RDEPENDS:rust-tree-sitter-swift+default-devel = " \
 cargo \
 rust-tree-sitter-swift-devel \
 "
RDEPENDS:rust-tree-sitter-swift-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
