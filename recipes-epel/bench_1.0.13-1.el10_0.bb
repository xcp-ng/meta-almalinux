# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bench"
PV = "1.0.13"
PR = "1.el10_0"
PACKAGES = " \
 bench \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bench-1.0.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8c5cf25908a7b4d82103a990a936cc9ff004efdaefd916840871781b9328f224"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bench-1.0.13-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bench;unpack=0"
SRC_URI[x86_64_v2_bench.sha256sum] = "07d1f5d11af5f231efb64b159e994fbe74df452ab86766940668de2f7463b7fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bench-1.0.13-1.el10_0.aarch64.rpm;name=aarch64_bench;unpack=0"
SRC_URI[aarch64_bench.sha256sum] = "76489ac0b1607bae60ef3ece1fe1488a676a217c0e73e04f88d941105705d30f"

RDEPENDS:bench = " \
 glibc \
 gmp \
 libffi \
 zlib-ng-compat \
 "
