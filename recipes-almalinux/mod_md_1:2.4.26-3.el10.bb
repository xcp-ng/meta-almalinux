# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_md"
PE = "1"
PV = "2.4.26"
PR = "3.el10"
PACKAGES = " \
 mod_md \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_md-2.4.26-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97a147ad5e361f5843ffd2346642040cfc96f68330d0b2a1e9aa58e4f06808d3"

URI_x86_64_v2_mod_md = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_md-2.4.26-3.el10.x86_64_v2.rpm;name=x86_64_v2_mod_md;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_md}"
SRC_URI[x86_64_v2_mod_md.sha256sum] = "0489160681cb070dcd7258c26bbdeb625d7bfe19a1da88577d6569413188f106"

URI_aarch64_mod_md = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_md-2.4.26-3.el10.aarch64.rpm;name=aarch64_mod_md;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_md}"
SRC_URI[aarch64_mod_md.sha256sum] = "e4c3b03818b012fe08cdd8d532c364e15c27836bbd93795a876be57c1bb79108"

RDEPENDS:mod_md = " \
 apr \
 apr-util \
 glibc \
 httpd-core \
 jansson \
 mod_ssl \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
