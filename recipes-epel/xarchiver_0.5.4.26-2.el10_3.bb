# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xarchiver"
PV = "0.5.4.26"
PR = "2.el10_3"
PACKAGES = " \
 xarchiver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xarchiver-0.5.4.26-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d0eb69b7bd84e1d8f8443f1396f773f246da5e947319bb1ed22312ef53035f4"

URI_x86_64_v2_xarchiver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xarchiver-0.5.4.26-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xarchiver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xarchiver}"
SRC_URI[x86_64_v2_xarchiver.sha256sum] = "0e0851ddf449239d4b0c6c7e694fe387690a4b3428a5f36d2d4a6d95fac05f68"

URI_aarch64_xarchiver = "${EPEL_MIRROR}/aarch64/Packages/x/xarchiver-0.5.4.26-2.el10_3.aarch64.rpm;name=aarch64_xarchiver;unpack=0"
SRC_URI:append = " ${URI_aarch64_xarchiver}"
SRC_URI[aarch64_xarchiver.sha256sum] = "798d898d7c610b43ede47d0f165f5df93861b42919c368d3dff0efac72d0a6f9"

RDEPENDS:xarchiver = " \
 bash \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 "
