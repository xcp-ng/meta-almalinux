# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerofrom"
PV = "0.1.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-zerofrom+alloc-devel \
 rust-zerofrom+default-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerofrom-0.1.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70d5005ad7044318f18d213cefde03e210251d26cc3b1d6224ad59505e2813aa"

URI_x86_64_v2_rust-zerofrom+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+alloc-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+alloc-devel.sha256sum] = "35b30eca2393540427a69736937d63ee40af3d3ebcb533f58f20f625e163cd3b"

URI_x86_64_v2_rust-zerofrom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+default-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+default-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+default-devel.sha256sum] = "92c0becee10b38fbd8da637f883f921ea71339b49d4cc25e88270e852d1a6ded"

URI_x86_64_v2_rust-zerofrom+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+derive-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+derive-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+derive-devel.sha256sum] = "e628feb387d779c1dd385ca497ba8eb4e464fe4ec99c3db2a84338a5463a4232"

URI_x86_64_v2_rust-zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-devel-0.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-devel.sha256sum] = "722d759e8c454cb491d6ef848e80ccb90d2ff03512ee6bc8c2a9f4765858e039"

URI_aarch64_rust-zerofrom+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+alloc-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-zerofrom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+alloc-devel}"
SRC_URI[aarch64_rust-zerofrom+alloc-devel.sha256sum] = "962497a0be4eee1b9592582abfca0e5c889974e32ce920d68a2f84c63163818c"

URI_aarch64_rust-zerofrom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+default-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-zerofrom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+default-devel}"
SRC_URI[aarch64_rust-zerofrom+default-devel.sha256sum] = "9dc102b480060bee3219033ec64881ac3e27383a7f09ce8be70bcf5f5d7d2320"

URI_aarch64_rust-zerofrom+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+derive-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-zerofrom+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+derive-devel}"
SRC_URI[aarch64_rust-zerofrom+derive-devel.sha256sum] = "c5230ccdcd96f31f0acd4226c755fffb52112901c9c1e662dcd7baa9a0f3d61a"

URI_aarch64_rust-zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-devel-0.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-devel}"
SRC_URI[aarch64_rust-zerofrom-devel.sha256sum] = "42d51467963cf2c9bf6761d90f7dd10385bca51113e50de56604dedc957ad505"

RDEPENDS:rust-zerofrom+alloc-devel = " \
 cargo \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom+default-devel = " \
 cargo \
 rust-zerofrom+alloc-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom+derive-devel = " \
 cargo \
 rust-zerofrom-derive-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom-devel = " \
 cargo \
 rust \
 "
