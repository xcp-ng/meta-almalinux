# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-messages"
PV = "17.1.0"
PR = "10.el10_2"
PACKAGES = " \
 rubygem-cucumber-messages \
 rubygem-cucumber-messages-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-messages-17.1.0-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "976bee011b8b113c5bbafe4d545240f30d0480c0c45310bbf3b7b1995188fab1"

URI_x86_64_v2_rubygem-cucumber-messages = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-messages-17.1.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-messages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-messages}"
SRC_URI[x86_64_v2_rubygem-cucumber-messages.sha256sum] = "1380879e1a154be4c1f41c6f9bef86a6e9e0b4769e6a5a79471474c7d91d99bd"

URI_x86_64_v2_rubygem-cucumber-messages-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-messages-doc-17.1.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-messages-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-messages-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-messages-doc.sha256sum] = "867e987bed0b5efd1922c882bd3b6337448deed3f7699d5657a47f3c0527775c"

URI_aarch64_rubygem-cucumber-messages = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-messages-17.1.0-10.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-messages;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-messages}"
SRC_URI[aarch64_rubygem-cucumber-messages.sha256sum] = "4d3823c87b676b4c0ebbebe1edf56c482ad4c97345e789ef98808c510915fefb"

URI_aarch64_rubygem-cucumber-messages-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-messages-doc-17.1.0-10.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-messages-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-messages-doc}"
SRC_URI[aarch64_rubygem-cucumber-messages-doc.sha256sum] = "9adf881efd5d684c81dc814eb08a8d656658e95e3469d04ae396f72941e48e3f"

RDEPENDS:rubygem-cucumber-messages = " \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-messages-doc = " \
 rubygem-cucumber-messages \
 "
