# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-ng-sys"
PV = "1.1.29"
PR = "1.el10_3"
PACKAGES = " \
 rust-libz-ng-sys+default-devel \
 rust-libz-ng-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-ng-sys-1.1.29-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75aa7e7b30453cb2f95af760f6fb845742e1103e1b8391107317bcad9d52be06"

URI_x86_64_v2_rust-libz-ng-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-ng-sys+default-devel-1.1.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-ng-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-ng-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-ng-sys+default-devel.sha256sum] = "174b47eb2eb530d6c42df3ffe34600d07836200018287ae8d5200cd71dc1bba5"

URI_x86_64_v2_rust-libz-ng-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-ng-sys-devel-1.1.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-ng-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-ng-sys-devel.sha256sum] = "53a28ef25369162943deb995e0692a86f1ac0a59d0a4eecf84ccc83daac852a1"

URI_aarch64_rust-libz-ng-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-ng-sys+default-devel-1.1.29-1.el10_3.noarch.rpm;name=aarch64_rust-libz-ng-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-ng-sys+default-devel}"
SRC_URI[aarch64_rust-libz-ng-sys+default-devel.sha256sum] = "077ed56225c8371e956c23824e96bc733f8e6b6b7a9a299c2f503e15a4ed5753"

URI_aarch64_rust-libz-ng-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-ng-sys-devel-1.1.29-1.el10_3.noarch.rpm;name=aarch64_rust-libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-ng-sys-devel}"
SRC_URI[aarch64_rust-libz-ng-sys-devel.sha256sum] = "ad84fcce3c4fad5fe337c3b35fc7ab5c4f3f36de56ecc7d71a7da5e48882bc5d"

RDEPENDS:rust-libz-ng-sys+default-devel = " \
 cargo \
 rust-libz-ng-sys-devel \
 "
RDEPENDS:rust-libz-ng-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 zlib-ng-devel \
 "
