# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-qmljs"
PV = "0.3.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-qmljs+default-devel \
 rust-tree-sitter-qmljs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-qmljs-0.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8368c65dada12235edbbbcf055fcb6542dcecf187d5851340198e86ad609b1fb"

URI_x86_64_v2_rust-tree-sitter-qmljs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-qmljs+default-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-qmljs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-qmljs+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-qmljs+default-devel.sha256sum] = "39be7c181f9bc056df04a919524b95a242042ad14d6b2a58e8d6640ddc419682"

URI_x86_64_v2_rust-tree-sitter-qmljs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-qmljs-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-qmljs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-qmljs-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-qmljs-devel.sha256sum] = "9fe9d23803a118dde2da57b1925418b344d5c11755cdfb42ac6b6d53902fa448"

URI_aarch64_rust-tree-sitter-qmljs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-qmljs+default-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-qmljs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-qmljs+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-qmljs+default-devel.sha256sum] = "8a6e62791ef0c37afd74e6db0839609acd5256a575f9c33ee03b6b84ef2ce8ac"

URI_aarch64_rust-tree-sitter-qmljs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-qmljs-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-qmljs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-qmljs-devel}"
SRC_URI[aarch64_rust-tree-sitter-qmljs-devel.sha256sum] = "d2e23c0ac8775491bab8f536c03bfc6a524fe5cb3c7c34e2f14702ccdd14fcb5"

RDEPENDS:rust-tree-sitter-qmljs+default-devel = " \
 cargo \
 rust-tree-sitter-qmljs-devel \
 "
RDEPENDS:rust-tree-sitter-qmljs-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
