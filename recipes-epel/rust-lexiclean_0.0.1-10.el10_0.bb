# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexiclean"
PV = "0.0.1"
PR = "10.el10_0"
PACKAGES = " \
 rust-lexiclean+default-devel \
 rust-lexiclean-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexiclean-0.0.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d0b587b645273d42daad1ca030a87b753772397578cd8e12205bd3c806ce9f7"

URI_x86_64_v2_rust-lexiclean+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexiclean+default-devel-0.0.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexiclean+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexiclean+default-devel}"
SRC_URI[x86_64_v2_rust-lexiclean+default-devel.sha256sum] = "0a4b7a4ffc73b06ee66cc2fc3b2470b079338fad8e2ef300322c288a396f7222"

URI_x86_64_v2_rust-lexiclean-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexiclean-devel-0.0.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexiclean-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexiclean-devel}"
SRC_URI[x86_64_v2_rust-lexiclean-devel.sha256sum] = "e2cd7573866f2c558da1205044ec7dbf8d6d3932bf70af9ba32025c9f34dd6d1"

URI_aarch64_rust-lexiclean+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexiclean+default-devel-0.0.1-10.el10_0.noarch.rpm;name=aarch64_rust-lexiclean+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexiclean+default-devel}"
SRC_URI[aarch64_rust-lexiclean+default-devel.sha256sum] = "68c8a2d50706fde7992250bf79b5a71c278e0977b31886c1b6417a79740f9e0d"

URI_aarch64_rust-lexiclean-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexiclean-devel-0.0.1-10.el10_0.noarch.rpm;name=aarch64_rust-lexiclean-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexiclean-devel}"
SRC_URI[aarch64_rust-lexiclean-devel.sha256sum] = "cbee22ae59213a060d8b473fdea9e6de5ac200385d9dff2fd4df548ab9cc548f"

RDEPENDS:rust-lexiclean+default-devel = " \
 cargo \
 rust-lexiclean-devel \
 "
RDEPENDS:rust-lexiclean-devel = " \
 cargo \
 "
