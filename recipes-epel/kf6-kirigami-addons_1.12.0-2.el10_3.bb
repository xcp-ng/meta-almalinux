# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami-addons"
PV = "1.12.0"
PR = "2.el10_3"
PACKAGES = " \
 kf6-kirigami-addons \
 kf6-kirigami-addons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-addons-1.12.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5f99cc664983998cadb193085243f2319e168c81b2a7409cc8fc758afad886c"

URI_x86_64_v2_kf6-kirigami-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-1.12.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-addons}"
SRC_URI[x86_64_v2_kf6-kirigami-addons.sha256sum] = "50134ee8b83e058396e923d9789dcf5c8f0286fe39ce15a1c4f9772f29b9c404"

URI_x86_64_v2_kf6-kirigami-addons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-devel-1.12.0-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-addons-devel}"
SRC_URI[x86_64_v2_kf6-kirigami-addons-devel.sha256sum] = "53cfd0495fbccfa59a9a92e05d90b52988071220ce4a5951bf8126c690e19e50"

URI_aarch64_kf6-kirigami-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-1.12.0-2.el10_3.aarch64.rpm;name=aarch64_kf6-kirigami-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-addons}"
SRC_URI[aarch64_kf6-kirigami-addons.sha256sum] = "097617fe8d5a2851003d9194a5248af9998a08a03b6e5b1cfd6843e9f88f045d"

URI_aarch64_kf6-kirigami-addons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-devel-1.12.0-2.el10_3.aarch64.rpm;name=aarch64_kf6-kirigami-addons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-addons-devel}"
SRC_URI[aarch64_kf6-kirigami-addons-devel.sha256sum] = "f182c4dea1f64d5a2a36488b95671e180385b057d19cc1826d4f2389881ae6d3"

RDEPENDS:kf6-kirigami-addons = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-addons-devel = " \
 cmake-filesystem \
 kf6-kirigami-addons \
 "
