# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-dalli"
PV = "3.2.0"
PR = "10.el10_1"
PACKAGES = " \
 rubygem-dalli \
 rubygem-dalli-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-dalli-3.2.0-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2609dd58b7b6ef48ac752c3f3d634cf62caf7f8dd291dd32df34b72b6e5b8493"

URI_x86_64_v2_rubygem-dalli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-dalli-3.2.0-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-dalli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-dalli}"
SRC_URI[x86_64_v2_rubygem-dalli.sha256sum] = "c7e074e1d8cdc5662c2c375248b89927aaff02f33c7aaa7f968af5df31a79ca0"

URI_x86_64_v2_rubygem-dalli-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-dalli-doc-3.2.0-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-dalli-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-dalli-doc}"
SRC_URI[x86_64_v2_rubygem-dalli-doc.sha256sum] = "f23151ef967bce6f102e9c42209b83114d64cd82615ba436724a397e2cc41f82"

URI_aarch64_rubygem-dalli = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-dalli-3.2.0-10.el10_1.noarch.rpm;name=aarch64_rubygem-dalli;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-dalli}"
SRC_URI[aarch64_rubygem-dalli.sha256sum] = "25965541dd478c8a836373f8c138ab9caf89b1e4ca6c3047fa4f88a2fd28a77c"

URI_aarch64_rubygem-dalli-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-dalli-doc-3.2.0-10.el10_1.noarch.rpm;name=aarch64_rubygem-dalli-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-dalli-doc}"
SRC_URI[aarch64_rubygem-dalli-doc.sha256sum] = "7be6e446ba9f0570059e0f6b566c68ccd5a3f8d289dac88c4d4fe49bdfd88bd7"

RDEPENDS:rubygem-dalli = " \
 ruby-default-gems \
 rubygems \
 "
RDEPENDS:rubygem-dalli-doc = " \
 rubygem-dalli \
 "
