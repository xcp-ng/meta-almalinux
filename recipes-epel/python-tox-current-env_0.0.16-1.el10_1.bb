# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tox-current-env"
PV = "0.0.16"
PR = "1.el10_1"
PACKAGES = " \
 python3-tox-current-env \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tox-current-env-0.0.16-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90b6181a7346489adcb211990b1f894421e02ab571dc5cbdecc60ae4b60f70ed"

URI_x86_64_v2_python3-tox-current-env = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tox-current-env-0.0.16-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tox-current-env;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tox-current-env}"
SRC_URI[x86_64_v2_python3-tox-current-env.sha256sum] = "37f7e78e858b91c6d9f7b056a60973fc01816f83e1c72b50b0ae22ccdb624853"

URI_aarch64_python3-tox-current-env = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tox-current-env-0.0.16-1.el10_1.noarch.rpm;name=aarch64_python3-tox-current-env;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tox-current-env}"
SRC_URI[aarch64_python3-tox-current-env.sha256sum] = "d386e2eb751e8f3db546c9a4b65a9afd91f364915997c46e894ad12d0e5448f3"

RDEPENDS:python3-tox-current-env = " \
 python3 \
 tox \
 "
