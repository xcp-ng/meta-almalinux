# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger0.8"
PV = "0.8.4"
PR = "9.el10_0"
PACKAGES = " \
 rust-env_logger0.8+atty-devel \
 rust-env_logger0.8+default-devel \
 rust-env_logger0.8+humantime-devel \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8+termcolor-devel \
 rust-env_logger0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger0.8-0.8.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6feab507a0e8e8af727052b6ff916b9726f7f4176bae40018c5b5689aabf69a"

URI_x86_64_v2_rust-env_logger0.8+atty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+atty-devel-0.8.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+atty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+atty-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+atty-devel.sha256sum] = "75cb88bc490961f57fbd981873d83ed614cd8b07fc1cfd176d247a46535c773a"

URI_x86_64_v2_rust-env_logger0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+default-devel-0.8.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+default-devel.sha256sum] = "de79b9a2d0a575c5e7af91dfb3447df0772a50d83670159eb4e5bec869e451b4"

URI_x86_64_v2_rust-env_logger0.8+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+humantime-devel-0.8.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+humantime-devel.sha256sum] = "4dd798ea617faa57321848c498aa840c594c8ab208565e6bf0ca5f3249865a39"

URI_x86_64_v2_rust-env_logger0.8+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+regex-devel-0.8.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+regex-devel.sha256sum] = "0d85e2df1b8767b9da920bb7f052f20cff0eb96646c234ee3b4c4b83da223fdf"

URI_x86_64_v2_rust-env_logger0.8+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+termcolor-devel-0.8.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+termcolor-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+termcolor-devel.sha256sum] = "d8ecd496613b906f281622b6255e56a488ddb88a9a2724eb77379e2467178c6c"

URI_x86_64_v2_rust-env_logger0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8-devel-0.8.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8-devel.sha256sum] = "911a7639fe80fb708a717b4b129f2ba037227e8dfd70d75303f222ff97554176"
RPROVIDES:rust-env_logger0.8-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger0.8+atty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+atty-devel-0.8.4-9.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.8+atty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+atty-devel}"
SRC_URI[aarch64_rust-env_logger0.8+atty-devel.sha256sum] = "765b893cf654045b5fe2294138a2360715dd84d10cf7daf772f163722a066695"

URI_aarch64_rust-env_logger0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+default-devel-0.8.4-9.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+default-devel}"
SRC_URI[aarch64_rust-env_logger0.8+default-devel.sha256sum] = "a5b78430841f044607bb25abedb9c1867ef275b80bbd7298934350751b51efe3"

URI_aarch64_rust-env_logger0.8+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+humantime-devel-0.8.4-9.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.8+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+humantime-devel}"
SRC_URI[aarch64_rust-env_logger0.8+humantime-devel.sha256sum] = "81d860f6e9cdc491fe9b23cc5d1b538236b3752fd16b901f69fbd388b6b394db"

URI_aarch64_rust-env_logger0.8+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+regex-devel-0.8.4-9.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.8+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+regex-devel}"
SRC_URI[aarch64_rust-env_logger0.8+regex-devel.sha256sum] = "d71207b0e9fc336853247b83f9eb4e12f749c40ac00b0bd36543ebbd6f143864"

URI_aarch64_rust-env_logger0.8+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+termcolor-devel-0.8.4-9.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.8+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+termcolor-devel}"
SRC_URI[aarch64_rust-env_logger0.8+termcolor-devel.sha256sum] = "88c4a23c10a93b500659cb1d9e90d6920cf0c33bdb49651c748ad0226ba2a538"

URI_aarch64_rust-env_logger0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8-devel-0.8.4-9.el10_0.noarch.rpm;name=aarch64_rust-env_logger0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8-devel}"
SRC_URI[aarch64_rust-env_logger0.8-devel.sha256sum] = "c4f1c6e648bd021917d6b25b2eac8c3a2b53a10f54f02a0d3ba87baad5daa086"
RPROVIDES:rust-env_logger0.8-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger0.8+atty-devel = " \
 cargo \
 rust-atty+default-devel \
 rust-env_logger0.8-devel \
 "
RDEPENDS:rust-env_logger0.8+default-devel = " \
 cargo \
 rust-env_logger0.8+atty-devel \
 rust-env_logger0.8+humantime-devel \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8+termcolor-devel \
 rust-env_logger0.8-devel \
 "
RDEPENDS:rust-env_logger0.8+humantime-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-humantime+default-devel \
 "
RDEPENDS:rust-env_logger0.8+regex-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_logger0.8+termcolor-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-env_logger0.8-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
