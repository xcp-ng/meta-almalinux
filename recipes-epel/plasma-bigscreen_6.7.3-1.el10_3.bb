# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-bigscreen"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-bigscreen \
 plasma-bigscreen-wayland \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-bigscreen-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a755930d1dad0aac359af4471c1ff4cbc326e1cc0941a196a89f3df09adfce17"

URI_x86_64_v2_plasma-bigscreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-bigscreen-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-bigscreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-bigscreen}"
SRC_URI[x86_64_v2_plasma-bigscreen.sha256sum] = "30c11bc44391f09b949bcefee8b77aa052da954437f52d2d8a319e5d0035a06c"

URI_x86_64_v2_plasma-bigscreen-wayland = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-bigscreen-wayland-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-bigscreen-wayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-bigscreen-wayland}"
SRC_URI[x86_64_v2_plasma-bigscreen-wayland.sha256sum] = "f731cb985c7e973955642c85f6cde6a4e55b4785999567277e730e88b235021a"

URI_aarch64_plasma-bigscreen = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-bigscreen-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-bigscreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-bigscreen}"
SRC_URI[aarch64_plasma-bigscreen.sha256sum] = "67d1482de394dd1bfd65483fbab4b408cb680e639f1a174882578efa68ae54cf"

URI_aarch64_plasma-bigscreen-wayland = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-bigscreen-wayland-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma-bigscreen-wayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-bigscreen-wayland}"
SRC_URI[aarch64_plasma-bigscreen-wayland.sha256sum] = "5389296ed679490600c05f2f7b1388a19e89acd45cd635c85bd014e45efdbcd2"

RDEPENDS:plasma-bigscreen = " \
 SDL3 \
 bash \
 glibc \
 kf6-bluez-qt \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-solid \
 libcec \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 plasma-activities \
 plasma-bigscreen-wayland \
 plasma-nano \
 plasma-workspace-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:plasma-bigscreen-wayland = " \
 bash \
 plasma-bigscreen \
 plasma-workspace \
 "
