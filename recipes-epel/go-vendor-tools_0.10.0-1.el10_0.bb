# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-vendor-tools"
PV = "0.10.0"
PR = "1.el10_0"
PACKAGES = " \
 go-vendor-tools \
 go-vendor-tools+all \
 go-vendor-tools-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/go-vendor-tools-0.10.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9dcce7774b88582cf2343395496ebc9270e9911165b91ad00b078b04e56324f"

URI_x86_64_v2_go-vendor-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools-0.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools}"
SRC_URI[x86_64_v2_go-vendor-tools.sha256sum] = "56bdb35e420c54f201f3fb0c9997fc056ba94c8f18c69ea018a6564e75d60380"

URI_x86_64_v2_go-vendor-tools+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools+all-0.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools+all}"
SRC_URI[x86_64_v2_go-vendor-tools+all.sha256sum] = "d13d6f8e0a0cd2c6ef70d0f607a4f16c84e17ebefd45bd793146403557cfe3b1"

URI_x86_64_v2_go-vendor-tools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools-doc-0.10.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools-doc}"
SRC_URI[x86_64_v2_go-vendor-tools-doc.sha256sum] = "f9d2f52888e0e41f81c84ac76b0d4c1f2bcdd4fa4a85da519f176379a7221cfd"

URI_aarch64_go-vendor-tools = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools-0.10.0-1.el10_0.noarch.rpm;name=aarch64_go-vendor-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools}"
SRC_URI[aarch64_go-vendor-tools.sha256sum] = "82624e4709904fcc22c2b63477ce401df20d03e8d658e14754508feced3098fc"

URI_aarch64_go-vendor-tools+all = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools+all-0.10.0-1.el10_0.noarch.rpm;name=aarch64_go-vendor-tools+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools+all}"
SRC_URI[aarch64_go-vendor-tools+all.sha256sum] = "a8b207b33a56f107967ef48e79f1fbbbac0991567cd4eef29e39cb89daa63a3f"

URI_aarch64_go-vendor-tools-doc = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools-doc-0.10.0-1.el10_0.noarch.rpm;name=aarch64_go-vendor-tools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools-doc}"
SRC_URI[aarch64_go-vendor-tools-doc.sha256sum] = "fbd08ce23e9b443a8871f4e8ef8349d869dc54aacf0b6039f3a588798f791e3d"

RDEPENDS:go-vendor-tools = " \
 python3 \
 python3-license-expression \
 "
RDEPENDS:go-vendor-tools+all = " \
 go-vendor-tools \
 python3 \
 python3-argcomplete \
 python3-specfile \
 python3-tomlkit \
 python3-zstarfile \
 "
RDEPENDS:go-vendor-tools-doc = " \
 "
