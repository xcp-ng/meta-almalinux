# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wordpress"
PV = "7.0.4"
PR = "1.el10_3"
PACKAGES = " \
 wordpress \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wordpress-7.0.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79d64c53e5701d30a2d4f7da1aa4b112d44de7546ddb69c4c0d870efc9d15a97"

URI_x86_64_v2_wordpress = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wordpress-7.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_wordpress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wordpress}"
SRC_URI[x86_64_v2_wordpress.sha256sum] = "04e1d480b0d3d593030592bee93ace0376a6c5a341bd661abcd25cc9e601ff4c"

URI_aarch64_wordpress = "${EPEL_MIRROR}/aarch64/Packages/w/wordpress-7.0.4-1.el10_3.noarch.rpm;name=aarch64_wordpress;unpack=0"
SRC_URI:append = " ${URI_aarch64_wordpress}"
SRC_URI[aarch64_wordpress.sha256sum] = "c5eecb9c766473ef789354f7f218f168ba627b62b4c89be1f1ff1faea30808c8"

RDEPENDS:wordpress = " \
 ca-certificates \
 httpd \
 httpd-filesystem \
 nginx-filesystem \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gettext \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-mysqli \
 virtual/php-openssl \
 virtual/php-simplexml \
 virtual/php-sodium \
 virtual/php-xml \
 virtual/php-xmlreader \
 virtual/php-zip \
 virtual/php-zlib \
 virtual/php_httpd_ \
 virtual/php_language__ge_7.2 \
 virtual/webserver \
 "
