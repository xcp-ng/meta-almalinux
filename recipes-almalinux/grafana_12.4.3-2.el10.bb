# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana"
PV = "12.4.3"
PR = "2.el10"
PACKAGES = " \
 grafana \
 grafana-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-12.4.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "907fe621bbcace4213d15d5fae30fd7e79b21db32e242730133fa80f8c2b15ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-12.4.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_grafana;unpack=0"
SRC_URI[x86_64_v2_grafana.sha256sum] = "5458fe4328b9a30ef579413c05a3b440428b76f1507684e2c26469d83e1bf497"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-selinux-12.4.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_grafana-selinux;unpack=0"
SRC_URI[x86_64_v2_grafana-selinux.sha256sum] = "f541f0230201265ceb273d61f8b939458a9d295a4982e6bd196f1d1c7642228c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-12.4.3-2.el10.aarch64.rpm;name=aarch64_grafana;unpack=0"
SRC_URI[aarch64_grafana.sha256sum] = "00a96fbf11494405ec200f5c86a5a1d702a9ea4ed1936be4e1d6d86818a42bbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-selinux-12.4.3-2.el10.aarch64.rpm;name=aarch64_grafana-selinux;unpack=0"
SRC_URI[aarch64_grafana-selinux.sha256sum] = "64a962d2e6819ced64f18ef21cc05672d5e72597a605cd48d845e8de25686fc3"

RDEPENDS:grafana = " \
 bash \
 glibc \
 grafana-selinux \
 shadow-utils \
 shared-mime-info \
 systemd \
 "
RDEPENDS:grafana-selinux = " \
 bash \
 policycoreutils-python-utils \
 virtual/selinux-policy-any \
 "
