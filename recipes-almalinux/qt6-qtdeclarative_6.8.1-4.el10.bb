# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtdeclarative"
PV = "6.8.1"
PR = "4.el10"
PACKAGES = " \
 qt6-qtdeclarative \
 qt6-qtdeclarative-devel \
 qt6-qtdeclarative-examples \
 qt6-qtdeclarative-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtdeclarative-6.8.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff0f3d6fdb67bcbddc1c25ec0f80b7d30a39ce997a1436a54842941442a46751"

URI_x86_64_v2_qt6-qtdeclarative = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdeclarative-6.8.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative}"
SRC_URI[x86_64_v2_qt6-qtdeclarative.sha256sum] = "3659a97cc8ba5811346ea9c173ac78b482de775c343993e95c06367c4f652869"

URI_x86_64_v2_qt6-qtdeclarative-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtdeclarative-devel-6.8.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative-devel}"
SRC_URI[x86_64_v2_qt6-qtdeclarative-devel.sha256sum] = "6d3fb91fa0a6ec33863d9505a2fd64f3f85f3e0b3b2b7bf9a249da9558f84c36"

URI_x86_64_v2_qt6-qtdeclarative-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtdeclarative-examples-6.8.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative-examples}"
SRC_URI[x86_64_v2_qt6-qtdeclarative-examples.sha256sum] = "869cc459df99d70e4619dd58992bcb7274b1d623a2af120c1962f929176938d5"

URI_x86_64_v2_qt6-qtdeclarative-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtdeclarative-static-6.8.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtdeclarative-static}"
SRC_URI[x86_64_v2_qt6-qtdeclarative-static.sha256sum] = "a01c5c4a4a1051a152dc7595ee6f844fd57ac75e9686759145e0cae0368b7288"

URI_aarch64_qt6-qtdeclarative = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdeclarative-6.8.1-4.el10.aarch64.rpm;name=aarch64_qt6-qtdeclarative;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative}"
SRC_URI[aarch64_qt6-qtdeclarative.sha256sum] = "78410d86aa833ee5648a232fab518684bbfdef092097e394104028e710303bca"

URI_aarch64_qt6-qtdeclarative-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtdeclarative-devel-6.8.1-4.el10.aarch64.rpm;name=aarch64_qt6-qtdeclarative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative-devel}"
SRC_URI[aarch64_qt6-qtdeclarative-devel.sha256sum] = "55ad962c63f5bad8a629f74bcb04fc7434c951a69c241c53cb9ebd3c578931f2"

URI_aarch64_qt6-qtdeclarative-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtdeclarative-examples-6.8.1-4.el10.aarch64.rpm;name=aarch64_qt6-qtdeclarative-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative-examples}"
SRC_URI[aarch64_qt6-qtdeclarative-examples.sha256sum] = "5f50b6e37b8367c60b787c0624ba63d8bfa5803fa4dac1cbcac1c80375cccc80"

URI_aarch64_qt6-qtdeclarative-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtdeclarative-static-6.8.1-4.el10.aarch64.rpm;name=aarch64_qt6-qtdeclarative-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtdeclarative-static}"
SRC_URI[aarch64_qt6-qtdeclarative-static.sha256sum] = "16830e284157b4f4831ae36f218887a9d06411ee17e30b481ee207678d7cfe6c"

RDEPENDS:qt6-qtdeclarative:x86_64_v2 = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
RDEPENDS:qt6-qtdeclarative:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
RDEPENDS:qt6-qtdeclarative-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qtdeclarative-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtdeclarative-static = " \
 cmake-filesystem \
 qt6-qtdeclarative-devel \
 "
