# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "joe"
PV = "4.6"
PR = "22.el10_1"
PACKAGES = " \
 joe \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/joe-4.6-22.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "03cce767e5b57742f5ba99b34eff88334741b8fc6371f68065a3776312a003cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/joe-4.6-22.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_joe;unpack=0"
SRC_URI[x86_64_v2_joe.sha256sum] = "20e0486684baab0f2e047cd097fa5da55e1ef587896f2ebf9566f82b2f788d3b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/joe-4.6-22.el10_1.aarch64.rpm;name=aarch64_joe;unpack=0"
SRC_URI[aarch64_joe.sha256sum] = "7e25ca5a76c06a59436a77aaa47447b32ee9cddb23e4ee69eddb08d2a57b4991"

RDEPENDS:joe = " \
 glibc \
 libselinux \
 ncurses-libs \
 "
