# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scroll"
PV = "0.13.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-scroll+default-devel \
 rust-scroll+derive-devel \
 rust-scroll+std-devel \
 rust-scroll-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scroll-0.13.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c9ca2a8aafb43c1854da9f954629fe4b80b98ab742a6705705b86cabb330878"

URI_x86_64_v2_rust-scroll+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll+default-devel-0.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll+default-devel}"
SRC_URI[x86_64_v2_rust-scroll+default-devel.sha256sum] = "1a001b3b7433699502eb16fe39607218379b0d8bf1ba83ce3032af0a0ff7e0cd"

URI_x86_64_v2_rust-scroll+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll+derive-devel-0.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll+derive-devel}"
SRC_URI[x86_64_v2_rust-scroll+derive-devel.sha256sum] = "b303d6ba99949ad2f2c77f24b7805a712991a18ac81cf902154b479222a60eb5"

URI_x86_64_v2_rust-scroll+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll+std-devel-0.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll+std-devel}"
SRC_URI[x86_64_v2_rust-scroll+std-devel.sha256sum] = "2bcfbb365fbe2df3b85156c3e8b51dd1fb66dc44b3bf8e9c4b686da4a46426aa"

URI_x86_64_v2_rust-scroll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scroll-devel-0.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scroll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scroll-devel}"
SRC_URI[x86_64_v2_rust-scroll-devel.sha256sum] = "638e908a17d561e9a8166db452b7851733cbd2fa514df5185f04a779bc06266a"

URI_aarch64_rust-scroll+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll+default-devel-0.13.0-1.el10_1.noarch.rpm;name=aarch64_rust-scroll+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll+default-devel}"
SRC_URI[aarch64_rust-scroll+default-devel.sha256sum] = "32db08d98149f5cd1730f0332549c25833bdd1bbd393fa5b406059d6caa33d52"

URI_aarch64_rust-scroll+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll+derive-devel-0.13.0-1.el10_1.noarch.rpm;name=aarch64_rust-scroll+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll+derive-devel}"
SRC_URI[aarch64_rust-scroll+derive-devel.sha256sum] = "5a4082ef741dd9ad2112b428d46d683c6ab443e8bad88a74929a5dc54f3d6cd8"

URI_aarch64_rust-scroll+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll+std-devel-0.13.0-1.el10_1.noarch.rpm;name=aarch64_rust-scroll+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll+std-devel}"
SRC_URI[aarch64_rust-scroll+std-devel.sha256sum] = "5a2bedd0f3ca96f013b4f5c8321137bb6b1b86d1a477bb5c08c5c347b1dbb0b5"

URI_aarch64_rust-scroll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scroll-devel-0.13.0-1.el10_1.noarch.rpm;name=aarch64_rust-scroll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scroll-devel}"
SRC_URI[aarch64_rust-scroll-devel.sha256sum] = "81cd9fdac130a9cac9107e6745b5d600033fd451368cf51bc9f1d1ce9332cf5b"

RDEPENDS:rust-scroll+default-devel = " \
 cargo \
 rust-scroll+std-devel \
 rust-scroll-devel \
 "
RDEPENDS:rust-scroll+derive-devel = " \
 cargo \
 rust-scroll-devel \
 rust-scroll_derive+default-devel \
 "
RDEPENDS:rust-scroll+std-devel = " \
 cargo \
 rust-scroll-devel \
 "
RDEPENDS:rust-scroll-devel = " \
 cargo \
 rust \
 "
