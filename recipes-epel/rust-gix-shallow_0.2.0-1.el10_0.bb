# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-shallow"
PV = "0.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-shallow+default-devel \
 rust-gix-shallow+serde-devel \
 rust-gix-shallow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-shallow-0.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21e011b86c7975d02f08aa041edc319bc13c788dbdceb65169a164f426ae7f98"

URI_x86_64_v2_rust-gix-shallow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+default-devel-0.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+default-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+default-devel.sha256sum] = "cc0ca799b7b588d1ab1bb1244ec31a4097846b67fdd066f855fa553b749c727f"

URI_x86_64_v2_rust-gix-shallow+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow+serde-devel-0.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow+serde-devel.sha256sum] = "41836538abdd6473f6d22b1947b2209bb447473de49a80b1d06dac4eb321a892"

URI_x86_64_v2_rust-gix-shallow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-shallow-devel-0.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-shallow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-shallow-devel}"
SRC_URI[x86_64_v2_rust-gix-shallow-devel.sha256sum] = "526151b62d69d42a648e2aa40042db0516e03a2ff4f64a33d0b655af9852d6fc"

URI_aarch64_rust-gix-shallow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+default-devel-0.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-shallow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+default-devel}"
SRC_URI[aarch64_rust-gix-shallow+default-devel.sha256sum] = "6496eceae94b9c5e6296b695364cb63569bd43911b2049d98bab84c124f99f57"

URI_aarch64_rust-gix-shallow+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow+serde-devel-0.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-shallow+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow+serde-devel}"
SRC_URI[aarch64_rust-gix-shallow+serde-devel.sha256sum] = "0285d3e301c81f20bb509503e49ecf0306333320b19b589f699ba52262507f00"

URI_aarch64_rust-gix-shallow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-shallow-devel-0.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-shallow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-shallow-devel}"
SRC_URI[aarch64_rust-gix-shallow-devel.sha256sum] = "bb3d3096ee1c5b04aaa80b0fdeaed3c46fe3c03c526adf07de291f70176836d3"

RDEPENDS:rust-gix-shallow+default-devel = " \
 cargo \
 rust-gix-shallow-devel \
 "
RDEPENDS:rust-gix-shallow+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-shallow-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-shallow-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-thiserror+default-devel \
 "
