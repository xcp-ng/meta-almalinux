# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grubby"
PV = "8.40"
PR = "77.el10"
PACKAGES = " \
 grubby \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/grubby-8.40-77.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ec2b61541f2619824d3a415a17db614abdd0811c8838349011f61e6f68cd150"

URI_x86_64_v2_grubby = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grubby-8.40-77.el10.x86_64_v2.rpm;name=x86_64_v2_grubby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grubby}"
SRC_URI[x86_64_v2_grubby.sha256sum] = "cb41b7cc7b9f673867d7b2a1b7586283878d9e28ad3c7249fe643123a2af65e9"

URI_aarch64_grubby = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grubby-8.40-77.el10.aarch64.rpm;name=aarch64_grubby;unpack=0"
SRC_URI:append = " ${URI_aarch64_grubby}"
SRC_URI[aarch64_grubby.sha256sum] = "110a88222e54a99d65c36c59e05f8f46ece177baf569cd9683fc02004426aba9"

RDEPENDS:grubby = " \
 bash \
 findutils \
 grub2-tools \
 grub2-tools-minimal \
 util-linux \
 "
