# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-task"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-task+alloc-devel \
 rust-futures-task+cfg-target-has-atomic-devel \
 rust-futures-task+default-devel \
 rust-futures-task+std-devel \
 rust-futures-task+unstable-devel \
 rust-futures-task-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-task-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f2f1bd6fabda9272c05cf3d2e387169adf7888c2fbf6f8917e3305578a10a5b"

URI_x86_64_v2_rust-futures-task+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+alloc-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-task+alloc-devel.sha256sum] = "dfd78161f1d0266bc8293d2a5c0b14cc76209b74c7a48bb9bb239106c543c619"

URI_x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+cfg-target-has-atomic-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-task+cfg-target-has-atomic-devel.sha256sum] = "f4703f0f2a77111b333bd55bed7e68434038441bb1a02b3b56da390175034cef"

URI_x86_64_v2_rust-futures-task+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+default-devel}"
SRC_URI[x86_64_v2_rust-futures-task+default-devel.sha256sum] = "041d607b17ce0480a04ee7beab9b34731350732e095b7cfdfbcd9f441e1fe1a7"

URI_x86_64_v2_rust-futures-task+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+std-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+std-devel}"
SRC_URI[x86_64_v2_rust-futures-task+std-devel.sha256sum] = "f7e0dfc25945ef14f8208db0e50a0b30698a583d2cd4be5713dd7ce147f02b49"

URI_x86_64_v2_rust-futures-task+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task+unstable-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-task+unstable-devel.sha256sum] = "a4826937acaaf70275430b9854b9033d0a90f7ca53888ed640933d87161178db"

URI_x86_64_v2_rust-futures-task-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-task-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-task-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-task-devel}"
SRC_URI[x86_64_v2_rust-futures-task-devel.sha256sum] = "2e0a4b0903df4fed2cbe24adb4d14af4475d3acae833fd571131f398169a9203"

URI_aarch64_rust-futures-task+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+alloc-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-task+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+alloc-devel}"
SRC_URI[aarch64_rust-futures-task+alloc-devel.sha256sum] = "292ed1ac8276a0431465cde42df607aa2be60f970ecf45b0f12e1036f14c8739"

URI_aarch64_rust-futures-task+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+cfg-target-has-atomic-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-task+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-task+cfg-target-has-atomic-devel.sha256sum] = "13896866f72a00692e6907222cf6aab773ed1051ce2d9ca9bff10836dff0e4ca"

URI_aarch64_rust-futures-task+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-task+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+default-devel}"
SRC_URI[aarch64_rust-futures-task+default-devel.sha256sum] = "282d56d11ecdd9bd3d46921b0f024f104d2874575d5e71c35484825a713374f8"

URI_aarch64_rust-futures-task+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+std-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-task+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+std-devel}"
SRC_URI[aarch64_rust-futures-task+std-devel.sha256sum] = "d7821c5fc17a8b80a0b687ab22f78ffdf7a2b9fdfb44e7eccabc277386d400eb"

URI_aarch64_rust-futures-task+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task+unstable-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-task+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task+unstable-devel}"
SRC_URI[aarch64_rust-futures-task+unstable-devel.sha256sum] = "cf986b715069dab274038bbe2770901f47ac8d4ed977c177e494dd1a810a1ab1"

URI_aarch64_rust-futures-task-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-task-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-task-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-task-devel}"
SRC_URI[aarch64_rust-futures-task-devel.sha256sum] = "a0d53dfeac5560da4188f434fe24d85fb6f850e9a24c6eb45d6428a049eded5a"

RDEPENDS:rust-futures-task+alloc-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+default-devel = " \
 cargo \
 rust-futures-task+std-devel \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+std-devel = " \
 cargo \
 rust-futures-task+alloc-devel \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task+unstable-devel = " \
 cargo \
 rust-futures-task-devel \
 "
RDEPENDS:rust-futures-task-devel = " \
 cargo \
 rust \
 "
