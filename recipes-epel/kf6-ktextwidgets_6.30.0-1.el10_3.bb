# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktextwidgets"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ktextwidgets \
 kf6-ktextwidgets-devel \
 kf6-ktextwidgets-doc \
 kf6-ktextwidgets-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-ktextwidgets-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d77b9a504cb63ecd954efed23f4c509f6e770a34c0fceb267ad90530342b846"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktextwidgets;unpack=0"
SRC_URI[x86_64_v2_kf6-ktextwidgets.sha256sum] = "d510c2c684d9c62373d3ad3ef19b986b2b8433d8a5eb280f3f4d7f25a2dccbc1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktextwidgets-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-ktextwidgets-devel.sha256sum] = "967e4bc9381edef64617c040f1bb06ff533f1e16a0c60f9697f0fe26c0480d47"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktextwidgets-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-ktextwidgets-doc.sha256sum] = "9daa5492acf71de7c8c105543cfcefbc00456cff002ce554fb93409c6b414eb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktextwidgets-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktextwidgets-html;unpack=0"
SRC_URI[x86_64_v2_kf6-ktextwidgets-html.sha256sum] = "67a8b6251a703af107a5fa56a1ca61394243ed5054fe4ff3f620ab1ecf0c69c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktextwidgets;unpack=0"
SRC_URI[aarch64_kf6-ktextwidgets.sha256sum] = "5d10f6dc73854b96b91f4667eec646f5fcd9fce3f88f3de359796d5bb8731fe7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ktextwidgets-devel;unpack=0"
SRC_URI[aarch64_kf6-ktextwidgets-devel.sha256sum] = "91f4fcee7882e34cc1bacd9699e712df8c38144a0bfec068020a47273b23f539"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktextwidgets-doc;unpack=0"
SRC_URI[aarch64_kf6-ktextwidgets-doc.sha256sum] = "1723c2eb89e51ca377d7786d38e01c430f21a9e4cbd3680f6bde400e5f7cb18c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktextwidgets-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ktextwidgets-html;unpack=0"
SRC_URI[aarch64_kf6-ktextwidgets-html.sha256sum] = "f6818d64782b7c22fd985691bb9d9dcc6b2ab49e382d1cbfe22b63415cb217c3"

RDEPENDS:kf6-ktextwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtspeech \
 "
RDEPENDS:kf6-ktextwidgets-devel = " \
 cmake-filesystem \
 glibc \
 kf6-ki18n-devel \
 kf6-ktextwidgets \
 kf6-sonnet-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-ktextwidgets-doc = " \
 "
RDEPENDS:kf6-ktextwidgets-html = " \
 "
