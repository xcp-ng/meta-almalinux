# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua"
PV = "5.4.8"
PR = "1.el10"
PACKAGES = " \
 lua \
 lua-devel \
 lua-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lua-5.4.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7550c1de82c0822809f028ed3b47aa479152dba5c26828d581e04a2b6175792"

URI_x86_64_v2_lua = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lua-5.4.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua}"
SRC_URI[x86_64_v2_lua.sha256sum] = "22a54f8887d3dd760912db87726b640ff9875e88b5f733a72b3d4a28ea23b2cf"
RPROVIDES:lua:x86_64_v2 = "virtual/lua"

URI_x86_64_v2_lua-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/lua-devel-5.4.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_lua-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-devel}"
SRC_URI[x86_64_v2_lua-devel.sha256sum] = "59dc4cd9ecc6358046e92e9dada1f9211e457a52b2fa0172492e889f50fb4222"

URI_x86_64_v2_lua-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lua-libs-5.4.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_lua-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-libs}"
SRC_URI[x86_64_v2_lua-libs.sha256sum] = "f573267247c4b1896900ae2a128495fa8b875950571c5123103335b2d9aacb6c"

URI_aarch64_lua = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lua-5.4.8-1.el10.aarch64.rpm;name=aarch64_lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua}"
SRC_URI[aarch64_lua.sha256sum] = "d15edd00d8da536aa7439b45c572a297057d9e256115b9c90ee28ee391e3b5dc"
RPROVIDES:lua:aarch64 = "virtual/lua"

URI_aarch64_lua-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/lua-devel-5.4.8-1.el10.aarch64.rpm;name=aarch64_lua-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-devel}"
SRC_URI[aarch64_lua-devel.sha256sum] = "f916c0fc7f4bd627ba0ef3b073c777d243a028fc3aca17aa45d63f78b2f6942a"

URI_aarch64_lua-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lua-libs-5.4.8-1.el10.aarch64.rpm;name=aarch64_lua-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-libs}"
SRC_URI[aarch64_lua-libs.sha256sum] = "d0eed609100dd19a4b1fa1d31bf0d5c2e11d0cf200fc27f6182f9d735138e9d5"

RDEPENDS:lua = " \
 glibc \
 lua-libs \
 readline \
 "
RDEPENDS:lua-devel = " \
 lua \
 lua-rpm-macros \
 pkgconf-pkg-config \
 "
RDEPENDS:lua-libs = " \
 glibc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/lua"

PROVIDES:append:aarch64 = " rpm/virtual/lua"
