# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oxygen-icon-theme"
PE = "1"
PV = "6.1.0"
PR = "1.el10_0"
PACKAGES = " \
 oxygen-icon-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oxygen-icon-theme-6.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78d0aadf7bf1671d4c0191576cf1a64783e9e689f391f6b41141c43382d0e723"

URI_x86_64_v2_oxygen-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-icon-theme-6.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxygen-icon-theme}"
SRC_URI[x86_64_v2_oxygen-icon-theme.sha256sum] = "f24b76f0263986191edf8727c0e590253acc729c677c2e91056e5192389c0c05"

URI_aarch64_oxygen-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/o/oxygen-icon-theme-6.1.0-1.el10_0.noarch.rpm;name=aarch64_oxygen-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxygen-icon-theme}"
SRC_URI[aarch64_oxygen-icon-theme.sha256sum] = "2ce20b2dc0b0dd4ee16900ccc6b3c4d723bea1cbf2d084258347cd86e828304f"

RDEPENDS:oxygen-icon-theme = " \
 bash \
 hicolor-icon-theme \
 "
