# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi0.24"
PV = "0.24.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-pyo3-ffi0.24+abi3-devel \
 rust-pyo3-ffi0.24+abi3-py310-devel \
 rust-pyo3-ffi0.24+abi3-py311-devel \
 rust-pyo3-ffi0.24+abi3-py312-devel \
 rust-pyo3-ffi0.24+abi3-py313-devel \
 rust-pyo3-ffi0.24+abi3-py37-devel \
 rust-pyo3-ffi0.24+abi3-py38-devel \
 rust-pyo3-ffi0.24+abi3-py39-devel \
 rust-pyo3-ffi0.24+default-devel \
 rust-pyo3-ffi0.24+extension-module-devel \
 rust-pyo3-ffi0.24-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi0.24-0.24.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "074c305af0e4975b63d94098c6e5c364296a0835e405c43d631de1caafe552ce"

URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+abi3-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+abi3-devel.sha256sum] = "ade11f47b877a48933fe594a77ace71f97aae2b1548245157d69a07766685587"

URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+abi3-py310-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+abi3-py310-devel.sha256sum] = "cbc9fca91501bdb1a09f972af3ad906d9cdaf710bc1f147c469789bd0a8ca671"

URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+abi3-py311-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+abi3-py311-devel.sha256sum] = "1e5857d507aca240203f1dc40a100fc8aec4ee41bbcd54c4e18d04a97b734dbe"

URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+abi3-py312-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+abi3-py312-devel.sha256sum] = "ca573465baf9976ca220e70c7c391107cb5e28f2a4ec4012f35eb1ad1703277b"

URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+abi3-py313-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+abi3-py313-devel.sha256sum] = "252feed1cbfbead1f2508fff7d1a7c39a287bec1b25e172d17981641f40e53f7"

URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+abi3-py37-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+abi3-py37-devel.sha256sum] = "0a68408e002c22fd004e0a403f5f3c02d18f1fa093ba0e8e0b5a91d5d161c76d"

URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+abi3-py38-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+abi3-py38-devel.sha256sum] = "399ad9a145faa0e0e2fca730dddd21f696f596f981a267fbef71aea70d63bde0"

URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+abi3-py39-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+abi3-py39-devel.sha256sum] = "687b4cf98edcb169cdeaae62550a9015f98f3b1489b476dd2c16aae36f89d6c6"

URI_x86_64_v2_rust-pyo3-ffi0.24+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+default-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+default-devel.sha256sum] = "5111748422e73492aec8aae4f1d9e46b479ad16a366cce14d8ccd0a4c2f231be"

URI_x86_64_v2_rust-pyo3-ffi0.24+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24+extension-module-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24+extension-module-devel.sha256sum] = "3ce8b38e40cf4bc24b3869c21ede7581ffa5f4f00399f4cbf8ae3722be585179"

URI_x86_64_v2_rust-pyo3-ffi0.24-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.24-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.24-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.24-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.24-devel.sha256sum] = "88a95eff420b61b65e1d305d1b839ff0ab3f588d3315473478c9e323a60494c8"

URI_aarch64_rust-pyo3-ffi0.24+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+abi3-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+abi3-devel.sha256sum] = "5146d8141749772d8e40486a55f42317c8c11f81afaf46981619189a062285d0"

URI_aarch64_rust-pyo3-ffi0.24+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+abi3-py310-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+abi3-py310-devel.sha256sum] = "5a78a94a8e387045459d6bf49e8ef4e60db32fb034b0c1d00ea6f298d5ac8491"

URI_aarch64_rust-pyo3-ffi0.24+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+abi3-py311-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+abi3-py311-devel.sha256sum] = "1df35b434f7c85802bfbdb797cf5fae30cafa0818b4f92a83d93a798cffde64d"

URI_aarch64_rust-pyo3-ffi0.24+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+abi3-py312-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+abi3-py312-devel.sha256sum] = "79380d07ab1114005ed0889f3a7416663e7186640167d6f517738ac32b2d948b"

URI_aarch64_rust-pyo3-ffi0.24+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+abi3-py313-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+abi3-py313-devel.sha256sum] = "5d5e9e940aa7b8a5091b816daa4a4fb0c3b7900da018831dc0dbd08addf5f0f3"

URI_aarch64_rust-pyo3-ffi0.24+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+abi3-py37-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+abi3-py37-devel.sha256sum] = "ce8432661cbbb4d0e662a3318fe0d58a198bf46c3def356ac704484a658f3fb8"

URI_aarch64_rust-pyo3-ffi0.24+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+abi3-py38-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+abi3-py38-devel.sha256sum] = "f354e52edfb60c14f237bdc2c0a385342ede3d145afee20238b588f157166865"

URI_aarch64_rust-pyo3-ffi0.24+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+abi3-py39-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+abi3-py39-devel.sha256sum] = "a28ab509f6cc8c35889945e575305679ee9c43f0920bff3f538eee350c1cf290"

URI_aarch64_rust-pyo3-ffi0.24+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+default-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+default-devel.sha256sum] = "dbb0f187cfa74c431e4385e760bd5578d8a80d21df4fb0c1589b350323b43db5"

URI_aarch64_rust-pyo3-ffi0.24+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24+extension-module-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24+extension-module-devel.sha256sum] = "41693aa6b64faa6e8ddad65b1a72f910829b25204bb0ff74a2021f3d5a142e77"

URI_aarch64_rust-pyo3-ffi0.24-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.24-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-pyo3-ffi0.24-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.24-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.24-devel.sha256sum] = "3c869f9d02e941d9173fc5f88a0d6508c88d047383d4335f02ce454bc3638a74"

RDEPENDS:rust-pyo3-ffi0.24+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py311-devel \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py312-devel \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py313-devel \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24+abi3-py313-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-devel \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py38-devel \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py39-devel \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.24+abi3-py310-devel \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24+default-devel = " \
 cargo \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.24-devel \
 "
RDEPENDS:rust-pyo3-ffi0.24-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config0.24+default-devel \
 rust-pyo3-build-config0.24+resolve-config-devel \
 "
