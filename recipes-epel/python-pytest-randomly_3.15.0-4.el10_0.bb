# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-randomly"
PV = "3.15.0"
PR = "4.el10_0"
PACKAGES = " \
 python3-pytest-randomly \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-randomly-3.15.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8dc225783687f69dcda87e8cf1860b67273d91e56a9727b2d20f7d9cd14aa237"

URI_x86_64_v2_python3-pytest-randomly = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-randomly-3.15.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-randomly;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-randomly}"
SRC_URI[x86_64_v2_python3-pytest-randomly.sha256sum] = "d193a80e8e42d863a5220f992e863ca3f6f179bfd8267fac120ce5d140a35351"

URI_aarch64_python3-pytest-randomly = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-randomly-3.15.0-4.el10_0.noarch.rpm;name=aarch64_python3-pytest-randomly;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-randomly}"
SRC_URI[aarch64_python3-pytest-randomly.sha256sum] = "183d8cc41c82bebea91d11c0a314ea0305f4e9e05f34a6fe454248bc40a8d35f"

RDEPENDS:python3-pytest-randomly = " \
 python3 \
 python3-pytest \
 "
