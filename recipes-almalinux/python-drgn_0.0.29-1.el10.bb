# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-drgn"
PV = "0.0.29"
PR = "1.el10"
PACKAGES = " \
 drgn \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-drgn-0.0.29-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdd706a9dcb4026626faa01d8f57149f13c5744667b0f82ef545d778ac84fcc3"

URI_x86_64_v2_drgn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/drgn-0.0.29-1.el10.x86_64_v2.rpm;name=x86_64_v2_drgn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_drgn}"
SRC_URI[x86_64_v2_drgn.sha256sum] = "948a9b5521496cc0f506e5c661d211bd3af2eb5eecebb22bd29bb54492b798f9"

URI_aarch64_drgn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/drgn-0.0.29-1.el10.aarch64.rpm;name=aarch64_drgn;unpack=0"
SRC_URI:append = " ${URI_aarch64_drgn}"
SRC_URI[aarch64_drgn.sha256sum] = "7a19da1c37f9342e25b9345a6f6309fb7d11e74c53d649fa6bb6ca698dfaaa6c"

RDEPENDS:drgn = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libgcc \
 libgomp \
 libkdumpfile \
 python3 \
 "
