# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Apache-LogFormat-Compiler"
PV = "0.36"
PR = "16.el10_0"
PACKAGES = " \
 perl-Apache-LogFormat-Compiler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Apache-LogFormat-Compiler-0.36-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c998122d8a07b97defabaa752684a38b625f41b90a2db1f4b1463192e8c11534"

URI_x86_64_v2_perl-Apache-LogFormat-Compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Apache-LogFormat-Compiler-0.36-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Apache-LogFormat-Compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Apache-LogFormat-Compiler}"
SRC_URI[x86_64_v2_perl-Apache-LogFormat-Compiler.sha256sum] = "ffe652e24e47d29d253fd7ce3b0157eb21652881ee936856c8068006e6105098"

URI_aarch64_perl-Apache-LogFormat-Compiler = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Apache-LogFormat-Compiler-0.36-16.el10_0.noarch.rpm;name=aarch64_perl-Apache-LogFormat-Compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Apache-LogFormat-Compiler}"
SRC_URI[aarch64_perl-Apache-LogFormat-Compiler.sha256sum] = "3b0352e61c9cbccf26055534bd74e17568b9429bd216cf83fafc1352968b2276"

RDEPENDS:perl-Apache-LogFormat-Compiler = " \
 perl-Carp \
 perl-POSIX-strftime-Compiler \
 perl-constant \
 perl-libs \
 "
