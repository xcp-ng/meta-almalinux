# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-tencent-cos"
PV = "2.0.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-reqsign-tencent-cos+default-devel \
 rust-reqsign-tencent-cos-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-tencent-cos-2.0.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6a2c03d30a96723aa275416c19bd59652b60162d3bd7f96b20838dabcd2cbdb"

URI_x86_64_v2_rust-reqsign-tencent-cos+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-tencent-cos+default-devel-2.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-tencent-cos+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-tencent-cos+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-tencent-cos+default-devel.sha256sum] = "a2161101afe663628f59c419e92c55a47b38508cba04323ed3be3d03aba1b7f6"

URI_x86_64_v2_rust-reqsign-tencent-cos-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-tencent-cos-devel-2.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-tencent-cos-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-tencent-cos-devel}"
SRC_URI[x86_64_v2_rust-reqsign-tencent-cos-devel.sha256sum] = "af93eaccfbae430fd35c91adc49b71177e2c6515ce32ff1841e1f789ede784ea"

URI_aarch64_rust-reqsign-tencent-cos+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-tencent-cos+default-devel-2.0.1-2.el10_1.noarch.rpm;name=aarch64_rust-reqsign-tencent-cos+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-tencent-cos+default-devel}"
SRC_URI[aarch64_rust-reqsign-tencent-cos+default-devel.sha256sum] = "1498fdcb05597b0faf04e779b6345ec072c84bac7882b5346d7fd03ddec1e2ba"

URI_aarch64_rust-reqsign-tencent-cos-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-tencent-cos-devel-2.0.1-2.el10_1.noarch.rpm;name=aarch64_rust-reqsign-tencent-cos-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-tencent-cos-devel}"
SRC_URI[aarch64_rust-reqsign-tencent-cos-devel.sha256sum] = "b4748de51b27608f75b828829ee23a5c19c14a76270e677ee13973ce3d564fe9"

RDEPENDS:rust-reqsign-tencent-cos+default-devel = " \
 cargo \
 rust-reqsign-tencent-cos-devel \
 "
RDEPENDS:rust-reqsign-tencent-cos-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
