# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcomps"
PV = "0.1.21"
PR = "3.el10"
PACKAGES = " \
 libcomps \
 libcomps-devel \
 python3-libcomps \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcomps-0.1.21-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63e2827c4689abca146ca2396b32694ca761aa1011c341b2a010fb93bf9d999a"

URI_x86_64_v2_libcomps = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcomps-0.1.21-3.el10.x86_64_v2.rpm;name=x86_64_v2_libcomps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcomps}"
SRC_URI[x86_64_v2_libcomps.sha256sum] = "1f32a13fcfe5a9acd65cd89bdb852aca9632943fe6cc94e805ab7af20c522a12"

URI_x86_64_v2_libcomps-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libcomps-devel-0.1.21-3.el10.x86_64_v2.rpm;name=x86_64_v2_libcomps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcomps-devel}"
SRC_URI[x86_64_v2_libcomps-devel.sha256sum] = "03cf2553a7ab0f9e8bbed8aa2817518c468d09fc0be78a0515984b6511fb46ab"

URI_x86_64_v2_python3-libcomps = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libcomps-0.1.21-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libcomps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libcomps}"
SRC_URI[x86_64_v2_python3-libcomps.sha256sum] = "b06617fb2d8bc916f96d93a2446f425387a6c6b5d8070ef9a844a4de30d09739"

URI_aarch64_libcomps = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcomps-0.1.21-3.el10.aarch64.rpm;name=aarch64_libcomps;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcomps}"
SRC_URI[aarch64_libcomps.sha256sum] = "dbda46039f36293808a9f39d3dc5cf22ca40aad5e4d130dda52f4a3dae8f6e5d"

URI_aarch64_libcomps-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libcomps-devel-0.1.21-3.el10.aarch64.rpm;name=aarch64_libcomps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcomps-devel}"
SRC_URI[aarch64_libcomps-devel.sha256sum] = "08448ca7ff63453177563439e63ea0093b9a14adaef494cac27e85b47d208c8c"

URI_aarch64_python3-libcomps = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libcomps-0.1.21-3.el10.aarch64.rpm;name=aarch64_python3-libcomps;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libcomps}"
SRC_URI[aarch64_python3-libcomps.sha256sum] = "3b85b031c684e77b801e05139cdc23e6774acfcedda7f30c0f52b999bd447b80"

RDEPENDS:libcomps = " \
 expat \
 glibc \
 libxml2 \
 "
RDEPENDS:libcomps-devel = " \
 expat-devel \
 libcomps \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libcomps = " \
 glibc \
 libcomps \
 python3 \
 python3-libs \
 zlib-ng-compat \
 "
