# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-sdkutils"
PV = "0.2.3"
PR = "2.el10_0"
PACKAGES = " \
 aws-c-sdkutils \
 aws-c-sdkutils-devel \
 aws-c-sdkutils-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-sdkutils-0.2.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86a6014b5258c9372cdf8643b0945ba94ad2c45df6ef451d6449c93409cd34c4"

URI_x86_64_v2_aws-c-sdkutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-sdkutils-0.2.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-sdkutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-sdkutils}"
SRC_URI[x86_64_v2_aws-c-sdkutils.sha256sum] = "259b23d611130daeb3877e480f36d9c139563cc5041096aa38b8a67eb7f07848"

URI_x86_64_v2_aws-c-sdkutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-sdkutils-devel-0.2.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-sdkutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-sdkutils-devel}"
SRC_URI[x86_64_v2_aws-c-sdkutils-devel.sha256sum] = "2fdc503136646a3e1921cce634083764fac8c4a27fdb4e8a7003564739a2cf59"

URI_x86_64_v2_aws-c-sdkutils-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-sdkutils-libs-0.2.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-sdkutils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-sdkutils-libs}"
SRC_URI[x86_64_v2_aws-c-sdkutils-libs.sha256sum] = "b80f3452d6f275b819c10a85153e6bc05017b5dd21d16ff6f6fb17a343515307"

URI_aarch64_aws-c-sdkutils = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-sdkutils-0.2.3-2.el10_0.aarch64.rpm;name=aarch64_aws-c-sdkutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-sdkutils}"
SRC_URI[aarch64_aws-c-sdkutils.sha256sum] = "dc95192eeea62f4b28868dde072b8c7364b37ae14d1231c38cb01f6c8d076014"

URI_aarch64_aws-c-sdkutils-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-sdkutils-devel-0.2.3-2.el10_0.aarch64.rpm;name=aarch64_aws-c-sdkutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-sdkutils-devel}"
SRC_URI[aarch64_aws-c-sdkutils-devel.sha256sum] = "f95a0d118acf93eb8b064a1e032ed2a6002a7d8035a322c1e60c45e6d39a1ecb"

URI_aarch64_aws-c-sdkutils-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-sdkutils-libs-0.2.3-2.el10_0.aarch64.rpm;name=aarch64_aws-c-sdkutils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-sdkutils-libs}"
SRC_URI[aarch64_aws-c-sdkutils-libs.sha256sum] = "3e6220bb74b2d2bd2a82dd0cafc550463d9ddcdad467966d1ab12d309993ee3f"

RDEPENDS:aws-c-sdkutils = " \
 aws-c-common-libs \
 "
RDEPENDS:aws-c-sdkutils-devel = " \
 aws-c-common-devel \
 aws-c-sdkutils-libs \
 cmake-filesystem \
 "
RDEPENDS:aws-c-sdkutils-libs = " \
 aws-c-common-libs \
 aws-c-sdkutils \
 glibc \
 "
