# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana"
PV = "12.4.3"
PR = "1.el10"
PACKAGES = " \
 grafana \
 grafana-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-12.4.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3c504c93261fb1fd6a922eb1d6efce96dbb7dc019cb27e5fc62924077d546b5"

URI_x86_64_v2_grafana = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-12.4.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_grafana;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana}"
SRC_URI[x86_64_v2_grafana.sha256sum] = "b5f7c381305616a9ed4f3cf3695fea34db2f63281cf43201e65658d379925aa0"

URI_x86_64_v2_grafana-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-selinux-12.4.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_grafana-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grafana-selinux}"
SRC_URI[x86_64_v2_grafana-selinux.sha256sum] = "f08f7565e4d1c135a5dba6a05a29289056f3787258f09f2b8388badeba0cd3ce"

URI_aarch64_grafana = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-12.4.3-1.el10.aarch64.rpm;name=aarch64_grafana;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana}"
SRC_URI[aarch64_grafana.sha256sum] = "90d18d602644d425340b5c505f5275998a9a0aaabd4c66f3eadb18ba8ad1fc3a"

URI_aarch64_grafana-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-selinux-12.4.3-1.el10.aarch64.rpm;name=aarch64_grafana-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_grafana-selinux}"
SRC_URI[aarch64_grafana-selinux.sha256sum] = "fc4742d5f7d3b18ab56f8130ce0fd555c3d1c570045ce094755c5a41c2397ce3"

RDEPENDS:grafana = " \
 bash \
 glibc \
 grafana-selinux \
 shadow-utils \
 shared-mime-info \
 systemd \
 "
RDEPENDS:grafana-selinux = " \
 bash \
 policycoreutils-python-utils \
 virtual/selinux-policy-any \
 "
