# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unbound"
PV = "1.25.1"
PR = "1.el10"
PACKAGES = " \
 python3-unbound \
 unbound \
 unbound-anchor \
 unbound-devel \
 unbound-dracut \
 unbound-libs \
 unbound-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/unbound-1.25.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56f8ea34847566a8c00e999a3932eb06c60dcbdaedb28903bc9c71766644e072"

URI_x86_64_v2_python3-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-unbound-1.25.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-unbound}"
SRC_URI[x86_64_v2_python3-unbound.sha256sum] = "50bfe87bd0dce9acbf07c44c6fa227e118ef7a2856c752046dfef7b84b50e23e"

URI_x86_64_v2_unbound = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unbound-1.25.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound}"
SRC_URI[x86_64_v2_unbound.sha256sum] = "5a65a9b34f9cef86e6a0f6f7dd536de922f647616d616da6af85fa73ece4f3c2"

URI_x86_64_v2_unbound-anchor = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unbound-anchor-1.25.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-anchor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-anchor}"
SRC_URI[x86_64_v2_unbound-anchor.sha256sum] = "55e3314dbc06d3c734a59554f85a7d0f1f71b805c223a5bba0d2a6bbf8b91813"

URI_x86_64_v2_unbound-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/unbound-devel-1.25.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-devel}"
SRC_URI[x86_64_v2_unbound-devel.sha256sum] = "1d138c59f2ea14e0cac76acc0373c540c6bf5c5bc8b0945baf971408daa07919"

URI_x86_64_v2_unbound-dracut = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unbound-dracut-1.25.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-dracut}"
SRC_URI[x86_64_v2_unbound-dracut.sha256sum] = "2ae45f975cbc36317e2f62c8df26cfdef7a8733ca5fbf49aebe69dd9c5a73837"

URI_x86_64_v2_unbound-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/unbound-libs-1.25.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-libs}"
SRC_URI[x86_64_v2_unbound-libs.sha256sum] = "22481ba6fe2a128ade80cc6dc99b827c486f3b5e9b7ab48466e2a48634af00ae"

URI_x86_64_v2_unbound-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-utils-1.25.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_unbound-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-utils}"
SRC_URI[x86_64_v2_unbound-utils.sha256sum] = "55364688ccc76486d11777bcb47615ee57ee5b8be690dd83a9f1f2a46d4ef385"

URI_aarch64_python3-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-unbound-1.25.1-1.el10.aarch64.rpm;name=aarch64_python3-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-unbound}"
SRC_URI[aarch64_python3-unbound.sha256sum] = "6a61f6728ece2e15f827f564b82e13277ffaa7e812d8ce2604af3bcf9cd51991"

URI_aarch64_unbound = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unbound-1.25.1-1.el10.aarch64.rpm;name=aarch64_unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound}"
SRC_URI[aarch64_unbound.sha256sum] = "bb6fb0729ff42f4181ba452d6fcb5a1d68012e3c9f43a3a80205fab80ea332b8"

URI_aarch64_unbound-anchor = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unbound-anchor-1.25.1-1.el10.aarch64.rpm;name=aarch64_unbound-anchor;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-anchor}"
SRC_URI[aarch64_unbound-anchor.sha256sum] = "7f417d35c866aac50820e4a102fa61d46e65c85998ea6e3842f9d055e07ae67c"

URI_aarch64_unbound-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/unbound-devel-1.25.1-1.el10.aarch64.rpm;name=aarch64_unbound-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-devel}"
SRC_URI[aarch64_unbound-devel.sha256sum] = "32e4549a85e9e30b225b1688429e70f512b8179eecf1b749fdf2296459077f97"

URI_aarch64_unbound-dracut = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unbound-dracut-1.25.1-1.el10.aarch64.rpm;name=aarch64_unbound-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-dracut}"
SRC_URI[aarch64_unbound-dracut.sha256sum] = "b57f5ac160b47a06f274d2800b7ca1a11f8a5b3a875c963bff8f04d91881c7b2"

URI_aarch64_unbound-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/unbound-libs-1.25.1-1.el10.aarch64.rpm;name=aarch64_unbound-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-libs}"
SRC_URI[aarch64_unbound-libs.sha256sum] = "7f2c9d09d985e5a165762ab199d9faca0d481929c0e0d8076830a5dd7c3218ea"

URI_aarch64_unbound-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-utils-1.25.1-1.el10.aarch64.rpm;name=aarch64_unbound-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-utils}"
SRC_URI[aarch64_unbound-utils.sha256sum] = "176b8a382082a52fd2145cd025f94fc0b54ee9ab0cda1b4aa41c158afe7f4fa6"

RDEPENDS:python3-unbound = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3 \
 python3-libs \
 systemd-libs \
 unbound-libs \
 "
RDEPENDS:unbound = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl \
 openssl-libs \
 protobuf-c \
 python3-libs \
 systemd-libs \
 unbound-anchor \
 unbound-libs \
 "
RDEPENDS:unbound-anchor = " \
 bash \
 expat \
 glibc \
 openssl-libs \
 unbound-libs \
 "
RDEPENDS:unbound-devel = " \
 libevent-devel \
 openssl-devel \
 pkgconf-pkg-config \
 python3-devel \
 unbound-libs \
 "
RDEPENDS:unbound-dracut = " \
 bash \
 dracut \
 unbound \
 "
RDEPENDS:unbound-libs = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3-libs \
 shadow-utils \
 systemd-libs \
 "
RDEPENDS:unbound-utils = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 python3-libs \
 unbound-libs \
 "
