# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Authen-SASL"
PV = "2.1700"
PR = "5.el10"
PACKAGES = " \
 perl-Authen-SASL \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Authen-SASL-2.1700-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4328b2a932fb3a413755acde69feed2eaa7b225c6f8d52d2efc32b9137eff093"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Authen-SASL-2.1700-5.el10.noarch.rpm;name=x86_64_v2_perl-Authen-SASL;unpack=0"
SRC_URI[x86_64_v2_perl-Authen-SASL.sha256sum] = "c859cc9585221cb13fae6ae9030807b324e7ba6588a9f990410d7eac3ab2dea3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Authen-SASL-2.1700-5.el10.noarch.rpm;name=aarch64_perl-Authen-SASL;unpack=0"
SRC_URI[aarch64_perl-Authen-SASL.sha256sum] = "c859cc9585221cb13fae6ae9030807b324e7ba6588a9f990410d7eac3ab2dea3"

RDEPENDS:perl-Authen-SASL = " \
 perl-Carp \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-GSSAPI \
 perl-Tie \
 perl-libs \
 perl-vars \
 "
