# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-lfs"
PV = "3.6.1"
PR = "8.el10_1"
PACKAGES = " \
 git-lfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/git-lfs-3.6.1-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42368267505af93006b7f5559e96460c3f296098aefa02e1e6664d704f025abc"

URI_x86_64_v2_git-lfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/git-lfs-3.6.1-8.el10_1.x86_64_v2.rpm;name=x86_64_v2_git-lfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-lfs}"
SRC_URI[x86_64_v2_git-lfs.sha256sum] = "caabae5ca952bbe20903709aaca67423b56900bca6f026f345f88bff498339f5"

URI_aarch64_git-lfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/git-lfs-3.6.1-8.el10_1.aarch64.rpm;name=aarch64_git-lfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-lfs}"
SRC_URI[aarch64_git-lfs.sha256sum] = "1a5a8ebc6253278ed33166d87fc625631e70a4e0d98ae1d2ab3858bb62e54004"

RDEPENDS:git-lfs = " \
 bash \
 git-core \
 glibc \
 "
