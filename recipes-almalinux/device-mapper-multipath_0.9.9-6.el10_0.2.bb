# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "device-mapper-multipath"
PV = "0.9.9"
PR = "6.el10_0.2"
PACKAGES = " \
 device-mapper-multipath \
 device-mapper-multipath-devel \
 device-mapper-multipath-libs \
 kpartx \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/device-mapper-multipath-0.9.9-6.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "016edacd8f9e756020d9e2054c44ffaaa004a82a203fc32e8ecb5a651ae31b7d"

URI_x86_64_v2_device-mapper-multipath = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath}"
SRC_URI[x86_64_v2_device-mapper-multipath.sha256sum] = "11f142bc711c78f96f6a868d03f0e84aa6e2a59d01068f15b6543128775cc7d4"

URI_x86_64_v2_device-mapper-multipath-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/device-mapper-multipath-devel-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath-devel}"
SRC_URI[x86_64_v2_device-mapper-multipath-devel.sha256sum] = "829a461f51f6de83daaa35518382a1b1b3c75e8db08a9cecda8212ad6067066d"

URI_x86_64_v2_device-mapper-multipath-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/device-mapper-multipath-libs-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_device-mapper-multipath-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_device-mapper-multipath-libs}"
SRC_URI[x86_64_v2_device-mapper-multipath-libs.sha256sum] = "46843f871d45dc7d85bfb6464919277f814d5bd54c7ceefe82a8ab4b51433ce4"

URI_x86_64_v2_kpartx = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kpartx-0.9.9-6.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_kpartx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpartx}"
SRC_URI[x86_64_v2_kpartx.sha256sum] = "5934fbbbef5426eed32b0b40eb614ce95fffc1940d2410c4c54dbd250e663923"

URI_aarch64_device-mapper-multipath = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-0.9.9-6.el10_0.2.aarch64.rpm;name=aarch64_device-mapper-multipath;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath}"
SRC_URI[aarch64_device-mapper-multipath.sha256sum] = "61af824c0333c4c2672c5048801be69cb8dbb56180c7fd0c9adf0060aeb7db85"

URI_aarch64_device-mapper-multipath-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/device-mapper-multipath-devel-0.9.9-6.el10_0.2.aarch64.rpm;name=aarch64_device-mapper-multipath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath-devel}"
SRC_URI[aarch64_device-mapper-multipath-devel.sha256sum] = "c64a4a538759f8a81f2ce4fe96a87ac92b8a60c0fd5d695bb421e029c238ed7a"

URI_aarch64_device-mapper-multipath-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/device-mapper-multipath-libs-0.9.9-6.el10_0.2.aarch64.rpm;name=aarch64_device-mapper-multipath-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_device-mapper-multipath-libs}"
SRC_URI[aarch64_device-mapper-multipath-libs.sha256sum] = "2e241dd035ece996c964b0f7adc2db13016b8336bdc6f9cbcfd01f40e2105aab"

URI_aarch64_kpartx = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kpartx-0.9.9-6.el10_0.2.aarch64.rpm;name=aarch64_kpartx;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpartx}"
SRC_URI[aarch64_kpartx.sha256sum] = "45ae22aa58b3f931c8d8d8fc66112ba085cb31f47c0690a4494e3efed9deb99f"

RDEPENDS:device-mapper-multipath = " \
 bash \
 device-mapper \
 device-mapper-libs \
 device-mapper-multipath-libs \
 glibc \
 kpartx \
 libgcc \
 libmount \
 readline \
 systemd \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:device-mapper-multipath-devel = " \
 device-mapper-multipath \
 device-mapper-multipath-libs \
 "
RDEPENDS:device-mapper-multipath-libs = " \
 device-mapper-libs \
 glibc \
 libaio \
 libgcc \
 libmount \
 systemd-libs \
 userspace-rcu \
 "
RDEPENDS:kpartx = " \
 bash \
 device-mapper-libs \
 glibc \
 "
