# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow"
PV = "57.3.0"
PR = "3.el10_3"
PACKAGES = " \
 rust-arrow+arrow-csv-devel \
 rust-arrow+arrow-ipc-devel \
 rust-arrow+arrow-json-devel \
 rust-arrow+canonical_extension_types-devel \
 rust-arrow+chrono-tz-devel \
 rust-arrow+csv-devel \
 rust-arrow+default-devel \
 rust-arrow+ffi-devel \
 rust-arrow+force_validate-devel \
 rust-arrow+ipc-devel \
 rust-arrow+json-devel \
 rust-arrow+prettyprint-devel \
 rust-arrow+test_utils-devel \
 rust-arrow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-57.3.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0ed046eff015fa6baa7067b6b924bbb6a4f7cb7f4d309a0be5baa01a42e5f09"

URI_x86_64_v2_rust-arrow+arrow-csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+arrow-csv-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+arrow-csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+arrow-csv-devel}"
SRC_URI[x86_64_v2_rust-arrow+arrow-csv-devel.sha256sum] = "92dcbba82e5a22efbf30d5cfbc431b30a4cd763250e922a60e5e7844c1483398"

URI_x86_64_v2_rust-arrow+arrow-ipc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+arrow-ipc-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+arrow-ipc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+arrow-ipc-devel}"
SRC_URI[x86_64_v2_rust-arrow+arrow-ipc-devel.sha256sum] = "e812c9a2181b790b0fcea2bf636d59fbd47474d48c22f92f5886312d92eb4055"

URI_x86_64_v2_rust-arrow+arrow-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+arrow-json-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+arrow-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+arrow-json-devel}"
SRC_URI[x86_64_v2_rust-arrow+arrow-json-devel.sha256sum] = "c54ca5b6fcd04f142f604f8b0a52e5b717ddc513d30a036bfb6f89ebeabcccc0"

URI_x86_64_v2_rust-arrow+canonical_extension_types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+canonical_extension_types-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+canonical_extension_types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+canonical_extension_types-devel}"
SRC_URI[x86_64_v2_rust-arrow+canonical_extension_types-devel.sha256sum] = "2abae1a3be63a73bd71151d715ee1902023210e5bc9abc31f68b0cf7418d90b0"

URI_x86_64_v2_rust-arrow+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+chrono-tz-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-arrow+chrono-tz-devel.sha256sum] = "4914d088b840641d50bdf38a11b3ec96093c1bbd1887cbbf29b7c81643ee4850"

URI_x86_64_v2_rust-arrow+csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+csv-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+csv-devel}"
SRC_URI[x86_64_v2_rust-arrow+csv-devel.sha256sum] = "b140536b2d25651ef026681cebb85eabc7d33aa393389985d1170679f5cf77f0"

URI_x86_64_v2_rust-arrow+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+default-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+default-devel}"
SRC_URI[x86_64_v2_rust-arrow+default-devel.sha256sum] = "b24d5e142367918fabd2207ddd69e888b9f92b11de17aa4850a51d409bbc70f3"

URI_x86_64_v2_rust-arrow+ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+ffi-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+ffi-devel}"
SRC_URI[x86_64_v2_rust-arrow+ffi-devel.sha256sum] = "acf9f4f3d6270c9440ddc2b338c89f19ba9a826be729352ab0f01e9a6028d599"

URI_x86_64_v2_rust-arrow+force_validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+force_validate-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+force_validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+force_validate-devel}"
SRC_URI[x86_64_v2_rust-arrow+force_validate-devel.sha256sum] = "998faf79299216ffa9e711c0b415dff2ad891210f495985d407336b17dce6ca3"

URI_x86_64_v2_rust-arrow+ipc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+ipc-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+ipc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+ipc-devel}"
SRC_URI[x86_64_v2_rust-arrow+ipc-devel.sha256sum] = "f039cb77a47c2b0d276985c61b1932379428e238282ab6b95581f30346b052df"

URI_x86_64_v2_rust-arrow+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+json-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+json-devel}"
SRC_URI[x86_64_v2_rust-arrow+json-devel.sha256sum] = "591a1bec429a1a74b4c2c138bfa082e5027ea4aff7c91d132278ac9c6b22a6f8"

URI_x86_64_v2_rust-arrow+prettyprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+prettyprint-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+prettyprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+prettyprint-devel}"
SRC_URI[x86_64_v2_rust-arrow+prettyprint-devel.sha256sum] = "0962360b96a5d277bc0d0e769636f8850459c708ac13b97820b66096e26b9be1"

URI_x86_64_v2_rust-arrow+test_utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow+test_utils-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow+test_utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow+test_utils-devel}"
SRC_URI[x86_64_v2_rust-arrow+test_utils-devel.sha256sum] = "1f3eb67745af0fa4dfda29ea7493d6471b2cd86b8a57f88a08da6a43104e7ba7"

URI_x86_64_v2_rust-arrow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-devel-57.3.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-devel}"
SRC_URI[x86_64_v2_rust-arrow-devel.sha256sum] = "0f9a73e24f7b11d161732afc8390dc80d57d9c35f7227abc9541b41c554e7fb9"

URI_aarch64_rust-arrow+arrow-csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+arrow-csv-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+arrow-csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+arrow-csv-devel}"
SRC_URI[aarch64_rust-arrow+arrow-csv-devel.sha256sum] = "bde58dfd5e492a023bb966728531e602b888d78fdd48240a15d0ee18130f9699"

URI_aarch64_rust-arrow+arrow-ipc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+arrow-ipc-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+arrow-ipc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+arrow-ipc-devel}"
SRC_URI[aarch64_rust-arrow+arrow-ipc-devel.sha256sum] = "2289f74a2eb56b70a22855b7b3fd4b242ccd073c60e8f7e2155cf6ac9e460293"

URI_aarch64_rust-arrow+arrow-json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+arrow-json-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+arrow-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+arrow-json-devel}"
SRC_URI[aarch64_rust-arrow+arrow-json-devel.sha256sum] = "ea4bc1dc259f5fdeaa7d40f5cbad8fa690a19b2cdb9f6878266a9a47a6ed12d5"

URI_aarch64_rust-arrow+canonical_extension_types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+canonical_extension_types-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+canonical_extension_types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+canonical_extension_types-devel}"
SRC_URI[aarch64_rust-arrow+canonical_extension_types-devel.sha256sum] = "cf6ae87e0ed4e4d8cac13b89983daf8710eba4a23ffc82317716d3fd27f4a34a"

URI_aarch64_rust-arrow+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+chrono-tz-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+chrono-tz-devel}"
SRC_URI[aarch64_rust-arrow+chrono-tz-devel.sha256sum] = "31718666d9fd2acf8d80663b418ad964d52df2a6846415cba768d25261bec8eb"

URI_aarch64_rust-arrow+csv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+csv-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+csv-devel}"
SRC_URI[aarch64_rust-arrow+csv-devel.sha256sum] = "dae17789122a6a3717f035c9d67f63a4cbb2f54063ad518f6144bb7b9802b091"

URI_aarch64_rust-arrow+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+default-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+default-devel}"
SRC_URI[aarch64_rust-arrow+default-devel.sha256sum] = "25416aa6a80aebbf14551a48367b6ec2b5562f7b5b97f26f159101455bf27694"

URI_aarch64_rust-arrow+ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+ffi-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+ffi-devel}"
SRC_URI[aarch64_rust-arrow+ffi-devel.sha256sum] = "c271c7a4f8cb4d76e4aece18936256a5840ed61eee2c7afb7c5999025abb4fff"

URI_aarch64_rust-arrow+force_validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+force_validate-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+force_validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+force_validate-devel}"
SRC_URI[aarch64_rust-arrow+force_validate-devel.sha256sum] = "eb281839fdf4d82fe9dd8acc2f4a1c6068435833cb093b379ff8d32263933f0a"

URI_aarch64_rust-arrow+ipc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+ipc-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+ipc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+ipc-devel}"
SRC_URI[aarch64_rust-arrow+ipc-devel.sha256sum] = "cf0943182f86881fb4c3c4f9902ed0bc0732a342c26705488cd3e581910fe29b"

URI_aarch64_rust-arrow+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+json-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+json-devel}"
SRC_URI[aarch64_rust-arrow+json-devel.sha256sum] = "646fbd2e38506e9defed14bea0bd5a7872d4f3444e9de2d5bca0a029d0fca06f"

URI_aarch64_rust-arrow+prettyprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+prettyprint-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+prettyprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+prettyprint-devel}"
SRC_URI[aarch64_rust-arrow+prettyprint-devel.sha256sum] = "5987decfe98e99ad79f41244d5185e60b4be5971dba08e4a374ed2cb68eb7ad9"

URI_aarch64_rust-arrow+test_utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow+test_utils-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow+test_utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow+test_utils-devel}"
SRC_URI[aarch64_rust-arrow+test_utils-devel.sha256sum] = "c5c886d3d0c19ce2182a18c08755ba61b04cfe5e62b5c8cbfb3a2505e73c8f4c"

URI_aarch64_rust-arrow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-devel-57.3.0-3.el10_3.noarch.rpm;name=aarch64_rust-arrow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-devel}"
SRC_URI[aarch64_rust-arrow-devel.sha256sum] = "7b7cecac27fac0b3fea298e7bdfa1dd3af5e68c03e9298ec0f58b1c0caa25765"

RDEPENDS:rust-arrow+arrow-csv-devel = " \
 cargo \
 rust-arrow-csv+default-devel \
 rust-arrow-devel \
 "
RDEPENDS:rust-arrow+arrow-ipc-devel = " \
 cargo \
 rust-arrow-devel \
 rust-arrow-ipc+default-devel \
 "
RDEPENDS:rust-arrow+arrow-json-devel = " \
 cargo \
 rust-arrow-devel \
 rust-arrow-json+default-devel \
 "
RDEPENDS:rust-arrow+canonical_extension_types-devel = " \
 cargo \
 rust-arrow-devel \
 rust-arrow-schema+canonical_extension_types-devel \
 "
RDEPENDS:rust-arrow+chrono-tz-devel = " \
 cargo \
 rust-arrow-array+chrono-tz-devel \
 rust-arrow-devel \
 "
RDEPENDS:rust-arrow+csv-devel = " \
 cargo \
 rust-arrow+arrow-csv-devel \
 rust-arrow-devel \
 "
RDEPENDS:rust-arrow+default-devel = " \
 cargo \
 rust-arrow+csv-devel \
 rust-arrow+ipc-devel \
 rust-arrow+json-devel \
 rust-arrow-devel \
 "
RDEPENDS:rust-arrow+ffi-devel = " \
 cargo \
 rust-arrow-array+ffi-devel \
 rust-arrow-data+ffi-devel \
 rust-arrow-devel \
 rust-arrow-schema+ffi-devel \
 "
RDEPENDS:rust-arrow+force_validate-devel = " \
 cargo \
 rust-arrow-array+force_validate-devel \
 rust-arrow-data+force_validate-devel \
 rust-arrow-devel \
 "
RDEPENDS:rust-arrow+ipc-devel = " \
 cargo \
 rust-arrow+arrow-ipc-devel \
 rust-arrow-devel \
 "
RDEPENDS:rust-arrow+json-devel = " \
 cargo \
 rust-arrow+arrow-json-devel \
 rust-arrow-devel \
 "
RDEPENDS:rust-arrow+prettyprint-devel = " \
 cargo \
 rust-arrow-cast+prettyprint-devel \
 rust-arrow-devel \
 "
RDEPENDS:rust-arrow+test_utils-devel = " \
 cargo \
 rust-arrow-devel \
 rust-half-devel \
 rust-rand0.9+std-devel \
 rust-rand0.9+std_rng-devel \
 rust-rand0.9+thread_rng-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-arrow-devel = " \
 cargo \
 rust \
 rust-arrow-arith+default-devel \
 rust-arrow-array+default-devel \
 rust-arrow-buffer+default-devel \
 rust-arrow-cast+default-devel \
 rust-arrow-data+default-devel \
 rust-arrow-ord+default-devel \
 rust-arrow-row+default-devel \
 rust-arrow-schema+default-devel \
 rust-arrow-select+default-devel \
 rust-arrow-string+default-devel \
 "
