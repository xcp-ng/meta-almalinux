# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-gen"
PV = "0.7.200"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxx-gen+default-devel \
 rust-cxx-gen-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-gen-0.7.200-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "918fd347968db8fd2b3a5397c0184f0bb686c24a296761c34d974bbc3cac9956"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen+default-devel-0.7.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx-gen+default-devel.sha256sum] = "0631e135d33311b278d938e1198fd598ca8ff75b5fee48245b36e7c941082a10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen-devel-0.7.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxx-gen-devel.sha256sum] = "bdb180f18922c842794b4ee76441ec05452e230015ec3463008566ee76558477"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen+default-devel-0.7.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-gen+default-devel;unpack=0"
SRC_URI[aarch64_rust-cxx-gen+default-devel.sha256sum] = "f981179923e3db4c6efc7baf31f58c5821f867e855571302407173055d5a1829"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen-devel-0.7.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxx-gen-devel;unpack=0"
SRC_URI[aarch64_rust-cxx-gen-devel.sha256sum] = "55d073497567af5187d5bea1a3dff90aeb775ad13c7445e3acdda316b4764e04"

RDEPENDS:rust-cxx-gen+default-devel = " \
 cargo \
 rust-cxx-gen-devel \
 "
RDEPENDS:rust-cxx-gen-devel = " \
 cargo \
 rust \
 rust-codespan-reporting+default-devel \
 rust-indexmap+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
