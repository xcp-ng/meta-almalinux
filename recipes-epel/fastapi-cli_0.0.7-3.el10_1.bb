# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastapi-cli"
PV = "0.0.7"
PR = "3.el10_1"
PACKAGES = " \
 fastapi-cli \
 fastapi-cli+standard \
 fastapi-cli-slim \
 fastapi-cli-slim+standard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fastapi-cli-0.0.7-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "301849281347b8f9f237dbc752a11ad5d0c236ca2c0fc52081f430a4781b119d"

URI_x86_64_v2_fastapi-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastapi-cli-0.0.7-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fastapi-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fastapi-cli}"
SRC_URI[x86_64_v2_fastapi-cli.sha256sum] = "fa0c98b638c4e3c20f5b598515cf89b1032f9ba15c38132bcfa630531fb34a92"

URI_x86_64_v2_fastapi-cli+standard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastapi-cli+standard-0.0.7-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fastapi-cli+standard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fastapi-cli+standard}"
SRC_URI[x86_64_v2_fastapi-cli+standard.sha256sum] = "e22b95b31544cdd246eb4eb2725e91c1ec45b17f665ea49b57a5df9c58028b30"

URI_x86_64_v2_fastapi-cli-slim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastapi-cli-slim-0.0.7-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fastapi-cli-slim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fastapi-cli-slim}"
SRC_URI[x86_64_v2_fastapi-cli-slim.sha256sum] = "2d076455e47ebd834f8bd77500bf8363fcfca003bd5e6bae2744565c140a5ea2"

URI_x86_64_v2_fastapi-cli-slim+standard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastapi-cli-slim+standard-0.0.7-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fastapi-cli-slim+standard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fastapi-cli-slim+standard}"
SRC_URI[x86_64_v2_fastapi-cli-slim+standard.sha256sum] = "4c66ff9e3705d367523bb0a614c6780c39bc1ea89063e0f91d34a1239bb97532"

URI_aarch64_fastapi-cli = "${EPEL_MIRROR}/aarch64/Packages/f/fastapi-cli-0.0.7-3.el10_1.noarch.rpm;name=aarch64_fastapi-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastapi-cli}"
SRC_URI[aarch64_fastapi-cli.sha256sum] = "1c6245ca9affeb396ea98c17d23118afa2b7bb652e7bc850010b412c74342c4c"

URI_aarch64_fastapi-cli+standard = "${EPEL_MIRROR}/aarch64/Packages/f/fastapi-cli+standard-0.0.7-3.el10_1.noarch.rpm;name=aarch64_fastapi-cli+standard;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastapi-cli+standard}"
SRC_URI[aarch64_fastapi-cli+standard.sha256sum] = "da75bb693fa557bbd9d3e5dd1a39ea03c4bcb7ed0b0ed5d36391a3604b8bef50"

URI_aarch64_fastapi-cli-slim = "${EPEL_MIRROR}/aarch64/Packages/f/fastapi-cli-slim-0.0.7-3.el10_1.noarch.rpm;name=aarch64_fastapi-cli-slim;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastapi-cli-slim}"
SRC_URI[aarch64_fastapi-cli-slim.sha256sum] = "68269b6922518e9905f24cc1323b33da2905d66daa9226631dc3d89389d3caab"

URI_aarch64_fastapi-cli-slim+standard = "${EPEL_MIRROR}/aarch64/Packages/f/fastapi-cli-slim+standard-0.0.7-3.el10_1.noarch.rpm;name=aarch64_fastapi-cli-slim+standard;unpack=0"
SRC_URI:append = " ${URI_aarch64_fastapi-cli-slim+standard}"
SRC_URI[aarch64_fastapi-cli-slim+standard.sha256sum] = "64134b0793d2f89f8818e9ba2ced6b9857b63a6fdb810313b4492025662807b6"

RDEPENDS:fastapi-cli = " \
 fastapi-cli-slim \
 python3 \
 python3-rich-toolkit \
 python3-typer \
 python3-uvicorn \
 python3-uvicorn+standard \
 "
RDEPENDS:fastapi-cli+standard = " \
 fastapi-cli \
 python3 \
 python3-uvicorn \
 python3-uvicorn+standard \
 "
RDEPENDS:fastapi-cli-slim = " \
 python3 \
 python3-rich-toolkit \
 python3-typer \
 python3-uvicorn \
 python3-uvicorn+standard \
 "
RDEPENDS:fastapi-cli-slim+standard = " \
 fastapi-cli-slim \
 python3 \
 python3-uvicorn \
 python3-uvicorn+standard \
 "
