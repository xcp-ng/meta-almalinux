# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdsh"
PV = "2.36"
PR = "3.el10_3"
PACKAGES = " \
 pdsh \
 pdsh-mod-dshgroup \
 pdsh-mod-genders \
 pdsh-mod-netgroup \
 pdsh-mod-slurm \
 pdsh-rcmd-rsh \
 pdsh-rcmd-ssh \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pdsh-2.36-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7c27f98d3a6044c721415bb35b99da37199dfa04ec7bd8872ece67a2f6d8159e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdsh-2.36-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdsh;unpack=0"
SRC_URI[x86_64_v2_pdsh.sha256sum] = "f483d0e9b04ca06c5f3fce5e3e88ae851a2d81db819494525cdebbf3fed94171"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdsh-mod-dshgroup-2.36-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdsh-mod-dshgroup;unpack=0"
SRC_URI[x86_64_v2_pdsh-mod-dshgroup.sha256sum] = "c4bb9e17241c1d4cd324b7a4a429a4fcbfab370acef047a6134eba32e3bd9361"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdsh-mod-genders-2.36-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdsh-mod-genders;unpack=0"
SRC_URI[x86_64_v2_pdsh-mod-genders.sha256sum] = "4112b9ea42d276f5051fd837da216e8d7f17ab4fa29fa0203ad7f67b5d98a1cb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdsh-mod-netgroup-2.36-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdsh-mod-netgroup;unpack=0"
SRC_URI[x86_64_v2_pdsh-mod-netgroup.sha256sum] = "3fd767d64dbe44c0ad79cf0c9c2b1f0852567894fe7abcc25205989f5919ea59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdsh-mod-slurm-2.36-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdsh-mod-slurm;unpack=0"
SRC_URI[x86_64_v2_pdsh-mod-slurm.sha256sum] = "26d5a590695a8d44825f960a35c9e92a09aaa58261cfe86ae81652f0c606fd18"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdsh-rcmd-rsh-2.36-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdsh-rcmd-rsh;unpack=0"
SRC_URI[x86_64_v2_pdsh-rcmd-rsh.sha256sum] = "d101962b0ba4a53af95eff4dabee7a8dc8fe2c97e0e4e64c2f9d8f1c84b19e5c"
RPROVIDES:pdsh-rcmd-rsh:append:x86_64_v2 = " virtual/pdsh-rcmd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdsh-rcmd-ssh-2.36-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pdsh-rcmd-ssh;unpack=0"
SRC_URI[x86_64_v2_pdsh-rcmd-ssh.sha256sum] = "d7418ad96ea8f79e8cbeb623c40abbef51b907d3b6a7aefe36c34cf75f6271c0"
RPROVIDES:pdsh-rcmd-ssh:append:x86_64_v2 = " virtual/pdsh-rcmd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pdsh-2.36-3.el10_3.aarch64.rpm;name=aarch64_pdsh;unpack=0"
SRC_URI[aarch64_pdsh.sha256sum] = "aa6e2d28b5d853fb21cd06835d12a1e93db728648e368967649d802eb287d5f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pdsh-mod-dshgroup-2.36-3.el10_3.aarch64.rpm;name=aarch64_pdsh-mod-dshgroup;unpack=0"
SRC_URI[aarch64_pdsh-mod-dshgroup.sha256sum] = "992c81e4af520bf224d101652636e27bd385aae3db070d5b3b6cb9ad40895ff5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pdsh-mod-genders-2.36-3.el10_3.aarch64.rpm;name=aarch64_pdsh-mod-genders;unpack=0"
SRC_URI[aarch64_pdsh-mod-genders.sha256sum] = "ab25581719fb49b295c9b8b1b9daa2f831555d6993085336b64b7b73c14c2579"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pdsh-mod-netgroup-2.36-3.el10_3.aarch64.rpm;name=aarch64_pdsh-mod-netgroup;unpack=0"
SRC_URI[aarch64_pdsh-mod-netgroup.sha256sum] = "41c8d7c42242b318c03b3b7578749b4e9ce2b8e01884f36b322d612dae4e58d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pdsh-mod-slurm-2.36-3.el10_3.aarch64.rpm;name=aarch64_pdsh-mod-slurm;unpack=0"
SRC_URI[aarch64_pdsh-mod-slurm.sha256sum] = "ae21239dbac9c3eca94c9c1ee263b1123ea82764cfdeffac5d36a7f65ead9a2c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pdsh-rcmd-rsh-2.36-3.el10_3.aarch64.rpm;name=aarch64_pdsh-rcmd-rsh;unpack=0"
SRC_URI[aarch64_pdsh-rcmd-rsh.sha256sum] = "c32fa22e742ea7776275513d7a96c33584d1c79b7a919df8466fe87fd274500e"
RPROVIDES:pdsh-rcmd-rsh:append:aarch64 = " virtual/pdsh-rcmd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pdsh-rcmd-ssh-2.36-3.el10_3.aarch64.rpm;name=aarch64_pdsh-rcmd-ssh;unpack=0"
SRC_URI[aarch64_pdsh-rcmd-ssh.sha256sum] = "917746dd322a1f6195626ea5c7485d56439ac88662242b9c2d8d466c0997030f"
RPROVIDES:pdsh-rcmd-ssh:append:aarch64 = " virtual/pdsh-rcmd"

RDEPENDS:pdsh = " \
 glibc \
 perl-File-Basename \
 perl-File-Path \
 perl-Getopt-Std \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 readline \
 virtual/pdsh-rcmd \
 "
RDEPENDS:pdsh-mod-dshgroup = " \
 glibc \
 pdsh \
 "
RDEPENDS:pdsh-mod-genders = " \
 genders \
 glibc \
 libgenders \
 pdsh \
 "
RDEPENDS:pdsh-mod-netgroup = " \
 glibc \
 pdsh \
 "
RDEPENDS:pdsh-mod-slurm = " \
 glibc \
 pdsh \
 slurm \
 slurm-libs \
 "
RDEPENDS:pdsh-rcmd-rsh = " \
 glibc \
 pdsh \
 "
RDEPENDS:pdsh-rcmd-ssh = " \
 glibc \
 openssh-clients \
 pdsh \
 "
