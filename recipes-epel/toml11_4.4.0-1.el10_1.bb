# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "toml11"
PV = "4.4.0"
PR = "1.el10_1"
PACKAGES = " \
 toml11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/toml11-4.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4d70976c77bb484d253bff610d0cda851952dc050cf7148b8db59538317f364"

URI_x86_64_v2_toml11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/toml11-devel-4.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_toml11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_toml11-devel}"
SRC_URI[x86_64_v2_toml11-devel.sha256sum] = "ad68b550e125cbec520de06152cb0894a6b5c72740ec930f19d316615f75dd22"

URI_aarch64_toml11-devel = "${EPEL_MIRROR}/aarch64/Packages/t/toml11-devel-4.4.0-1.el10_1.aarch64.rpm;name=aarch64_toml11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_toml11-devel}"
SRC_URI[aarch64_toml11-devel.sha256sum] = "3908b5390378262e8d35898dfadd25342b18bc596c61428ac53d09b208dcea36"

RDEPENDS:toml11-devel = " \
 cmake-filesystem \
 "
