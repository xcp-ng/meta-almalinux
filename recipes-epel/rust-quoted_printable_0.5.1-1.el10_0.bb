# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quoted_printable"
PV = "0.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-quoted_printable+default-devel \
 rust-quoted_printable+std-devel \
 rust-quoted_printable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quoted_printable-0.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f2441e075157b158d8e1bc12e73600c975375a40e3f19a1a9d8c59bb56f7938"

URI_x86_64_v2_rust-quoted_printable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quoted_printable+default-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quoted_printable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quoted_printable+default-devel}"
SRC_URI[x86_64_v2_rust-quoted_printable+default-devel.sha256sum] = "c8f6cc217947ac1d9ddf9483b101e95f3b926071cefc0467581fc8010410a723"

URI_x86_64_v2_rust-quoted_printable+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quoted_printable+std-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quoted_printable+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quoted_printable+std-devel}"
SRC_URI[x86_64_v2_rust-quoted_printable+std-devel.sha256sum] = "925d038630f25c5082b3ef1aec52137d7be4e195a9a0d4a51a1689d2c77b692a"

URI_x86_64_v2_rust-quoted_printable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quoted_printable-devel-0.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quoted_printable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quoted_printable-devel}"
SRC_URI[x86_64_v2_rust-quoted_printable-devel.sha256sum] = "0f72d315ac2a53e59b1538735d75c7438019fc8cabc84ce11d67a85e95419671"

URI_aarch64_rust-quoted_printable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quoted_printable+default-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-quoted_printable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quoted_printable+default-devel}"
SRC_URI[aarch64_rust-quoted_printable+default-devel.sha256sum] = "357f28550a4b640929d9a92bf9870f17e018f857360f2fd736f7a44987cff1b2"

URI_aarch64_rust-quoted_printable+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quoted_printable+std-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-quoted_printable+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quoted_printable+std-devel}"
SRC_URI[aarch64_rust-quoted_printable+std-devel.sha256sum] = "542c51f46169a04fe8a92f291b883e2501adb6568c2d3805e66a96585140d45d"

URI_aarch64_rust-quoted_printable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quoted_printable-devel-0.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-quoted_printable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quoted_printable-devel}"
SRC_URI[aarch64_rust-quoted_printable-devel.sha256sum] = "5bfe85c4f4110c43ffdfb10c515ba3e8ad16d84c29882ea266972e301ffbb3d7"

RDEPENDS:rust-quoted_printable+default-devel = " \
 cargo \
 rust-quoted_printable+std-devel \
 rust-quoted_printable-devel \
 "
RDEPENDS:rust-quoted_printable+std-devel = " \
 cargo \
 rust-quoted_printable-devel \
 "
RDEPENDS:rust-quoted_printable-devel = " \
 cargo \
 "
