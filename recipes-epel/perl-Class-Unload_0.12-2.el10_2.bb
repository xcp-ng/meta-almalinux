# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Unload"
PV = "0.12"
PR = "2.el10_2"
PACKAGES = " \
 perl-Class-Unload \
 perl-Class-Unload-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Unload-0.12-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfa0d487e3f5d67a5717094a690ffb0d6bc19d5e26715642ac05f3eb1ecbb6c2"

URI_x86_64_v2_perl-Class-Unload = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Unload-0.12-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Unload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Unload}"
SRC_URI[x86_64_v2_perl-Class-Unload.sha256sum] = "bb494e598dd7c9f7d518843e6a9b5bb21cf1098ed4e1e8a11ffb3af753a28a36"

URI_x86_64_v2_perl-Class-Unload-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Unload-tests-0.12-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Unload-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Unload-tests}"
SRC_URI[x86_64_v2_perl-Class-Unload-tests.sha256sum] = "35b8b1f170a73e484132ea17ab1c64c2b9c39fc22d5e4df0c3eff7e7628d7170"

URI_aarch64_perl-Class-Unload = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Unload-0.12-2.el10_2.noarch.rpm;name=aarch64_perl-Class-Unload;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Unload}"
SRC_URI[aarch64_perl-Class-Unload.sha256sum] = "154b0dc69eb2619155fbcca80e06fef723ffe5a5668b3df681ee7db280fc51e5"

URI_aarch64_perl-Class-Unload-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Unload-tests-0.12-2.el10_2.noarch.rpm;name=aarch64_perl-Class-Unload-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Unload-tests}"
SRC_URI[aarch64_perl-Class-Unload-tests.sha256sum] = "c9d7e1aa58270dd3d5b451acb013ed704f3cf94eea79b6bb68c0959aef6e6bea"

RDEPENDS:perl-Class-Unload = " \
 perl-Class-Inspector \
 perl-libs \
 "
RDEPENDS:perl-Class-Unload-tests = " \
 bash \
 perl-Class-Inspector \
 perl-Class-Unload \
 perl-Moose \
 perl-Test-Harness \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
