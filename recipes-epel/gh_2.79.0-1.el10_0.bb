# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gh"
PV = "2.79.0"
PR = "1.el10_0"
PACKAGES = " \
 gh \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gh-2.79.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "38d2238bb8b96fcbd45a9a64452511c77612b2c2c742aead64509a629e112441"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gh-2.79.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gh;unpack=0"
SRC_URI[x86_64_v2_gh.sha256sum] = "6fecfa67b5e4fefe7a27c42dfa9c89f3b2bd2b469a37b7b4072f19ea67f17b58"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gh-2.79.0-1.el10_0.aarch64.rpm;name=aarch64_gh;unpack=0"
SRC_URI[aarch64_gh.sha256sum] = "ecbcf1447c845471a64b9b10a05e41088fe12d7f7807b395c1ab25763db60128"

RDEPENDS:gh = " \
 git-core \
 glibc \
 "
