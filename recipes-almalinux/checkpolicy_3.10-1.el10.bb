# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "checkpolicy"
PV = "3.10"
PR = "1.el10"
PACKAGES = " \
 checkpolicy \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/checkpolicy-3.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f1c50a36b6f8a81643e0099a74ff757fb92bf4b01bccdd0d1bd4cdcc7c9c58b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/checkpolicy-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_checkpolicy;unpack=0"
SRC_URI[x86_64_v2_checkpolicy.sha256sum] = "cbebaf42d53b653c70faf6ba787a3b3cea3588962a46e2f21cd52f7c762c271b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/checkpolicy-3.10-1.el10.aarch64.rpm;name=aarch64_checkpolicy;unpack=0"
SRC_URI[aarch64_checkpolicy.sha256sum] = "c38a6dbf47c7c675ae1acc58347eee516feac367df29290173c5a90b94aad061"

RDEPENDS:checkpolicy = " \
 glibc \
 "
