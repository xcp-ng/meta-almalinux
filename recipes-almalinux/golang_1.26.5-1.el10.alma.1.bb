# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang"
PV = "1.26.5"
PR = "1.el10.alma.1"
PACKAGES = " \
 go-toolset \
 golang \
 golang-bin \
 golang-docs \
 golang-misc \
 golang-race \
 golang-src \
 golang-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-1.26.5-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b67817b6fccc1208922fabc26d5b37c835e156e4ee8bfb9599de992c97d9770"

URI_x86_64_v2_go-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-toolset-1.26.5-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_go-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-toolset}"
SRC_URI[x86_64_v2_go-toolset.sha256sum] = "11e4ab0de520d0064c6434fe9a7c4ab5ecc1eac4970bd20052f623dc6ac278cc"

URI_x86_64_v2_golang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-1.26.5-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang}"
SRC_URI[x86_64_v2_golang.sha256sum] = "2fe636570f126a741f11787f4b4e43cc8cbc5d28001b0f3b50cf1c41072fd29e"

URI_x86_64_v2_golang-bin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-bin-1.26.5-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-bin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-bin}"
SRC_URI[x86_64_v2_golang-bin.sha256sum] = "c0bd51baf890c57325567a1907a4ea6be20a6e2653e40d99139f17ffc8a4674f"

URI_x86_64_v2_golang-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-docs-1.26.5-1.el10.alma.1.noarch.rpm;name=x86_64_v2_golang-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-docs}"
SRC_URI[x86_64_v2_golang-docs.sha256sum] = "20762dc96b2ae6720d0e88c74ce6ef8ce308bed8d58897f93f26772220e65e59"

URI_x86_64_v2_golang-misc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-misc-1.26.5-1.el10.alma.1.noarch.rpm;name=x86_64_v2_golang-misc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-misc}"
SRC_URI[x86_64_v2_golang-misc.sha256sum] = "dfeb7edf281377cd80c1dc5074157633b8210a941fbb9d2cf6dd49bddc2f24ad"

URI_x86_64_v2_golang-race = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-race-1.26.5-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-race;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-race}"
SRC_URI[x86_64_v2_golang-race.sha256sum] = "ac13690da1a47c46663017a21fc5ef0208de3362d1068099f934ac4cec262df5"

URI_x86_64_v2_golang-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-src-1.26.5-1.el10.alma.1.noarch.rpm;name=x86_64_v2_golang-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-src}"
SRC_URI[x86_64_v2_golang-src.sha256sum] = "183e077324efc858f83262bd381f0d8a2fdfce3465e8913fd0c292fb9d42cf59"

URI_x86_64_v2_golang-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-tests-1.26.5-1.el10.alma.1.noarch.rpm;name=x86_64_v2_golang-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-tests}"
SRC_URI[x86_64_v2_golang-tests.sha256sum] = "15183887a78a69dc3445ddc3bd33abd7b6c4c2f629a627ad3db4f93bb44b7a9e"
RPROVIDES:golang-tests:x86_64_v2 = "virtual/libtiffxx.so.6___64bit_"

URI_aarch64_go-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-toolset-1.26.5-1.el10.alma.1.aarch64.rpm;name=aarch64_go-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-toolset}"
SRC_URI[aarch64_go-toolset.sha256sum] = "9d002749a13732accb5f95641a27877cbad4f12d180eebb972b4f736b591c384"

URI_aarch64_golang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-1.26.5-1.el10.alma.1.aarch64.rpm;name=aarch64_golang;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang}"
SRC_URI[aarch64_golang.sha256sum] = "3678c612114f522b12046bc7fccbcd1c1ae71360c05f0fbb0814d87e86fdee4b"

URI_aarch64_golang-bin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-bin-1.26.5-1.el10.alma.1.aarch64.rpm;name=aarch64_golang-bin;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-bin}"
SRC_URI[aarch64_golang-bin.sha256sum] = "18490e7b49785b896c94159b2c54ed570ba512e79ee52c8478b2ae68b4ebce06"

URI_aarch64_golang-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-docs-1.26.5-1.el10.alma.1.noarch.rpm;name=aarch64_golang-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-docs}"
SRC_URI[aarch64_golang-docs.sha256sum] = "20762dc96b2ae6720d0e88c74ce6ef8ce308bed8d58897f93f26772220e65e59"

URI_aarch64_golang-misc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-misc-1.26.5-1.el10.alma.1.noarch.rpm;name=aarch64_golang-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-misc}"
SRC_URI[aarch64_golang-misc.sha256sum] = "dfeb7edf281377cd80c1dc5074157633b8210a941fbb9d2cf6dd49bddc2f24ad"

URI_aarch64_golang-race = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-race-1.26.5-1.el10.alma.1.aarch64.rpm;name=aarch64_golang-race;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-race}"
SRC_URI[aarch64_golang-race.sha256sum] = "8af9087e1cd9091d5246f72b5fb887213bbb8bd4096b432539f490035a711ba8"

URI_aarch64_golang-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-src-1.26.5-1.el10.alma.1.noarch.rpm;name=aarch64_golang-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-src}"
SRC_URI[aarch64_golang-src.sha256sum] = "183e077324efc858f83262bd381f0d8a2fdfce3465e8913fd0c292fb9d42cf59"

URI_aarch64_golang-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-tests-1.26.5-1.el10.alma.1.noarch.rpm;name=aarch64_golang-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-tests}"
SRC_URI[aarch64_golang-tests.sha256sum] = "15183887a78a69dc3445ddc3bd33abd7b6c4c2f629a627ad3db4f93bb44b7a9e"
RPROVIDES:golang-tests:aarch64 = "virtual/libtiffxx.so.6___64bit_"

RDEPENDS:go-toolset = " \
 delve \
 golang \
 "
RDEPENDS:golang = " \
 golang-bin \
 golang-race \
 golang-src \
 openssl-devel \
 "
RDEPENDS:golang-bin = " \
 alternatives \
 bash \
 gcc \
 glibc \
 golang \
 "
RDEPENDS:golang-docs = " \
 golang \
 "
RDEPENDS:golang-misc = " \
 golang \
 "
RDEPENDS:golang-race = " \
 golang \
 "
RDEPENDS:golang-src = " \
 "
RDEPENDS:golang-tests = " \
 golang \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libtiffxx.so.6___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libtiffxx.so.6___64bit_"
