# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnfs"
PV = "5.0.3"
PR = "2.el10_0"
PACKAGES = " \
 libnfs \
 libnfs-devel \
 libnfs-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnfs-5.0.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d7c1a200039c4439a315127b0782ec9d2ee381dbbdaa6333dea753bd77ed19d"

URI_x86_64_v2_libnfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnfs-5.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfs}"
SRC_URI[x86_64_v2_libnfs.sha256sum] = "4b6baeb0a62c549c21d817771384a7765694b588f20c84577aa59a0480fa5242"

URI_x86_64_v2_libnfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnfs-devel-5.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfs-devel}"
SRC_URI[x86_64_v2_libnfs-devel.sha256sum] = "7357502575ffa81e441f5df025f9c67f55be4417133505db7040999ac1345404"

URI_x86_64_v2_libnfs-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnfs-utils-5.0.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnfs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnfs-utils}"
SRC_URI[x86_64_v2_libnfs-utils.sha256sum] = "e0f7bdb094a7ac04ed8893a3f71869f213f678f8eda76f0fde22ad4e219debf1"

URI_aarch64_libnfs = "${EPEL_MIRROR}/aarch64/Packages/l/libnfs-5.0.3-2.el10_0.aarch64.rpm;name=aarch64_libnfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfs}"
SRC_URI[aarch64_libnfs.sha256sum] = "1f9b105f86ad39d9749c4a8ff7c858d2eda3e5ff196816cf2dc010700423d642"

URI_aarch64_libnfs-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libnfs-devel-5.0.3-2.el10_0.aarch64.rpm;name=aarch64_libnfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfs-devel}"
SRC_URI[aarch64_libnfs-devel.sha256sum] = "44091fd0ab302567cc192d772e82fecd0b67001c02de3767516d694717660d0c"

URI_aarch64_libnfs-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libnfs-utils-5.0.3-2.el10_0.aarch64.rpm;name=aarch64_libnfs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnfs-utils}"
SRC_URI[aarch64_libnfs-utils.sha256sum] = "57f94c1a89166465e695e0abcbaa5e98b24bfd2c1988b9b409a13d3282a72df6"

RDEPENDS:libnfs = " \
 glibc \
 "
RDEPENDS:libnfs-devel = " \
 libnfs \
 pkgconf-pkg-config \
 "
RDEPENDS:libnfs-utils = " \
 glibc \
 libnfs \
 "
