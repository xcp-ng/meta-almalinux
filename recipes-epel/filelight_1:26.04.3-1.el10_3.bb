# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "filelight"
PE = "1"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 filelight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/filelight-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a878e92acb251917f3a57b0a459a75a1b49559749a8fa1cb1f7480966e41b04"

URI_x86_64_v2_filelight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/filelight-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_filelight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_filelight}"
SRC_URI[x86_64_v2_filelight.sha256sum] = "34ec80b0e244db2c0072efe413dd19cc8013b70bae127ba73c0863edcfd39471"

URI_aarch64_filelight = "${EPEL_MIRROR}/aarch64/Packages/f/filelight-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_filelight;unpack=0"
SRC_URI:append = " ${URI_aarch64_filelight}"
SRC_URI[aarch64_filelight.sha256sum] = "da8d8c3e6b25a302b6c8766e47646519393d61bec3e5783a1ff474b968e79b82"

RDEPENDS:filelight = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kquickcharts \
 kf6-kwidgetsaddons \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
