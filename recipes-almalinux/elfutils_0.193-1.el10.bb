# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "elfutils"
PV = "0.193"
PR = "1.el10"
PACKAGES = " \
 elfutils \
 elfutils-debuginfod \
 elfutils-debuginfod-client \
 elfutils-debuginfod-client-devel \
 elfutils-default-yama-scope \
 elfutils-devel \
 elfutils-libelf \
 elfutils-libelf-devel \
 elfutils-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/elfutils-0.193-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59c95d4ff12f54f8d3aad6e11cac361e71a43e742b3019ae05c5ca33134bfea0"

URI_x86_64_v2_elfutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-0.193-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils}"
SRC_URI[x86_64_v2_elfutils.sha256sum] = "0af3efa8dfac6985ab61b4e04891cb06585c8129f0384fed13dbd81b4f9da538"

URI_x86_64_v2_elfutils-debuginfod = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-0.193-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod}"
SRC_URI[x86_64_v2_elfutils-debuginfod.sha256sum] = "fd008af678363738e6a1dfc2b91adbf48e83182f958179bcadb581a4fbf9e8aa"

URI_x86_64_v2_elfutils-debuginfod-client = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-debuginfod-client-0.193-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod-client}"
SRC_URI[x86_64_v2_elfutils-debuginfod-client.sha256sum] = "baab87915f8567f5c69cf93621ec92cd1bb559f2d794d7674e6f02f0913e5473"

URI_x86_64_v2_elfutils-debuginfod-client-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-debuginfod-client-devel-0.193-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-debuginfod-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-debuginfod-client-devel}"
SRC_URI[x86_64_v2_elfutils-debuginfod-client-devel.sha256sum] = "12fa7e5ab4d6e7aaebdd9cdd2fb3a107015f174fc20e44f70fa32a9e39733d20"

URI_x86_64_v2_elfutils-default-yama-scope = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-default-yama-scope-0.193-1.el10.noarch.rpm;name=x86_64_v2_elfutils-default-yama-scope;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-default-yama-scope}"
SRC_URI[x86_64_v2_elfutils-default-yama-scope.sha256sum] = "a6ad680aca0ab4536bf415cb2afd3794d87cf2894f2955355765c5e361b86958"

URI_x86_64_v2_elfutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-devel-0.193-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-devel}"
SRC_URI[x86_64_v2_elfutils-devel.sha256sum] = "d2840202536b97f0d280ff8c3f97399d9efe2824e33b67ca03699f2f39015df1"

URI_x86_64_v2_elfutils-libelf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-libelf-0.193-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-libelf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libelf}"
SRC_URI[x86_64_v2_elfutils-libelf.sha256sum] = "ddca256aae6140a33a92b31bd2ed52973a7aee07859171c6492cdbc51ce7914d"

URI_x86_64_v2_elfutils-libelf-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/elfutils-libelf-devel-0.193-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libelf-devel}"
SRC_URI[x86_64_v2_elfutils-libelf-devel.sha256sum] = "e4aa73fa4028460521e802cbb1a69e402674c2e1426921d02c033851dd325b2a"

URI_x86_64_v2_elfutils-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/elfutils-libs-0.193-1.el10.x86_64_v2.rpm;name=x86_64_v2_elfutils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_elfutils-libs}"
SRC_URI[x86_64_v2_elfutils-libs.sha256sum] = "d190c275fbbe9de6e5af37a92b903ec08c4838ca1578f99187e53b5294f05e91"

URI_aarch64_elfutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-0.193-1.el10.aarch64.rpm;name=aarch64_elfutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils}"
SRC_URI[aarch64_elfutils.sha256sum] = "527bf3f81334f246c95d0e4a17a87ee2afb0bf16c9b7fc3f52813317f413e777"

URI_aarch64_elfutils-debuginfod = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-debuginfod-0.193-1.el10.aarch64.rpm;name=aarch64_elfutils-debuginfod;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod}"
SRC_URI[aarch64_elfutils-debuginfod.sha256sum] = "3156fd8d76fc8fd87a3499702757edbb96709291a02b73afdc2b0e2862fd9fc9"

URI_aarch64_elfutils-debuginfod-client = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-debuginfod-client-0.193-1.el10.aarch64.rpm;name=aarch64_elfutils-debuginfod-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod-client}"
SRC_URI[aarch64_elfutils-debuginfod-client.sha256sum] = "da016b99179a5e3216bb0e116dd960fd0e9e5ffd2dc859df941b4a0db0fdd98e"

URI_aarch64_elfutils-debuginfod-client-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-debuginfod-client-devel-0.193-1.el10.aarch64.rpm;name=aarch64_elfutils-debuginfod-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-debuginfod-client-devel}"
SRC_URI[aarch64_elfutils-debuginfod-client-devel.sha256sum] = "20622f94ba72c1493354ffd8abd30f060eaf8310857f2c5253b932c7cecd8a05"

URI_aarch64_elfutils-default-yama-scope = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-default-yama-scope-0.193-1.el10.noarch.rpm;name=aarch64_elfutils-default-yama-scope;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-default-yama-scope}"
SRC_URI[aarch64_elfutils-default-yama-scope.sha256sum] = "a6ad680aca0ab4536bf415cb2afd3794d87cf2894f2955355765c5e361b86958"

URI_aarch64_elfutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-devel-0.193-1.el10.aarch64.rpm;name=aarch64_elfutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-devel}"
SRC_URI[aarch64_elfutils-devel.sha256sum] = "e2c00f0bb25d1f619efd7d4ac52e8e1e25b4c560a3e0f4e1548f437f47ffc119"

URI_aarch64_elfutils-libelf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-libelf-0.193-1.el10.aarch64.rpm;name=aarch64_elfutils-libelf;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libelf}"
SRC_URI[aarch64_elfutils-libelf.sha256sum] = "c6d09c4affeb7254169b934a5c910c9c0ebae74fe57064bd396f153715a93f7f"

URI_aarch64_elfutils-libelf-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/elfutils-libelf-devel-0.193-1.el10.aarch64.rpm;name=aarch64_elfutils-libelf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libelf-devel}"
SRC_URI[aarch64_elfutils-libelf-devel.sha256sum] = "09ae6c67f4059348e46215a39be5f3fd4acb6edc4246f5a419fb96908e688ff1"

URI_aarch64_elfutils-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/elfutils-libs-0.193-1.el10.aarch64.rpm;name=aarch64_elfutils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_elfutils-libs}"
SRC_URI[aarch64_elfutils-libs.sha256sum] = "a80dcd03b06a90b3b2324d5ebbb336482d37f4a2352489b920edffe5c47a9b21"

RDEPENDS:elfutils = " \
 bash \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libarchive \
 libgcc \
 libstdc++ \
 "
RDEPENDS:elfutils-debuginfod = " \
 bash \
 bsdtar \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 json-c \
 libarchive \
 libgcc \
 libmicrohttpd \
 libstdc++ \
 rpm-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 xz-libs \
 "
RDEPENDS:elfutils-debuginfod-client = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 json-c \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:elfutils-debuginfod-client-devel = " \
 elfutils-debuginfod-client \
 pkgconf-pkg-config \
 "
RDEPENDS:elfutils-default-yama-scope = " \
 bash \
 "
RDEPENDS:elfutils-devel = " \
 elfutils-libelf-devel \
 elfutils-libs \
 libzstd-devel \
 pkgconf-pkg-config \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:elfutils-libelf = " \
 glibc \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:elfutils-libelf-devel = " \
 elfutils-libelf \
 libzstd-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:elfutils-libs = " \
 bzip2-libs \
 elfutils-default-yama-scope \
 elfutils-libelf \
 glibc \
 libzstd \
 xz-libs \
 zlib-ng-compat \
 "
