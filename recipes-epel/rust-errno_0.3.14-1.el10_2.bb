# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-errno"
PV = "0.3.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-errno+default-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-errno-0.3.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac5dbbe54a554e64e6b66f2e841fb258bceda138d2ea155a5e49a6e95fb4c9e1"

URI_x86_64_v2_rust-errno+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno+default-devel-0.3.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno+default-devel}"
SRC_URI[x86_64_v2_rust-errno+default-devel.sha256sum] = "52ddb544cd553004dc7d422d47a5f92b3475b94d56aa965f2fd721571bbf460a"
RPROVIDES:rust-errno+default-devel:x86_64_v2 = "virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"

URI_x86_64_v2_rust-errno+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno+std-devel-0.3.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno+std-devel}"
SRC_URI[x86_64_v2_rust-errno+std-devel.sha256sum] = "f6e7dcc06dc052117e0c0675741673ca0fe224618e8f43d6fa482803f3552b7c"

URI_x86_64_v2_rust-errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-errno-devel-0.3.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-errno-devel}"
SRC_URI[x86_64_v2_rust-errno-devel.sha256sum] = "412a4ff763a0dc42f9eae25caa6b220110aef83eb221bf848cb30cbf9761575d"

URI_aarch64_rust-errno+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno+default-devel-0.3.14-1.el10_2.noarch.rpm;name=aarch64_rust-errno+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno+default-devel}"
SRC_URI[aarch64_rust-errno+default-devel.sha256sum] = "46e155240581f5f93e374ed520bc42af1477ff17d862cff7af4cf91531641f78"
RPROVIDES:rust-errno+default-devel:aarch64 = "virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"

URI_aarch64_rust-errno+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno+std-devel-0.3.14-1.el10_2.noarch.rpm;name=aarch64_rust-errno+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno+std-devel}"
SRC_URI[aarch64_rust-errno+std-devel.sha256sum] = "0320e74c83022265ca09cf7deb16c12491b2f52edafe8ef68d984bf60592709b"

URI_aarch64_rust-errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-errno-devel-0.3.14-1.el10_2.noarch.rpm;name=aarch64_rust-errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-errno-devel}"
SRC_URI[aarch64_rust-errno-devel.sha256sum] = "267208f081529916c8268ba4bdad408e8cb6bd8913a339bd00eb980ed118ce27"

RDEPENDS:rust-errno+default-devel = " \
 cargo \
 rust-errno+std-devel \
 rust-errno-devel \
 "
RDEPENDS:rust-errno+std-devel = " \
 cargo \
 rust-errno-devel \
 rust-libc+std-devel \
 "
RDEPENDS:rust-errno-devel = " \
 cargo \
 rust \
 rust-libc-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_errno/default__ge_0.2.0_with_crate_errno/default__lt_0.4.0~"
