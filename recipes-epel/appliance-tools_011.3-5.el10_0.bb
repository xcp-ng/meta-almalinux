# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "appliance-tools"
PV = "011.3"
PR = "5.el10_0"
PACKAGES = " \
 appliance-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/appliance-tools-011.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8773883dfbcd555440fc56af1e2b018e37508cf7d01dbd2503fc6173d161d75"

URI_x86_64_v2_appliance-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/appliance-tools-011.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_appliance-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_appliance-tools}"
SRC_URI[x86_64_v2_appliance-tools.sha256sum] = "565c4031363a3dbae3eba8f06e383d231f1256ebaa1d39082a1157f0161184b8"

URI_aarch64_appliance-tools = "${EPEL_MIRROR}/aarch64/Packages/a/appliance-tools-011.3-5.el10_0.noarch.rpm;name=aarch64_appliance-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_appliance-tools}"
SRC_URI[aarch64_appliance-tools.sha256sum] = "740940d614d161d181f67ffdab2226b8e88b50644f0d637173658d0568e8df1f"

RDEPENDS:appliance-tools = " \
 curl \
 kpartx \
 python3 \
 python3-imgcreate \
 python3-progress \
 python3-setuptools \
 qemu-img \
 rsync \
 sssd-client \
 xfsprogs \
 xz \
 zlib-ng-compat \
 "
