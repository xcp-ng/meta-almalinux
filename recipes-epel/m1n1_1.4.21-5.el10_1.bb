# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "m1n1"
PV = "1.4.21"
PR = "5.el10_1"
PACKAGES:x86_64_v2 = " \
 m1n1 \
 m1n1-tools \
"
PACKAGES:aarch64 = " \
 m1n1 \
 m1n1-stage1 \
 m1n1-tools \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/m1n1-1.4.21-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f21de907f1833eaf678b62a4604db01bf4225d0b3ca38a819f791424be6246c"

URI_x86_64_v2_m1n1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/m1n1-1.4.21-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_m1n1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_m1n1}"
SRC_URI[x86_64_v2_m1n1.sha256sum] = "8ced26eb0b39f9f6c84f93628893f2c5455a09619ecb3cfd4dbb1bf9762950b6"

URI_x86_64_v2_m1n1-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/m1n1-tools-1.4.21-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_m1n1-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_m1n1-tools}"
SRC_URI[x86_64_v2_m1n1-tools.sha256sum] = "e25115a2667e6366796dbb5461c00965ae3b9a15e479ae710aee8e78c3b69ff2"

URI_aarch64_m1n1 = "${EPEL_MIRROR}/aarch64/Packages/m/m1n1-1.4.21-5.el10_1.aarch64.rpm;name=aarch64_m1n1;unpack=0"
SRC_URI:append = " ${URI_aarch64_m1n1}"
SRC_URI[aarch64_m1n1.sha256sum] = "d03ed77387fdc86578528787b0460298c8abc275d921bdb834ffaa9c697c572a"

URI_aarch64_m1n1-stage1 = "${EPEL_MIRROR}/aarch64/Packages/m/m1n1-stage1-1.4.21-5.el10_1.aarch64.rpm;name=aarch64_m1n1-stage1;unpack=0"
SRC_URI:append = " ${URI_aarch64_m1n1-stage1}"
SRC_URI[aarch64_m1n1-stage1.sha256sum] = "f5b77406954a3ec732e15496047a325cdc4ac3504268de57c294e263435e62ff"

URI_aarch64_m1n1-tools = "${EPEL_MIRROR}/aarch64/Packages/m/m1n1-tools-1.4.21-5.el10_1.noarch.rpm;name=aarch64_m1n1-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_m1n1-tools}"
SRC_URI[aarch64_m1n1-tools.sha256sum] = "84113adacd4dd9b85fa8f134aa31f4132b942c42c8cee325ffb6ea90bc136032"

RDEPENDS:m1n1 = " \
 "
RDEPENDS:m1n1-tools = " \
 bash \
 m1n1 \
 python3 \
 python3-construct \
 python3-pyserial \
 systemd-udev \
 "
RDEPENDS:m1n1-stage1 = " \
 "
