# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-fortran"
PV = "0.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-fortran+default-devel \
 rust-tree-sitter-fortran-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-fortran-0.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4e29ae322f98334847d10240306cca19e103a539f5b42c59f2df081a9a2dc72"

URI_x86_64_v2_rust-tree-sitter-fortran+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-fortran+default-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-fortran+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-fortran+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-fortran+default-devel.sha256sum] = "4cf81dc935e24a6caf21e169d86cb13e84fc1fff663caa74e7b0f27b5728e2c7"

URI_x86_64_v2_rust-tree-sitter-fortran-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-fortran-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-fortran-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-fortran-devel.sha256sum] = "fe932832d62a978bb97dedb5929f9370b48205a39675b37d6366064482ab1066"

URI_aarch64_rust-tree-sitter-fortran+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-fortran+default-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-fortran+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-fortran+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-fortran+default-devel.sha256sum] = "801c1b239b7ae9abea79f256719a88a000d3d590f1465567ed23e8e88a4910cf"

URI_aarch64_rust-tree-sitter-fortran-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-fortran-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-fortran-devel}"
SRC_URI[aarch64_rust-tree-sitter-fortran-devel.sha256sum] = "eda9fca41ed29b6ed8c3a12741c01f482cdc198bdc139a644961b96ede4ed621"

RDEPENDS:rust-tree-sitter-fortran+default-devel = " \
 cargo \
 rust-tree-sitter-fortran-devel \
 "
RDEPENDS:rust-tree-sitter-fortran-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
