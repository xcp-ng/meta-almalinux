# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SDL2"
PV = "2.28.5"
PR = "6.el10"
PACKAGES = " \
 SDL2 \
 SDL2-devel \
 SDL2-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/SDL2-2.28.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75bbb43f02e96ade36f5dfad06ffdb70388b13e0e8dc770a8c8f90bde482ba7d"

URI_x86_64_v2_SDL2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/SDL2-2.28.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_SDL2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2}"
SRC_URI[x86_64_v2_SDL2.sha256sum] = "bb7abb4e9fcdbebd9bf9daf1bc9d727889389a721e80b501e4d7c37914d951f7"
RPROVIDES:SDL2:x86_64_v2 = "virtual/SDL2_x86-64__ge_2.0.18 virtual/libSDL2-2.0.so.0___64bit_"

URI_x86_64_v2_SDL2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/SDL2-devel-2.28.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_SDL2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2-devel}"
SRC_URI[x86_64_v2_SDL2-devel.sha256sum] = "27d85ab9f9a0ff252e207c6c11595007ea0414bf68d0faba50dd678ec84881de"

URI_x86_64_v2_SDL2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/SDL2-static-2.28.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_SDL2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SDL2-static}"
SRC_URI[x86_64_v2_SDL2-static.sha256sum] = "8107c00a72b97ed8bb16d936e222a8c4a7672ed931de2d8b244c6ea7b75fccbd"

URI_aarch64_SDL2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/SDL2-2.28.5-6.el10.aarch64.rpm;name=aarch64_SDL2;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2}"
SRC_URI[aarch64_SDL2.sha256sum] = "377fa62e43226c697ce68074350657459b74a8bf0806d9327a760df22e318744"
RPROVIDES:SDL2:aarch64 = "virtual/SDL2_aarch-64__ge_2.0.18 virtual/libSDL2-2.0.so.0___64bit_"

URI_aarch64_SDL2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/SDL2-devel-2.28.5-6.el10.aarch64.rpm;name=aarch64_SDL2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2-devel}"
SRC_URI[aarch64_SDL2-devel.sha256sum] = "ad8a1c727a60a1c77c14d93844e8e8815d9e248f7d6576e6600680bf948cfc60"

URI_aarch64_SDL2-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/SDL2-static-2.28.5-6.el10.aarch64.rpm;name=aarch64_SDL2-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_SDL2-static}"
SRC_URI[aarch64_SDL2-static.sha256sum] = "5ac8171f50bbced8efb270db80027524a4eb512fe9efafaaa49a370f5861240d"

RDEPENDS:SDL2 = " \
 glibc \
 libdecor \
 "
RDEPENDS:SDL2-devel = " \
 SDL2 \
 bash \
 cmake-filesystem \
 libX11-devel \
 libglvnd-devel \
 mesa-libEGL-devel \
 pkgconf-pkg-config \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:SDL2-static = " \
 SDL2-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/SDL2_x86-64__ge_2.0.18 rpm/virtual/libSDL2-2.0.so.0___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/SDL2_aarch-64__ge_2.0.18 rpm/virtual/libSDL2-2.0.so.0___64bit_"
