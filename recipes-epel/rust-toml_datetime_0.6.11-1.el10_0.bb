# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_datetime"
PV = "0.6.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-toml_datetime+default-devel \
 rust-toml_datetime+serde-devel \
 rust-toml_datetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_datetime-0.6.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2c1898e61e558f93242368775f371b8feff305a67525a0a53d6908415c24f22"

URI_x86_64_v2_rust-toml_datetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+default-devel-0.6.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+default-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+default-devel.sha256sum] = "bf739cb8fc4576b9232420f0c39a8cc6980c7696afbc2885d7c59342c88117c9"

URI_x86_64_v2_rust-toml_datetime+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime+serde-devel-0.6.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime+serde-devel.sha256sum] = "b49b779860403e30e5cf170e347f3207cb59d747f8d00fa37c4ba8f36c5015b4"

URI_x86_64_v2_rust-toml_datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime-devel-0.6.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime-devel.sha256sum] = "8ff2348a38fe6249c7d22d6f20abc27e3df8f25c309997dc060a2aa84d28c1c1"

URI_aarch64_rust-toml_datetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+default-devel-0.6.11-1.el10_0.noarch.rpm;name=aarch64_rust-toml_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+default-devel}"
SRC_URI[aarch64_rust-toml_datetime+default-devel.sha256sum] = "af431403ca10b56c0047499ea5c4591272ac4a8a2b04f7a7dde1348ea8d832ec"

URI_aarch64_rust-toml_datetime+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime+serde-devel-0.6.11-1.el10_0.noarch.rpm;name=aarch64_rust-toml_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime+serde-devel}"
SRC_URI[aarch64_rust-toml_datetime+serde-devel.sha256sum] = "2f42f7d8b5a261de8477c2b2cdb3c5cd10764bf0dc9740fc9eeae5c11799eafa"

URI_aarch64_rust-toml_datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime-devel-0.6.11-1.el10_0.noarch.rpm;name=aarch64_rust-toml_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime-devel}"
SRC_URI[aarch64_rust-toml_datetime-devel.sha256sum] = "9bc3408902f854ec62a641a485d5f28d585a1961e7b1c6443eb8ad594d43f827"

RDEPENDS:rust-toml_datetime+default-devel = " \
 cargo \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-toml_datetime-devel \
 "
RDEPENDS:rust-toml_datetime-devel = " \
 cargo \
 rust \
 "
