# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-packetline-blocking"
PV = "0.19.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-packetline-blocking+async-io-devel \
 rust-gix-packetline-blocking+blocking-io-devel \
 rust-gix-packetline-blocking+default-devel \
 rust-gix-packetline-blocking+document-features-devel \
 rust-gix-packetline-blocking+serde-devel \
 rust-gix-packetline-blocking-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-packetline-blocking-0.19.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "874cb5a33f35cff10f73bbee7125d43d81772e4e14afb0a5e2b013dba1a9d6e5"

URI_x86_64_v2_rust-gix-packetline-blocking+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+async-io-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+async-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+async-io-devel.sha256sum] = "48bdc165eaffe501584eab17464bc00d97988cf75ffc485521978b9088b75374"

URI_x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+blocking-io-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+blocking-io-devel.sha256sum] = "c6bc319778f4e63569657940e76fc60fe3470256ec7921f808100fff9176d790"

URI_x86_64_v2_rust-gix-packetline-blocking+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+default-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+default-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+default-devel.sha256sum] = "ff239c1fdaa2acd69c7875006eb700d0aa37dee7134772a4a7d24029a8c30b66"

URI_x86_64_v2_rust-gix-packetline-blocking+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+document-features-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+document-features-devel.sha256sum] = "4bb94b43306d0278fd45a1e822984573df96d1dafd1f069940fdf6c2df42672c"

URI_x86_64_v2_rust-gix-packetline-blocking+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking+serde-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking+serde-devel.sha256sum] = "1ddc422de823df0ae59676ed46d5f0d786dc67f9cb89f315239e2aa17895ecea"

URI_x86_64_v2_rust-gix-packetline-blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-blocking-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-blocking-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-blocking-devel.sha256sum] = "1eb5e8db96e7fc1dd2f28d8b01e35ff91802316f1782c332f9063019489ea541"

URI_aarch64_rust-gix-packetline-blocking+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+async-io-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+async-io-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+async-io-devel.sha256sum] = "16af6b0d26967a65d6cfacce0fb8d7dac6bed5cba3cbf577777c20d7452ae31d"

URI_aarch64_rust-gix-packetline-blocking+blocking-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+blocking-io-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+blocking-io-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+blocking-io-devel.sha256sum] = "9f80e4f9b2060d31b2f1ce2182514cf05bca6d829d5d6a532ca5017cf896f9e0"

URI_aarch64_rust-gix-packetline-blocking+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+default-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+default-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+default-devel.sha256sum] = "6cd056654a7fc87bc4a8b1f04638cbbbd9fd38215f225fdc1ee00c04bf8d7a73"

URI_aarch64_rust-gix-packetline-blocking+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+document-features-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+document-features-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+document-features-devel.sha256sum] = "9ba5444e33477c9ade45114d592673c5efaa3267bf418b6e16560fa2deac03c8"

URI_aarch64_rust-gix-packetline-blocking+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking+serde-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline-blocking+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking+serde-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking+serde-devel.sha256sum] = "764ac8bdd17d8e1b3284c845bbfe179402dfa4d472e0cb0fe0ddc6b84945e7ff"

URI_aarch64_rust-gix-packetline-blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-blocking-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-blocking-devel}"
SRC_URI[aarch64_rust-gix-packetline-blocking-devel.sha256sum] = "9d1f19583cbe828a990043491520821ad1b5315abefddc0d9442202e43d5d2cd"

RDEPENDS:rust-gix-packetline-blocking+async-io-devel = " \
 cargo \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+blocking-io-devel = " \
 cargo \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+default-devel = " \
 cargo \
 rust-gix-packetline-blocking+blocking-io-devel \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-packetline-blocking-devel \
 "
RDEPENDS:rust-gix-packetline-blocking+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-faster-hex+serde-devel \
 rust-gix-packetline-blocking-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-packetline-blocking-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 rust-gix-trace+default-devel \
 rust-thiserror+default-devel \
 "
