# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mc"
PE = "1"
PV = "4.8.31"
PR = "3.el10"
PACKAGES = " \
 mc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mc-4.8.31-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3dc0e5110b1dec69d9aba4364794dc103c3522e6c8541cd0f511ee8fcea0a2a"

URI_x86_64_v2_mc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mc-4.8.31-3.el10.x86_64_v2.rpm;name=x86_64_v2_mc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mc}"
SRC_URI[x86_64_v2_mc.sha256sum] = "94515aa9b364597d83742b048ff24dfc355bb6f678d2a25b9a417bab830d4f1a"

URI_aarch64_mc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mc-4.8.31-3.el10.aarch64.rpm;name=aarch64_mc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mc}"
SRC_URI[aarch64_mc.sha256sum] = "5415c86a0f2bc5ac1e4bb9520bec566b9a76075575da24c70962dfab12cae01b"

RDEPENDS:mc = " \
 bash \
 e2fsprogs-libs \
 glib2 \
 glibc \
 perl-File-Basename \
 perl-File-Temp \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 slang \
 "
