# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-Mmap"
PV = "0.21"
PR = "1.el10_3"
PACKAGES = " \
 perl-Sys-Mmap \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-Mmap-0.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "28ca1848543b8e10c96a2c6205dc540517208a1ee503e489c5c9c47db7028273"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-Mmap-0.21-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Mmap;unpack=0"
SRC_URI[x86_64_v2_perl-Sys-Mmap.sha256sum] = "1d937bf45f0da0e6c7768d7500e0fb61a7b23aa6300e28b10e98209353d6a880"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-Mmap-0.21-1.el10_3.aarch64.rpm;name=aarch64_perl-Sys-Mmap;unpack=0"
SRC_URI[aarch64_perl-Sys-Mmap.sha256sum] = "128ba7f9e1b20980fdc6a4c7587738d4ee903bc7f1d5d8ae8320731c08154f30"

RDEPENDS:perl-Sys-Mmap = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
