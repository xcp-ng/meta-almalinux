# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasmatube"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 plasmatube \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasmatube-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b879c66e533daec0ec729552f39504a7489788a0cb9a8f6d9a256f4e845fa56"

URI_x86_64_v2_plasmatube = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasmatube-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasmatube;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasmatube}"
SRC_URI[x86_64_v2_plasmatube.sha256sum] = "d457ed67f74271f4073ab58b30d87b9b0194429be463974b443212a5ff1951a8"

URI_aarch64_plasmatube = "${EPEL_MIRROR}/aarch64/Packages/p/plasmatube-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_plasmatube;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasmatube}"
SRC_URI[aarch64_plasmatube.sha256sum] = "4fdaf4dc769d89f36868e86ceb447e7d225e1df27fe119a51195da832bdd0e08"

RDEPENDS:plasmatube = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kwindowsystem \
 kf6-purpose \
 libstdc++ \
 mpvqt \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
