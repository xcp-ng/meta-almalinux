# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-PNG-Libpng"
PV = "0.59"
PR = "1.el10_0"
PACKAGES = " \
 perl-Image-PNG-Libpng \
 perl-Image-PNG-Libpng-tests \
 perl-Image-PNG-Libpng-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Image-PNG-Libpng-0.59-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2855edad7fac1889f688a2d18283fa79b6f8c389d883711e9397e43cf237f100"

URI_x86_64_v2_perl-Image-PNG-Libpng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-PNG-Libpng-0.59-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Image-PNG-Libpng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-PNG-Libpng}"
SRC_URI[x86_64_v2_perl-Image-PNG-Libpng.sha256sum] = "eddb94edb036dd5edd420955c7b3c26a768eba3b2dbc086c94d9903700d008bf"

URI_x86_64_v2_perl-Image-PNG-Libpng-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-PNG-Libpng-tests-0.59-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-PNG-Libpng-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-PNG-Libpng-tests}"
SRC_URI[x86_64_v2_perl-Image-PNG-Libpng-tests.sha256sum] = "865f9ccd769a948e9afe3483c67df521d7beaf5bc9beb3249531c892c86a1794"

URI_x86_64_v2_perl-Image-PNG-Libpng-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-PNG-Libpng-tools-0.59-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-PNG-Libpng-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-PNG-Libpng-tools}"
SRC_URI[x86_64_v2_perl-Image-PNG-Libpng-tools.sha256sum] = "4c94eb7b3f1daf08e46118fef7232b12f6b87c8caac1c2d48f60cf954d9b5bc9"

URI_aarch64_perl-Image-PNG-Libpng = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-PNG-Libpng-0.59-1.el10_0.aarch64.rpm;name=aarch64_perl-Image-PNG-Libpng;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-PNG-Libpng}"
SRC_URI[aarch64_perl-Image-PNG-Libpng.sha256sum] = "2ef75596cb6c463b8d7e84958894a81d155a906a77c13f180f2433c261807746"

URI_aarch64_perl-Image-PNG-Libpng-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-PNG-Libpng-tests-0.59-1.el10_0.noarch.rpm;name=aarch64_perl-Image-PNG-Libpng-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-PNG-Libpng-tests}"
SRC_URI[aarch64_perl-Image-PNG-Libpng-tests.sha256sum] = "ed3692ff6b4abb58a0d8b1e74b50c4de86da7fda2125acc7892366467270a3be"

URI_aarch64_perl-Image-PNG-Libpng-tools = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-PNG-Libpng-tools-0.59-1.el10_0.noarch.rpm;name=aarch64_perl-Image-PNG-Libpng-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-PNG-Libpng-tools}"
SRC_URI[aarch64_perl-Image-PNG-Libpng-tools.sha256sum] = "e9bc0fae3f62937df963593c29a00d3d3cfd1ee573945fbfc432d8b206dfd8ee"

RDEPENDS:perl-Image-PNG-Libpng = " \
 glibc \
 libpng \
 perl-Carp \
 perl-Exporter \
 perl-Image-PNG-Libpng \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Image-PNG-Libpng-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Compare \
 perl-FindBin \
 perl-Image-PNG-Libpng \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 virtual/coreutils \
 "
RDEPENDS:perl-Image-PNG-Libpng-tools = " \
 perl-Data-Dumper \
 perl-Getopt-Long \
 perl-Image-PNG-Libpng \
 perl-interpreter \
 perl-libs \
 "
