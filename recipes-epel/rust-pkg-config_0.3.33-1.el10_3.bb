# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkg-config"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-pkg-config+default-devel \
 rust-pkg-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pkg-config-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96894f22855b4dac405011b3aac67e316fb28a6f6dbc2e2391b9146dcaaf6c49"

URI_x86_64_v2_rust-pkg-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkg-config+default-devel}"
SRC_URI[x86_64_v2_rust-pkg-config+default-devel.sha256sum] = "a9c77fd7acd72f0b71336502d62906ec9cc63089e6163e395bc690482d8ba61e"

URI_x86_64_v2_rust-pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkg-config-devel}"
SRC_URI[x86_64_v2_rust-pkg-config-devel.sha256sum] = "f5b66842c302f0ea27d8acd6d8be04500087839157b607f326d810443046d948"

URI_aarch64_rust-pkg-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-pkg-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkg-config+default-devel}"
SRC_URI[aarch64_rust-pkg-config+default-devel.sha256sum] = "38197597f619c25ea6b93c07bed2efc3d29541c9e1814e522f8b8abbab55174f"

URI_aarch64_rust-pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkg-config-devel}"
SRC_URI[aarch64_rust-pkg-config-devel.sha256sum] = "16d7529378a4b7f921c74e455ca9bf2ecc0cb5673aadfec724ebb7ec762b7a3c"

RDEPENDS:rust-pkg-config+default-devel = " \
 cargo \
 rust-pkg-config-devel \
 "
RDEPENDS:rust-pkg-config-devel = " \
 cargo \
 pkgconf-pkg-config \
 rust \
 "
