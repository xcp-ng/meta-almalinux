# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ivf"
PV = "0.1.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-ivf+default-devel \
 rust-ivf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ivf-0.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20f7559d13170889d717edd5d6a20d559c6226a19421d88ca6908af216e4557f"

URI_x86_64_v2_rust-ivf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ivf+default-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ivf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ivf+default-devel}"
SRC_URI[x86_64_v2_rust-ivf+default-devel.sha256sum] = "3a4495852056901d92a88094c90755bcc78e281fe7dce9a75a2e7c00f510efcf"

URI_x86_64_v2_rust-ivf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ivf-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ivf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ivf-devel}"
SRC_URI[x86_64_v2_rust-ivf-devel.sha256sum] = "3b111300a7e416c1967b1b065b6fbe2291476fc414c850135f92447c0e37215e"

URI_aarch64_rust-ivf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ivf+default-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-ivf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ivf+default-devel}"
SRC_URI[aarch64_rust-ivf+default-devel.sha256sum] = "750f7bd482ff80b691235c87601240ae9c159b22592b2778e30e4c46e1c57bb7"

URI_aarch64_rust-ivf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ivf-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-ivf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ivf-devel}"
SRC_URI[aarch64_rust-ivf-devel.sha256sum] = "cc877122bdcc84322a87549b3dcb5e43bc70a885135e5761e817c12f98c6664b"

RDEPENDS:rust-ivf+default-devel = " \
 cargo \
 rust-ivf-devel \
 "
RDEPENDS:rust-ivf-devel = " \
 cargo \
 rust-bitstream-io+default-devel \
 "
