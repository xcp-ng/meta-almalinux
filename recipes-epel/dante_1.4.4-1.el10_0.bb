# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dante"
PV = "1.4.4"
PR = "1.el10_0"
PACKAGES = " \
 dante \
 dante-devel \
 dante-server \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dante-1.4.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "337adb4171aa50adeecd14c8cfbb53fdf1239bcbfc6150ee9adceb3e7a3e4aeb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dante-1.4.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dante;unpack=0"
SRC_URI[x86_64_v2_dante.sha256sum] = "6b17a5aeeb58c42277af56bc9eeddcf0e8eba8b638029562d8922df17ad9f4de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dante-devel-1.4.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dante-devel;unpack=0"
SRC_URI[x86_64_v2_dante-devel.sha256sum] = "1321d2923f74ab8978c0992303fa75a8f789aad97a740955c256a66f4387f40b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dante-server-1.4.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dante-server;unpack=0"
SRC_URI[x86_64_v2_dante-server.sha256sum] = "02eed2f0bf4cce504b8c30f9a0295d474693997a42e6bf91fe2bb89b3fccdb24"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dante-1.4.4-1.el10_0.aarch64.rpm;name=aarch64_dante;unpack=0"
SRC_URI[aarch64_dante.sha256sum] = "0b68f9cbbb94bd0eb53ff6cc9c0b50a713b8b07cc38fd47c8352cd1ef3f74b07"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dante-devel-1.4.4-1.el10_0.aarch64.rpm;name=aarch64_dante-devel;unpack=0"
SRC_URI[aarch64_dante-devel.sha256sum] = "5460743c4c609d2c386d37f968f144173f5394bad4f9867e66a2ae09979ff842"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dante-server-1.4.4-1.el10_0.aarch64.rpm;name=aarch64_dante-server;unpack=0"
SRC_URI[aarch64_dante-server.sha256sum] = "35d0d0e4ad8ef5902bf02a9f9af00f611d88e7178bd4b1855eba8489420c125c"

RDEPENDS:dante = " \
 bash \
 glibc \
 krb5-libs \
 miniupnpc \
 "
RDEPENDS:dante-devel = " \
 dante \
 "
RDEPENDS:dante-server = " \
 bash \
 dante \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 miniupnpc \
 pam-libs \
 "
