# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_stat"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_stat+default-devel \
 rust-uu_stat+selinux-devel \
 rust-uu_stat-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_stat-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4317116bac7350654964ab3a207e1190b4bbdf2fac50d43d105a95dd7cf119b"

URI_x86_64_v2_rust-uu_stat+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_stat+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_stat+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_stat+default-devel}"
SRC_URI[x86_64_v2_rust-uu_stat+default-devel.sha256sum] = "29d78b3a419c3d3b7553a580345ccd0b72945b24f4b685dc83614c6e41efde37"

URI_x86_64_v2_rust-uu_stat+selinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_stat+selinux-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_stat+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_stat+selinux-devel}"
SRC_URI[x86_64_v2_rust-uu_stat+selinux-devel.sha256sum] = "e0619763d671ea9f65ab47a95cd98183af220e2e538e9cb8a3657fb194e9e139"

URI_x86_64_v2_rust-uu_stat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_stat-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_stat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_stat-devel}"
SRC_URI[x86_64_v2_rust-uu_stat-devel.sha256sum] = "da46e7cdb2e28a46303c55c10227931368f069241c65d70464962def72020c9b"

URI_aarch64_rust-uu_stat+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_stat+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_stat+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_stat+default-devel}"
SRC_URI[aarch64_rust-uu_stat+default-devel.sha256sum] = "cdfddc349da63f0266c2984d44e26b1577088bf986c1ba181a7b3a6d49cdc0da"

URI_aarch64_rust-uu_stat+selinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_stat+selinux-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_stat+selinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_stat+selinux-devel}"
SRC_URI[aarch64_rust-uu_stat+selinux-devel.sha256sum] = "ee05b4ba2b15b8d12272b9f53e17952744145ab4991af5b4150fbbff8f7e96e4"

URI_aarch64_rust-uu_stat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_stat-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_stat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_stat-devel}"
SRC_URI[aarch64_rust-uu_stat-devel.sha256sum] = "6b121dbceffb2f52afba524495e6619097ce632e28fcc3bc67abf549ba841c79"

RDEPENDS:rust-uu_stat+default-devel = " \
 cargo \
 rust-uu_stat-devel \
 "
RDEPENDS:rust-uu_stat+selinux-devel = " \
 cargo \
 rust-uu_stat-devel \
 rust-uucore+selinux-devel \
 "
RDEPENDS:rust-uu_stat-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+fsext-devel \
 rust-uucore+libc-devel \
 rust-uucore+time-devel \
 "
