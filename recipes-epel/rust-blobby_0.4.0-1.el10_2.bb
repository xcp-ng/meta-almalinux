# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blobby"
PV = "0.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-blobby+alloc-devel \
 rust-blobby+default-devel \
 rust-blobby-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blobby-0.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8781b5724e6c30debda97879a4a2638e5b2538bbd0f483d97ee84ab807d4bd0"

URI_x86_64_v2_rust-blobby+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blobby+alloc-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blobby+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blobby+alloc-devel}"
SRC_URI[x86_64_v2_rust-blobby+alloc-devel.sha256sum] = "c5c419d6606cc69478eec62839a9d23afaac6b48a854a08a27e7862fb357a6a7"

URI_x86_64_v2_rust-blobby+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blobby+default-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blobby+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blobby+default-devel}"
SRC_URI[x86_64_v2_rust-blobby+default-devel.sha256sum] = "e4124fe5f2d9918460c956a33f1a2a888801c8ad49a83f52445a64aa23d56689"

URI_x86_64_v2_rust-blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blobby-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blobby-devel}"
SRC_URI[x86_64_v2_rust-blobby-devel.sha256sum] = "6b0c53f40bb569bd99e3d361cb0241142cf5deef218513c5dc6f19e21e2b8d55"

URI_aarch64_rust-blobby+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blobby+alloc-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-blobby+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blobby+alloc-devel}"
SRC_URI[aarch64_rust-blobby+alloc-devel.sha256sum] = "e591c9d0d42cc0141ace6b5101ec2b2518ef290cfe61a564e4596765c7ee03d3"

URI_aarch64_rust-blobby+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blobby+default-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-blobby+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blobby+default-devel}"
SRC_URI[aarch64_rust-blobby+default-devel.sha256sum] = "6e9b70f7cd8d408e6e8c41f709ecd92c3b1aba84f3cf1112ddf0f5982e628f20"

URI_aarch64_rust-blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blobby-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blobby-devel}"
SRC_URI[aarch64_rust-blobby-devel.sha256sum] = "14f07648c738583afdef452d3cae2b24a56376e60088825c4fa2ebc55e34edc6"

RDEPENDS:rust-blobby+alloc-devel = " \
 cargo \
 rust-blobby-devel \
 "
RDEPENDS:rust-blobby+default-devel = " \
 cargo \
 rust-blobby-devel \
 "
RDEPENDS:rust-blobby-devel = " \
 cargo \
 rust \
 "
