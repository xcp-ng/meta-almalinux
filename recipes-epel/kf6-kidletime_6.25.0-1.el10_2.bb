# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kidletime"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kidletime \
 kf6-kidletime-devel \
 kf6-kidletime-doc \
 kf6-kidletime-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kidletime-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78aacb5588c3a734bdac2710280b740795ef616b10b914fc5d98acb5d52f01d9"

URI_x86_64_v2_kf6-kidletime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime}"
SRC_URI[x86_64_v2_kf6-kidletime.sha256sum] = "37a26775089ab02dfd8f7334770340f4bfa52071184099874bfd86fbc1c26296"

URI_x86_64_v2_kf6-kidletime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime-devel}"
SRC_URI[x86_64_v2_kf6-kidletime-devel.sha256sum] = "4c4842ce9a6ebcb4b48e586a4c958f8a5dd1e7ef050f3331ebf4a6fb409b4167"

URI_x86_64_v2_kf6-kidletime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kidletime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime-doc}"
SRC_URI[x86_64_v2_kf6-kidletime-doc.sha256sum] = "2f09956033290ec26a2f4cf32e0a2e4598f905ff1096f10c8e0e334214398761"

URI_x86_64_v2_kf6-kidletime-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kidletime-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kidletime-html}"
SRC_URI[x86_64_v2_kf6-kidletime-html.sha256sum] = "cb82a3f8b045f7d3e7b982f7c7faa8e321f266fa916e2a2c0ae6be2111dd215b"

URI_aarch64_kf6-kidletime = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kidletime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime}"
SRC_URI[aarch64_kf6-kidletime.sha256sum] = "5a928bde22d3e1bc3cc265adbd9a7010a3394fddf6961afdb390bfaeaa270d61"

URI_aarch64_kf6-kidletime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kidletime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime-devel}"
SRC_URI[aarch64_kf6-kidletime-devel.sha256sum] = "4615eb6d5fdc66b3503a2d0d6c8dd3ce3308a73151236e5369a49801e6a72ece"

URI_aarch64_kf6-kidletime-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kidletime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime-doc}"
SRC_URI[aarch64_kf6-kidletime-doc.sha256sum] = "aae3f21d73a9e75bce40772f889eb36e6fac3f9ee5bc2ab69ba56072136120ad"

URI_aarch64_kf6-kidletime-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kidletime-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kidletime-html}"
SRC_URI[aarch64_kf6-kidletime-html.sha256sum] = "5e771f592e8e965c5be5a35c4b18ae1526ebc8ffee0fafed405b1a70f865924f"

RDEPENDS:kf6-kidletime = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kidletime-devel = " \
 cmake-filesystem \
 kf6-kidletime \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kidletime-doc = " \
 "
RDEPENDS:kf6-kidletime-html = " \
 "
