# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-file-read-tokio"
PV = "3.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-file-read-tokio+default-devel \
 rust-reqsign-file-read-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-file-read-tokio-3.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e31d66f96dc9f847e260ee5f7cf81930b57b5abba0f5167a03b3f8046b68f6d"

URI_x86_64_v2_rust-reqsign-file-read-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-file-read-tokio+default-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-file-read-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-file-read-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-file-read-tokio+default-devel.sha256sum] = "c2ded470f1749c4b2d53153d9acff70c367a9a32b28dcbfead50fb423371081c"

URI_x86_64_v2_rust-reqsign-file-read-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-file-read-tokio-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-file-read-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-file-read-tokio-devel}"
SRC_URI[x86_64_v2_rust-reqsign-file-read-tokio-devel.sha256sum] = "a984ea190881f1400ef6e933b0bbd29c5721e6c4210183c6cab8ee4ff04a557b"

URI_aarch64_rust-reqsign-file-read-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-file-read-tokio+default-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-file-read-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-file-read-tokio+default-devel}"
SRC_URI[aarch64_rust-reqsign-file-read-tokio+default-devel.sha256sum] = "cb132e601190ba041ddcb76de15d48e73bc87587a3b4bcd4bc527108bcd1c0ea"

URI_aarch64_rust-reqsign-file-read-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-file-read-tokio-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-file-read-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-file-read-tokio-devel}"
SRC_URI[aarch64_rust-reqsign-file-read-tokio-devel.sha256sum] = "5d0d66108d5d925b8637362bec4cae96d93a0d08c1e09ae732e61ef63c01a6a4"

RDEPENDS:rust-reqsign-file-read-tokio+default-devel = " \
 cargo \
 rust-reqsign-file-read-tokio-devel \
 "
RDEPENDS:rust-reqsign-file-read-tokio-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-reqsign-core+default-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 "
