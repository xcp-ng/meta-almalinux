# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rspec-mocks"
PV = "3.13.0"
PR = "3.el10"
PACKAGES = " \
 rubygem-rspec-mocks \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rubygem-rspec-mocks-3.13.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65ece9972543b167878e53205467105d49c0d379b0f06a7c4e372dd9b2daaf18"

URI_x86_64_v2_rubygem-rspec-mocks = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rubygem-rspec-mocks-3.13.0-3.el10.noarch.rpm;name=x86_64_v2_rubygem-rspec-mocks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rspec-mocks}"
SRC_URI[x86_64_v2_rubygem-rspec-mocks.sha256sum] = "ede93478799f104d3ea32dc411c1fb75492282566f9577b98fbedddc355f6ed7"

URI_aarch64_rubygem-rspec-mocks = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rubygem-rspec-mocks-3.13.0-3.el10.noarch.rpm;name=aarch64_rubygem-rspec-mocks;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rspec-mocks}"
SRC_URI[aarch64_rubygem-rspec-mocks.sha256sum] = "ede93478799f104d3ea32dc411c1fb75492282566f9577b98fbedddc355f6ed7"

RDEPENDS:rubygem-rspec-mocks = " \
 rubygem-diff-lcs \
 rubygem-rspec-support \
 rubygems \
 "
