# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rusty-fork"
PV = "0.3.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-rusty-fork+default-devel \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork+wait-timeout-devel \
 rust-rusty-fork-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rusty-fork-0.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f9502432d9ac04b1737bd7ff86721404ca8c22f231781d207b3503f15b2660ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork+default-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rusty-fork+default-devel.sha256sum] = "6c43cabbb95ac8ae8b710444655f28a4307eec74a9882366242058688a8b770a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork+timeout-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork+timeout-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rusty-fork+timeout-devel.sha256sum] = "34f49e2d3ef36aab2bd05e60b38f7cc34e0000156f1fa97369c35cf0fed45f36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork+wait-timeout-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork+wait-timeout-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rusty-fork+wait-timeout-devel.sha256sum] = "5ff16801d21b68afc787d7169b5d372194fc0c2780b9b36535d38468614b231c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rusty-fork-devel-0.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rusty-fork-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rusty-fork-devel.sha256sum] = "59c75e81b38d4765fa0a3f5dff50daeba09977247ce43f86a79b86581271b1c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork+default-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rusty-fork+default-devel;unpack=0"
SRC_URI[aarch64_rust-rusty-fork+default-devel.sha256sum] = "08486eb5af9c442aa554136846e84898fdba9a93f887d0f2f48d4c03f531dcaf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork+timeout-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rusty-fork+timeout-devel;unpack=0"
SRC_URI[aarch64_rust-rusty-fork+timeout-devel.sha256sum] = "a6e6f838214f5493aa27060c8f186cb90d4f7ef7e91dce253fbd866f7c4c0e58"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork+wait-timeout-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rusty-fork+wait-timeout-devel;unpack=0"
SRC_URI[aarch64_rust-rusty-fork+wait-timeout-devel.sha256sum] = "ba7c31abd5f96d88bbec4081cef60547f303728f8c70f8e982591e1b02bd9462"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rusty-fork-devel-0.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rusty-fork-devel;unpack=0"
SRC_URI[aarch64_rust-rusty-fork-devel.sha256sum] = "dd2f32ca3ed0723f742a266e8bc18c622f4579f1a744c0230eeaeab4ee0600a1"

RDEPENDS:rust-rusty-fork+default-devel = " \
 cargo \
 rust-rusty-fork+timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-rusty-fork+timeout-devel = " \
 cargo \
 rust-rusty-fork+wait-timeout-devel \
 rust-rusty-fork-devel \
 "
RDEPENDS:rust-rusty-fork+wait-timeout-devel = " \
 cargo \
 rust-rusty-fork-devel \
 rust-wait-timeout+default-devel \
 "
RDEPENDS:rust-rusty-fork-devel = " \
 cargo \
 rust-fnv+default-devel \
 rust-quick-error1+default-devel \
 rust-tempfile+default-devel \
 "
