# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librepo"
PV = "1.19.0"
PR = "1.el10"
PACKAGES = " \
 librepo \
 librepo-devel \
 python3-librepo \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/librepo-1.19.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8490cc20d5c3feff14b144e45b0de301498caa47200db3df657478b6b662174f"

URI_x86_64_v2_librepo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librepo-1.19.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_librepo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librepo}"
SRC_URI[x86_64_v2_librepo.sha256sum] = "b874591b2410bf2da127799c8fe756081a7dfd91bf862fa4c17f25f0e8f0acf3"

URI_x86_64_v2_librepo-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librepo-devel-1.19.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_librepo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librepo-devel}"
SRC_URI[x86_64_v2_librepo-devel.sha256sum] = "e55256da58e556db552e46a0fc11bc1f108436fa69a3edc5dff86617a334bac4"

URI_x86_64_v2_python3-librepo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-librepo-1.19.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-librepo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-librepo}"
SRC_URI[x86_64_v2_python3-librepo.sha256sum] = "20c986fab29809f7bdf337ca3fbf68fedbaab53641dff5e9568a21003dc769af"

URI_aarch64_librepo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librepo-1.19.0-1.el10.aarch64.rpm;name=aarch64_librepo;unpack=0"
SRC_URI:append = " ${URI_aarch64_librepo}"
SRC_URI[aarch64_librepo.sha256sum] = "e6f2ab54f52b887e13d73b92237b0458ade775c9ee4e2a50b3b4bcec70a9a552"

URI_aarch64_librepo-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librepo-devel-1.19.0-1.el10.aarch64.rpm;name=aarch64_librepo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librepo-devel}"
SRC_URI[aarch64_librepo-devel.sha256sum] = "2ab5ca51602e5531a1c705af72188437180557768ccacefe408152bef101c7a9"

URI_aarch64_python3-librepo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-librepo-1.19.0-1.el10.aarch64.rpm;name=aarch64_python3-librepo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-librepo}"
SRC_URI[aarch64_python3-librepo.sha256sum] = "26e06287cd24217714bc788b91049a5c30e697dde70bd9f37f5f5beff0d3abd7"

RDEPENDS:librepo:x86_64_v2 = " \
 glib2 \
 glibc \
 libgcc \
 libxml2 \
 openssl-libs \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_7.52.0 \
"
RDEPENDS:librepo:aarch64 = " \
 glib2 \
 glibc \
 libgcc \
 libxml2 \
 openssl-libs \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_7.52.0 \
"
RDEPENDS:librepo-devel = " \
 glib2-devel \
 libcurl-devel \
 librepo \
 libxml2-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-librepo = " \
 glib2 \
 glibc \
 libgcc \
 librepo \
 python3 \
 python3-libs \
 "
