# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa"
PV = "24.2.8"
PR = "3.el10_0.alma.1"
PACKAGES:x86_64_v2 = " \
 mesa-dri-drivers \
 mesa-filesystem \
 mesa-libEGL \
 mesa-libEGL-devel \
 mesa-libGL \
 mesa-libGL-devel \
 mesa-libOSMesa \
 mesa-libOSMesa-devel \
 mesa-libgbm \
 mesa-libgbm-devel \
 mesa-libglapi \
 mesa-libxatracker \
 mesa-vulkan-drivers \
"
PACKAGES:aarch64 = " \
 mesa-dri-drivers \
 mesa-filesystem \
 mesa-libEGL \
 mesa-libEGL-devel \
 mesa-libGL \
 mesa-libGL-devel \
 mesa-libOSMesa \
 mesa-libOSMesa-devel \
 mesa-libgbm \
 mesa-libgbm-devel \
 mesa-libglapi \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-24.2.8-3.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b24ef8438833c76a9bf832dd21cdac1d09e86713ea17bc2015c865d0d7a3469a"

URI_x86_64_v2_mesa-dri-drivers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-dri-drivers-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-dri-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-dri-drivers}"
SRC_URI[x86_64_v2_mesa-dri-drivers.sha256sum] = "ee15b8e47647013adb24018e5d43eedba9e36328fdb4d7efa415d41e30d3ba2d"

URI_x86_64_v2_mesa-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-filesystem-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-filesystem}"
SRC_URI[x86_64_v2_mesa-filesystem.sha256sum] = "ad3cebd9714112713acf4e667c23ea803ca233922c6272b9890d094587168ba9"

URI_x86_64_v2_mesa-libEGL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libEGL}"
SRC_URI[x86_64_v2_mesa-libEGL.sha256sum] = "b83584b69fa4aa5d3c7c53b85e0cb4c5600303e08560c035c4b186101cc86498"

URI_x86_64_v2_mesa-libEGL-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-devel-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libEGL-devel}"
SRC_URI[x86_64_v2_mesa-libEGL-devel.sha256sum] = "09e0676b89c6773bcee39c1c52cbb3e504ae6fc2d5baaa8440ed004b94967534"

URI_x86_64_v2_mesa-libGL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGL}"
SRC_URI[x86_64_v2_mesa-libGL.sha256sum] = "509999e9f62dd0ba09b0a7bcab2b8439be34b414283ea14a5de4c62f21ce6ec8"

URI_x86_64_v2_mesa-libGL-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-devel-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGL-devel}"
SRC_URI[x86_64_v2_mesa-libGL-devel.sha256sum] = "abe3bed725e4e2194c51bb4d1ef55a999428b302ad1bceaa56d6d9b0a6b8d919"

URI_x86_64_v2_mesa-libOSMesa = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mesa-libOSMesa-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libOSMesa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libOSMesa}"
SRC_URI[x86_64_v2_mesa-libOSMesa.sha256sum] = "cd011baaaba809baa4c8c7cf4de5e1780adca426432e62fd7105afc2296a9311"

URI_x86_64_v2_mesa-libOSMesa-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mesa-libOSMesa-devel-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libOSMesa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libOSMesa-devel}"
SRC_URI[x86_64_v2_mesa-libOSMesa-devel.sha256sum] = "7f25f6e08d9caffbf1b8ae2a68a028723e2edff0a16de48db8f55971fcf3e511"

URI_x86_64_v2_mesa-libgbm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libgbm}"
SRC_URI[x86_64_v2_mesa-libgbm.sha256sum] = "577ad30d12f318ea9a8f3c733bc301d54f0ff6a33133525a4ec570464c4030c3"

URI_x86_64_v2_mesa-libgbm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-devel-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libgbm-devel}"
SRC_URI[x86_64_v2_mesa-libgbm-devel.sha256sum] = "0380971e25870bc99a16dfde992d32feaea1a9a2eb70895a13f3db47fd7a4231"

URI_x86_64_v2_mesa-libglapi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libglapi-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libglapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libglapi}"
SRC_URI[x86_64_v2_mesa-libglapi.sha256sum] = "59dda405bfabcd859132fd335a478be4d59a739c69cdb3bec6bbc68e6b923b8c"

URI_x86_64_v2_mesa-libxatracker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libxatracker-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libxatracker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libxatracker}"
SRC_URI[x86_64_v2_mesa-libxatracker.sha256sum] = "434e055b672de3b649192cd2da88db6585fcfc7debf195f915ac0e0e823e07b0"

URI_x86_64_v2_mesa-vulkan-drivers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-vulkan-drivers-24.2.8-3.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-vulkan-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-vulkan-drivers}"
SRC_URI[x86_64_v2_mesa-vulkan-drivers.sha256sum] = "ff550e4cb381558df408e1c97d4106ec76e5e9f655cac83295e200fa6b6dd79c"

URI_aarch64_mesa-dri-drivers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-dri-drivers-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-dri-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-dri-drivers}"
SRC_URI[aarch64_mesa-dri-drivers.sha256sum] = "f358608fb104ab767ad2f929b55c28dea33715ae774cae1e20a3bb2d568c9eb8"

URI_aarch64_mesa-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-filesystem-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-filesystem}"
SRC_URI[aarch64_mesa-filesystem.sha256sum] = "5e32db2818b65f41b1bb374daee6911f93164d902631b98663a9294fc6df6277"

URI_aarch64_mesa-libEGL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-libEGL;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libEGL}"
SRC_URI[aarch64_mesa-libEGL.sha256sum] = "ac68af7c1a68d9f9093b5194481c4b20d761400b11bf776eb940137c135424dc"

URI_aarch64_mesa-libEGL-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-devel-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-libEGL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libEGL-devel}"
SRC_URI[aarch64_mesa-libEGL-devel.sha256sum] = "a79ef4bce4928996dc3b55c1c60c4a5fa36bceeb20524a6724475b8d01528b4f"

URI_aarch64_mesa-libGL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-libGL;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGL}"
SRC_URI[aarch64_mesa-libGL.sha256sum] = "c7d795ceb109754faf3312235491f746fe63d84300343bddd4fe1fed2c2c53cf"

URI_aarch64_mesa-libGL-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-devel-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-libGL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGL-devel}"
SRC_URI[aarch64_mesa-libGL-devel.sha256sum] = "fe14de237c21f2dc0e1d41075320133a9c703ffeab5a5d326d9dc1c271282c3a"

URI_aarch64_mesa-libOSMesa = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mesa-libOSMesa-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-libOSMesa;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libOSMesa}"
SRC_URI[aarch64_mesa-libOSMesa.sha256sum] = "285d442c16d2196d2b3ae3e6ef3735b44a2a047f600f5e9c9e28940a413bcab9"

URI_aarch64_mesa-libOSMesa-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mesa-libOSMesa-devel-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-libOSMesa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libOSMesa-devel}"
SRC_URI[aarch64_mesa-libOSMesa-devel.sha256sum] = "183722b65d3c26d26ccde7477f5c3c5aaba2ec11a68e2ae38d8128e239dadd43"

URI_aarch64_mesa-libgbm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-libgbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libgbm}"
SRC_URI[aarch64_mesa-libgbm.sha256sum] = "1b20c5dee26c4476f553d5aa415fcb67896f47a98fd0627b4047ba3dc9f909d3"

URI_aarch64_mesa-libgbm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-devel-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-libgbm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libgbm-devel}"
SRC_URI[aarch64_mesa-libgbm-devel.sha256sum] = "715c79992d801fc453adfb971ae2581e92dc0c31bdff0c3a29d6bf488376bfe9"

URI_aarch64_mesa-libglapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libglapi-24.2.8-3.el10_0.alma.1.aarch64.rpm;name=aarch64_mesa-libglapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libglapi}"
SRC_URI[aarch64_mesa-libglapi.sha256sum] = "a498e2b716c15528dd39fda05497d8f48ebaf0b03506cfa6b388325d73683816"

RDEPENDS:mesa-dri-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libX11-xcb \
 libdrm \
 libgcc \
 libstdc++ \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 mesa-libgbm \
 mesa-libglapi \
 zlib-ng-compat \
 "
RDEPENDS:mesa-filesystem = " \
 "
RDEPENDS:mesa-libEGL = " \
 expat \
 glibc \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libwayland-server \
 libxcb \
 libxshmfence \
 mesa-dri-drivers \
 mesa-libgbm \
 mesa-libglapi \
 "
RDEPENDS:mesa-libEGL-devel = " \
 libglvnd-devel \
 mesa-libEGL \
 "
RDEPENDS:mesa-libGL = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libXext \
 libXfixes \
 libXxf86vm \
 libdrm \
 libglvnd-glx \
 libxcb \
 libxshmfence \
 mesa-dri-drivers \
 mesa-libglapi \
 "
RDEPENDS:mesa-libGL-devel = " \
 libdrm-devel \
 libglvnd-devel \
 mesa-libGL \
 mesa-libglapi \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-libOSMesa = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 mesa-libglapi \
 zlib-ng-compat \
 "
RDEPENDS:mesa-libOSMesa-devel = " \
 mesa-libOSMesa \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-libgbm = " \
 expat \
 glibc \
 libdrm \
 libwayland-server \
 libxcb \
 mesa-dri-drivers \
 "
RDEPENDS:mesa-libgbm-devel = " \
 mesa-libgbm \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-libglapi = " \
 glibc \
 mesa-dri-drivers \
 "
RDEPENDS:mesa-libxatracker = " \
 expat \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-vulkan-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libX11-xcb \
 libdrm \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 vulkan-loader \
 zlib-ng-compat \
 "
