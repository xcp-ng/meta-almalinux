# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prost-derive"
PV = "0.13.5"
PR = "2.el10_2"
PACKAGES = " \
 rust-prost-derive+default-devel \
 rust-prost-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prost-derive-0.13.5-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "134788b5dc54386c11135c12e30b5154e73c4191fc2faaa24be603f4b06d2eb2"

URI_x86_64_v2_rust-prost-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-derive+default-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-derive+default-devel}"
SRC_URI[x86_64_v2_rust-prost-derive+default-devel.sha256sum] = "a6654c023f1c71801565094ef3e0f1a4f9ff97d27d09d94b1e17d0bf32fc2dc7"

URI_x86_64_v2_rust-prost-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prost-derive-devel-0.13.5-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prost-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prost-derive-devel}"
SRC_URI[x86_64_v2_rust-prost-derive-devel.sha256sum] = "4b7a3859fac3eff6e782f864ca5a076418a2edfb5afab1a688bc52218438b9f2"

URI_aarch64_rust-prost-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-derive+default-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-derive+default-devel}"
SRC_URI[aarch64_rust-prost-derive+default-devel.sha256sum] = "f240a2fb9f2b25ac863b66046ac2843c2ba6f7d0032b70baaacf8781c288793b"

URI_aarch64_rust-prost-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prost-derive-devel-0.13.5-2.el10_2.noarch.rpm;name=aarch64_rust-prost-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prost-derive-devel}"
SRC_URI[aarch64_rust-prost-derive-devel.sha256sum] = "55212e127a9d1065d7de1398953c1596f2999267e5156c050154fdbe4a31a822"

RDEPENDS:rust-prost-derive+default-devel = " \
 cargo \
 rust-prost-derive-devel \
 "
RDEPENDS:rust-prost-derive-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 virtual/crate_itertools/default__ge_0.10.1_with_crate_itertools/default__lt_0.15.0~ \
 "
