# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unrealircd"
PV = "6.1.10"
PR = "1.el10_0"
PACKAGES = " \
 unrealircd \
 unrealircd-maxmind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unrealircd-6.1.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0963e0189c765c888850d7cff374bfeb6c6bb621e4ceeddb78513e9a6b98442c"

URI_x86_64_v2_unrealircd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unrealircd-6.1.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unrealircd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unrealircd}"
SRC_URI[x86_64_v2_unrealircd.sha256sum] = "9cf1e330187fa1bf87e9fee1eb5648650a6c6c7598c8f1ec21dc421b0768e706"

URI_x86_64_v2_unrealircd-maxmind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unrealircd-maxmind-6.1.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unrealircd-maxmind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unrealircd-maxmind}"
SRC_URI[x86_64_v2_unrealircd-maxmind.sha256sum] = "dead09a782753b398fe0eb332af5b04a269f4ee05a4761e65c2c2d7a093c45f6"

URI_aarch64_unrealircd = "${EPEL_MIRROR}/aarch64/Packages/u/unrealircd-6.1.10-1.el10_0.aarch64.rpm;name=aarch64_unrealircd;unpack=0"
SRC_URI:append = " ${URI_aarch64_unrealircd}"
SRC_URI[aarch64_unrealircd.sha256sum] = "ca505ebfff1637b93fde0735ab889359775594d869d72ebde452a44ce0df9225"

URI_aarch64_unrealircd-maxmind = "${EPEL_MIRROR}/aarch64/Packages/u/unrealircd-maxmind-6.1.10-1.el10_0.aarch64.rpm;name=aarch64_unrealircd-maxmind;unpack=0"
SRC_URI:append = " ${URI_aarch64_unrealircd-maxmind}"
SRC_URI[aarch64_unrealircd-maxmind.sha256sum] = "683261e4b2538051a1d5b9e2f181d85a5498fe31a26ce32d2c3648837cc606bf"

RDEPENDS:unrealircd = " \
 bash \
 c-ares \
 glibc \
 jansson \
 libargon2 \
 libsodium \
 libxcrypt \
 openssl \
 openssl-libs \
 pcre2 \
 shadow-utils \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:unrealircd-maxmind = " \
 glibc \
 libmaxminddb \
 unrealircd \
 "
