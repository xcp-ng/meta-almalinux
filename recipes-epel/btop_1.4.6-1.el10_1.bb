# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "btop"
PV = "1.4.6"
PR = "1.el10_1"
PACKAGES = " \
 btop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/btop-1.4.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e431f62756b7bcca1617bf21bb2c08a6b3ddaef840d9d9bcf5896c0c7882967"

URI_x86_64_v2_btop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/btop-1.4.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_btop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_btop}"
SRC_URI[x86_64_v2_btop.sha256sum] = "b8576d2d32db4852cd3504256c041b31ed629b80fabd0d6cf0431da2cef0a557"

URI_aarch64_btop = "${EPEL_MIRROR}/aarch64/Packages/b/btop-1.4.6-1.el10_1.aarch64.rpm;name=aarch64_btop;unpack=0"
SRC_URI:append = " ${URI_aarch64_btop}"
SRC_URI[aarch64_btop.sha256sum] = "b9f427aefd1f9c3de732c988cbf0e2f6467cfdb4b3c6364e59fa821abb6cf07e"

RDEPENDS:btop = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 "
