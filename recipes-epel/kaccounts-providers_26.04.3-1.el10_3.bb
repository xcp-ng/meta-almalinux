# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaccounts-providers"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kaccounts-providers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaccounts-providers-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "738e51a8d8c953d91a564cecd0c1d6700e6881f5f192561b97bfdffe77111a95"

URI_x86_64_v2_kaccounts-providers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaccounts-providers-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaccounts-providers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaccounts-providers}"
SRC_URI[x86_64_v2_kaccounts-providers.sha256sum] = "059514b1b0490dab9ada25392eabb42aaf2be829ad27c80ac71aced2fee2954c"

URI_aarch64_kaccounts-providers = "${EPEL_MIRROR}/aarch64/Packages/k/kaccounts-providers-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kaccounts-providers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaccounts-providers}"
SRC_URI[aarch64_kaccounts-providers.sha256sum] = "56f0956e8de902ca9dc51c5fb9f3223250424edaa06cfa2d3a67ae8e15dfba67"

RDEPENDS:kaccounts-providers = " \
 glibc \
 kaccounts-integration-qt6 \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kpackage \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 signon-plugin-oauth2 \
 signon-ui \
 "
