# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-LoadLines"
PV = "1.047"
PR = "1.el10_0"
PACKAGES = " \
 perl-File-LoadLines \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-LoadLines-1.047-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c6e6ee80b3ea841fdf2fad48f07671ae06a3a022007a3f7bdae44896627ed6a"

URI_x86_64_v2_perl-File-LoadLines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-LoadLines-1.047-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-LoadLines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-LoadLines}"
SRC_URI[x86_64_v2_perl-File-LoadLines.sha256sum] = "1a8c351e9be4a29a4b03faad662cb0444df83c5a7b99296a7f63b26dadb5b96a"

URI_aarch64_perl-File-LoadLines = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-LoadLines-1.047-1.el10_0.noarch.rpm;name=aarch64_perl-File-LoadLines;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-LoadLines}"
SRC_URI[aarch64_perl-File-LoadLines.sha256sum] = "375031d3821d739f94a5df26c46047e9435ef26b55383641bc52872423d93167"

RDEPENDS:perl-File-LoadLines = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-libs \
 "
