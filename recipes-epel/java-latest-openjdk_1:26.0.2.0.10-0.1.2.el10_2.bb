# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk"
PE = "1"
PV = "26.0.2.0.10"
PR = "0.1.2.el10_2"
PACKAGES = " \
 java-latest-openjdk \
 java-latest-openjdk-crypto-adapter \
 java-latest-openjdk-crypto-adapter-fastdebug \
 java-latest-openjdk-crypto-adapter-slowdebug \
 java-latest-openjdk-demo \
 java-latest-openjdk-demo-fastdebug \
 java-latest-openjdk-demo-slowdebug \
 java-latest-openjdk-devel \
 java-latest-openjdk-devel-fastdebug \
 java-latest-openjdk-devel-slowdebug \
 java-latest-openjdk-fastdebug \
 java-latest-openjdk-headless \
 java-latest-openjdk-headless-fastdebug \
 java-latest-openjdk-headless-slowdebug \
 java-latest-openjdk-javadoc \
 java-latest-openjdk-javadoc-zip \
 java-latest-openjdk-jmods \
 java-latest-openjdk-jmods-fastdebug \
 java-latest-openjdk-jmods-slowdebug \
 java-latest-openjdk-slowdebug \
 java-latest-openjdk-src \
 java-latest-openjdk-src-fastdebug \
 java-latest-openjdk-src-slowdebug \
 java-latest-openjdk-static-libs \
 java-latest-openjdk-static-libs-fastdebug \
 java-latest-openjdk-static-libs-slowdebug \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-26.0.2.0.10-0.1.2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "959e74d5f3926144eb20821c2728f850172cbf86ee27270ffbf69379fe9b515a"

URI_x86_64_v2_java-latest-openjdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk}"
SRC_URI[x86_64_v2_java-latest-openjdk.sha256sum] = "d3b761f74f97784b2a9efa5513c29246b168fda6ff3fb0883f5c54f65b379476"

URI_x86_64_v2_java-latest-openjdk-crypto-adapter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-crypto-adapter}"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter.sha256sum] = "15f385a7f70ef86190ff75f42ec7f161a7a3a5cc117fa8896552d8c537c43409"

URI_x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-fastdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "151f09720c9c07fcab91bf474a7799c58d25e0f37268b9ffbdd4201c084db196"

URI_x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-slowdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "2279d5de9db88e204aee84904b12168b996f552098d96637b5b95786e92b253f"

URI_x86_64_v2_java-latest-openjdk-demo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo.sha256sum] = "46a1229e78f0901f39060fdd39834605c371bdec22d535258458d8f127bc1078"

URI_x86_64_v2_java-latest-openjdk-demo-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-fastdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-fastdebug.sha256sum] = "e0fae3ba59c51e53caaf7b4e82f3df4a43aee3090908b68a0fd543d311555220"

URI_x86_64_v2_java-latest-openjdk-demo-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-slowdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-slowdebug.sha256sum] = "453201b128dc51f36384cd1cac0f126f05e5fa941a830f16d5753e46d21360da"

URI_x86_64_v2_java-latest-openjdk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel.sha256sum] = "b9f46cbaa1fa00810bdd11500b035f00e25beeeffcbdaf761976086f83242d2b"

URI_x86_64_v2_java-latest-openjdk-devel-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-fastdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-fastdebug.sha256sum] = "18140fbd512757c886d21421ef06de47b85b7767e0a6e43922d8b28114171d64"

URI_x86_64_v2_java-latest-openjdk-devel-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-slowdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-slowdebug.sha256sum] = "db098783a251fb674f40d337749ef94e95d10e2006098b6d4acc8eebfcb7e54e"

URI_x86_64_v2_java-latest-openjdk-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-fastdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-fastdebug.sha256sum] = "8394c64ac2b2667f596902a42989651ea5c94f1cbc6d9e95877bbb2ab5c93aa7"

URI_x86_64_v2_java-latest-openjdk-headless = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless.sha256sum] = "a3abaeb1b324beee8b0fb90ca7cb192f78358e2c884fafe97175d9a25d2fa601"

URI_x86_64_v2_java-latest-openjdk-headless-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-fastdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-fastdebug.sha256sum] = "5d761571e236ba85c669552576d72f20d250e3bb631cb95d62441b56a1b14a10"

URI_x86_64_v2_java-latest-openjdk-headless-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-slowdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-slowdebug.sha256sum] = "de70db46b5a4a2f612784595d4f5d9fd18aef712227a8d702d5756b95fce0c9f"

URI_x86_64_v2_java-latest-openjdk-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc.sha256sum] = "62b032e656df97b6d8dea01b671fc2c3471b0950606d96acea0bfd83e6b029c9"

URI_x86_64_v2_java-latest-openjdk-javadoc-zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-zip-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc-zip.sha256sum] = "f911247eeb09ae9b08cbefc6c9371d4f2fd44a51d6767232c09bbe7c215892ba"

URI_x86_64_v2_java-latest-openjdk-jmods = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods.sha256sum] = "b9dd6c38ca6fc29ccf358294059e209c1625ae20a1a8a6077bb3a53bc7ec5bc8"

URI_x86_64_v2_java-latest-openjdk-jmods-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-fastdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-fastdebug.sha256sum] = "7cb216c81194d1c01cc5094445bc135f97bba8e57bd94283e54cea5a3396f83b"

URI_x86_64_v2_java-latest-openjdk-jmods-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-slowdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-slowdebug.sha256sum] = "55b3ceec5f529a3d63aafaa58b488f673c2a3a7d7017c7e67f4d30bd2a021e07"

URI_x86_64_v2_java-latest-openjdk-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-slowdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-slowdebug.sha256sum] = "d5c02492580aa0966b61507aac09143c1f4ab9218ab93347a7e0a34e3facdd90"

URI_x86_64_v2_java-latest-openjdk-src = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src}"
SRC_URI[x86_64_v2_java-latest-openjdk-src.sha256sum] = "6b5b37ce9bcd7dd190b3363b4f7019ea74a9ea3b5a7431596f7e5b0bba869fbb"

URI_x86_64_v2_java-latest-openjdk-src-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-fastdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-src-fastdebug.sha256sum] = "3a09638b6bd24658c8aca92377e0adce7e68dcd2b01f897310c81c5dd10dd14a"

URI_x86_64_v2_java-latest-openjdk-src-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-slowdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-src-slowdebug.sha256sum] = "5685c7e37a0e894ebd3e88065151056aa8164f9f1045de8a8c238816cb7d7e2c"

URI_x86_64_v2_java-latest-openjdk-static-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs.sha256sum] = "d6a1e503ec9748e04d570ac87efcca33abb3cff2c5a58ee0f9f10bf01d2abb2e"

URI_x86_64_v2_java-latest-openjdk-static-libs-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-fastdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "8cbcad70e446aa93f63a197cf98f73f2cedc756a31396536117e1a2c5d828983"

URI_x86_64_v2_java-latest-openjdk-static-libs-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-slowdebug-26.0.2.0.10-0.1.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "b8030151c81d0dad98c568f15bc1403629a3cbf3803c7890f61835619a3b8d5f"

URI_aarch64_java-latest-openjdk = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk}"
SRC_URI[aarch64_java-latest-openjdk.sha256sum] = "58c26ca7ca3a69c1e22947a6e3ff3a65c0cb416cb5562a89ceb82b92e526c9fd"

URI_aarch64_java-latest-openjdk-crypto-adapter = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-crypto-adapter}"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter.sha256sum] = "79acce3e51219f86e30739738e9ae867e6615414c8b71479be90a96f27cf2ee9"

URI_aarch64_java-latest-openjdk-crypto-adapter-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-fastdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-crypto-adapter-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "50eeed205136dd935d8ab3fe978e6a606292d08ee5ef9388e977c4e38f72418c"

URI_aarch64_java-latest-openjdk-crypto-adapter-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-slowdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-crypto-adapter-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "c5d42d2702bfa4bd501904388949adf1b7e2a2ceb19ce143e8e410e352825736"

URI_aarch64_java-latest-openjdk-demo = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo}"
SRC_URI[aarch64_java-latest-openjdk-demo.sha256sum] = "2023d41d40083d5b1b4ea025fbeec57471bc5f4a69bebf3b01e29e8fa97f2043"

URI_aarch64_java-latest-openjdk-demo-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-fastdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-demo-fastdebug.sha256sum] = "9b80b2e0038d7a02e2a7ea15857d048fcccc290634c5a8e5e53aa7494e502c99"

URI_aarch64_java-latest-openjdk-demo-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-slowdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-demo-slowdebug.sha256sum] = "73d90ca53fe578eaeff8c428fd99630ff879f95284e2454de59d1f356667b958"

URI_aarch64_java-latest-openjdk-devel = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel}"
SRC_URI[aarch64_java-latest-openjdk-devel.sha256sum] = "b738376a765c02f4435c11dc1d761c3eda26af180872266fa9ec5686cefea5e0"

URI_aarch64_java-latest-openjdk-devel-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-fastdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-devel-fastdebug.sha256sum] = "537a41a09f028e67aa83d417daf7d649915db6bcbfa9608b5c726e2d4dab090c"

URI_aarch64_java-latest-openjdk-devel-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-slowdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-devel-slowdebug.sha256sum] = "7c3b0dace92a4e2e499eeea0a852b24566130d1a3e2ed7a472dae5a741436c49"

URI_aarch64_java-latest-openjdk-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-fastdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-fastdebug.sha256sum] = "7b2105d6b2f606c673f6dd1d8267f34e9b5df5309be12de0252207be74ce1cb7"

URI_aarch64_java-latest-openjdk-headless = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless}"
SRC_URI[aarch64_java-latest-openjdk-headless.sha256sum] = "350e601a230dda25302d0352ce2832441ff673579d49b75904ffd5f53c3370c1"

URI_aarch64_java-latest-openjdk-headless-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-fastdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-headless-fastdebug.sha256sum] = "27091e25306b2565fade6e05b5a352ebb99ecea788aa44cba65f1e9570f17eda"

URI_aarch64_java-latest-openjdk-headless-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-slowdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-headless-slowdebug.sha256sum] = "164e15e4a17ac4e3a84de34a4171de971d7220e7987547761131d943884ff674"

URI_aarch64_java-latest-openjdk-javadoc = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-javadoc}"
SRC_URI[aarch64_java-latest-openjdk-javadoc.sha256sum] = "60db822bf5733de6e5f1c374550cdcee15d689f094e5bf27f69d9c8d3595678a"

URI_aarch64_java-latest-openjdk-javadoc-zip = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-zip-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-latest-openjdk-javadoc-zip.sha256sum] = "57bca36bbcc01fb935ec10d28aa45dee6891680030989dc0356b5e3ff8c16d72"

URI_aarch64_java-latest-openjdk-jmods = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods}"
SRC_URI[aarch64_java-latest-openjdk-jmods.sha256sum] = "d7f25a2d360446746f2edc12eac6ba03ca45c39f82b7e46bf464701ebd759e24"

URI_aarch64_java-latest-openjdk-jmods-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-fastdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-jmods-fastdebug.sha256sum] = "49665c51c4e63d34e19968fa20deae32dadd353c4d55ee838fb0173ec3a9de9a"

URI_aarch64_java-latest-openjdk-jmods-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-slowdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-jmods-slowdebug.sha256sum] = "21e132b5e08f91b2e8c22dadfb090416aef0783b837dad7765c59f425b215e56"

URI_aarch64_java-latest-openjdk-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-slowdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-slowdebug.sha256sum] = "7e492d2d05543ef17e359fd4f0f7da30963fc39dccc50667125a424849ec0a3f"

URI_aarch64_java-latest-openjdk-src = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src}"
SRC_URI[aarch64_java-latest-openjdk-src.sha256sum] = "996ea9ce53e7a9311c0f103da92fc7f3fec40e9b02ee33ca9a850dedc89902c2"

URI_aarch64_java-latest-openjdk-src-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-fastdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-src-fastdebug.sha256sum] = "b714e5413ab53bd48dd5236db49d8ad10c87c76ecbd23e2380f7ad4e4743c621"

URI_aarch64_java-latest-openjdk-src-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-slowdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-src-slowdebug.sha256sum] = "020557d046071818526147b82c822c824e1c4546ac41e0f86b48c069e13cebfc"

URI_aarch64_java-latest-openjdk-static-libs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs}"
SRC_URI[aarch64_java-latest-openjdk-static-libs.sha256sum] = "c0d6428edb1ff86de54c8e1aff5fd4f983206a56402a79ce88a5937c567c0024"

URI_aarch64_java-latest-openjdk-static-libs-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-fastdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "1ee787f13b41c1411eb797d089816b8b2891550b7c405d7774a218fdd449d0ea"

URI_aarch64_java-latest-openjdk-static-libs-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-slowdebug-26.0.2.0.10-0.1.2.el10_2.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "58062fc044dbb1651494a25ef4b350a072bc50797bd02a1ea78a6a989c9fd739"

RDEPENDS:java-latest-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-fastdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-slowdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-demo = " \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-demo-fastdebug = " \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-demo-slowdebug = " \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-fastdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-slowdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-javadoc = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-jmods = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-jmods-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-jmods-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
RDEPENDS:java-latest-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-src = " \
 java-latest-openjdk-headless \
 "
RDEPENDS:java-latest-openjdk-src-fastdebug = " \
 java-latest-openjdk-headless-fastdebug \
 "
RDEPENDS:java-latest-openjdk-src-slowdebug = " \
 java-latest-openjdk-headless-slowdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-static-libs-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
