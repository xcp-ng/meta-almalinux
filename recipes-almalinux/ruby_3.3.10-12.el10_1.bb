# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby"
PV = "3.3.10"
PR = "12.el10_1"
PACKAGES = " \
 ruby \
 ruby-bundled-gems \
 ruby-default-gems \
 ruby-devel \
 ruby-doc \
 ruby-libs \
 rubygem-bigdecimal \
 rubygem-bundler \
 rubygem-io-console \
 rubygem-irb \
 rubygem-json \
 rubygem-minitest \
 rubygem-power_assert \
 rubygem-psych \
 rubygem-racc \
 rubygem-rake \
 rubygem-rbs \
 rubygem-rdoc \
 rubygem-rexml \
 rubygem-rss \
 rubygem-test-unit \
 rubygem-typeprof \
 rubygems \
 rubygems-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby-3.3.10-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f9330facfe6b77651c98ba5440eab3cdcb33daff843d013cc880d08f60152dc"

URI_x86_64_v2_ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-3.3.10-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby}"
SRC_URI[x86_64_v2_ruby.sha256sum] = "58b256d4383c3fd61dc2c150f270baf84af71cd037448eb6bbe9982675106e5b"

URI_x86_64_v2_ruby-bundled-gems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-bundled-gems-3.3.10-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_ruby-bundled-gems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-bundled-gems}"
SRC_URI[x86_64_v2_ruby-bundled-gems.sha256sum] = "aea7884258d4795d49e3c71e0a30b75d32e11076e2c77a3d08c097da69d2fb1c"

URI_x86_64_v2_ruby-default-gems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-default-gems-3.3.10-12.el10_1.noarch.rpm;name=x86_64_v2_ruby-default-gems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-default-gems}"
SRC_URI[x86_64_v2_ruby-default-gems.sha256sum] = "71336de45838042488655b02bea61b62400f4d94b04ed23d206415cd8b15ec26"

URI_x86_64_v2_ruby-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-devel-3.3.10-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_ruby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-devel}"
SRC_URI[x86_64_v2_ruby-devel.sha256sum] = "b312292404706b5d4399b19fcfa3cc47938d5d0071fa94f11f634373fc2ddf23"

URI_x86_64_v2_ruby-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby-doc-3.3.10-12.el10_1.noarch.rpm;name=x86_64_v2_ruby-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-doc}"
SRC_URI[x86_64_v2_ruby-doc.sha256sum] = "1dc3201acb37e02b7a10c5379c6661f06102eca93e72e0d962d082e92401246b"

URI_x86_64_v2_ruby-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby-libs-3.3.10-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_ruby-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby-libs}"
SRC_URI[x86_64_v2_ruby-libs.sha256sum] = "ba4791b91630e1ca576939eda07d756fb4a4ce0b97c8a3851030fb74b67f2a41"

URI_x86_64_v2_rubygem-bigdecimal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bigdecimal-3.1.5-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_rubygem-bigdecimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-bigdecimal}"
SRC_URI[x86_64_v2_rubygem-bigdecimal.sha256sum] = "8d4b659c97f42a78ffbaaf8f99b01122cdccc613ca24d4576a49c3947456d689"

URI_x86_64_v2_rubygem-bundler = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-bundler-2.5.22-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-bundler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-bundler}"
SRC_URI[x86_64_v2_rubygem-bundler.sha256sum] = "c069a2edb81761f5fd0588c1baf91bbf67a19c7339badeed3027a3363a38c31f"

URI_x86_64_v2_rubygem-io-console = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-io-console-0.7.1-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_rubygem-io-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-io-console}"
SRC_URI[x86_64_v2_rubygem-io-console.sha256sum] = "0310568e3737dcf23fb03add6facac82a9c6d147823ad01d9b4e974dcce8bea5"

URI_x86_64_v2_rubygem-irb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-irb-1.13.1-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-irb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-irb}"
SRC_URI[x86_64_v2_rubygem-irb.sha256sum] = "2e5cc8766e4390c807aba6bb4fea5b071ca6cc3432043097cd0e4c3b7117e869"

URI_x86_64_v2_rubygem-json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-json-2.7.2-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_rubygem-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-json}"
SRC_URI[x86_64_v2_rubygem-json.sha256sum] = "23e3a3b50e67ff8595bc55540c7f545a82a9ce5b92404db7aefd2dd97da18a6b"

URI_x86_64_v2_rubygem-minitest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-minitest-5.20.0-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-minitest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-minitest}"
SRC_URI[x86_64_v2_rubygem-minitest.sha256sum] = "20b709f6262e3d72ded9cf8976cb92fbdfb99c2ca19f59c21713278bcb852a81"

URI_x86_64_v2_rubygem-power_assert = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-power_assert-2.0.3-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-power_assert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-power_assert}"
SRC_URI[x86_64_v2_rubygem-power_assert.sha256sum] = "2f57a40c4ace00b519b3ba1f854e786342304c85fd71db351ee88eb0df3d842a"

URI_x86_64_v2_rubygem-psych = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-psych-5.1.2-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_rubygem-psych;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-psych}"
SRC_URI[x86_64_v2_rubygem-psych.sha256sum] = "61ad9a7b9dff049f2eb3eb5cd27c8ac003b260d1c2cfca2837d8b13d75d172aa"

URI_x86_64_v2_rubygem-racc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-racc-1.7.3-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_rubygem-racc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-racc}"
SRC_URI[x86_64_v2_rubygem-racc.sha256sum] = "59a634ea06834d0ef7c67ca0ee43e334c38db514889a33187f39d3dd1ad1ccb0"

URI_x86_64_v2_rubygem-rake = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rake-13.1.0-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-rake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rake}"
SRC_URI[x86_64_v2_rubygem-rake.sha256sum] = "5281a9c6f4002817832f4a4c2f2eb3fe22e0865b1bfd825f7540119177b643b5"

URI_x86_64_v2_rubygem-rbs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rbs-3.4.0-12.el10_1.x86_64_v2.rpm;name=x86_64_v2_rubygem-rbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rbs}"
SRC_URI[x86_64_v2_rubygem-rbs.sha256sum] = "8297095f4a155c14f7e5445e2091c9f1f6e2d148bd4d39c6b926ff6ceba69378"

URI_x86_64_v2_rubygem-rdoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rdoc-6.6.3.1-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-rdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rdoc}"
SRC_URI[x86_64_v2_rubygem-rdoc.sha256sum] = "6fea1cdf73490412d0ddd620dd81c74fa1cdc2f10ffe3473608c6f31c7830999"

URI_x86_64_v2_rubygem-rexml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rexml-3.4.4-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-rexml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rexml}"
SRC_URI[x86_64_v2_rubygem-rexml.sha256sum] = "98c79088c5d4b9effe0618523a7f9fd20d6604837195598c91cc0fefc1a5e9b0"

URI_x86_64_v2_rubygem-rss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-rss-0.3.1-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-rss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rss}"
SRC_URI[x86_64_v2_rubygem-rss.sha256sum] = "1d6ce5b2df6a3c2cb96f7bb0876e3403fd8cc9dd4725fb0f8d784d311faa44f1"

URI_x86_64_v2_rubygem-test-unit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-test-unit-3.6.1-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-test-unit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-test-unit}"
SRC_URI[x86_64_v2_rubygem-test-unit.sha256sum] = "cc92b48f4586b1e1ebbdac44d3f38e4df1939c1d3e032d1797d5c9dbf4d9164a"

URI_x86_64_v2_rubygem-typeprof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-typeprof-0.21.9-12.el10_1.noarch.rpm;name=x86_64_v2_rubygem-typeprof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-typeprof}"
SRC_URI[x86_64_v2_rubygem-typeprof.sha256sum] = "9caae83a9a9cd8259017898d5c6e52aca0e0b184f310aee284d785127c93f834"

URI_x86_64_v2_rubygems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-3.5.22-12.el10_1.noarch.rpm;name=x86_64_v2_rubygems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygems}"
SRC_URI[x86_64_v2_rubygems.sha256sum] = "615b63152271dcf5db817f5a34f82a1afe84641688cd2c06c3df67001f07a626"

URI_x86_64_v2_rubygems-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygems-devel-3.5.22-12.el10_1.noarch.rpm;name=x86_64_v2_rubygems-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygems-devel}"
SRC_URI[x86_64_v2_rubygems-devel.sha256sum] = "a4d9e56afe95335efefaee74ee6f7f4111f27816169f5fcd954a9b8412c4f78d"

URI_aarch64_ruby = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-3.3.10-12.el10_1.aarch64.rpm;name=aarch64_ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby}"
SRC_URI[aarch64_ruby.sha256sum] = "860612147d4f127449598f41c85f9e03948f2e415b042ec54ad7f73eaa786099"

URI_aarch64_ruby-bundled-gems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-bundled-gems-3.3.10-12.el10_1.aarch64.rpm;name=aarch64_ruby-bundled-gems;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-bundled-gems}"
SRC_URI[aarch64_ruby-bundled-gems.sha256sum] = "b865fa680d46ce8b071a243060a1c014a339cb2daf3044e56510fa3fc8399b32"

URI_aarch64_ruby-default-gems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-default-gems-3.3.10-12.el10_1.noarch.rpm;name=aarch64_ruby-default-gems;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-default-gems}"
SRC_URI[aarch64_ruby-default-gems.sha256sum] = "71336de45838042488655b02bea61b62400f4d94b04ed23d206415cd8b15ec26"

URI_aarch64_ruby-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-devel-3.3.10-12.el10_1.aarch64.rpm;name=aarch64_ruby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-devel}"
SRC_URI[aarch64_ruby-devel.sha256sum] = "b63fbf9061f47011e7fda3ffda8589e631f66d9e7e800053778093e15c78b99f"

URI_aarch64_ruby-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby-doc-3.3.10-12.el10_1.noarch.rpm;name=aarch64_ruby-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-doc}"
SRC_URI[aarch64_ruby-doc.sha256sum] = "1dc3201acb37e02b7a10c5379c6661f06102eca93e72e0d962d082e92401246b"

URI_aarch64_ruby-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby-libs-3.3.10-12.el10_1.aarch64.rpm;name=aarch64_ruby-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby-libs}"
SRC_URI[aarch64_ruby-libs.sha256sum] = "5976b970ac7b5b1010613f899b51cbc6015772d6c1c520cfeb0f2d7cd4923028"

URI_aarch64_rubygem-bigdecimal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bigdecimal-3.1.5-12.el10_1.aarch64.rpm;name=aarch64_rubygem-bigdecimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-bigdecimal}"
SRC_URI[aarch64_rubygem-bigdecimal.sha256sum] = "df4c3bfe6ae01ae6fad350608a0dc1f65a8920d909b6e905a2a59c1f6740f7f3"

URI_aarch64_rubygem-bundler = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-bundler-2.5.22-12.el10_1.noarch.rpm;name=aarch64_rubygem-bundler;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-bundler}"
SRC_URI[aarch64_rubygem-bundler.sha256sum] = "c069a2edb81761f5fd0588c1baf91bbf67a19c7339badeed3027a3363a38c31f"

URI_aarch64_rubygem-io-console = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-io-console-0.7.1-12.el10_1.aarch64.rpm;name=aarch64_rubygem-io-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-io-console}"
SRC_URI[aarch64_rubygem-io-console.sha256sum] = "9825e7bdb7d9ff3fbd68b311dd6f29b4c65baaa8a668c870935a5facfea88b7e"

URI_aarch64_rubygem-irb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-irb-1.13.1-12.el10_1.noarch.rpm;name=aarch64_rubygem-irb;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-irb}"
SRC_URI[aarch64_rubygem-irb.sha256sum] = "2e5cc8766e4390c807aba6bb4fea5b071ca6cc3432043097cd0e4c3b7117e869"

URI_aarch64_rubygem-json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-json-2.7.2-12.el10_1.aarch64.rpm;name=aarch64_rubygem-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-json}"
SRC_URI[aarch64_rubygem-json.sha256sum] = "e281a850925ee0d8b8b8c3d3c9163e69eec54b7a9091c3d9af71ebf3234eecde"

URI_aarch64_rubygem-minitest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-minitest-5.20.0-12.el10_1.noarch.rpm;name=aarch64_rubygem-minitest;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-minitest}"
SRC_URI[aarch64_rubygem-minitest.sha256sum] = "20b709f6262e3d72ded9cf8976cb92fbdfb99c2ca19f59c21713278bcb852a81"

URI_aarch64_rubygem-power_assert = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-power_assert-2.0.3-12.el10_1.noarch.rpm;name=aarch64_rubygem-power_assert;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-power_assert}"
SRC_URI[aarch64_rubygem-power_assert.sha256sum] = "2f57a40c4ace00b519b3ba1f854e786342304c85fd71db351ee88eb0df3d842a"

URI_aarch64_rubygem-psych = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-psych-5.1.2-12.el10_1.aarch64.rpm;name=aarch64_rubygem-psych;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-psych}"
SRC_URI[aarch64_rubygem-psych.sha256sum] = "5474d95087c453b89a859f690a46799c5a2143073ffe136f4add4d518d6b279b"

URI_aarch64_rubygem-racc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-racc-1.7.3-12.el10_1.aarch64.rpm;name=aarch64_rubygem-racc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-racc}"
SRC_URI[aarch64_rubygem-racc.sha256sum] = "fe9b22b6919a5a7951dc7fccbaf2c23cdc44d3f78ceceff1453a532c5af33ff4"

URI_aarch64_rubygem-rake = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rake-13.1.0-12.el10_1.noarch.rpm;name=aarch64_rubygem-rake;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rake}"
SRC_URI[aarch64_rubygem-rake.sha256sum] = "5281a9c6f4002817832f4a4c2f2eb3fe22e0865b1bfd825f7540119177b643b5"

URI_aarch64_rubygem-rbs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rbs-3.4.0-12.el10_1.aarch64.rpm;name=aarch64_rubygem-rbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rbs}"
SRC_URI[aarch64_rubygem-rbs.sha256sum] = "89fb943dcbab57f844358168682524e22e6b6bd42a856b1be352c25eec85f331"

URI_aarch64_rubygem-rdoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rdoc-6.6.3.1-12.el10_1.noarch.rpm;name=aarch64_rubygem-rdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rdoc}"
SRC_URI[aarch64_rubygem-rdoc.sha256sum] = "6fea1cdf73490412d0ddd620dd81c74fa1cdc2f10ffe3473608c6f31c7830999"

URI_aarch64_rubygem-rexml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rexml-3.4.4-12.el10_1.noarch.rpm;name=aarch64_rubygem-rexml;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rexml}"
SRC_URI[aarch64_rubygem-rexml.sha256sum] = "98c79088c5d4b9effe0618523a7f9fd20d6604837195598c91cc0fefc1a5e9b0"

URI_aarch64_rubygem-rss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-rss-0.3.1-12.el10_1.noarch.rpm;name=aarch64_rubygem-rss;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rss}"
SRC_URI[aarch64_rubygem-rss.sha256sum] = "1d6ce5b2df6a3c2cb96f7bb0876e3403fd8cc9dd4725fb0f8d784d311faa44f1"

URI_aarch64_rubygem-test-unit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-test-unit-3.6.1-12.el10_1.noarch.rpm;name=aarch64_rubygem-test-unit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-test-unit}"
SRC_URI[aarch64_rubygem-test-unit.sha256sum] = "cc92b48f4586b1e1ebbdac44d3f38e4df1939c1d3e032d1797d5c9dbf4d9164a"

URI_aarch64_rubygem-typeprof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-typeprof-0.21.9-12.el10_1.noarch.rpm;name=aarch64_rubygem-typeprof;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-typeprof}"
SRC_URI[aarch64_rubygem-typeprof.sha256sum] = "9caae83a9a9cd8259017898d5c6e52aca0e0b184f310aee284d785127c93f834"

URI_aarch64_rubygems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-3.5.22-12.el10_1.noarch.rpm;name=aarch64_rubygems;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygems}"
SRC_URI[aarch64_rubygems.sha256sum] = "615b63152271dcf5db817f5a34f82a1afe84641688cd2c06c3df67001f07a626"

URI_aarch64_rubygems-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygems-devel-3.5.22-12.el10_1.noarch.rpm;name=aarch64_rubygems-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygems-devel}"
SRC_URI[aarch64_rubygems-devel.sha256sum] = "a4d9e56afe95335efefaee74ee6f7f4111f27816169f5fcd954a9b8412c4f78d"

RDEPENDS:ruby = " \
 glibc \
 gmp \
 libxcrypt \
 ruby-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby-bundled-gems = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygem-irb \
 rubygems \
 "
RDEPENDS:ruby-default-gems = " \
 ruby \
 ruby-default-gems \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:ruby-devel = " \
 pkgconf-pkg-config \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:ruby-doc = " \
 rubygem-rdoc \
 "
RDEPENDS:ruby-libs = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:rubygem-bigdecimal = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-bundler = " \
 ruby \
 rubygem-io-console \
 rubygems \
 "
RDEPENDS:rubygem-io-console = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-irb = " \
 ruby \
 ruby-default-gems \
 rubygem-rdoc \
 rubygems \
 "
RDEPENDS:rubygem-json = " \
 glibc \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-minitest = " \
 rubygems \
 "
RDEPENDS:rubygem-power_assert = " \
 rubygems \
 "
RDEPENDS:rubygem-psych = " \
 glibc \
 libyaml \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-racc = " \
 glibc \
 ruby \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rake = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-rbs = " \
 glibc \
 ruby \
 ruby-default-gems \
 ruby-libs \
 rubygems \
 "
RDEPENDS:rubygem-rdoc = " \
 ruby \
 rubygem-io-console \
 rubygem-json \
 rubygem-psych \
 rubygems \
 "
RDEPENDS:rubygem-rexml = " \
 rubygems \
 "
RDEPENDS:rubygem-rss = " \
 rubygem-rexml \
 rubygems \
 "
RDEPENDS:rubygem-test-unit = " \
 rubygem-power_assert \
 rubygems \
 "
RDEPENDS:rubygem-typeprof = " \
 ruby \
 rubygem-rbs \
 rubygems \
 "
RDEPENDS:rubygems = " \
 ruby \
 ruby-libs \
 rubygem-psych \
 "
RDEPENDS:rubygems-devel = " \
 ruby \
 rubygem-json \
 rubygem-rdoc \
 rubygems \
 "
