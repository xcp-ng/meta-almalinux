# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rouge"
PV = "4.4.0"
PR = "1.el10_0"
PACKAGES = " \
 rubygem-rouge \
 rubygem-rouge-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-rouge-4.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4997810da8985cfb955e28355cc7c2c78508f62fcddc2da4d065df116a42f40a"

URI_x86_64_v2_rubygem-rouge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rouge-4.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rouge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rouge}"
SRC_URI[x86_64_v2_rubygem-rouge.sha256sum] = "2614ff1beb742a8ab4636522ca7bb3878ae091401f59e41fee65152bf1df3109"

URI_x86_64_v2_rubygem-rouge-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rouge-doc-4.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rouge-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rouge-doc}"
SRC_URI[x86_64_v2_rubygem-rouge-doc.sha256sum] = "1476a0314cfe50a2f72b84b9ca0f5b8b15f9d7246975579e31a214fbd11d3263"

URI_aarch64_rubygem-rouge = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rouge-4.4.0-1.el10_0.noarch.rpm;name=aarch64_rubygem-rouge;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rouge}"
SRC_URI[aarch64_rubygem-rouge.sha256sum] = "692fc62748645f54bf5cffaddd441c65cb5af401e80a503d332536ee44eec123"

URI_aarch64_rubygem-rouge-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rouge-doc-4.4.0-1.el10_0.noarch.rpm;name=aarch64_rubygem-rouge-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rouge-doc}"
SRC_URI[aarch64_rubygem-rouge-doc.sha256sum] = "80dc1d8cc7b92240301434e52fa89cba6779d9e256d68b25b13209f27633d318"

RDEPENDS:rubygem-rouge = " \
 ruby \
 rubygems \
 "
RDEPENDS:rubygem-rouge-doc = " \
 rubygem-rouge \
 "
