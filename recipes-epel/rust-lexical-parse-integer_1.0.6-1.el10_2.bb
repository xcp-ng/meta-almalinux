# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexical-parse-integer"
PV = "1.0.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-lexical-parse-integer+compact-devel \
 rust-lexical-parse-integer+default-devel \
 rust-lexical-parse-integer+format-devel \
 rust-lexical-parse-integer+lint-devel \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-parse-integer+radix-devel \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-parse-integer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexical-parse-integer-1.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05bb289cda51e62a1bf6964dde3ef7a2e1b6a409db3b30ddf4d8a62cd0e71fb8"

URI_x86_64_v2_rust-lexical-parse-integer+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+compact-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+compact-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+compact-devel.sha256sum] = "9dd723803aff8b9f4f5449a373548e635aed596c5afac9bac87cbe6daf4f394d"

URI_x86_64_v2_rust-lexical-parse-integer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+default-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+default-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+default-devel.sha256sum] = "472da1aae5c4caedf780b18c7bab770bafa69584eabaaff31892d83e7a88a464"

URI_x86_64_v2_rust-lexical-parse-integer+format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+format-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+format-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+format-devel.sha256sum] = "02e07681d8fb7cef319b259727457ed7af7464a0e72d2265a7e971e564072bef"

URI_x86_64_v2_rust-lexical-parse-integer+lint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+lint-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+lint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+lint-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+lint-devel.sha256sum] = "b878e50781f78b29848fe5c13eee383e7d634c6092233f3250e6c0a2f60a3007"

URI_x86_64_v2_rust-lexical-parse-integer+power-of-two-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+power-of-two-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+power-of-two-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+power-of-two-devel.sha256sum] = "18f574bd1c3026f54884646b44586c06225dcae2a7e52618f4c36e36654a7437"

URI_x86_64_v2_rust-lexical-parse-integer+radix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+radix-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+radix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+radix-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+radix-devel.sha256sum] = "5e056c3a314ad6187a318844c2899b89816c4be8600d0d8ddc8f7fd6ba101da5"

URI_x86_64_v2_rust-lexical-parse-integer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer+std-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer+std-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer+std-devel.sha256sum] = "bcaca08e98dd5e25b18a819be61747726eed5e76e328fc6efcd256354120ff66"

URI_x86_64_v2_rust-lexical-parse-integer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexical-parse-integer-devel-1.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexical-parse-integer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexical-parse-integer-devel}"
SRC_URI[x86_64_v2_rust-lexical-parse-integer-devel.sha256sum] = "ce2ce124efdd8369576bfa7ce47783e9f70615b0f9bce45efb59f00af5cde770"

URI_aarch64_rust-lexical-parse-integer+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+compact-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-integer+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+compact-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+compact-devel.sha256sum] = "3d4cb6e1004fd6fb5515c9ca83c866d9bc585e8c102a07de363bc96dc28d163d"

URI_aarch64_rust-lexical-parse-integer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+default-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+default-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+default-devel.sha256sum] = "ad4b127c0ee09356280e613c0390ca78557e42b7a0458a98db493afa9c678060"

URI_aarch64_rust-lexical-parse-integer+format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+format-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-integer+format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+format-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+format-devel.sha256sum] = "7472023f080d723f22e4dea96c67e17d3ad6dc457f9dfe86650819460e68a340"

URI_aarch64_rust-lexical-parse-integer+lint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+lint-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-integer+lint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+lint-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+lint-devel.sha256sum] = "6b563599b922a605d48d94b7b1654ea26b9bf5f21593f574478759718d257f8a"

URI_aarch64_rust-lexical-parse-integer+power-of-two-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+power-of-two-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-integer+power-of-two-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+power-of-two-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+power-of-two-devel.sha256sum] = "3473275aff192ddd1ed40be11c650631deab24d4f31dab438d24f15caa3d7ea2"

URI_aarch64_rust-lexical-parse-integer+radix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+radix-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-integer+radix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+radix-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+radix-devel.sha256sum] = "0e98d0fcf4096a1e0d32fd1fe9ff21e3eb93862f8b272b740b55b821171af461"

URI_aarch64_rust-lexical-parse-integer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer+std-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer+std-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer+std-devel.sha256sum] = "44f84bd5badf9a1294e14f35a01719ef23356b31a36d4352a9d8a34cbc66c115"

URI_aarch64_rust-lexical-parse-integer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexical-parse-integer-devel-1.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-lexical-parse-integer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexical-parse-integer-devel}"
SRC_URI[aarch64_rust-lexical-parse-integer-devel.sha256sum] = "a7bb5e5b84d4da3c7432c4e0a5d57a375441a015ead56821772b1ac7715afb9a"

RDEPENDS:rust-lexical-parse-integer+compact-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+compact-devel \
 "
RDEPENDS:rust-lexical-parse-integer+default-devel = " \
 cargo \
 rust-lexical-parse-integer+std-devel \
 rust-lexical-parse-integer-devel \
 "
RDEPENDS:rust-lexical-parse-integer+format-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+format-devel \
 "
RDEPENDS:rust-lexical-parse-integer+lint-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+lint-devel \
 "
RDEPENDS:rust-lexical-parse-integer+power-of-two-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+power-of-two-devel \
 "
RDEPENDS:rust-lexical-parse-integer+radix-devel = " \
 cargo \
 rust-lexical-parse-integer+power-of-two-devel \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+radix-devel \
 "
RDEPENDS:rust-lexical-parse-integer+std-devel = " \
 cargo \
 rust-lexical-parse-integer-devel \
 rust-lexical-util+std-devel \
 "
RDEPENDS:rust-lexical-parse-integer-devel = " \
 cargo \
 rust \
 rust-lexical-util+parse-integers-devel \
 rust-lexical-util-devel \
 "
