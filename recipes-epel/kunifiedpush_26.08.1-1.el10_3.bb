# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kunifiedpush"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kunifiedpush \
 kunifiedpush-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kunifiedpush-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "acea8cd1a03a5b490fa9e6680f69947c137085cbfb88d12d671496c6fcf7a627"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush;unpack=0"
SRC_URI[x86_64_v2_kunifiedpush.sha256sum] = "d13bbe4481dcebc1e6fb57aee4d0a90446275e2a9632f204305e215a6ab48d5f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush-devel;unpack=0"
SRC_URI[x86_64_v2_kunifiedpush-devel.sha256sum] = "2bf5df053e376539c830e5001450ab0ea4051484588a5ff80b6dd0e92648e3de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kunifiedpush;unpack=0"
SRC_URI[aarch64_kunifiedpush.sha256sum] = "c3924614bcbca8397d6e5c7cda50ecff39887c301008032f8f31eb7f8cd73a70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kunifiedpush-devel;unpack=0"
SRC_URI[aarch64_kunifiedpush-devel.sha256sum] = "2e3620c02903cd4b7269d111a9d770eac3301e99b786e54853e65d718f0fcfb4"

RDEPENDS:kunifiedpush = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kservice \
 kf6-solid \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:kunifiedpush-devel = " \
 cmake-filesystem \
 kunifiedpush \
 "
