# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zeal"
PV = "0.7.2"
PR = "2.el10_0"
PACKAGES = " \
 zeal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zeal-0.7.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efd92fb8b4cd2ca0f3788f26869ebda1ed8cc798858a6bddbcff698dec825cac"

URI_x86_64_v2_zeal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zeal-0.7.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zeal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zeal}"
SRC_URI[x86_64_v2_zeal.sha256sum] = "b7c7c1a4cb5120e81b1fd8a30b736b978999e8e17b736d3aeac3e4bd56a3910a"

URI_aarch64_zeal = "${EPEL_MIRROR}/aarch64/Packages/z/zeal-0.7.2-2.el10_0.aarch64.rpm;name=aarch64_zeal;unpack=0"
SRC_URI:append = " ${URI_aarch64_zeal}"
SRC_URI[aarch64_zeal.sha256sum] = "d07eba3a6e934b58170c9e4006e55b9a42ff731816da84bd6c17dafbc08af0ba"

RDEPENDS:zeal = " \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libarchive \
 libgcc \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 sqlite-libs \
 xcb-util-keysyms \
 "
