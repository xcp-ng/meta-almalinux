# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyqt6"
PV = "6.9.0"
PR = "1.el10"
PACKAGES = " \
 python-pyqt6-doc \
 python-pyqt6-rpm-macros \
 python3-pyqt6 \
 python3-pyqt6-base \
 python3-pyqt6-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pyqt6-6.9.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ee01318b98b1f57ce3f25db770f01640ea440ebc101f512ae7ea19c403f90fc"

URI_x86_64_v2_python-pyqt6-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python-pyqt6-doc-6.9.0-1.el10.noarch.rpm;name=x86_64_v2_python-pyqt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyqt6-doc}"
SRC_URI[x86_64_v2_python-pyqt6-doc.sha256sum] = "22c8a977a86735c5d27d907ca994b6eb80f877eccce9500c21a4132c724243a1"

URI_x86_64_v2_python-pyqt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-pyqt6-rpm-macros-6.9.0-1.el10.noarch.rpm;name=x86_64_v2_python-pyqt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyqt6-rpm-macros}"
SRC_URI[x86_64_v2_python-pyqt6-rpm-macros.sha256sum] = "f8eadc547fa3e3842220ce7f0a0d0a2a9b2c9f38876157c9c9b23e2adac99a4d"

URI_x86_64_v2_python3-pyqt6 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyqt6-6.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6}"
SRC_URI[x86_64_v2_python3-pyqt6.sha256sum] = "90208a13d52d6bc818f4c356178255776f550e64bc1e4f52eb78825cab0ccc5e"

URI_x86_64_v2_python3-pyqt6-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyqt6-base-6.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-base}"
SRC_URI[x86_64_v2_python3-pyqt6-base.sha256sum] = "b709f58490049e7615e1d89f31c005d4cf501eaf4c65008c3dcfb18bbaf84208"

URI_x86_64_v2_python3-pyqt6-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyqt6-devel-6.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-devel}"
SRC_URI[x86_64_v2_python3-pyqt6-devel.sha256sum] = "0beec7f14bea6475ebc6f1aca86dcb878f38b45cc0be1da915362cc8a753a4ba"

URI_aarch64_python-pyqt6-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python-pyqt6-doc-6.9.0-1.el10.noarch.rpm;name=aarch64_python-pyqt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyqt6-doc}"
SRC_URI[aarch64_python-pyqt6-doc.sha256sum] = "22c8a977a86735c5d27d907ca994b6eb80f877eccce9500c21a4132c724243a1"

URI_aarch64_python-pyqt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-pyqt6-rpm-macros-6.9.0-1.el10.noarch.rpm;name=aarch64_python-pyqt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyqt6-rpm-macros}"
SRC_URI[aarch64_python-pyqt6-rpm-macros.sha256sum] = "f8eadc547fa3e3842220ce7f0a0d0a2a9b2c9f38876157c9c9b23e2adac99a4d"

URI_aarch64_python3-pyqt6 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyqt6-6.9.0-1.el10.aarch64.rpm;name=aarch64_python3-pyqt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6}"
SRC_URI[aarch64_python3-pyqt6.sha256sum] = "863869bb3ce5104b9f9fc6d2d735ac7b6451e392b858d101864fd2807b471c24"

URI_aarch64_python3-pyqt6-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyqt6-base-6.9.0-1.el10.aarch64.rpm;name=aarch64_python3-pyqt6-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-base}"
SRC_URI[aarch64_python3-pyqt6-base.sha256sum] = "f0aea13e067a90d9e189993ab68e47e14ff587fc26f36590be147185c90206cb"

URI_aarch64_python3-pyqt6-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyqt6-devel-6.9.0-1.el10.aarch64.rpm;name=aarch64_python3-pyqt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-devel}"
SRC_URI[aarch64_python3-pyqt6-devel.sha256sum] = "f01d3d006a8853e69e46d3cc9b6156a36c186e6aee179f9b1b7e5182985dcfe3"

RDEPENDS:python-pyqt6-doc = " \
 "
RDEPENDS:python-pyqt6-rpm-macros = " \
 "
RDEPENDS:python3-pyqt6 = " \
 glibc \
 libstdc++ \
 python3 \
 python3-pyqt6-base \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtconnectivity \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtquick3d \
 qt6-qtremoteobjects \
 qt6-qtsensors \
 qt6-qtserialport \
 qt6-qtspeech \
 qt6-qtsvg \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-help \
 qt6-qtwebchannel \
 qt6-qtwebsockets \
 "
RDEPENDS:python3-pyqt6-base = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libstdc++ \
 python-pyqt6-rpm-macros \
 python3 \
 python3-dbus \
 python3-libs \
 python3-pyqt6-sip \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:python3-pyqt6-devel = " \
 python3-pyqt6 \
 qt6-qtbase-devel \
 "
