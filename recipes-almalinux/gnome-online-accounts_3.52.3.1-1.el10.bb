# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-online-accounts"
PV = "3.52.3.1"
PR = "1.el10"
PACKAGES = " \
 gnome-online-accounts \
 gnome-online-accounts-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-online-accounts-3.52.3.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b650704c115b2260e9c65728cf4734900cd903cc359b9aeeb9db25a4a0bad659"

URI_x86_64_v2_gnome-online-accounts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-online-accounts-3.52.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-online-accounts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-online-accounts}"
SRC_URI[x86_64_v2_gnome-online-accounts.sha256sum] = "fb023eae6cb04ea58be669a0658d6115d64e1fc1fd9d81d0efc6b47ed71e9c56"

URI_x86_64_v2_gnome-online-accounts-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-online-accounts-devel-3.52.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-online-accounts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-online-accounts-devel}"
SRC_URI[x86_64_v2_gnome-online-accounts-devel.sha256sum] = "929bde50df52dd7ba826965a2d76db5da4fb3b3f2f70848837812f6af9e80de1"

URI_aarch64_gnome-online-accounts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-online-accounts-3.52.3.1-1.el10.aarch64.rpm;name=aarch64_gnome-online-accounts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-online-accounts}"
SRC_URI[aarch64_gnome-online-accounts.sha256sum] = "7fa9bff441c5f6c6d77f3bef85e798a8ca88c7543661cae30dfd264954d4e03d"

URI_aarch64_gnome-online-accounts-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-online-accounts-devel-3.52.3.1-1.el10.aarch64.rpm;name=aarch64_gnome-online-accounts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-online-accounts-devel}"
SRC_URI[aarch64_gnome-online-accounts-devel.sha256sum] = "afe99897ad393f4779c70e81cc4dd62a74c456cd3e67e5b24ab84aa1fa1eaf0c"

RDEPENDS:gnome-online-accounts = " \
 gcr-libs \
 glib2 \
 glibc \
 gtk4 \
 gvfs-goa \
 json-glib \
 keyutils-libs \
 krb5-libs \
 libadwaita \
 libgcc \
 libsecret \
 libsoup3 \
 libxml2 \
 rest \
 "
RDEPENDS:gnome-online-accounts-devel = " \
 glib2-devel \
 gnome-online-accounts \
 gnome-online-accounts-devel \
 gtk4-devel \
 libadwaita-devel \
 pkgconf-pkg-config \
 "
