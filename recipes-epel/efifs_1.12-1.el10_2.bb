# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "efifs"
PV = "1.12"
PR = "1.el10_2"
PACKAGES = " \
 efifs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/efifs-1.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2d3e7effe37463c607825f297679e88edb6c66830980a57a5fb8628421296ab"

URI_x86_64_v2_efifs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/efifs-1.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_efifs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_efifs}"
SRC_URI[x86_64_v2_efifs.sha256sum] = "fc992fc48d73224b4a2049476a5c9d5f94848a14917bf1115e220ff7635c4ba9"

URI_aarch64_efifs = "${EPEL_MIRROR}/aarch64/Packages/e/efifs-1.12-1.el10_2.aarch64.rpm;name=aarch64_efifs;unpack=0"
SRC_URI:append = " ${URI_aarch64_efifs}"
SRC_URI[aarch64_efifs.sha256sum] = "40deb79c01c39efd3895ac61d67b9ea8a351e170315bbbaae9549526942a4029"

RDEPENDS:efifs = " \
 efi-filesystem \
 "
