# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "abseil-cpp"
PV = "20240722.2"
PR = "1.el10_2"
PACKAGES = " \
 abseil-cpp \
 abseil-cpp-devel \
 abseil-cpp-testing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/abseil-cpp-20240722.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91347d8f1c2a8da5a7d0d00d9cad487c235d51b0fafe7e13f3582e9d63630d17"

URI_x86_64_v2_abseil-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/abseil-cpp-20240722.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_abseil-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_abseil-cpp}"
SRC_URI[x86_64_v2_abseil-cpp.sha256sum] = "96666b6f8b8677492e608d55d5ca9774766b03b34df17bae03812422a565942f"

URI_x86_64_v2_abseil-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/abseil-cpp-devel-20240722.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_abseil-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_abseil-cpp-devel}"
SRC_URI[x86_64_v2_abseil-cpp-devel.sha256sum] = "11c73f08ea618c418ae2e72a5332503232ba5953da9c04ad22284719d30ea6eb"

URI_x86_64_v2_abseil-cpp-testing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/abseil-cpp-testing-20240722.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_abseil-cpp-testing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_abseil-cpp-testing}"
SRC_URI[x86_64_v2_abseil-cpp-testing.sha256sum] = "d282d14b3111a565562c755be6172c184c7d3709a9383b7497dc4ada2a0fa5de"

URI_aarch64_abseil-cpp = "${EPEL_MIRROR}/aarch64/Packages/a/abseil-cpp-20240722.2-1.el10_2.aarch64.rpm;name=aarch64_abseil-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_abseil-cpp}"
SRC_URI[aarch64_abseil-cpp.sha256sum] = "049fe33433ab1cefcc8afba32f4d96b9333e6e5519c29c7fd02f367cff8183a3"

URI_aarch64_abseil-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/a/abseil-cpp-devel-20240722.2-1.el10_2.aarch64.rpm;name=aarch64_abseil-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_abseil-cpp-devel}"
SRC_URI[aarch64_abseil-cpp-devel.sha256sum] = "51b2a329ba39da46edac282c7f9df340762743ae556041589e47bbaa5df034b4"

URI_aarch64_abseil-cpp-testing = "${EPEL_MIRROR}/aarch64/Packages/a/abseil-cpp-testing-20240722.2-1.el10_2.aarch64.rpm;name=aarch64_abseil-cpp-testing;unpack=0"
SRC_URI:append = " ${URI_aarch64_abseil-cpp-testing}"
SRC_URI[aarch64_abseil-cpp-testing.sha256sum] = "17e414f5ed575ac45196d00c57d8196798f3a855f1501ed514d59d92257325a2"

RDEPENDS:abseil-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:abseil-cpp-devel = " \
 abseil-cpp \
 abseil-cpp-testing \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:abseil-cpp-testing = " \
 abseil-cpp \
 glibc \
 gmock \
 gtest \
 libgcc \
 libstdc++ \
 "
