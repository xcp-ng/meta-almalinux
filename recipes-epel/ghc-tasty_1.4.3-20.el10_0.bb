# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tasty"
PV = "1.4.3"
PR = "20.el10_0"
PACKAGES = " \
 ghc-tasty \
 ghc-tasty-devel \
 ghc-tasty-doc \
 ghc-tasty-prof \
 ghc-wcwidth \
 ghc-wcwidth-devel \
 ghc-wcwidth-doc \
 ghc-wcwidth-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tasty-1.4.3-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7f671f881e344a92fa55edfcbf6a3a145217e548e1e953c7f269b2cc08e002c"

URI_x86_64_v2_ghc-tasty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-1.4.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty}"
SRC_URI[x86_64_v2_ghc-tasty.sha256sum] = "fd4f68e999a5fbd2aaa913b97ffdf2349eac6907cb7c4b7d18c788a7e3e2c54f"

URI_x86_64_v2_ghc-tasty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-devel-1.4.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-devel}"
SRC_URI[x86_64_v2_ghc-tasty-devel.sha256sum] = "d7c7f81d60276ef195fd8571ac2b72c714c8105ed341ca0b54884c5c4d322efa"

URI_x86_64_v2_ghc-tasty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-doc-1.4.3-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tasty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-doc}"
SRC_URI[x86_64_v2_ghc-tasty-doc.sha256sum] = "cc747eba6e47a4ba4c681c2e78ec960259c24e2115666eecce2000eb061ce501"

URI_x86_64_v2_ghc-tasty-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tasty-prof-1.4.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tasty-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tasty-prof}"
SRC_URI[x86_64_v2_ghc-tasty-prof.sha256sum] = "65c144dff7173a52e2834507e83ef9e3e8567802a0089975c3f4f6289226607b"

URI_x86_64_v2_ghc-wcwidth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wcwidth-0.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wcwidth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wcwidth}"
SRC_URI[x86_64_v2_ghc-wcwidth.sha256sum] = "007ca7a81a71f0bd5509ae552e5fe63002af355c2144221415eaee5aa9c6cc28"

URI_x86_64_v2_ghc-wcwidth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wcwidth-devel-0.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wcwidth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wcwidth-devel}"
SRC_URI[x86_64_v2_ghc-wcwidth-devel.sha256sum] = "0f0acdfb864429c204c51135293d5ccf5dc708a01e217b4fa1bbff769de1819b"

URI_x86_64_v2_ghc-wcwidth-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wcwidth-doc-0.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-wcwidth-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wcwidth-doc}"
SRC_URI[x86_64_v2_ghc-wcwidth-doc.sha256sum] = "424ea9c6f6d0b514b626f04b1a1fb7761aa7c471ed24a8ca27e810c9322b19d4"

URI_x86_64_v2_ghc-wcwidth-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-wcwidth-prof-0.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-wcwidth-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-wcwidth-prof}"
SRC_URI[x86_64_v2_ghc-wcwidth-prof.sha256sum] = "e45168ff54030b582758284c59f30b5c7cd8730cc7c3c28bf0e9f8d6e9bcb0f1"

URI_aarch64_ghc-tasty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-1.4.3-20.el10_0.aarch64.rpm;name=aarch64_ghc-tasty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty}"
SRC_URI[aarch64_ghc-tasty.sha256sum] = "33cfc97fb2d3a17e3b9a0bfd2e16f721aa834fbace91f38768963c5adceee614"

URI_aarch64_ghc-tasty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-devel-1.4.3-20.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-devel}"
SRC_URI[aarch64_ghc-tasty-devel.sha256sum] = "777ce4c40aba7d3eec987bb2032e269474f80d01dbdf8b53e773a9235c9699cb"

URI_aarch64_ghc-tasty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-doc-1.4.3-20.el10_0.noarch.rpm;name=aarch64_ghc-tasty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-doc}"
SRC_URI[aarch64_ghc-tasty-doc.sha256sum] = "ad161b9c428c452a0e507695c8f08d8a39e42f8d27c3b730ad23f31f6a867f75"

URI_aarch64_ghc-tasty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tasty-prof-1.4.3-20.el10_0.aarch64.rpm;name=aarch64_ghc-tasty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tasty-prof}"
SRC_URI[aarch64_ghc-tasty-prof.sha256sum] = "2372667fcff3b2539805ecb2c652a32d4b0ba00ce6ef0f99b4d14b3238e998c1"

URI_aarch64_ghc-wcwidth = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wcwidth-0.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc-wcwidth;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wcwidth}"
SRC_URI[aarch64_ghc-wcwidth.sha256sum] = "bb160feb15183e1ae88ade5aadcf1ef2256bb9a7fe7ca63d6db66354fcda2d9c"

URI_aarch64_ghc-wcwidth-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wcwidth-devel-0.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc-wcwidth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wcwidth-devel}"
SRC_URI[aarch64_ghc-wcwidth-devel.sha256sum] = "ad710f108d74dd1a639201929435753e0509da1b79cd6cd9e84f7807b9a3d2c2"

URI_aarch64_ghc-wcwidth-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wcwidth-doc-0.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc-wcwidth-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wcwidth-doc}"
SRC_URI[aarch64_ghc-wcwidth-doc.sha256sum] = "80ecdc25e773b70e09b38e6d6d843a8ba64da00032fdd86470ca76bd5b7ab375"

URI_aarch64_ghc-wcwidth-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-wcwidth-prof-0.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc-wcwidth-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-wcwidth-prof}"
SRC_URI[aarch64_ghc-wcwidth-prof.sha256sum] = "bb127f1eb9c58dfde01671476c43f4f763b55cdd831aecd22697797516e254b6"

RDEPENDS:ghc-tasty = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-optparse-applicative \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-stm \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tasty-devel = " \
 ghc-ansi-terminal-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-optparse-applicative-devel \
 ghc-stm-devel \
 ghc-tagged-devel \
 ghc-tasty \
 ghc-transformers-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-tasty-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tasty-prof = " \
 ghc-ansi-terminal-prof \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-optparse-applicative-prof \
 ghc-stm-prof \
 ghc-tagged-prof \
 ghc-tasty-devel \
 ghc-transformers-prof \
 ghc-unix-prof \
 "
RDEPENDS:ghc-wcwidth = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-wcwidth-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-wcwidth \
 "
RDEPENDS:ghc-wcwidth-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-wcwidth-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-wcwidth-devel \
 "
