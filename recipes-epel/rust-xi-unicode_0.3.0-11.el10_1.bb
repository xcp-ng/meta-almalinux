# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xi-unicode"
PV = "0.3.0"
PR = "11.el10_1"
PACKAGES = " \
 rust-xi-unicode+default-devel \
 rust-xi-unicode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-xi-unicode-0.3.0-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49a18ebb74965cfe99acab8f782bb31e82bb80312cf3125db5e6fda0b5e15d23"

URI_x86_64_v2_rust-xi-unicode+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xi-unicode+default-devel-0.3.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xi-unicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xi-unicode+default-devel}"
SRC_URI[x86_64_v2_rust-xi-unicode+default-devel.sha256sum] = "35015476c9bde917e36d4161109d25074d1125e5b2182dfc62a00a1cd61a711a"

URI_x86_64_v2_rust-xi-unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xi-unicode-devel-0.3.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xi-unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-xi-unicode-devel}"
SRC_URI[x86_64_v2_rust-xi-unicode-devel.sha256sum] = "3e7e7ffe59f3aee12be04980a2fab249d30b3757c4b8d563da61b2748ca17d94"

URI_aarch64_rust-xi-unicode+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xi-unicode+default-devel-0.3.0-11.el10_1.noarch.rpm;name=aarch64_rust-xi-unicode+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xi-unicode+default-devel}"
SRC_URI[aarch64_rust-xi-unicode+default-devel.sha256sum] = "e0c54e5adeffda63d1f483b458fa5eadb3da47b4b425468de2821e310f705c89"

URI_aarch64_rust-xi-unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-xi-unicode-devel-0.3.0-11.el10_1.noarch.rpm;name=aarch64_rust-xi-unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-xi-unicode-devel}"
SRC_URI[aarch64_rust-xi-unicode-devel.sha256sum] = "6813a0358942facac70032ce747140049a2c070c5192f62105bdd8f14f5c3da6"

RDEPENDS:rust-xi-unicode+default-devel = " \
 cargo \
 rust-xi-unicode-devel \
 "
RDEPENDS:rust-xi-unicode-devel = " \
 cargo \
 "
