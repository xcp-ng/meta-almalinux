# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-disks"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-disks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-disks-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6524064aa1ea846c86f7dbbe50daa2d6327d3ed519ec54ae1d09604629c578e5"

URI_x86_64_v2_plasma-disks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-disks-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-disks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-disks}"
SRC_URI[x86_64_v2_plasma-disks.sha256sum] = "af3e16b3bd0636532b0b1905e0ee348ed504653f2f8e04e3ec2410e8e25b1e6a"

URI_aarch64_plasma-disks = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-disks-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-disks;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-disks}"
SRC_URI[aarch64_plasma-disks.sha256sum] = "ba329bdd1f8ff85efd1f35b254c4247de3b2c2543aea07320d8ac151571c5fa1"

RDEPENDS:plasma-disks = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kservice \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 smartmontools \
 "
