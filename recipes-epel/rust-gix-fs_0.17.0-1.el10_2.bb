# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-fs"
PV = "0.17.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-fs+default-devel \
 rust-gix-fs+serde-devel \
 rust-gix-fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-fs-0.17.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc8f6c4631656c8d93fe96d973961a4736992f73c3b9bec343de90afa7ca7d2f"

URI_x86_64_v2_rust-gix-fs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs+default-devel-0.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs+default-devel}"
SRC_URI[x86_64_v2_rust-gix-fs+default-devel.sha256sum] = "ed287ef92258d98b15bed5e42119bd657868e66e9f459ad7fb5b05679a5cd9de"

URI_x86_64_v2_rust-gix-fs+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs+serde-devel-0.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-fs+serde-devel.sha256sum] = "4ceaa4cd0c1b7f51af6dd7a6fae34606fabbd825a3a576c842cbcd3fd26c3a79"

URI_x86_64_v2_rust-gix-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs-devel-0.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs-devel}"
SRC_URI[x86_64_v2_rust-gix-fs-devel.sha256sum] = "f5bcc36946fce01e0d2c5a081d0e569ff49922f3ee26d69ff8217f6a0d933fc7"

URI_aarch64_rust-gix-fs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs+default-devel-0.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs+default-devel}"
SRC_URI[aarch64_rust-gix-fs+default-devel.sha256sum] = "9e30dbb9fb25f4a91d32720696d07e812169cae70af3ed745e40c305eb231c52"

URI_aarch64_rust-gix-fs+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs+serde-devel-0.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-fs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs+serde-devel}"
SRC_URI[aarch64_rust-gix-fs+serde-devel.sha256sum] = "7f4798b8cd44ccc7dde610fe2b75bb1e67ae3ad564435cbec04ac67faf006d03"

URI_aarch64_rust-gix-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs-devel-0.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs-devel}"
SRC_URI[aarch64_rust-gix-fs-devel.sha256sum] = "0078818637ac741d85685b0c25c3edd299f4ab7a7ed383765de9f7da9235c2c9"

RDEPENDS:rust-gix-fs+default-devel = " \
 cargo \
 rust-gix-fs-devel \
 "
RDEPENDS:rust-gix-fs+serde-devel = " \
 cargo \
 rust-gix-fs-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-fs-devel = " \
 cargo \
 rust \
 rust-bstr+default-devel \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 rust-gix-features+default-devel \
 rust-gix-features+fs-read-dir-devel \
 rust-gix-path+default-devel \
 rust-gix-utils+default-devel \
 rust-thiserror+default-devel \
 "
