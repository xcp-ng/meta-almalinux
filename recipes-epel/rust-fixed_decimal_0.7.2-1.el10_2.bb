# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fixed_decimal"
PV = "0.7.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-fixed_decimal+default-devel \
 rust-fixed_decimal+ryu-devel \
 rust-fixed_decimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fixed_decimal-0.7.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6c649a0ba2baf902f9ddc0cda78a13807d272b3a5e87fa4dcad98f6cce66c38"

URI_x86_64_v2_rust-fixed_decimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed_decimal+default-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed_decimal+default-devel}"
SRC_URI[x86_64_v2_rust-fixed_decimal+default-devel.sha256sum] = "a1a96cf2be1acaac365d86a401c3b0b5e18532efd0581e935ca05ea6a9342257"

URI_x86_64_v2_rust-fixed_decimal+ryu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed_decimal+ryu-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed_decimal+ryu-devel}"
SRC_URI[x86_64_v2_rust-fixed_decimal+ryu-devel.sha256sum] = "01db4879159fe9bebda9bdef74f9e1490aa4e6d3cc97301f88e05847c8900c6a"

URI_x86_64_v2_rust-fixed_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed_decimal-devel-0.7.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed_decimal-devel}"
SRC_URI[x86_64_v2_rust-fixed_decimal-devel.sha256sum] = "4a5db13e5f141b9016512bff18d75139f3789d213b2c9d69b734a84df013ed70"

URI_aarch64_rust-fixed_decimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed_decimal+default-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-fixed_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed_decimal+default-devel}"
SRC_URI[aarch64_rust-fixed_decimal+default-devel.sha256sum] = "4d282faf55635f8983b8fe7811e896339fdac72d81305362abc4febacce9878b"

URI_aarch64_rust-fixed_decimal+ryu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed_decimal+ryu-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-fixed_decimal+ryu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed_decimal+ryu-devel}"
SRC_URI[aarch64_rust-fixed_decimal+ryu-devel.sha256sum] = "743138422ebea3d33b6c1a195fdbcb2c7cf0a350f23b4d08cf62e726263ed81d"

URI_aarch64_rust-fixed_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed_decimal-devel-0.7.2-1.el10_2.noarch.rpm;name=aarch64_rust-fixed_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed_decimal-devel}"
SRC_URI[aarch64_rust-fixed_decimal-devel.sha256sum] = "a5e431f8e93d086a726c2a3422c7b677613d582e1fc7e148fd3fa4724f618e2e"

RDEPENDS:rust-fixed_decimal+default-devel = " \
 cargo \
 rust-fixed_decimal-devel \
 "
RDEPENDS:rust-fixed_decimal+ryu-devel = " \
 cargo \
 rust-fixed_decimal-devel \
 rust-ryu+small-devel \
 rust-ryu-devel \
 "
RDEPENDS:rust-fixed_decimal-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec-devel \
 rust-writeable+alloc-devel \
 rust-writeable-devel \
 "
