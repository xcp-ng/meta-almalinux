# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "potrace"
PV = "1.16"
PR = "16.el10"
PACKAGES = " \
 potrace \
 potrace-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/potrace-1.16-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ac6a6f5b60dab4ec86c12036204573a57b34037f6eedef8a3e2804d3a8db4f2"

URI_x86_64_v2_potrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/potrace-1.16-16.el10.x86_64_v2.rpm;name=x86_64_v2_potrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_potrace}"
SRC_URI[x86_64_v2_potrace.sha256sum] = "ce9685fbf6c3852482b6f8edef6c4adc62721ab68f4e2b8b02ea6811a0a7f7dc"

URI_x86_64_v2_potrace-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/potrace-devel-1.16-16.el10.x86_64_v2.rpm;name=x86_64_v2_potrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_potrace-devel}"
SRC_URI[x86_64_v2_potrace-devel.sha256sum] = "61ae1f38ecace5c5e483ce79aed9c0db3ddb10b652c0917d023109738a4169ab"

URI_aarch64_potrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/potrace-1.16-16.el10.aarch64.rpm;name=aarch64_potrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_potrace}"
SRC_URI[aarch64_potrace.sha256sum] = "19ffaa02a70572d6e9c19caafb18f4718a180ace8b264fb32b29dfd1d670255b"

URI_aarch64_potrace-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/potrace-devel-1.16-16.el10.aarch64.rpm;name=aarch64_potrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_potrace-devel}"
SRC_URI[aarch64_potrace-devel.sha256sum] = "ca7ccca2aaaa5c54dec9f9ddd38757eab5e683cea3cdc7dad66d6cd5686ac65d"

RDEPENDS:potrace = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:potrace-devel = " \
 potrace \
 "
