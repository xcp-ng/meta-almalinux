# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linuxptp"
PV = "4.4"
PR = "9.el10"
PACKAGES = " \
 linuxptp \
 linuxptp-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/linuxptp-4.4-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f26fd26ca65435c9fdc76d8d1457c4d1f981c7726ddcde354ed4b00aa75c05b"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - linuxptp: libcap.so.2()(64bit)

URI_x86_64_v2_linuxptp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/linuxptp-4.4-9.el10.x86_64_v2.rpm;name=x86_64_v2_linuxptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linuxptp}"
SRC_URI[x86_64_v2_linuxptp.sha256sum] = "c76bfbb9c080425515cd418af295c64148a3fce69aaca7f984be3b01aa4102e3"

URI_x86_64_v2_linuxptp-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/linuxptp-selinux-4.4-9.el10.noarch.rpm;name=x86_64_v2_linuxptp-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linuxptp-selinux}"
SRC_URI[x86_64_v2_linuxptp-selinux.sha256sum] = "efb7e018cd1f29d21c041e282a77731e19ae617330f63992c7f2669483afe567"

URI_aarch64_linuxptp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/linuxptp-4.4-9.el10.aarch64.rpm;name=aarch64_linuxptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_linuxptp}"
SRC_URI[aarch64_linuxptp.sha256sum] = "62bc0c3aa3489e12103d0c75cde0290d951a62cace6fe27372ea060a40013a81"

URI_aarch64_linuxptp-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/linuxptp-selinux-4.4-9.el10.noarch.rpm;name=aarch64_linuxptp-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_linuxptp-selinux}"
SRC_URI[aarch64_linuxptp-selinux.sha256sum] = "efb7e018cd1f29d21c041e282a77731e19ae617330f63992c7f2669483afe567"

RDEPENDS:linuxptp:x86_64_v2 = " \
 bash \
 glibc \
 gnutls \
 libcap \
 linuxptp-selinux \
 setup \
 shadow-utils \
 systemd \
"
RDEPENDS:linuxptp:aarch64 = " \
 bash \
 glibc \
 gnutls \
 linuxptp-selinux \
 setup \
 shadow-utils \
 systemd \
"
RDEPENDS:linuxptp-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
