# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencryptoki"
PV = "3.27.0"
PR = "1.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 opencryptoki \
 opencryptoki-ccatok \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"
PACKAGES:aarch64 = " \
 opencryptoki \
 opencryptoki-devel \
 opencryptoki-icsftok \
 opencryptoki-libs \
 opencryptoki-swtok \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/opencryptoki-3.27.0-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5140c822c35cde339ab755e7a6602a28215106aeea0c9632d6c5f744443036f8"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - opencryptoki: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-3.27.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki;unpack=0"
SRC_URI[x86_64_v2_opencryptoki.sha256sum] = "755da1c95b3c71c799f3e027a28f95756007b17928b6f64fac22e0483b900907"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-ccatok-3.27.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-ccatok;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-ccatok.sha256sum] = "85f08c576f627d42749fd116c9cc05d1b654c7bde9b6a0a5856bf6303c7610a3"
RPROVIDES:opencryptoki-ccatok:append:x86_64_v2 = " virtual/opencryptoki_token_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/opencryptoki-devel-3.27.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-devel;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-devel.sha256sum] = "ddcb2486618cbd762ec82b148215ade380aa23e8eddddf8fd4e7330566b10961"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-icsftok-3.27.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-icsftok;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-icsftok.sha256sum] = "48da34b4455b1d72278c0ba5e6f3b313e080a559e059a18574c071570f573f29"
RPROVIDES:opencryptoki-icsftok:append:x86_64_v2 = " virtual/opencryptoki_token_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-libs-3.27.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-libs;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-libs.sha256sum] = "2bb581172d6335ea385f0b1a6c3f1b8aa9d3697a5ffe9b167907f4afae244651"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/opencryptoki-swtok-3.27.0-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_opencryptoki-swtok;unpack=0"
SRC_URI[x86_64_v2_opencryptoki-swtok.sha256sum] = "67caf00b7c39f3b78db3e748a5b155e5ce099aba503fa978e1982af41d1912fc"
RPROVIDES:opencryptoki-swtok:append:x86_64_v2 = " virtual/opencryptoki_token_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-3.27.0-1.el10.alma.1.aarch64.rpm;name=aarch64_opencryptoki;unpack=0"
SRC_URI[aarch64_opencryptoki.sha256sum] = "d7e5a6dc1fdd16f6b939346c5c21cae2607ea14d761b8a9beb695f365148e3f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/opencryptoki-devel-3.27.0-1.el10.alma.1.aarch64.rpm;name=aarch64_opencryptoki-devel;unpack=0"
SRC_URI[aarch64_opencryptoki-devel.sha256sum] = "3d0ef4cf01afea211d6850dee1ec92257bf2c8c30a6310505f342bfe713c60d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-icsftok-3.27.0-1.el10.alma.1.aarch64.rpm;name=aarch64_opencryptoki-icsftok;unpack=0"
SRC_URI[aarch64_opencryptoki-icsftok.sha256sum] = "2355019b824f06d2ea726795ccfa525ceb078afb1a3a8220608957805560217d"
RPROVIDES:opencryptoki-icsftok:append:aarch64 = " virtual/opencryptoki_token_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-libs-3.27.0-1.el10.alma.1.aarch64.rpm;name=aarch64_opencryptoki-libs;unpack=0"
SRC_URI[aarch64_opencryptoki-libs.sha256sum] = "9348248988d4a37e5575241f7e611d073d45aba3abd8282ef0312b608818a34e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/opencryptoki-swtok-3.27.0-1.el10.alma.1.aarch64.rpm;name=aarch64_opencryptoki-swtok;unpack=0"
SRC_URI[aarch64_opencryptoki-swtok.sha256sum] = "4caf3542a36e8349c8a29f69514ba99fc75c47be8fddee0f67b328b1562833bc"
RPROVIDES:opencryptoki-swtok:append:aarch64 = " virtual/opencryptoki_token_"

RDEPENDS:opencryptoki:x86_64_v2 = " \
 bash \
 diffutils \
 glibc \
 libcap \
 opencryptoki-libs \
 openssl \
 openssl-libs \
 selinux-policy \
 shadow-utils \
 systemd \
 virtual/coreutils \
 virtual/opencryptoki_token_ \
"
RDEPENDS:opencryptoki:aarch64 = " \
 bash \
 diffutils \
 glibc \
 opencryptoki-libs \
 openssl \
 openssl-libs \
 selinux-policy \
 shadow-utils \
 systemd \
 virtual/coreutils \
 virtual/opencryptoki_token_ \
"
RDEPENDS:opencryptoki-ccatok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-devel = " \
 opencryptoki-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:opencryptoki-icsftok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:opencryptoki-libs = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:opencryptoki-swtok = " \
 glibc \
 opencryptoki-libs \
 openldap \
 openssl-libs \
 "
