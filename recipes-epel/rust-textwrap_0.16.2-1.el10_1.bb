# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-textwrap"
PV = "0.16.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-textwrap+default-devel \
 rust-textwrap+smawk-devel \
 rust-textwrap+terminal_size-devel \
 rust-textwrap+unicode-linebreak-devel \
 rust-textwrap+unicode-width-devel \
 rust-textwrap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-textwrap-0.16.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f638d664e60788987efa8bdb0e7cf39ba6ee2d9a823f22848a322f651efea775"

URI_x86_64_v2_rust-textwrap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+default-devel-0.16.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+default-devel}"
SRC_URI[x86_64_v2_rust-textwrap+default-devel.sha256sum] = "c3f5f7517890e6792b823c9680914e4205b1a4816c4564b29840c51f92d494b5"

URI_x86_64_v2_rust-textwrap+smawk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+smawk-devel-0.16.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+smawk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+smawk-devel}"
SRC_URI[x86_64_v2_rust-textwrap+smawk-devel.sha256sum] = "219bc7b0729fa79810db4974b98c7a3be9710fc88fc0fe791bfbdcf4b5eaeca4"

URI_x86_64_v2_rust-textwrap+terminal_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+terminal_size-devel-0.16.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+terminal_size-devel}"
SRC_URI[x86_64_v2_rust-textwrap+terminal_size-devel.sha256sum] = "07037c5a71b1c24626365c06bc919451b97a527a97b99ac000372e5471a3f916"

URI_x86_64_v2_rust-textwrap+unicode-linebreak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+unicode-linebreak-devel-0.16.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+unicode-linebreak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+unicode-linebreak-devel}"
SRC_URI[x86_64_v2_rust-textwrap+unicode-linebreak-devel.sha256sum] = "ee6b1c174476903d1f51c5f626e75a8110b0feecb8da6ec0d0abd6a55a3639d5"

URI_x86_64_v2_rust-textwrap+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+unicode-width-devel-0.16.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-textwrap+unicode-width-devel.sha256sum] = "df5cb82e5edb9e52a6b6e175c58f5a4f9f30021580a7c0cec8511ba2b1b41290"

URI_x86_64_v2_rust-textwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap-devel-0.16.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap-devel}"
SRC_URI[x86_64_v2_rust-textwrap-devel.sha256sum] = "cd3e0946d298e0a259172d1e5ee1ee365a7651f44eeec4223fb4e40a2fcf789d"

URI_aarch64_rust-textwrap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+default-devel-0.16.2-1.el10_1.noarch.rpm;name=aarch64_rust-textwrap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+default-devel}"
SRC_URI[aarch64_rust-textwrap+default-devel.sha256sum] = "98142c09f54fe42ae9d266e44ab50b0e2bec5bc9e9cf69547ee79073fb87d9ee"

URI_aarch64_rust-textwrap+smawk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+smawk-devel-0.16.2-1.el10_1.noarch.rpm;name=aarch64_rust-textwrap+smawk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+smawk-devel}"
SRC_URI[aarch64_rust-textwrap+smawk-devel.sha256sum] = "fceefac980616255a1cb19020b4cff1bea4365b61be435dee676ff5c3bf55972"

URI_aarch64_rust-textwrap+terminal_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+terminal_size-devel-0.16.2-1.el10_1.noarch.rpm;name=aarch64_rust-textwrap+terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+terminal_size-devel}"
SRC_URI[aarch64_rust-textwrap+terminal_size-devel.sha256sum] = "1cde4fe100d1b9e0d349c1f7b4d6ad3f74a1272d989d83df8498b9634d195955"

URI_aarch64_rust-textwrap+unicode-linebreak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+unicode-linebreak-devel-0.16.2-1.el10_1.noarch.rpm;name=aarch64_rust-textwrap+unicode-linebreak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+unicode-linebreak-devel}"
SRC_URI[aarch64_rust-textwrap+unicode-linebreak-devel.sha256sum] = "2c1c5f6c076c37752be99183bcd2b86fdae3ab67739343fc2e46056d8b6aac96"

URI_aarch64_rust-textwrap+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+unicode-width-devel-0.16.2-1.el10_1.noarch.rpm;name=aarch64_rust-textwrap+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+unicode-width-devel}"
SRC_URI[aarch64_rust-textwrap+unicode-width-devel.sha256sum] = "7116fa865726186fbd11e2b5706087216b17079fbb992463b9cacb89834c392a"

URI_aarch64_rust-textwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap-devel-0.16.2-1.el10_1.noarch.rpm;name=aarch64_rust-textwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap-devel}"
SRC_URI[aarch64_rust-textwrap-devel.sha256sum] = "a6874d2351e353e7a2b4ebf50f85f4358e32a91d1ff37f8fb4e8450a0b737029"

RDEPENDS:rust-textwrap+default-devel = " \
 cargo \
 rust-textwrap+smawk-devel \
 rust-textwrap+unicode-linebreak-devel \
 rust-textwrap+unicode-width-devel \
 rust-textwrap-devel \
 "
RDEPENDS:rust-textwrap+smawk-devel = " \
 cargo \
 rust-smawk+default-devel \
 rust-textwrap-devel \
 "
RDEPENDS:rust-textwrap+terminal_size-devel = " \
 cargo \
 rust-terminal_size+default-devel \
 rust-textwrap-devel \
 "
RDEPENDS:rust-textwrap+unicode-linebreak-devel = " \
 cargo \
 rust-textwrap-devel \
 rust-unicode-linebreak+default-devel \
 "
RDEPENDS:rust-textwrap+unicode-width-devel = " \
 cargo \
 rust-textwrap-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-textwrap-devel = " \
 cargo \
 rust \
 "
