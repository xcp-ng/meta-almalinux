# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2"
PE = "1"
PV = "2.12"
PR = "29.el10_1.2.alma.1"
PACKAGES:x86_64_v2 = " \
 grub2-common \
 grub2-efi-aa64-modules \
 grub2-efi-x64 \
 grub2-efi-x64-cdboot \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-ppc64le-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
"
PACKAGES:aarch64 = " \
 grub2-common \
 grub2-efi-aa64 \
 grub2-efi-aa64-cdboot \
 grub2-efi-aa64-modules \
 grub2-efi-x64-modules \
 grub2-pc-modules \
 grub2-ppc64le-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/grub2-2.12-29.el10_1.2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d74242e3e08c3dc561ddc066f25bd123e72bfaadc2a5b1d201c598cf3582ff34"

URI_x86_64_v2_grub2-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-common-2.12-29.el10_1.2.alma.1.noarch.rpm;name=x86_64_v2_grub2-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-common}"
SRC_URI[x86_64_v2_grub2-common.sha256sum] = "e606582e7e575c7e49840876ec76e92a5365febbf184a28a2a0c1ef93c14b3b0"

URI_x86_64_v2_grub2-efi-aa64-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-aa64-modules-2.12-29.el10_1.2.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-aa64-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-aa64-modules}"
SRC_URI[x86_64_v2_grub2-efi-aa64-modules.sha256sum] = "88a7c02c78c672311b5efcf69502550161b8fe2ba4a4dd4da6ceed69fb65d48d"

URI_x86_64_v2_grub2-efi-x64 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-2.12-29.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64}"
SRC_URI[x86_64_v2_grub2-efi-x64.sha256sum] = "88427c65b7ff39803350577d1cf868f7b99080b573a696702e9b0fc1bcb2b57a"

URI_x86_64_v2_grub2-efi-x64-cdboot = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-cdboot-2.12-29.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-efi-x64-cdboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64-cdboot}"
SRC_URI[x86_64_v2_grub2-efi-x64-cdboot.sha256sum] = "0e9592bc5e20eef3b32d40b1e40b5e3981dffb4d138f3dd1a104e11a9febe6dc"

URI_x86_64_v2_grub2-efi-x64-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-efi-x64-modules-2.12-29.el10_1.2.alma.1.noarch.rpm;name=x86_64_v2_grub2-efi-x64-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-efi-x64-modules}"
SRC_URI[x86_64_v2_grub2-efi-x64-modules.sha256sum] = "c242e1db75c86f86c534dd060b1383790b478ae10983b04bc1307ff7b6499ae8"

URI_x86_64_v2_grub2-pc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-2.12-29.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-pc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-pc}"
SRC_URI[x86_64_v2_grub2-pc.sha256sum] = "e2ab4e995783088f8ccd269b402d66c9b0e673698e2d0a6205d806091577281c"

URI_x86_64_v2_grub2-pc-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-pc-modules-2.12-29.el10_1.2.alma.1.noarch.rpm;name=x86_64_v2_grub2-pc-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-pc-modules}"
SRC_URI[x86_64_v2_grub2-pc-modules.sha256sum] = "d3355bd4dd743099f1ddaad918e54c33cfee355313ed56f2faca99c6da911857"

URI_x86_64_v2_grub2-ppc64le-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-ppc64le-modules-2.12-29.el10_1.2.alma.1.noarch.rpm;name=x86_64_v2_grub2-ppc64le-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-ppc64le-modules}"
SRC_URI[x86_64_v2_grub2-ppc64le-modules.sha256sum] = "7fb74d1d103ac7dea7046f6dac6dc7a7832ee0d726af1b4472c9d69b5c35305c"

URI_x86_64_v2_grub2-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-2.12-29.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools}"
SRC_URI[x86_64_v2_grub2-tools.sha256sum] = "5cb411ee87de40acee7e9339006bd7441a71369a6c6928b6215385ede56250ea"

URI_x86_64_v2_grub2-tools-efi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-efi-2.12-29.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-efi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-efi}"
SRC_URI[x86_64_v2_grub2-tools-efi.sha256sum] = "6a5043a0c85cf534f5a5f9162c0f86853b63fc21f47d3a9d7e749082e3dc3a11"

URI_x86_64_v2_grub2-tools-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-extra-2.12-29.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-extra}"
SRC_URI[x86_64_v2_grub2-tools-extra.sha256sum] = "a5bb891dd5c557e264a09af01e70d8827fe7d012b244c956b0900413c66aede0"

URI_x86_64_v2_grub2-tools-minimal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/grub2-tools-minimal-2.12-29.el10_1.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_grub2-tools-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-tools-minimal}"
SRC_URI[x86_64_v2_grub2-tools-minimal.sha256sum] = "797f2a7d643c45b96d784773159a83c87b4b7b496c5d967c514246891a0bd3be"

URI_aarch64_grub2-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-common-2.12-29.el10_1.2.alma.1.noarch.rpm;name=aarch64_grub2-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-common}"
SRC_URI[aarch64_grub2-common.sha256sum] = "e606582e7e575c7e49840876ec76e92a5365febbf184a28a2a0c1ef93c14b3b0"

URI_aarch64_grub2-efi-aa64 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-2.12-29.el10_1.2.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64}"
SRC_URI[aarch64_grub2-efi-aa64.sha256sum] = "9355ba3798272c96bb64a1e8bde7b8bc20a99597857181caf80fa62bbc7ed3ed"

URI_aarch64_grub2-efi-aa64-cdboot = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-cdboot-2.12-29.el10_1.2.alma.1.aarch64.rpm;name=aarch64_grub2-efi-aa64-cdboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64-cdboot}"
SRC_URI[aarch64_grub2-efi-aa64-cdboot.sha256sum] = "0b87b34cb7c3dfd233689db028b0a356de30d97601573e210347396ed336b349"

URI_aarch64_grub2-efi-aa64-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-aa64-modules-2.12-29.el10_1.2.alma.1.noarch.rpm;name=aarch64_grub2-efi-aa64-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-aa64-modules}"
SRC_URI[aarch64_grub2-efi-aa64-modules.sha256sum] = "88a7c02c78c672311b5efcf69502550161b8fe2ba4a4dd4da6ceed69fb65d48d"

URI_aarch64_grub2-efi-x64-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-efi-x64-modules-2.12-29.el10_1.2.alma.1.noarch.rpm;name=aarch64_grub2-efi-x64-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-efi-x64-modules}"
SRC_URI[aarch64_grub2-efi-x64-modules.sha256sum] = "c242e1db75c86f86c534dd060b1383790b478ae10983b04bc1307ff7b6499ae8"

URI_aarch64_grub2-pc-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-pc-modules-2.12-29.el10_1.2.alma.1.noarch.rpm;name=aarch64_grub2-pc-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-pc-modules}"
SRC_URI[aarch64_grub2-pc-modules.sha256sum] = "d3355bd4dd743099f1ddaad918e54c33cfee355313ed56f2faca99c6da911857"

URI_aarch64_grub2-ppc64le-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-ppc64le-modules-2.12-29.el10_1.2.alma.1.noarch.rpm;name=aarch64_grub2-ppc64le-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-ppc64le-modules}"
SRC_URI[aarch64_grub2-ppc64le-modules.sha256sum] = "7fb74d1d103ac7dea7046f6dac6dc7a7832ee0d726af1b4472c9d69b5c35305c"

URI_aarch64_grub2-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-2.12-29.el10_1.2.alma.1.aarch64.rpm;name=aarch64_grub2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools}"
SRC_URI[aarch64_grub2-tools.sha256sum] = "7de31c105c0a7cb9a61072cffb14243f0e2a3ea015a0152c954ec54a05460a4c"

URI_aarch64_grub2-tools-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-extra-2.12-29.el10_1.2.alma.1.aarch64.rpm;name=aarch64_grub2-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools-extra}"
SRC_URI[aarch64_grub2-tools-extra.sha256sum] = "13bbf0477fbcca29b6f1162fccc400a719bb54c8751d6692ef6d7026e3e123a2"

URI_aarch64_grub2-tools-minimal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/grub2-tools-minimal-2.12-29.el10_1.2.alma.1.aarch64.rpm;name=aarch64_grub2-tools-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-tools-minimal}"
SRC_URI[aarch64_grub2-tools-minimal.sha256sum] = "8bf81d441b598b732d0cd8d3f14208a4f96f4c0822d642e5aa6dc2519ff6be14"

RDEPENDS:grub2-common = " \
 bash \
 grep \
 util-linux-core \
 virtual/coreutils \
 "
RDEPENDS:grub2-efi-aa64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64 = " \
 bash \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-x64-cdboot = " \
 grub2-common \
 "
RDEPENDS:grub2-efi-x64-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-pc = " \
 dracut \
 file \
 gettext-runtime \
 grub2-common \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-minimal \
 which \
 "
RDEPENDS:grub2-pc-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-ppc64le-modules = " \
 grub2-common \
 "
RDEPENDS:grub2-tools = " \
 bash \
 device-mapper-libs \
 dracut \
 file \
 gettext-runtime \
 glibc \
 grep \
 grub2-common \
 os-prober \
 sed \
 systemd \
 xz-libs \
 "
RDEPENDS:grub2-tools-efi = " \
 device-mapper-libs \
 file \
 gettext-runtime \
 glibc \
 grub2-common \
 os-prober \
 "
RDEPENDS:grub2-tools-extra = " \
 bash \
 device-mapper-libs \
 file \
 freetype \
 gettext-runtime \
 glibc \
 grub2-common \
 grub2-tools-minimal \
 mtools \
 os-prober \
 xz-libs \
 "
RDEPENDS:grub2-tools-minimal = " \
 bash \
 device-mapper-libs \
 fuse-libs \
 gettext-runtime \
 glibc \
 grub2-common \
 xz-libs \
 "
RDEPENDS:grub2-efi-aa64 = " \
 bash \
 efi-filesystem \
 grub2-common \
 grub2-tools \
 grub2-tools-minimal \
 "
RDEPENDS:grub2-efi-aa64-cdboot = " \
 grub2-common \
 "
