# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Coro-Multicore"
PV = "1.07"
PR = "14.el10_0"
PACKAGES = " \
 perl-Coro-Multicore-tests \
 perlmulticore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Coro-Multicore-1.07-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d19b29b13e4a9737f50ed6ffa02ff4215ec760a36636c69810cc2abb4d8c80c"

URI_x86_64_v2_perl-Coro-Multicore-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Coro-Multicore-tests-1.07-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Coro-Multicore-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Coro-Multicore-tests}"
SRC_URI[x86_64_v2_perl-Coro-Multicore-tests.sha256sum] = "04ae69329ac42e651491e26aba98af18d5693d7c347fccd6937edf52aff7925e"

URI_x86_64_v2_perlmulticore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perlmulticore-devel-1.07-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perlmulticore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perlmulticore-devel}"
SRC_URI[x86_64_v2_perlmulticore-devel.sha256sum] = "4ad1562b2b00242ba84d260122e417c2e4dbbb09a2bcf4e93a8f9e6e04961c3c"

URI_aarch64_perl-Coro-Multicore-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Coro-Multicore-tests-1.07-14.el10_0.noarch.rpm;name=aarch64_perl-Coro-Multicore-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Coro-Multicore-tests}"
SRC_URI[aarch64_perl-Coro-Multicore-tests.sha256sum] = "f91b38147be7a8cbc801f4887c7d5b90bd4890151727d19519c44a24eacdaaa1"

URI_aarch64_perlmulticore-devel = "${EPEL_MIRROR}/aarch64/Packages/p/perlmulticore-devel-1.07-14.el10_0.aarch64.rpm;name=aarch64_perlmulticore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_perlmulticore-devel}"
SRC_URI[aarch64_perlmulticore-devel.sha256sum] = "bb18cd651edb219bdd4c482bb1e9a7424ac05daf40e21511fed595f4402175b0"

RDEPENDS:perl-Coro-Multicore-tests = " \
 bash \
 "
RDEPENDS:perlmulticore-devel = " \
 "
