# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-chunk"
PV = "0.4.12"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-chunk+default-devel \
 rust-gix-chunk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-chunk-0.4.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02575728325b56ca00992c8689cfc25e8bd225617b11116277ed8ce9f472cdee"

URI_x86_64_v2_rust-gix-chunk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-chunk+default-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-chunk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-chunk+default-devel}"
SRC_URI[x86_64_v2_rust-gix-chunk+default-devel.sha256sum] = "0ab2afff77ef208ebf459717bb938f475d17c5312c954be6f204037e75f5c70a"

URI_x86_64_v2_rust-gix-chunk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-chunk-devel-0.4.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-chunk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-chunk-devel}"
SRC_URI[x86_64_v2_rust-gix-chunk-devel.sha256sum] = "d2f622db5e05ad0b40c420715b916fc11aadfb12bd9ee4a9646ea51d89aca606"

URI_aarch64_rust-gix-chunk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-chunk+default-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-gix-chunk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-chunk+default-devel}"
SRC_URI[aarch64_rust-gix-chunk+default-devel.sha256sum] = "d5f34fc5fa4a5a8f48d43e95691fbc072cfd0a06068fe568ceb761336a3cd0ff"

URI_aarch64_rust-gix-chunk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-chunk-devel-0.4.12-1.el10_2.noarch.rpm;name=aarch64_rust-gix-chunk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-chunk-devel}"
SRC_URI[aarch64_rust-gix-chunk-devel.sha256sum] = "1529bf0e24e12b6fa6dd0663db67d0a852759eae05fe4ea8d57e0041072321c9"

RDEPENDS:rust-gix-chunk+default-devel = " \
 cargo \
 rust-gix-chunk-devel \
 "
RDEPENDS:rust-gix-chunk-devel = " \
 cargo \
 rust \
 rust-thiserror+default-devel \
 "
