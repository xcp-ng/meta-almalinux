# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scrub"
PV = "2.6.1"
PR = "11.el10"
PACKAGES = " \
 scrub \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/scrub-2.6.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3109f54a12fe9ab79e2df5112b4a0d395a5f75f7627d496396c4f95ad0832d6"

URI_x86_64_v2_scrub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scrub-2.6.1-11.el10.x86_64_v2.rpm;name=x86_64_v2_scrub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scrub}"
SRC_URI[x86_64_v2_scrub.sha256sum] = "f3848f490d88ce32a229355e024b17984edd3000554f9e4c7abc9947b9692fac"

URI_aarch64_scrub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scrub-2.6.1-11.el10.aarch64.rpm;name=aarch64_scrub;unpack=0"
SRC_URI:append = " ${URI_aarch64_scrub}"
SRC_URI[aarch64_scrub.sha256sum] = "ad46509c355ff025eb8930d2cbff7ccbebfe25a10f3b246728fdf12cf01cd864"

RDEPENDS:scrub = " \
 glibc \
 openssl-libs \
 "
