# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-print-manager"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-print-manager \
 plasma-print-manager-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-print-manager-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7547e87079e4da3642d79d4daae0b91feed9fff9785daa5f20d7ae3ae73de93"

URI_x86_64_v2_plasma-print-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-print-manager-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-print-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-print-manager}"
SRC_URI[x86_64_v2_plasma-print-manager.sha256sum] = "b66df1b0656837f372419e06bd8c95d7fcf449e98ce6d079c369c98d93a90892"

URI_x86_64_v2_plasma-print-manager-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-print-manager-libs-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-print-manager-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-print-manager-libs}"
SRC_URI[x86_64_v2_plasma-print-manager-libs.sha256sum] = "0f671a80b57d2c7e0e132edd8421f026f7bea3df1e895fcd6b5653ff3cbd1df0"

URI_aarch64_plasma-print-manager = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-print-manager-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-print-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-print-manager}"
SRC_URI[aarch64_plasma-print-manager.sha256sum] = "b766cadbbe54cdf303d676d985266bf5567b0020066754210e1d3776e7410eed"

URI_aarch64_plasma-print-manager-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-print-manager-libs-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-print-manager-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-print-manager-libs}"
SRC_URI[aarch64_plasma-print-manager-libs.sha256sum] = "34a9786896027b85024f705e4d850f61800f554dadd9c358cd1e13cf3fd5e117"

RDEPENDS:plasma-print-manager = " \
 PackageKit-Qt6 \
 cups \
 cups-libs \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-print-manager-libs \
 plasma-workspace \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 system-config-printer-libs \
 "
RDEPENDS:plasma-print-manager-libs = " \
 cups-libs \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libplasma \
 libstdc++ \
 plasma-print-manager \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
