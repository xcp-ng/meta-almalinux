# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pykickstart"
PV = "3.52.12"
PR = "1.el10.alma.1"
PACKAGES = " \
 pykickstart \
 python3-kickstart \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pykickstart-3.52.12-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9cf445646849886d26c5ff960804ddc9cd9b9c5924500c8716fa572ca658d50"

URI_x86_64_v2_pykickstart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pykickstart-3.52.12-1.el10.alma.1.noarch.rpm;name=x86_64_v2_pykickstart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pykickstart}"
SRC_URI[x86_64_v2_pykickstart.sha256sum] = "fc8765a9bbe55154366e2ddb92d21f6ba36eb804ca31224e0a70a2c879a4e39f"

URI_x86_64_v2_python3-kickstart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-kickstart-3.52.12-1.el10.alma.1.noarch.rpm;name=x86_64_v2_python3-kickstart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kickstart}"
SRC_URI[x86_64_v2_python3-kickstart.sha256sum] = "6d935221583d0f392d06811d6a23a8224f68df7599cd32eef87c349ab1e9ee97"

URI_aarch64_pykickstart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pykickstart-3.52.12-1.el10.alma.1.noarch.rpm;name=aarch64_pykickstart;unpack=0"
SRC_URI:append = " ${URI_aarch64_pykickstart}"
SRC_URI[aarch64_pykickstart.sha256sum] = "fc8765a9bbe55154366e2ddb92d21f6ba36eb804ca31224e0a70a2c879a4e39f"

URI_aarch64_python3-kickstart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-kickstart-3.52.12-1.el10.alma.1.noarch.rpm;name=aarch64_python3-kickstart;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kickstart}"
SRC_URI[aarch64_python3-kickstart.sha256sum] = "6d935221583d0f392d06811d6a23a8224f68df7599cd32eef87c349ab1e9ee97"

RDEPENDS:pykickstart = " \
 python3 \
 python3-kickstart \
 "
RDEPENDS:python3-kickstart = " \
 python3 \
 python3-requests \
 "
