# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapraid"
PV = "12.4"
PR = "1.el10_0"
PACKAGES = " \
 snapraid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapraid-12.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8efac28e63c6c4445322a726bee132140d77b489674fb648fc41d74401bdc2e8"

URI_x86_64_v2_snapraid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapraid-12.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapraid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapraid}"
SRC_URI[x86_64_v2_snapraid.sha256sum] = "29ab537cdba30924013d5692af718904e26fb0d5dcbcac56395cc0dbe6f4cb60"

URI_aarch64_snapraid = "${EPEL_MIRROR}/aarch64/Packages/s/snapraid-12.4-1.el10_0.aarch64.rpm;name=aarch64_snapraid;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapraid}"
SRC_URI[aarch64_snapraid.sha256sum] = "90d5e906f1d141697c7ad9bfce29c954417bee67ae856a16ea8f7631010a2322"

RDEPENDS:snapraid = " \
 glibc \
 libblkid \
 "
