# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tang"
PV = "14"
PR = "13.el10"
PACKAGES = " \
 tang \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tang-14-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18267aa184ac5f514c13a53f3904a052cbab3e6b7f373938f04d17150ad14c68"

URI_x86_64_v2_tang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tang-14-13.el10.x86_64_v2.rpm;name=x86_64_v2_tang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tang}"
SRC_URI[x86_64_v2_tang.sha256sum] = "3acb5512db2236bfbd623f6046f09162289228c11145012869f17618efd30358"

URI_aarch64_tang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tang-14-13.el10.aarch64.rpm;name=aarch64_tang;unpack=0"
SRC_URI:append = " ${URI_aarch64_tang}"
SRC_URI[aarch64_tang.sha256sum] = "b76d815e90be0dc04a5cb3f342922a57e3cc39a23447b49e05736e626e8d344d"

RDEPENDS:tang = " \
 bash \
 glibc \
 grep \
 jansson \
 jose \
 libgcc \
 libjose \
 llhttp \
 sed \
 shadow-utils \
 virtual/coreutils \
 "
