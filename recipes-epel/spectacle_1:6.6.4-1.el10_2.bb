# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spectacle"
PE = "1"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 spectacle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spectacle-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3bcdeafda5d008e0c3eb56882dce43559a6d85d82c4c2f0ea5994052d38829a9"

URI_x86_64_v2_spectacle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spectacle-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spectacle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spectacle}"
SRC_URI[x86_64_v2_spectacle.sha256sum] = "c870829d1e99b8b8d23b5472fb09379ec474ddb3cff7c0bf36b1d6839347e012"

URI_aarch64_spectacle = "${EPEL_MIRROR}/aarch64/Packages/s/spectacle-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_spectacle;unpack=0"
SRC_URI:append = " ${URI_aarch64_spectacle}"
SRC_URI[aarch64_spectacle.sha256sum] = "7def35c9f86768db479e86c0735b59686c6e6a0c227058d4a4257758d38094a5"

RDEPENDS:spectacle = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-prison \
 kf6-purpose \
 kpipewire \
 kquickimageeditor-qt6 \
 layer-shell-qt \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 "
