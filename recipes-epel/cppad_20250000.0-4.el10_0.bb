# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cppad"
PV = "20250000.0"
PR = "4.el10_0"
PACKAGES = " \
 cppad \
 cppad-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cppad-20250000.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ba2ed8a07c14a81e65212c8a2510b0fc1ace00cb4e259388a6eaf2d77cf596a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppad-20250000.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppad;unpack=0"
SRC_URI[x86_64_v2_cppad.sha256sum] = "773c258698d80ebbdb3837deaed6ef8efb994050428fb598265e7e525d8c7418"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppad-devel-20250000.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppad-devel;unpack=0"
SRC_URI[x86_64_v2_cppad-devel.sha256sum] = "3e66e4acb541809ac3420633d66b810c9c62e73a5d1f183ca430e1c48ca24387"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cppad-20250000.0-4.el10_0.aarch64.rpm;name=aarch64_cppad;unpack=0"
SRC_URI[aarch64_cppad.sha256sum] = "40a91c8a2fa4daf92c82a2e3f6511d8057a1362dd73ebf71a3f1d1a4858deb33"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cppad-devel-20250000.0-4.el10_0.aarch64.rpm;name=aarch64_cppad-devel;unpack=0"
SRC_URI[aarch64_cppad-devel.sha256sum] = "3d761dc80157a8cf6ec0a4142e6db1fa3ff22fab262f31dd03ecf9eb5c9a360e"

RDEPENDS:cppad = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:cppad-devel = " \
 cppad \
 pkgconf-pkg-config \
 "
