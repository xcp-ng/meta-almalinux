# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bogofilter"
PV = "1.2.5"
PR = "19.el10_1"
PACKAGES = " \
 bogofilter \
 bogofilter-bogoupgrade \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bogofilter-1.2.5-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e202ca56680e113ea9fb933e129f300874c075fcd1c2a3f7ab959e2b1c2a6848"

URI_x86_64_v2_bogofilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bogofilter-1.2.5-19.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bogofilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bogofilter}"
SRC_URI[x86_64_v2_bogofilter.sha256sum] = "59d1153ce87c4e358dc8000cba4232c0083fe63df0147c49f51ff71c404220e2"

URI_x86_64_v2_bogofilter-bogoupgrade = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bogofilter-bogoupgrade-1.2.5-19.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bogofilter-bogoupgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bogofilter-bogoupgrade}"
SRC_URI[x86_64_v2_bogofilter-bogoupgrade.sha256sum] = "cbec9e26ebf38d223013957a83c27ef1b8bc29e9408004e07d2abe908f5a85fb"

URI_aarch64_bogofilter = "${EPEL_MIRROR}/aarch64/Packages/b/bogofilter-1.2.5-19.el10_1.aarch64.rpm;name=aarch64_bogofilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_bogofilter}"
SRC_URI[aarch64_bogofilter.sha256sum] = "87eafc8c7a55bb609e89c85cb6b9d902f01c41a2e3e7c0a2a4cdf6fbe68a800c"

URI_aarch64_bogofilter-bogoupgrade = "${EPEL_MIRROR}/aarch64/Packages/b/bogofilter-bogoupgrade-1.2.5-19.el10_1.aarch64.rpm;name=aarch64_bogofilter-bogoupgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_bogofilter-bogoupgrade}"
SRC_URI[aarch64_bogofilter-bogoupgrade.sha256sum] = "a617eec9d99ebf05f8d4c855b00f0a478f395150c4142e59284f65a5e029c3f0"

RDEPENDS:bogofilter = " \
 bash \
 glibc \
 sqlite-libs \
 "
RDEPENDS:bogofilter-bogoupgrade = " \
 bogofilter \
 perl-Pod-Usage \
 perl-filetest \
 perl-interpreter \
 perl-libs \
 "
