# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-notify-types"
PV = "2.1.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-notify-types+default-devel \
 rust-notify-types+serde-devel \
 rust-notify-types+serialization-compat-6-devel \
 rust-notify-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-notify-types-2.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3799ff7e0d843bdcc601f878100512c10ad6636a7188e41e5d2e148b9813319a"

URI_x86_64_v2_rust-notify-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types+default-devel-2.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types+default-devel}"
SRC_URI[x86_64_v2_rust-notify-types+default-devel.sha256sum] = "1da1061de2ae775971781d29b42c14e39040de8ba7312704605b62208ffeaeef"

URI_x86_64_v2_rust-notify-types+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types+serde-devel-2.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types+serde-devel}"
SRC_URI[x86_64_v2_rust-notify-types+serde-devel.sha256sum] = "0136056a98bf58534e36a2df7a95ac622265e7da3c92bec8738bc0eaad91b5cc"

URI_x86_64_v2_rust-notify-types+serialization-compat-6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types+serialization-compat-6-devel-2.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types+serialization-compat-6-devel}"
SRC_URI[x86_64_v2_rust-notify-types+serialization-compat-6-devel.sha256sum] = "0509727b9c90b2bac563b28d55e6d92453bec20a1ad87de5ae6b799c211d3ac2"

URI_x86_64_v2_rust-notify-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-types-devel-2.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-types-devel}"
SRC_URI[x86_64_v2_rust-notify-types-devel.sha256sum] = "72be7cc2bfa65d6bb200de513ff0f84b6afa39d504bd334272ccb0121726b847"

URI_aarch64_rust-notify-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types+default-devel-2.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types+default-devel}"
SRC_URI[aarch64_rust-notify-types+default-devel.sha256sum] = "8e4a21b1d2ad5d2f68fc497cdf13ec64f5a83fa8469b2c49da45e2d584a392dc"

URI_aarch64_rust-notify-types+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types+serde-devel-2.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify-types+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types+serde-devel}"
SRC_URI[aarch64_rust-notify-types+serde-devel.sha256sum] = "a78cda3490407ea0240c800e3d65b0e29f3ebaad0ae5eb8b5570b0662a3285ba"

URI_aarch64_rust-notify-types+serialization-compat-6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types+serialization-compat-6-devel-2.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify-types+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types+serialization-compat-6-devel}"
SRC_URI[aarch64_rust-notify-types+serialization-compat-6-devel.sha256sum] = "93a4dcaabbca1ebe25aee4ae28efb3af13483a43d83bd002816f6a34669e5f49"

URI_aarch64_rust-notify-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-types-devel-2.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-types-devel}"
SRC_URI[aarch64_rust-notify-types-devel.sha256sum] = "f382b2701e58f1cc0fe77c6602ae19fc170a14883a0bc45fbad20f87fa09ec39"

RDEPENDS:rust-notify-types+default-devel = " \
 cargo \
 rust-notify-types-devel \
 "
RDEPENDS:rust-notify-types+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-notify-types-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-notify-types+serialization-compat-6-devel = " \
 cargo \
 rust-notify-types-devel \
 "
RDEPENDS:rust-notify-types-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 "
