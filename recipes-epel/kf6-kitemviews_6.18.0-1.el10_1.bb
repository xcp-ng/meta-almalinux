# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kitemviews"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kitemviews \
 kf6-kitemviews-devel \
 kf6-kitemviews-doc \
 kf6-kitemviews-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kitemviews-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fb7f69e543071569e5c0f4152742e21859a008f6c809659ded612023ea55054"

URI_x86_64_v2_kf6-kitemviews = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews}"
SRC_URI[x86_64_v2_kf6-kitemviews.sha256sum] = "1cbe7fda48f2038eef0008c89714eae5b8d40aa4f8ad67c42a2470ae9527bfb5"

URI_x86_64_v2_kf6-kitemviews-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kitemviews-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-devel}"
SRC_URI[x86_64_v2_kf6-kitemviews-devel.sha256sum] = "e90460b67b698001b02e22cae4cd72fdc62fb78085aae74c98399fe9ab4e408e"

URI_x86_64_v2_kf6-kitemviews-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemviews-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-doc}"
SRC_URI[x86_64_v2_kf6-kitemviews-doc.sha256sum] = "6392962b25ae9a2be56d737684cdaaa3fc1d683723077b95575f1b59b6f06cef"

URI_x86_64_v2_kf6-kitemviews-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kitemviews-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kitemviews-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kitemviews-html}"
SRC_URI[x86_64_v2_kf6-kitemviews-html.sha256sum] = "65b7dc9b94863f3892b682c0fb509063652bf93faa80fc3dcde63d73dbcd59bd"

URI_aarch64_kf6-kitemviews = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kitemviews;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews}"
SRC_URI[aarch64_kf6-kitemviews.sha256sum] = "808c38b99cbafce87ac8a89a2f7862017c7001fd236c24d6e24a1208551319c7"

URI_aarch64_kf6-kitemviews-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kitemviews-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-devel}"
SRC_URI[aarch64_kf6-kitemviews-devel.sha256sum] = "2bde4a3600acdd77c4cbd79c463c0b7a0a46bfacdc583a526b523e9169d25987"

URI_aarch64_kf6-kitemviews-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kitemviews-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-doc}"
SRC_URI[aarch64_kf6-kitemviews-doc.sha256sum] = "4b3b5594cdf2627a60345cfe5f2a629dd9e8b889c2fb6530688934247b8d63d2"

URI_aarch64_kf6-kitemviews-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kitemviews-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kitemviews-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kitemviews-html}"
SRC_URI[aarch64_kf6-kitemviews-html.sha256sum] = "dc361c5e5c23ac576ff25761eb21fae0b5334c87d101cd6f57840324cc2b10b1"

RDEPENDS:kf6-kitemviews = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kitemviews \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kitemviews-doc = " \
 "
RDEPENDS:kf6-kitemviews-html = " \
 "
