# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-CSV"
PV = "2.06"
PR = "1.el10_2"
PACKAGES = " \
 perl-Text-CSV \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-CSV-2.06-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26e13726e8d565052d128f5a7d185efd3a75817f6ddd2049d0631151773c32f3"

URI_x86_64_v2_perl-Text-CSV = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-CSV-2.06-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-CSV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-CSV}"
SRC_URI[x86_64_v2_perl-Text-CSV.sha256sum] = "1086dfba3888826bfcdce50b714373b1e4fb4666ab0270d2fadbae511ceca8fa"

URI_aarch64_perl-Text-CSV = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-CSV-2.06-1.el10_2.noarch.rpm;name=aarch64_perl-Text-CSV;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-CSV}"
SRC_URI[aarch64_perl-Text-CSV.sha256sum] = "68bd4d404066c73264ddd13830b0e88b38c9152bb4a1457c27ff5a8e8b3a550f"

RDEPENDS:perl-Text-CSV = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-libs \
 perl-overload \
 perl-vars \
 "
