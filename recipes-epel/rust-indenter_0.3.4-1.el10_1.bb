# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indenter"
PV = "0.3.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-indenter+default-devel \
 rust-indenter+std-devel \
 rust-indenter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indenter-0.3.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f79388da78ea3d092d88e8f585da0188e2041c6f73c499c1c14392cb266fba5"

URI_x86_64_v2_rust-indenter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indenter+default-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indenter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indenter+default-devel}"
SRC_URI[x86_64_v2_rust-indenter+default-devel.sha256sum] = "43b9a184d067b84682687d70c9347049cb782adab8fdfafe92a4cb1dac71f257"

URI_x86_64_v2_rust-indenter+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indenter+std-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indenter+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indenter+std-devel}"
SRC_URI[x86_64_v2_rust-indenter+std-devel.sha256sum] = "4d4dc990c53f74c341fe3c63b9429c94a7136c6147c3ce8b6f6803306cfae78f"

URI_x86_64_v2_rust-indenter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indenter-devel-0.3.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indenter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indenter-devel}"
SRC_URI[x86_64_v2_rust-indenter-devel.sha256sum] = "2cd2449c1e801d2c5d57fab5e819ddbcd556d207da998fb574545ed7506495bc"

URI_aarch64_rust-indenter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indenter+default-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-indenter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indenter+default-devel}"
SRC_URI[aarch64_rust-indenter+default-devel.sha256sum] = "e24c5c67c895be1efcd26bb23c142a4b9f00bd367d19c00d8f40b59e079ed83c"

URI_aarch64_rust-indenter+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indenter+std-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-indenter+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indenter+std-devel}"
SRC_URI[aarch64_rust-indenter+std-devel.sha256sum] = "5ca9c5351251068b8ffb99690c91877b82c6705be1e1836aa6d7c2933c156436"

URI_aarch64_rust-indenter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indenter-devel-0.3.4-1.el10_1.noarch.rpm;name=aarch64_rust-indenter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indenter-devel}"
SRC_URI[aarch64_rust-indenter-devel.sha256sum] = "519e0383ac35eb689bfbfd5d5103aca54e7f20ce254d55ef0c313bb54faa7c6f"

RDEPENDS:rust-indenter+default-devel = " \
 cargo \
 rust-indenter-devel \
 "
RDEPENDS:rust-indenter+std-devel = " \
 cargo \
 rust-indenter-devel \
 "
RDEPENDS:rust-indenter-devel = " \
 cargo \
 rust \
 "
