# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openexr"
PV = "3.1.10"
PR = "12.el10"
PACKAGES = " \
 openexr \
 openexr-devel \
 openexr-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openexr-3.1.10-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e433db0b14d76ed17718587b8005ee991668efc1e7d0cb87ac741af84e7989d"

URI_x86_64_v2_openexr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-3.1.10-12.el10.x86_64_v2.rpm;name=x86_64_v2_openexr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openexr}"
SRC_URI[x86_64_v2_openexr.sha256sum] = "b600382cb88a87ead4a3d956059d099beff5a915ebb9e8ce700d1066435ab230"

URI_x86_64_v2_openexr-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openexr-devel-3.1.10-12.el10.x86_64_v2.rpm;name=x86_64_v2_openexr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openexr-devel}"
SRC_URI[x86_64_v2_openexr-devel.sha256sum] = "29b29bd75ef7a6790cdcdddd886e256cc6020647ce8cf5d391a9577493cf9b08"

URI_x86_64_v2_openexr-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openexr-libs-3.1.10-12.el10.x86_64_v2.rpm;name=x86_64_v2_openexr-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openexr-libs}"
SRC_URI[x86_64_v2_openexr-libs.sha256sum] = "209263e5552905ddc45295563376af40000f41659971f37629d7fb2c1cf69bf4"

URI_aarch64_openexr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-3.1.10-12.el10.aarch64.rpm;name=aarch64_openexr;unpack=0"
SRC_URI:append = " ${URI_aarch64_openexr}"
SRC_URI[aarch64_openexr.sha256sum] = "52dc4a2e929bdae1ea972dfcd92566863d3da52ccefeef924a5cc6089d581254"

URI_aarch64_openexr-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openexr-devel-3.1.10-12.el10.aarch64.rpm;name=aarch64_openexr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openexr-devel}"
SRC_URI[aarch64_openexr-devel.sha256sum] = "630f6121fcaeb079d110e1b392410cab3a87e6307d00423ef13b5f12281b99ea"

URI_aarch64_openexr-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openexr-libs-3.1.10-12.el10.aarch64.rpm;name=aarch64_openexr-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openexr-libs}"
SRC_URI[aarch64_openexr-libs.sha256sum] = "fed49c31ec0ae8230ce8629c31e09d5273b9806430832650e5b653c2f6517029"

RDEPENDS:openexr = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 openexr-libs \
 "
RDEPENDS:openexr-devel = " \
 cmake-filesystem \
 imath-devel \
 openexr-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:openexr-libs = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
