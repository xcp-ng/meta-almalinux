# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-plac"
PV = "1.4.5"
PR = "4.el10_0"
PACKAGES = " \
 python-plac-doc \
 python3-plac \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-plac-1.4.5-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "455c04813800132dbbf34f97305d9cb1e0a8f94eebf14b74d305a9a72282fae8"

URI_x86_64_v2_python-plac-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-plac-doc-1.4.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-plac-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-plac-doc}"
SRC_URI[x86_64_v2_python-plac-doc.sha256sum] = "af774d2d676c97b886f6a5084355a27c5d745447520f0a2f4bbb9644e2a4f424"

URI_x86_64_v2_python3-plac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-plac-1.4.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-plac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-plac}"
SRC_URI[x86_64_v2_python3-plac.sha256sum] = "b80e1eaa8e33bb8abfd05002f9c3d6b39bcd8f68a4893e4899b1307398fbae0b"

URI_aarch64_python-plac-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-plac-doc-1.4.5-4.el10_0.noarch.rpm;name=aarch64_python-plac-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-plac-doc}"
SRC_URI[aarch64_python-plac-doc.sha256sum] = "da2e3c97f0df53bd98baa6723b35f6d41d6ffbc418c31e6e2e4e6585f19782dd"

URI_aarch64_python3-plac = "${EPEL_MIRROR}/aarch64/Packages/p/python3-plac-1.4.5-4.el10_0.noarch.rpm;name=aarch64_python3-plac;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-plac}"
SRC_URI[aarch64_python3-plac.sha256sum] = "507815f625070ef0237f821cd9ad91515de50f6cef35b66096636533da11d2d1"

RDEPENDS:python-plac-doc = " \
 "
RDEPENDS:python3-plac = " \
 python3 \
 "
