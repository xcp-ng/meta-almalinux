# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmtp"
PV = "1.1.19"
PR = "9.el10"
PACKAGES = " \
 libmtp \
 libmtp-devel \
 libmtp-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libmtp-1.1.19-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "258b6515100a99eac63790cb7078d90602b7d45534da99ae274be473b4efb39c"

URI_x86_64_v2_libmtp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmtp-1.1.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_libmtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmtp}"
SRC_URI[x86_64_v2_libmtp.sha256sum] = "6f84ef864b38f0df976b6809aca7756fc11c9c7e7f31f29071105edd493766e6"

URI_x86_64_v2_libmtp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmtp-devel-1.1.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_libmtp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmtp-devel}"
SRC_URI[x86_64_v2_libmtp-devel.sha256sum] = "662debdf02202e0250aff436cb75910b9840128dbf22b7cada1dbc278f26e357"

URI_x86_64_v2_libmtp-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmtp-examples-1.1.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_libmtp-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmtp-examples}"
SRC_URI[x86_64_v2_libmtp-examples.sha256sum] = "387858c199bdf742afd01033fb2d251f6d23122f469139b66e0deb36bda76e56"

URI_aarch64_libmtp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmtp-1.1.19-9.el10.aarch64.rpm;name=aarch64_libmtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmtp}"
SRC_URI[aarch64_libmtp.sha256sum] = "a08c46dff2c295f2d161b6c67615d1297f5040b11d5f0d02e1d51a10c847b2ed"

URI_aarch64_libmtp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmtp-devel-1.1.19-9.el10.aarch64.rpm;name=aarch64_libmtp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmtp-devel}"
SRC_URI[aarch64_libmtp-devel.sha256sum] = "c4259f329372637f21f73b9687d41b34fa396372662a9c16a30d3fea901c6842"

URI_aarch64_libmtp-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmtp-examples-1.1.19-9.el10.aarch64.rpm;name=aarch64_libmtp-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmtp-examples}"
SRC_URI[aarch64_libmtp-examples.sha256sum] = "47a6672f6ecbc21651d731b3657a74eb65464cd43b72c03e0e693259c6edc2df"

RDEPENDS:libmtp = " \
 glibc \
 libusb1 \
 "
RDEPENDS:libmtp-devel = " \
 libmtp \
 libusb1-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libmtp-examples = " \
 glibc \
 libmtp \
 "
