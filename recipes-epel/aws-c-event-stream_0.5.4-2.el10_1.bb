# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-event-stream"
PV = "0.5.4"
PR = "2.el10_1"
PACKAGES = " \
 aws-c-event-stream \
 aws-c-event-stream-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/aws-c-event-stream-0.5.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "992289d40aed18cb49f6be38063d5e377b416981273f8a5ac3229c4c87d7f2c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-event-stream-0.5.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-event-stream;unpack=0"
SRC_URI[x86_64_v2_aws-c-event-stream.sha256sum] = "bcc85250b8f9e27524a7f95f224c3eeb99d371b7cac566e1bc387dced532220c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-event-stream-devel-0.5.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-event-stream-devel;unpack=0"
SRC_URI[x86_64_v2_aws-c-event-stream-devel.sha256sum] = "04c3933ea8b499b52654b482c12802c8d9823a84d2dbd2f8fb97561b76a3eebc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aws-c-event-stream-0.5.4-2.el10_1.aarch64.rpm;name=aarch64_aws-c-event-stream;unpack=0"
SRC_URI[aarch64_aws-c-event-stream.sha256sum] = "a2e84fc78a4115d01d3eeeff95d6f41ab8c6f2d485425e39a4502eee669bda74"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/aws-c-event-stream-devel-0.5.4-2.el10_1.aarch64.rpm;name=aarch64_aws-c-event-stream-devel;unpack=0"
SRC_URI[aarch64_aws-c-event-stream-devel.sha256sum] = "b257dfe341de6a4c7ba936c60766896e4bdfe953be89b2fd8120f1d4a47291f0"

RDEPENDS:aws-c-event-stream = " \
 aws-c-common-libs \
 aws-c-io \
 aws-checksums-libs \
 glibc \
 "
RDEPENDS:aws-c-event-stream-devel = " \
 aws-c-common-devel \
 aws-c-event-stream \
 aws-c-io-devel \
 aws-checksums-devel \
 cmake-filesystem \
 openssl-devel \
 "
