# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "neon"
PV = "0.37.1"
PR = "4.el10_3"
PACKAGES = " \
 neon \
 neon-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/neon-0.37.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a1dc0cb5596791e2d31c95e48e26a38894117770d76c7ef2be4200a0a6352d03"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neon-0.37.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neon;unpack=0"
SRC_URI[x86_64_v2_neon.sha256sum] = "7abc6533700190ef554a91c4b9f85bf9b6cbdece1a429e690b001570a4d43a39"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neon-devel-0.37.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neon-devel;unpack=0"
SRC_URI[x86_64_v2_neon-devel.sha256sum] = "185b48dfd48856c570a14a597f9b67adb922cb8f9c0bf7c6a3a882e1fe51145b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/neon-0.37.1-4.el10_3.aarch64.rpm;name=aarch64_neon;unpack=0"
SRC_URI[aarch64_neon.sha256sum] = "a3b229b68230965c15c39e747825d7d50e5ca7fa5e26786362248c434b4d9f39"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/neon-devel-0.37.1-4.el10_3.aarch64.rpm;name=aarch64_neon-devel;unpack=0"
SRC_URI[aarch64_neon-devel.sha256sum] = "600a66ff356a36ab97dafc639db2f4d521b629312d805d19b5b94001d49125b0"

RDEPENDS:neon = " \
 expat \
 glibc \
 krb5-libs \
 libntlm \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:neon-devel = " \
 bash \
 expat-devel \
 neon \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
