# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libjoedog"
PV = "0.1.2"
PR = "26.el10_0"
PACKAGES = " \
 libjoedog \
 libjoedog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libjoedog-0.1.2-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab9a996536b9275aa15078398f9b1818ffde80c359a6be54813c55e113e719e3"

URI_x86_64_v2_libjoedog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjoedog-0.1.2-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjoedog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjoedog}"
SRC_URI[x86_64_v2_libjoedog.sha256sum] = "22680976817bce817f5a554cd2e3e13838349154e4df5eb195d8f20f56cc69ac"

URI_x86_64_v2_libjoedog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libjoedog-devel-0.1.2-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libjoedog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libjoedog-devel}"
SRC_URI[x86_64_v2_libjoedog-devel.sha256sum] = "176ae3bd98925f2a93d857e34aeaf29aaf4b8721979a8b7d0e659bfa393062ae"

URI_aarch64_libjoedog = "${EPEL_MIRROR}/aarch64/Packages/l/libjoedog-0.1.2-26.el10_0.aarch64.rpm;name=aarch64_libjoedog;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjoedog}"
SRC_URI[aarch64_libjoedog.sha256sum] = "d23b4f23aaea999f24b38a29d01b304ea54d0a1b23cbc088a218fc1e404def30"

URI_aarch64_libjoedog-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libjoedog-devel-0.1.2-26.el10_0.aarch64.rpm;name=aarch64_libjoedog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libjoedog-devel}"
SRC_URI[aarch64_libjoedog-devel.sha256sum] = "2cd65dad0e86d1ecb11b0e46ca7e2d0af2213e160e61571a3cf8c44031e832cb"

RDEPENDS:libjoedog = " \
 glibc \
 "
RDEPENDS:libjoedog-devel = " \
 libjoedog \
 "
