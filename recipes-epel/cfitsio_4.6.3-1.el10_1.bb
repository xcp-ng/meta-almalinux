# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cfitsio"
PV = "4.6.3"
PR = "1.el10_1"
PACKAGES = " \
 cfitsio \
 cfitsio-devel \
 cfitsio-docs \
 cfitsio-static \
 cfitsio-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cfitsio-4.6.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a058c7001efb0d8bb2c0e856f57f228eed3dd34b4647874d2ebc6abda5874c5c"

URI_x86_64_v2_cfitsio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-4.6.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio}"
SRC_URI[x86_64_v2_cfitsio.sha256sum] = "a4bfe24ffc038398c09712e7ac4f3da3f6a4a36df234cec64aa9c8c5e2deb195"

URI_x86_64_v2_cfitsio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-devel-4.6.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-devel}"
SRC_URI[x86_64_v2_cfitsio-devel.sha256sum] = "bee4d6869bd629a3e334ad636682666c3eda4ece251f8c126df662128d1802f0"

URI_x86_64_v2_cfitsio-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-docs-4.6.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cfitsio-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-docs}"
SRC_URI[x86_64_v2_cfitsio-docs.sha256sum] = "250b6b1443e067df50cf3a5354ef7607863645313eac869ceeee8ded2a5f1dde"

URI_x86_64_v2_cfitsio-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-static-4.6.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-static}"
SRC_URI[x86_64_v2_cfitsio-static.sha256sum] = "fbf8ed44676f7186523224f20e5378f2b63f28868d9c431c80a643a8263c7a0b"

URI_x86_64_v2_cfitsio-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cfitsio-utils-4.6.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cfitsio-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cfitsio-utils}"
SRC_URI[x86_64_v2_cfitsio-utils.sha256sum] = "67337cae43fc28e9fe56ac1ef73549035ebf49fd478842ed52019441cfaf8d65"

URI_aarch64_cfitsio = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-4.6.3-1.el10_1.aarch64.rpm;name=aarch64_cfitsio;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio}"
SRC_URI[aarch64_cfitsio.sha256sum] = "d0cb125d084f51d81b3882434b3c402328c1a2ff9d5caffb1b5599ec21d3162a"

URI_aarch64_cfitsio-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-devel-4.6.3-1.el10_1.aarch64.rpm;name=aarch64_cfitsio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-devel}"
SRC_URI[aarch64_cfitsio-devel.sha256sum] = "b036dfc4908acb2ea7c534860cc24cdeff87287dbec4efd1a3d69a2caefb3acc"

URI_aarch64_cfitsio-docs = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-docs-4.6.3-1.el10_1.noarch.rpm;name=aarch64_cfitsio-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-docs}"
SRC_URI[aarch64_cfitsio-docs.sha256sum] = "09930185168d723b2b4d74a1ed4ada665aa6541b85e1c209021af1fb8fea0ea8"

URI_aarch64_cfitsio-static = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-static-4.6.3-1.el10_1.aarch64.rpm;name=aarch64_cfitsio-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-static}"
SRC_URI[aarch64_cfitsio-static.sha256sum] = "978b57130e72c281611e39a1291d4bb5842a94fc7d2271793db2a969700058f6"

URI_aarch64_cfitsio-utils = "${EPEL_MIRROR}/aarch64/Packages/c/cfitsio-utils-4.6.3-1.el10_1.aarch64.rpm;name=aarch64_cfitsio-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_cfitsio-utils}"
SRC_URI[aarch64_cfitsio-utils.sha256sum] = "0cb9dc7b785c61f32d933560ad13aec32d3b93b3b875b627f37453545b4a4c1e"

RDEPENDS:cfitsio = " \
 bzip2-libs \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:cfitsio-devel = " \
 cfitsio \
 pkgconf-pkg-config \
 "
RDEPENDS:cfitsio-docs = " \
 "
RDEPENDS:cfitsio-static = " \
 "
RDEPENDS:cfitsio-utils = " \
 cfitsio \
 glibc \
 "
