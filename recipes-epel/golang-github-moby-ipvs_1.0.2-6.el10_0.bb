# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-moby-ipvs"
PV = "1.0.2"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-moby-ipvs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-moby-ipvs-1.0.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "883866307d44124df97f7778582f6bad1f4a92ebfb96bb7c69790eb412b16b01"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-moby-ipvs-devel: golang(github.com/vishvananda/netns)

URI_x86_64_v2_golang-github-moby-ipvs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-moby-ipvs-devel-1.0.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-moby-ipvs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-moby-ipvs-devel}"
SRC_URI[x86_64_v2_golang-github-moby-ipvs-devel.sha256sum] = "dc6cd2bd27c1769e6fa1531497d3fc550cafab382cbf4422ed241009d61af533"

URI_aarch64_golang-github-moby-ipvs-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-moby-ipvs-devel-1.0.2-6.el10_0.noarch.rpm;name=aarch64_golang-github-moby-ipvs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-moby-ipvs-devel}"
SRC_URI[aarch64_golang-github-moby-ipvs-devel.sha256sum] = "9564200dfe34a92311cf4bd9ce7b4720b98aa2045533f9a38d1bec3a334fb6f8"

RDEPENDS:golang-github-moby-ipvs-devel:x86_64_v2 = " \
 go-filesystem \
 golang-github-sirupsen-logrus-devel \
 golang-github-vishvananda-netlink-devel \
 golang-x-sys-devel \
"
RDEPENDS:golang-github-moby-ipvs-devel:aarch64 = " \
 go-filesystem \
 golang-github-sirupsen-logrus-devel \
 golang-github-vishvananda-netlink-devel \
 golang-github-vishvananda-netns-devel \
 golang-x-sys-devel \
"
