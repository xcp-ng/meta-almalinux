# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pasetors"
PV = "0.7.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-pasetors+default-devel \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors+p384-devel \
 rust-pasetors+paserk-devel \
 rust-pasetors+rand_core-devel \
 rust-pasetors+regex-devel \
 rust-pasetors+serde-devel \
 rust-pasetors+serde_json-devel \
 rust-pasetors+sha2-devel \
 rust-pasetors+std-devel \
 rust-pasetors+time-devel \
 rust-pasetors+v2-devel \
 rust-pasetors+v3-devel \
 rust-pasetors+v4-devel \
 rust-pasetors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pasetors-0.7.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3077a7db1357918c346902e0e396040c02133277de6140aeb9c56cf3cc1f791"

URI_x86_64_v2_rust-pasetors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+default-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+default-devel}"
SRC_URI[x86_64_v2_rust-pasetors+default-devel.sha256sum] = "a94912163fbeaf07b94cca58758ed794f8cf1e8cd9a0972574f721649e3a1e8a"

URI_x86_64_v2_rust-pasetors+ed25519-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+ed25519-compact-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+ed25519-compact-devel}"
SRC_URI[x86_64_v2_rust-pasetors+ed25519-compact-devel.sha256sum] = "5ed26784837239361f2d02303dff6ac148cb3b27b08779e9653748f7e8de7803"

URI_x86_64_v2_rust-pasetors+orion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+orion-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+orion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+orion-devel}"
SRC_URI[x86_64_v2_rust-pasetors+orion-devel.sha256sum] = "2764ee2ff8cce4df73e4d71e9b3787c56450c77df65dba0a86fcadf77ad3bf5a"

URI_x86_64_v2_rust-pasetors+p384-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+p384-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+p384-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+p384-devel}"
SRC_URI[x86_64_v2_rust-pasetors+p384-devel.sha256sum] = "1350aee40f0926e82e8500ed7f530b73845fb58f4e10bc3d819e19c373a79242"

URI_x86_64_v2_rust-pasetors+paserk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+paserk-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+paserk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+paserk-devel}"
SRC_URI[x86_64_v2_rust-pasetors+paserk-devel.sha256sum] = "1abd34eb8d3c7e2dcb5175027328df594128f3e68149d164787378cb4f8fbc77"

URI_x86_64_v2_rust-pasetors+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+rand_core-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+rand_core-devel}"
SRC_URI[x86_64_v2_rust-pasetors+rand_core-devel.sha256sum] = "6df888ae230982be44866e0b096446717c6a69d1aa750a7b47fa8a93d4a4a3db"

URI_x86_64_v2_rust-pasetors+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+regex-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+regex-devel}"
SRC_URI[x86_64_v2_rust-pasetors+regex-devel.sha256sum] = "d7a2d900f8e578ac5635f846a19a629c98a516b4cd524aa375459f21edf52eb3"

URI_x86_64_v2_rust-pasetors+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+serde-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+serde-devel}"
SRC_URI[x86_64_v2_rust-pasetors+serde-devel.sha256sum] = "744c816daa23201e65e1738ebdde57d01743d7251e7ff11ae4ef12287bc050da"

URI_x86_64_v2_rust-pasetors+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+serde_json-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+serde_json-devel}"
SRC_URI[x86_64_v2_rust-pasetors+serde_json-devel.sha256sum] = "9b4ded8a119e208f421bb2b35b1f1e9363f8f8fa1445e5efe7206fbb5451a651"

URI_x86_64_v2_rust-pasetors+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+sha2-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+sha2-devel}"
SRC_URI[x86_64_v2_rust-pasetors+sha2-devel.sha256sum] = "0a2745b336dcc8e7bacab0c12484231ac25bdfdf231fbd38bb21e55f269646f6"

URI_x86_64_v2_rust-pasetors+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+std-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+std-devel}"
SRC_URI[x86_64_v2_rust-pasetors+std-devel.sha256sum] = "6b038b0b47ac091a31f49a73cfc0ea8ca4d3294a35eda6c4bbe5a7e521a133a5"

URI_x86_64_v2_rust-pasetors+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+time-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+time-devel}"
SRC_URI[x86_64_v2_rust-pasetors+time-devel.sha256sum] = "05a13117d97644672f043207fe4b343b3b816aba2915ad3843d3e9a685b05887"

URI_x86_64_v2_rust-pasetors+v2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v2-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v2-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v2-devel.sha256sum] = "4728fd29afd94fb1fb9e1dbf04a51facda6a7d43c67c34d4fb1ab892bdc05af7"

URI_x86_64_v2_rust-pasetors+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v3-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v3-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v3-devel.sha256sum] = "9f8357f1c6657d6f1286dada6c03968c49ca1ae608cbeb285e282cedd1710779"

URI_x86_64_v2_rust-pasetors+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors+v4-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors+v4-devel}"
SRC_URI[x86_64_v2_rust-pasetors+v4-devel.sha256sum] = "7da21a177fd7315036dcfc1c128d587a019f89b49837c7fc1aa03244fa3f21d1"

URI_x86_64_v2_rust-pasetors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pasetors-devel-0.7.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pasetors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pasetors-devel}"
SRC_URI[x86_64_v2_rust-pasetors-devel.sha256sum] = "f995fdfd488770ce3ecc7655b9583e0fcef570ed9dfa1d96f2d34f0e20b24fb3"

URI_aarch64_rust-pasetors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+default-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+default-devel}"
SRC_URI[aarch64_rust-pasetors+default-devel.sha256sum] = "b530d4cbe9fa540f72f78f6ac610b97f5f73e1757a84b1b6353b617898fad4e1"

URI_aarch64_rust-pasetors+ed25519-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+ed25519-compact-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+ed25519-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+ed25519-compact-devel}"
SRC_URI[aarch64_rust-pasetors+ed25519-compact-devel.sha256sum] = "6b197dbd1e71c810404e3a2865b8597d948ed6eea8a9e711942d644c5e7825f6"

URI_aarch64_rust-pasetors+orion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+orion-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+orion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+orion-devel}"
SRC_URI[aarch64_rust-pasetors+orion-devel.sha256sum] = "6884c5a18e0cd700d0ee1e77e165ca071af2e0f0fad67095d152d603d1e95a7f"

URI_aarch64_rust-pasetors+p384-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+p384-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+p384-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+p384-devel}"
SRC_URI[aarch64_rust-pasetors+p384-devel.sha256sum] = "aca1e3615ee8726de76e217657dcfe5f5f08ffe52be872d304e8e5c628efca92"

URI_aarch64_rust-pasetors+paserk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+paserk-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+paserk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+paserk-devel}"
SRC_URI[aarch64_rust-pasetors+paserk-devel.sha256sum] = "b3a58c6e687fcc0ed2d86ec5cc2d77848c47f23bce701fd2b89c1526e56ada3a"

URI_aarch64_rust-pasetors+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+rand_core-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+rand_core-devel}"
SRC_URI[aarch64_rust-pasetors+rand_core-devel.sha256sum] = "1a047d0317069535d41a80f5c59e456cbd3f64f29f365abc0bba7da56c2ebbf1"

URI_aarch64_rust-pasetors+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+regex-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+regex-devel}"
SRC_URI[aarch64_rust-pasetors+regex-devel.sha256sum] = "f527730eeacd5fb34ad0102d6f5e30d7ce6c57a3ecc9aceb2f8b8efe21f8305d"

URI_aarch64_rust-pasetors+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+serde-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+serde-devel}"
SRC_URI[aarch64_rust-pasetors+serde-devel.sha256sum] = "57b8adb4ee9073bd34f8e11fde49003b0ac9f0293beaf81024b1a6f0ecba8c9d"

URI_aarch64_rust-pasetors+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+serde_json-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+serde_json-devel}"
SRC_URI[aarch64_rust-pasetors+serde_json-devel.sha256sum] = "c7d51879a81f5959c77a3dd52dbbba1f955911c61f767a7b90a243e8eb7200e0"

URI_aarch64_rust-pasetors+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+sha2-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+sha2-devel}"
SRC_URI[aarch64_rust-pasetors+sha2-devel.sha256sum] = "1a9aea7060b3998c0b2e5d0c3cc179d73859788ed7afe183c256e05e57e0bdcf"

URI_aarch64_rust-pasetors+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+std-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+std-devel}"
SRC_URI[aarch64_rust-pasetors+std-devel.sha256sum] = "07868d802362766c0aaa93047da309a2a7d0771b226ebefcc5ea792fb2c75ffb"

URI_aarch64_rust-pasetors+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+time-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+time-devel}"
SRC_URI[aarch64_rust-pasetors+time-devel.sha256sum] = "e24bbbb6900668cc5423c229212fd11567654e6cb007d121bb7b04d3d2343716"

URI_aarch64_rust-pasetors+v2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v2-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+v2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v2-devel}"
SRC_URI[aarch64_rust-pasetors+v2-devel.sha256sum] = "a35e30a9996eeffece549a77f222c8a981997617bea778490e2d0971155206fd"

URI_aarch64_rust-pasetors+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v3-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v3-devel}"
SRC_URI[aarch64_rust-pasetors+v3-devel.sha256sum] = "eba946059007e170f8286ef12b14f55b9b4554cf7650ec41b61fbb8794c65eed"

URI_aarch64_rust-pasetors+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors+v4-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors+v4-devel}"
SRC_URI[aarch64_rust-pasetors+v4-devel.sha256sum] = "44dca54958a4949c5f818ddf7ab6fa1c83c7e7c0bf5a531fc01a93a3caf6723e"

URI_aarch64_rust-pasetors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pasetors-devel-0.7.8-1.el10_3.noarch.rpm;name=aarch64_rust-pasetors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pasetors-devel}"
SRC_URI[aarch64_rust-pasetors-devel.sha256sum] = "6ce69e90e9f7602316a9bad882a998b0a71215d5ded4e305686d6708135a09c8"

RDEPENDS:rust-pasetors+default-devel = " \
 cargo \
 rust-pasetors+paserk-devel \
 rust-pasetors+std-devel \
 rust-pasetors+v4-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+ed25519-compact-devel = " \
 cargo \
 rust-ed25519-compact+random-devel \
 rust-ed25519-compact-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+orion-devel = " \
 cargo \
 rust-orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+p384-devel = " \
 cargo \
 rust-p384+default-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+paserk-devel = " \
 cargo \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+rand_core-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-rand_core0.6+getrandom-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-pasetors+regex-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-pasetors+serde-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-pasetors+serde_json-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-pasetors+sha2-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-sha2_0.10+default-devel \
 "
RDEPENDS:rust-pasetors+std-devel = " \
 cargo \
 rust-pasetors+regex-devel \
 rust-pasetors+serde_json-devel \
 rust-pasetors+time-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+time-devel = " \
 cargo \
 rust-pasetors-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-pasetors+v2-devel = " \
 cargo \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+v3-devel = " \
 cargo \
 rust-pasetors+p384-devel \
 rust-pasetors+rand_core-devel \
 rust-pasetors+sha2-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors+v4-devel = " \
 cargo \
 rust-pasetors+ed25519-compact-devel \
 rust-pasetors+orion-devel \
 rust-pasetors-devel \
 "
RDEPENDS:rust-pasetors-devel = " \
 cargo \
 rust \
 rust-ct-codecs-devel \
 rust-getrandom+default-devel \
 rust-subtle-devel \
 rust-zeroize-devel \
 "
