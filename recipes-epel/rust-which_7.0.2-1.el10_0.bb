# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-which"
PV = "7.0.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-which+default-devel \
 rust-which+regex-devel \
 rust-which+tracing-devel \
 rust-which-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-which-7.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "109b69ca81de45fa6e4d2deb6f721e3e7088252a9f581abe9639b66511e6015a"

URI_x86_64_v2_rust-which+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+default-devel-7.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+default-devel}"
SRC_URI[x86_64_v2_rust-which+default-devel.sha256sum] = "7f3006d27bc71059ee059fb130765a3cf0546388c43f9acd5c5d87d0e11ecb05"

URI_x86_64_v2_rust-which+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+regex-devel-7.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+regex-devel}"
SRC_URI[x86_64_v2_rust-which+regex-devel.sha256sum] = "1f269d297dcea7428c55c258781e25c419e17a653c72fb1e930dce9dd75f02ec"

URI_x86_64_v2_rust-which+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which+tracing-devel-7.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which+tracing-devel}"
SRC_URI[x86_64_v2_rust-which+tracing-devel.sha256sum] = "06c4396818936f80624327a781fd82a7d23cfcc026f12bb91833ba2b44837898"

URI_x86_64_v2_rust-which-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which-devel-7.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which-devel}"
SRC_URI[x86_64_v2_rust-which-devel.sha256sum] = "3cd054fa8db13ca78a07223043449c06623384b61307cab652a4cdcc43bb8ddb"

URI_aarch64_rust-which+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+default-devel-7.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-which+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+default-devel}"
SRC_URI[aarch64_rust-which+default-devel.sha256sum] = "17fe2d36163b723c778c12c522a66e292de54a57f0f3efe91e07b5ba05c09a7e"

URI_aarch64_rust-which+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+regex-devel-7.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-which+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+regex-devel}"
SRC_URI[aarch64_rust-which+regex-devel.sha256sum] = "18b060a8814f0cced9bc4a5b864fcb51e9e1643da1e2885e8a18a250e2d37967"

URI_aarch64_rust-which+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which+tracing-devel-7.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-which+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which+tracing-devel}"
SRC_URI[aarch64_rust-which+tracing-devel.sha256sum] = "31c55b34b44b2ef1b713efd46c179f5594289f60cfdbdbb780c5e7198388f163"

URI_aarch64_rust-which-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which-devel-7.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-which-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which-devel}"
SRC_URI[aarch64_rust-which-devel.sha256sum] = "87f660beb77033e8d576ad49f025f3e0b832d0428f18aca28e637ffdc5614f5f"

RDEPENDS:rust-which+default-devel = " \
 cargo \
 rust-which-devel \
 "
RDEPENDS:rust-which+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-which-devel \
 "
RDEPENDS:rust-which-devel = " \
 cargo \
 rust \
 rust-either+default-devel \
 rust-env_home+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
