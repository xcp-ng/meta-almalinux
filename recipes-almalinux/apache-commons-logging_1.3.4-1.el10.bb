# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-logging"
PV = "1.3.4"
PR = "1.el10"
PACKAGES = " \
 apache-commons-logging \
 apache-commons-logging-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apache-commons-logging-1.3.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8354c6461cbe815bef28d9ff999ab603fec67126106a232f70791910105f613e"

URI_x86_64_v2_apache-commons-logging = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apache-commons-logging-1.3.4-1.el10.noarch.rpm;name=x86_64_v2_apache-commons-logging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-logging}"
SRC_URI[x86_64_v2_apache-commons-logging.sha256sum] = "d46190bcd4adf877cecc60e46f2c5e0367ea10256a03c19add17e9ed82a01811"

URI_x86_64_v2_apache-commons-logging-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-logging-javadoc-1.3.4-1.el10.noarch.rpm;name=x86_64_v2_apache-commons-logging-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-logging-javadoc}"
SRC_URI[x86_64_v2_apache-commons-logging-javadoc.sha256sum] = "537dcfb4646b0e6a7a6edb1d4d15f359d85d0ee342e24a7fc638a8ab66c96180"

URI_aarch64_apache-commons-logging = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apache-commons-logging-1.3.4-1.el10.noarch.rpm;name=aarch64_apache-commons-logging;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-logging}"
SRC_URI[aarch64_apache-commons-logging.sha256sum] = "d46190bcd4adf877cecc60e46f2c5e0367ea10256a03c19add17e9ed82a01811"

URI_aarch64_apache-commons-logging-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-logging-javadoc-1.3.4-1.el10.noarch.rpm;name=aarch64_apache-commons-logging-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-logging-javadoc}"
SRC_URI[aarch64_apache-commons-logging-javadoc.sha256sum] = "537dcfb4646b0e6a7a6edb1d4d15f359d85d0ee342e24a7fc638a8ab66c96180"

RDEPENDS:apache-commons-logging = " \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-logging-javadoc = " \
 javapackages-filesystem \
 "
