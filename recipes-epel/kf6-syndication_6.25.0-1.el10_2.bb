# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syndication"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-syndication \
 kf6-syndication-devel \
 kf6-syndication-doc \
 kf6-syndication-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-syndication-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c12291fb35990463b98734b277d6748020bede383de03ad70bd7fcef4f9db1c6"

URI_x86_64_v2_kf6-syndication = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication}"
SRC_URI[x86_64_v2_kf6-syndication.sha256sum] = "6c27f76afac48749f4200e61820add0cde6d40b710a02fb169beea748597c498"

URI_x86_64_v2_kf6-syndication-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syndication-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication-devel}"
SRC_URI[x86_64_v2_kf6-syndication-devel.sha256sum] = "77c79dc5086b120b543190c99a0c534ad4b40da7339d3922745c8f827ac010ea"

URI_x86_64_v2_kf6-syndication-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syndication-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication-doc}"
SRC_URI[x86_64_v2_kf6-syndication-doc.sha256sum] = "21a45cc5aabec2b9d7dcc9c28ca296a675603ec523b23b8321f09d958a03ae7a"

URI_x86_64_v2_kf6-syndication-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syndication-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syndication-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syndication-html}"
SRC_URI[x86_64_v2_kf6-syndication-html.sha256sum] = "17ccbef16348f76651fa770cbcc07ca7d8aa2c67ab222be911cb1734653abf23"

URI_aarch64_kf6-syndication = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-syndication;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication}"
SRC_URI[aarch64_kf6-syndication.sha256sum] = "e7ae5ebdc3817c947ba407474ff2f971961891388eb716a84a6b7b99364d7a96"

URI_aarch64_kf6-syndication-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-syndication-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication-devel}"
SRC_URI[aarch64_kf6-syndication-devel.sha256sum] = "911ce4b4908df474626caa219dbe75a4680ffe582197fe16c3e8a4c837adaba4"

URI_aarch64_kf6-syndication-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-syndication-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication-doc}"
SRC_URI[aarch64_kf6-syndication-doc.sha256sum] = "11ba35978772b280e598211af8a54f011b005cbb0256f746cf3227e7e9928a3f"

URI_aarch64_kf6-syndication-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syndication-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-syndication-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syndication-html}"
SRC_URI[aarch64_kf6-syndication-html.sha256sum] = "0fd15202e78d01c56600236adb6f94f3102b6672b302c6748c0f85af94e040e7"

RDEPENDS:kf6-syndication = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-syndication-devel = " \
 cmake-filesystem \
 kf6-syndication \
 "
RDEPENDS:kf6-syndication-doc = " \
 "
RDEPENDS:kf6-syndication-html = " \
 "
