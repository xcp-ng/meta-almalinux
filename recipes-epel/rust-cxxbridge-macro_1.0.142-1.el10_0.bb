# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-macro"
PV = "1.0.142"
PR = "1.el10_0"
PACKAGES = " \
 rust-cxxbridge-macro+clang-ast-devel \
 rust-cxxbridge-macro+default-devel \
 rust-cxxbridge-macro+experimental-async-fn-devel \
 rust-cxxbridge-macro+flate2-devel \
 rust-cxxbridge-macro+serde-devel \
 rust-cxxbridge-macro+serde_derive-devel \
 rust-cxxbridge-macro+serde_json-devel \
 rust-cxxbridge-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-macro-1.0.142-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2df57ad983bceb4888ec2025decb7580301b556eee30a593b79dae8f5b9343f5"

URI_x86_64_v2_rust-cxxbridge-macro+clang-ast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+clang-ast-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+clang-ast-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+clang-ast-devel.sha256sum] = "dcbb979589bec5dfc7a6dfcddb5617f5882ade0e9282056a7264cc6d7f23fc57"

URI_x86_64_v2_rust-cxxbridge-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+default-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+default-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+default-devel.sha256sum] = "0f91941669a61c4a1de9948ae099460fc9807f3dc78974e48416ef8fb7ed4334"

URI_x86_64_v2_rust-cxxbridge-macro+experimental-async-fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+experimental-async-fn-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+experimental-async-fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+experimental-async-fn-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+experimental-async-fn-devel.sha256sum] = "ae98604cc7d2b2b8111ffac0a8854609b2ac491ed06769c2409dd84af3eec607"

URI_x86_64_v2_rust-cxxbridge-macro+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+flate2-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+flate2-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+flate2-devel.sha256sum] = "b3db64be4545b62d5b52e4fa1528298d220cb2dbb4ae6f90f92103363f55ae09"

URI_x86_64_v2_rust-cxxbridge-macro+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+serde-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+serde-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+serde-devel.sha256sum] = "57074925cb385b49e3a6d24984f24f925e62f5871e1df73ffccbc7ab10724085"

URI_x86_64_v2_rust-cxxbridge-macro+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+serde_derive-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+serde_derive-devel.sha256sum] = "289f497b5f37a6723f6a8b867c76a73670aa557a0ea34a95f7c7d6f700f2e891"

URI_x86_64_v2_rust-cxxbridge-macro+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+serde_json-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro+serde_json-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+serde_json-devel.sha256sum] = "b99a0fde012360e799a247aad055bb73e5775fb5673ec2a5f8f12daf2c6cb0a1"

URI_x86_64_v2_rust-cxxbridge-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxxbridge-macro-devel}"
SRC_URI[x86_64_v2_rust-cxxbridge-macro-devel.sha256sum] = "62b16cf934aed5a8c18cd4280820ae834685566d09e6b5e829818ffd452ecc7e"

URI_aarch64_rust-cxxbridge-macro+clang-ast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+clang-ast-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-macro+clang-ast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+clang-ast-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+clang-ast-devel.sha256sum] = "a37f2d0b4bbc14719e6aa10e783e39017db83f1ab17f03d47c6d6e485527b729"

URI_aarch64_rust-cxxbridge-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+default-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+default-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+default-devel.sha256sum] = "82432f13e36027517ee98b788ecc186d19f5c0aa2c30cb3ac0917f1f3b37b1db"

URI_aarch64_rust-cxxbridge-macro+experimental-async-fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+experimental-async-fn-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-macro+experimental-async-fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+experimental-async-fn-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+experimental-async-fn-devel.sha256sum] = "44a2ad197d79c2537724ff8491a71661994917a35aacecfd4fc02d5044030b67"

URI_aarch64_rust-cxxbridge-macro+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+flate2-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-macro+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+flate2-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+flate2-devel.sha256sum] = "e11b03860a38a9058c013dfcf3d45a33c6335399411a5144229abd58bc5e70fc"

URI_aarch64_rust-cxxbridge-macro+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+serde-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-macro+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+serde-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+serde-devel.sha256sum] = "f66405378a2e90f2b033d3cbff9678ae3084e351a57dd26c9d76495da9a8c60a"

URI_aarch64_rust-cxxbridge-macro+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+serde_derive-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-macro+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+serde_derive-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+serde_derive-devel.sha256sum] = "c4f7332ffd530b6b7ccf3c75a88fed4553d22b63fe9b8f320144c97366156411"

URI_aarch64_rust-cxxbridge-macro+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+serde_json-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-macro+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro+serde_json-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro+serde_json-devel.sha256sum] = "f85b82d17fb6aef86042d487849612d2cdec6893e79579917a4509881573e2b1"

URI_aarch64_rust-cxxbridge-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxxbridge-macro-devel}"
SRC_URI[aarch64_rust-cxxbridge-macro-devel.sha256sum] = "8c087fc696ee5928f9874a6504c4e1787093712ee490697032726f988ab7a6e7"

RDEPENDS:rust-cxxbridge-macro+clang-ast-devel = " \
 cargo \
 rust-clang-ast+default-devel \
 rust-cxxbridge-macro-devel \
 "
RDEPENDS:rust-cxxbridge-macro+default-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 "
RDEPENDS:rust-cxxbridge-macro+experimental-async-fn-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 "
RDEPENDS:rust-cxxbridge-macro+flate2-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 rust-flate2+default-devel \
 "
RDEPENDS:rust-cxxbridge-macro+serde-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-cxxbridge-macro+serde_derive-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-cxxbridge-macro+serde_json-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-cxxbridge-macro-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rustversion+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
