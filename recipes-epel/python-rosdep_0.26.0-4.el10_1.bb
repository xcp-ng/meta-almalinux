# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rosdep"
PV = "0.26.0"
PR = "4.el10_1"
PACKAGES = " \
 python-rosdep-doc \
 python3-rosdep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rosdep-0.26.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6cd48411e305860bb93dedf4b2842d95886919b303f699582328379bd6a44a9"

URI_x86_64_v2_python-rosdep-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-rosdep-doc-0.26.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-rosdep-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-rosdep-doc}"
SRC_URI[x86_64_v2_python-rosdep-doc.sha256sum] = "54cd15c33780238be5a88cac9d9269c7fc2f7fa27ba5b54fd98d80a7d16b7f1e"

URI_x86_64_v2_python3-rosdep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rosdep-0.26.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rosdep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rosdep}"
SRC_URI[x86_64_v2_python3-rosdep.sha256sum] = "3745fe9090f0f4078fc7c54dd4e22c0ba1adad24ee3ce3f160bde3253c3c566f"

URI_aarch64_python-rosdep-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-rosdep-doc-0.26.0-4.el10_1.noarch.rpm;name=aarch64_python-rosdep-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-rosdep-doc}"
SRC_URI[aarch64_python-rosdep-doc.sha256sum] = "b00e54901c5eb4b4bb421570ace6ff0065fa9bbb57634785048e0704282ade25"

URI_aarch64_python3-rosdep = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rosdep-0.26.0-4.el10_1.noarch.rpm;name=aarch64_python3-rosdep;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rosdep}"
SRC_URI[aarch64_python3-rosdep.sha256sum] = "143534665fb6b695be28d9aaf465e222978df03278e2dc970d26cbbf2fa01bd8"

RDEPENDS:python-rosdep-doc = " \
 "
RDEPENDS:python3-rosdep = " \
 python-srpm-macros \
 python3 \
 python3-catkin_pkg \
 python3-pyyaml \
 python3-rosdistro \
 python3-rospkg \
 "
