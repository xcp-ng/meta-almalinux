# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Glib-Object-Introspection"
PV = "0.052"
PR = "1.el10_1"
PACKAGES = " \
 perl-Glib-Object-Introspection \
 perl-Glib-Object-Introspection-tests \
 perli11ndoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Glib-Object-Introspection-0.052-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b944077212658ff41762daa4cebd64d34cb90b50fb65031e9cfcea54020db45"

URI_x86_64_v2_perl-Glib-Object-Introspection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Glib-Object-Introspection-0.052-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Glib-Object-Introspection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Glib-Object-Introspection}"
SRC_URI[x86_64_v2_perl-Glib-Object-Introspection.sha256sum] = "f8da7978f28167b9967421987e6cb6dc19c9cc66cd1984d88a4cb0b053da6110"

URI_x86_64_v2_perl-Glib-Object-Introspection-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Glib-Object-Introspection-tests-0.052-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Glib-Object-Introspection-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Glib-Object-Introspection-tests}"
SRC_URI[x86_64_v2_perl-Glib-Object-Introspection-tests.sha256sum] = "4cc702beff90e0ec58334a80baa4aaef14ac4a5bcc5525fc353ae0d2ecb32f55"

URI_x86_64_v2_perli11ndoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perli11ndoc-0.052-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perli11ndoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perli11ndoc}"
SRC_URI[x86_64_v2_perli11ndoc.sha256sum] = "36e89a195739cbe11eefb3b5d1bd4016a10e739dbc91d295eb80ad2c0b93124b"

URI_aarch64_perl-Glib-Object-Introspection = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Glib-Object-Introspection-0.052-1.el10_1.aarch64.rpm;name=aarch64_perl-Glib-Object-Introspection;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Glib-Object-Introspection}"
SRC_URI[aarch64_perl-Glib-Object-Introspection.sha256sum] = "2956ed4a7d3c35d324165781c12d8a20390df83895dc2b6e23a3216eee222d1c"

URI_aarch64_perl-Glib-Object-Introspection-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Glib-Object-Introspection-tests-0.052-1.el10_1.aarch64.rpm;name=aarch64_perl-Glib-Object-Introspection-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Glib-Object-Introspection-tests}"
SRC_URI[aarch64_perl-Glib-Object-Introspection-tests.sha256sum] = "dba634b54832daa897c04bdad66dc2b0648b23544d3493f0c970ed9a7443a561"

URI_aarch64_perli11ndoc = "${EPEL_MIRROR}/aarch64/Packages/p/perli11ndoc-0.052-1.el10_1.noarch.rpm;name=aarch64_perli11ndoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_perli11ndoc}"
SRC_URI[aarch64_perli11ndoc.sha256sum] = "1ac2b4da9c42e275135588bf18273a46f7432c9efeaa655dd97d9f06c9b64ea9"

RDEPENDS:perl-Glib-Object-Introspection = " \
 glib2 \
 glibc \
 gobject-introspection \
 libffi \
 perl-Carp \
 perl-Glib \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Glib-Object-Introspection-tests = " \
 bash \
 cairo \
 cairo-gobject \
 glib2 \
 glibc \
 perl-Glib \
 perl-Glib-Object-Introspection \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perli11ndoc = " \
 perl-File-Basename \
 perl-File-Find \
 perl-Glib-Object-Introspection \
 perl-PathTools \
 perl-Text-Tabs+Wrap \
 perl-XML-LibXML \
 perl-interpreter \
 perl-libs \
 perl-open \
 "
