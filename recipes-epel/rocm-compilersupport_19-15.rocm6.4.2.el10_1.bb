# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-compilersupport"
PV = "19"
PR = "15.rocm6.4.2.el10_1"
PACKAGES:x86_64_v2 = " \
 hipcc \
 hipcc-libomp-devel \
 rocm-clang \
 rocm-clang-devel \
 rocm-clang-libs \
 rocm-clang-runtime-devel \
 rocm-clang-tools-extra \
 rocm-clang-tools-extra-devel \
 rocm-comgr \
 rocm-comgr-devel \
 rocm-compilersupport-macros \
 rocm-device-libs \
 rocm-libc++ \
 rocm-libc++-devel \
 rocm-libc++-static \
 rocm-lld \
 rocm-llvm \
 rocm-llvm-devel \
 rocm-llvm-filesystem \
 rocm-llvm-libs \
 rocm-llvm-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-compilersupport-19-15.rocm6.4.2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38cc779212b751383d5bf5000e2779fd7bb025470336487238bd5cef3e2c3d65"

URI_x86_64_v2_hipcc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipcc-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipcc}"
SRC_URI[x86_64_v2_hipcc.sha256sum] = "e641809d5249bc7ef5e2802c6f10f83ae2672cf48db619b40051d597263e71ea"

URI_x86_64_v2_hipcc-libomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipcc-libomp-devel-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipcc-libomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipcc-libomp-devel}"
SRC_URI[x86_64_v2_hipcc-libomp-devel.sha256sum] = "261201c8907261887186d2637b4ffaa3b78e0851e5b64632745538031208c7de"

URI_x86_64_v2_rocm-clang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang}"
SRC_URI[x86_64_v2_rocm-clang.sha256sum] = "3d285c33e4df5cabf3fb6f0cdaf95acc9395ccb76072013eba3fee7287f810ba"

URI_x86_64_v2_rocm-clang-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-devel-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-devel}"
SRC_URI[x86_64_v2_rocm-clang-devel.sha256sum] = "b850293b9b09aa23de36128a802bff36b15a1955a2f7c0c14b10723899ac4052"

URI_x86_64_v2_rocm-clang-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-libs-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-libs}"
SRC_URI[x86_64_v2_rocm-clang-libs.sha256sum] = "f11e6d32a07f0b0698d603bc3efe77fc3877bf88c3ec7adbee284d6c47f6eb0d"

URI_x86_64_v2_rocm-clang-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-runtime-devel-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-runtime-devel}"
SRC_URI[x86_64_v2_rocm-clang-runtime-devel.sha256sum] = "19838e3f2327369280843a3ffb35f8801d45a2e8e8a788e0f95f311f24921261"

URI_x86_64_v2_rocm-clang-tools-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-tools-extra-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-tools-extra}"
SRC_URI[x86_64_v2_rocm-clang-tools-extra.sha256sum] = "7c4b6e1f195d0159874f7c7821e64c830584c9433bc3001d114abe4211b8b776"

URI_x86_64_v2_rocm-clang-tools-extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-clang-tools-extra-devel-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-clang-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-clang-tools-extra-devel}"
SRC_URI[x86_64_v2_rocm-clang-tools-extra-devel.sha256sum] = "ed24f2edd502d90a7627e3dbbb2b7d28b1698da77cabf6d2169d8505556329ac"

URI_x86_64_v2_rocm-comgr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-comgr-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-comgr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-comgr}"
SRC_URI[x86_64_v2_rocm-comgr.sha256sum] = "503fa302376b1a0760faa38a32f5939a317c7eee928e7f8517c4fa669b2a69c3"

URI_x86_64_v2_rocm-comgr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-comgr-devel-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-comgr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-comgr-devel}"
SRC_URI[x86_64_v2_rocm-comgr-devel.sha256sum] = "0133b2a5aa69e2493751ed9805a9eda9d24187e08eb5300ae3278bef421fa56d"

URI_x86_64_v2_rocm-compilersupport-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-compilersupport-macros-19-15.rocm6.4.2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-compilersupport-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-compilersupport-macros}"
SRC_URI[x86_64_v2_rocm-compilersupport-macros.sha256sum] = "1447413652cfd2a142e5cc70f838919d1a0cc66551eea430a58cd19b777d51ee"

URI_x86_64_v2_rocm-device-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-device-libs-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-device-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-device-libs}"
SRC_URI[x86_64_v2_rocm-device-libs.sha256sum] = "41c44921f0f88080b05b1718d8ac87b70f6c3621fe0635bff3a23fca104f2a67"

URI_x86_64_v2_rocm-libc++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-libc++-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-libc++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-libc++}"
SRC_URI[x86_64_v2_rocm-libc++.sha256sum] = "248b8f3235982e31a539181142da23889364fa1ca8193cb2d282bc7a48b63337"

URI_x86_64_v2_rocm-libc++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-libc++-devel-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-libc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-libc++-devel}"
SRC_URI[x86_64_v2_rocm-libc++-devel.sha256sum] = "6f0b297dd54826cbfa244e9d62c1c4176a5d97efcff6f5ebd295052ba6874a61"

URI_x86_64_v2_rocm-libc++-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-libc++-static-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-libc++-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-libc++-static}"
SRC_URI[x86_64_v2_rocm-libc++-static.sha256sum] = "9873a5701d587f110dd11adfa8c74afce2eb6f0d175009c28e273a02a4a8840d"

URI_x86_64_v2_rocm-lld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-lld-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-lld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-lld}"
SRC_URI[x86_64_v2_rocm-lld.sha256sum] = "6b565de7f5289247b059afd5b939dc9136a68bd80a3ae2bd987030b971c1a2ef"

URI_x86_64_v2_rocm-llvm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm}"
SRC_URI[x86_64_v2_rocm-llvm.sha256sum] = "2b57e056b36221f124f5258828792485637a2ae1cd9ab8025327ed9ec8fcb9d9"

URI_x86_64_v2_rocm-llvm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-devel-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-devel}"
SRC_URI[x86_64_v2_rocm-llvm-devel.sha256sum] = "cd5b4303faea3846c2163d7da1568b779f25c9ca7226f029ba71edea3ce555e6"

URI_x86_64_v2_rocm-llvm-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-filesystem-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-filesystem}"
SRC_URI[x86_64_v2_rocm-llvm-filesystem.sha256sum] = "a4b90758d79a6f21056de4284af090ecc4af57d541c9ae43e42472582d26b8ff"

URI_x86_64_v2_rocm-llvm-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-libs-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-libs}"
SRC_URI[x86_64_v2_rocm-llvm-libs.sha256sum] = "8ec7c6428ecd4e175d03c21c5cdc22f76af8afd8dbf3df62967f5673c0e58e61"

URI_x86_64_v2_rocm-llvm-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-llvm-static-19-15.rocm6.4.2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-llvm-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-llvm-static}"
SRC_URI[x86_64_v2_rocm-llvm-static.sha256sum] = "aa20ec1c08651feaa86ced01accbe94bf132dd358310501bf48c0da1190a7c15"

RDEPENDS:hipcc = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-base \
 rocm-device-libs \
 "
RDEPENDS:hipcc-libomp-devel = " \
 hipcc \
 libomp-devel \
 "
RDEPENDS:rocm-clang = " \
 git \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 rocm-clang-libs \
 rocm-clang-runtime-devel \
 rocm-libc++-devel \
 rocm-llvm-libs \
 "
RDEPENDS:rocm-clang-devel = " \
 rocm-clang \
 rocm-clang-libs \
 "
RDEPENDS:rocm-clang-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-llvm-libs \
 "
RDEPENDS:rocm-clang-runtime-devel = " \
 "
RDEPENDS:rocm-clang-tools-extra = " \
 python3 \
 rocm-clang-libs \
 "
RDEPENDS:rocm-clang-tools-extra-devel = " \
 rocm-clang-tools-extra \
 "
RDEPENDS:rocm-comgr = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:rocm-comgr-devel = " \
 cmake-filesystem \
 rocm-comgr \
 rocm-device-libs \
 "
RDEPENDS:rocm-compilersupport-macros = " \
 "
RDEPENDS:rocm-device-libs = " \
 cmake-filesystem \
 rocm-clang-devel \
 rocm-lld \
 rocm-llvm-static \
 "
RDEPENDS:rocm-libc++ = " \
 glibc \
 libgcc \
 rocm-llvm-filesystem \
 "
RDEPENDS:rocm-libc++-devel = " \
 rocm-libc++ \
 "
RDEPENDS:rocm-libc++-static = " \
 rocm-libc++-devel \
 "
RDEPENDS:rocm-lld = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 rocm-llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:rocm-llvm = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 python3 \
 rocm-llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:rocm-llvm-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-llvm \
 rocm-llvm-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:rocm-llvm-filesystem = " \
 "
RDEPENDS:rocm-llvm-libs = " \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 libzstd \
 rocm-libc++ \
 rocm-llvm-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:rocm-llvm-static = " \
 rocm-llvm-devel \
 "
