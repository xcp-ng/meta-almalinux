# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ant"
PV = "1.10.15"
PR = "1.el10"
PACKAGES = " \
 ant \
 ant-antlr \
 ant-apache-bcel \
 ant-apache-bsf \
 ant-apache-oro \
 ant-apache-regexp \
 ant-apache-resolver \
 ant-apache-xalan2 \
 ant-commons-logging \
 ant-commons-net \
 ant-imageio \
 ant-jakartamail \
 ant-javadoc \
 ant-jdepend \
 ant-jmf \
 ant-jsch \
 ant-junit \
 ant-junit5 \
 ant-lib \
 ant-manual \
 ant-openjdk21 \
 ant-swing \
 ant-testutil \
 ant-unbound \
 ant-xz \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ant-1.10.15-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2237c77279aead8b0af6e84357463668013aab248489bc0f5fdcd72e5ee9ff2"

URI_x86_64_v2_ant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant}"
SRC_URI[x86_64_v2_ant.sha256sum] = "6ed82f177576605468ab0bb7cb2d6dcd8db41fc93a272b448169f781b91bfa6d"

URI_x86_64_v2_ant-antlr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-antlr-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-antlr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-antlr}"
SRC_URI[x86_64_v2_ant-antlr.sha256sum] = "de1d9c2dbcc8228ba7cce95d337366ac79de90f8e9f981a0a8a88565e1b42c92"

URI_x86_64_v2_ant-apache-bcel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-apache-bcel-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-apache-bcel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-apache-bcel}"
SRC_URI[x86_64_v2_ant-apache-bcel.sha256sum] = "7064408add04128a7a45ac48f41e89ee93a6be13ba47472875c0e7aa6d2ffa8c"

URI_x86_64_v2_ant-apache-bsf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-apache-bsf-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-apache-bsf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-apache-bsf}"
SRC_URI[x86_64_v2_ant-apache-bsf.sha256sum] = "6e516e6b90274ebb0c6dcaf7707912b5780a38d63e009a9f7581368a4f97a450"

URI_x86_64_v2_ant-apache-oro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-apache-oro-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-apache-oro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-apache-oro}"
SRC_URI[x86_64_v2_ant-apache-oro.sha256sum] = "bc8d48099e5ef6082ac128f23ba32a8c29d3d01b3df8451246938ccf7c497ca7"

URI_x86_64_v2_ant-apache-regexp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-apache-regexp-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-apache-regexp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-apache-regexp}"
SRC_URI[x86_64_v2_ant-apache-regexp.sha256sum] = "eddbea9cc3921781487d01b5e5d2f457348665ab7bd0dae5b83beeb7eb1e271b"

URI_x86_64_v2_ant-apache-resolver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-apache-resolver-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-apache-resolver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-apache-resolver}"
SRC_URI[x86_64_v2_ant-apache-resolver.sha256sum] = "6100aa69c470912557cda99d04b31e3b9a32084910d303534919daf0c148345b"

URI_x86_64_v2_ant-apache-xalan2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-apache-xalan2-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-apache-xalan2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-apache-xalan2}"
SRC_URI[x86_64_v2_ant-apache-xalan2.sha256sum] = "7d77a937f1de8ff13b3e07c58d597ca9a73d7de00a59a96260d4624769706d6b"

URI_x86_64_v2_ant-commons-logging = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-commons-logging-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-commons-logging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-commons-logging}"
SRC_URI[x86_64_v2_ant-commons-logging.sha256sum] = "6a1915d0524e42f7f6284d77fb69a99d10fd245ab9d2060fa3e06e545393c55e"

URI_x86_64_v2_ant-commons-net = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-commons-net-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-commons-net;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-commons-net}"
SRC_URI[x86_64_v2_ant-commons-net.sha256sum] = "e9a2466f9f292342c04c0f4e4df2e27c8a51f094185dc93072cdf2d956d1ec78"

URI_x86_64_v2_ant-imageio = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ant-imageio-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-imageio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-imageio}"
SRC_URI[x86_64_v2_ant-imageio.sha256sum] = "4e5f71f8c879a2e3824f5b0f6bf261e7fb95579946597cbd33b416713dfcc1e3"

URI_x86_64_v2_ant-jakartamail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-jakartamail-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-jakartamail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-jakartamail}"
SRC_URI[x86_64_v2_ant-jakartamail.sha256sum] = "aeb7952467ec601b56459046b67e5ad8f3f220bccdeb9628286d125ebc804ba1"

URI_x86_64_v2_ant-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ant-javadoc-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-javadoc}"
SRC_URI[x86_64_v2_ant-javadoc.sha256sum] = "e4f0ea43448ab4e496d0f038b61ec55cfff8aba52d587b72fd118a749f19e23a"

URI_x86_64_v2_ant-jdepend = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-jdepend-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-jdepend;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-jdepend}"
SRC_URI[x86_64_v2_ant-jdepend.sha256sum] = "b11fd7fdb1af1a3e3f09f9b07412bfae89b29fc18effd72c8e94ebf258f6cfbe"

URI_x86_64_v2_ant-jmf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-jmf-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-jmf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-jmf}"
SRC_URI[x86_64_v2_ant-jmf.sha256sum] = "a3359195c9edf7639e1abce9df2cef1cc45301a3307400186290f3a0487c7b24"

URI_x86_64_v2_ant-jsch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-jsch-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-jsch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-jsch}"
SRC_URI[x86_64_v2_ant-jsch.sha256sum] = "d6407c7ca2000292c27eac7f12c2681b8b822616d3e2669ad093ab69bd0dcc32"

URI_x86_64_v2_ant-junit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-junit-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-junit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-junit}"
SRC_URI[x86_64_v2_ant-junit.sha256sum] = "c33b571af5834a05f6faa05d22f3ac68319a1107ff9bced7142902356547573a"

URI_x86_64_v2_ant-junit5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-junit5-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-junit5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-junit5}"
SRC_URI[x86_64_v2_ant-junit5.sha256sum] = "b0f013a56757d73e7e2af05f24c3f76db3b5d2cde499bb15a586b351109e25b9"

URI_x86_64_v2_ant-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-lib-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-lib}"
SRC_URI[x86_64_v2_ant-lib.sha256sum] = "109b3aaaf7bf0dd198e7476f1ea9b13d0b1d82e029b03029eaf0b37a17e3714a"

URI_x86_64_v2_ant-manual = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ant-manual-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-manual}"
SRC_URI[x86_64_v2_ant-manual.sha256sum] = "51d4bfa98f52726d315ecc57d9aaca528af207f4d949f775510da1e7e238cddc"

URI_x86_64_v2_ant-openjdk21 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ant-openjdk21-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-openjdk21;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-openjdk21}"
SRC_URI[x86_64_v2_ant-openjdk21.sha256sum] = "00551f332862d854c7773f56cda47ec453d8fa615ae4ecd71ce9895533caa750"
RPROVIDES:ant-openjdk21:append:x86_64_v2 = " virtual/ant-jdk-binding"

URI_x86_64_v2_ant-swing = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-swing-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-swing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-swing}"
SRC_URI[x86_64_v2_ant-swing.sha256sum] = "d3fa20198bba13c68807dc487a89e5fcfbe222996730efed076abb3c3c42bf15"

URI_x86_64_v2_ant-testutil = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-testutil-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-testutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-testutil}"
SRC_URI[x86_64_v2_ant-testutil.sha256sum] = "ad15ff6bb4e9bc83b82d41f862c2785c30061ba9cba3f24a55f0221e310a9b9b"

URI_x86_64_v2_ant-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-unbound-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-unbound}"
SRC_URI[x86_64_v2_ant-unbound.sha256sum] = "b0432d7c68e4d65606a5bb4377a31889d748051f9560e369aae1240971ccf9a9"
RPROVIDES:ant-unbound:append:x86_64_v2 = " virtual/ant-jdk-binding"

URI_x86_64_v2_ant-xz = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ant-xz-1.10.15-1.el10.noarch.rpm;name=x86_64_v2_ant-xz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ant-xz}"
SRC_URI[x86_64_v2_ant-xz.sha256sum] = "5bc5258bc4f5ac4debed6abc063728a8c3f1a42e51fa74227cb3ff3cb3e09b09"

URI_aarch64_ant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-1.10.15-1.el10.noarch.rpm;name=aarch64_ant;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant}"
SRC_URI[aarch64_ant.sha256sum] = "6ed82f177576605468ab0bb7cb2d6dcd8db41fc93a272b448169f781b91bfa6d"

URI_aarch64_ant-antlr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-antlr-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-antlr;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-antlr}"
SRC_URI[aarch64_ant-antlr.sha256sum] = "de1d9c2dbcc8228ba7cce95d337366ac79de90f8e9f981a0a8a88565e1b42c92"

URI_aarch64_ant-apache-bcel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-apache-bcel-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-apache-bcel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-apache-bcel}"
SRC_URI[aarch64_ant-apache-bcel.sha256sum] = "7064408add04128a7a45ac48f41e89ee93a6be13ba47472875c0e7aa6d2ffa8c"

URI_aarch64_ant-apache-bsf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-apache-bsf-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-apache-bsf;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-apache-bsf}"
SRC_URI[aarch64_ant-apache-bsf.sha256sum] = "6e516e6b90274ebb0c6dcaf7707912b5780a38d63e009a9f7581368a4f97a450"

URI_aarch64_ant-apache-oro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-apache-oro-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-apache-oro;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-apache-oro}"
SRC_URI[aarch64_ant-apache-oro.sha256sum] = "bc8d48099e5ef6082ac128f23ba32a8c29d3d01b3df8451246938ccf7c497ca7"

URI_aarch64_ant-apache-regexp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-apache-regexp-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-apache-regexp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-apache-regexp}"
SRC_URI[aarch64_ant-apache-regexp.sha256sum] = "eddbea9cc3921781487d01b5e5d2f457348665ab7bd0dae5b83beeb7eb1e271b"

URI_aarch64_ant-apache-resolver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-apache-resolver-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-apache-resolver;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-apache-resolver}"
SRC_URI[aarch64_ant-apache-resolver.sha256sum] = "6100aa69c470912557cda99d04b31e3b9a32084910d303534919daf0c148345b"

URI_aarch64_ant-apache-xalan2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-apache-xalan2-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-apache-xalan2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-apache-xalan2}"
SRC_URI[aarch64_ant-apache-xalan2.sha256sum] = "7d77a937f1de8ff13b3e07c58d597ca9a73d7de00a59a96260d4624769706d6b"

URI_aarch64_ant-commons-logging = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-commons-logging-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-commons-logging;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-commons-logging}"
SRC_URI[aarch64_ant-commons-logging.sha256sum] = "6a1915d0524e42f7f6284d77fb69a99d10fd245ab9d2060fa3e06e545393c55e"

URI_aarch64_ant-commons-net = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-commons-net-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-commons-net;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-commons-net}"
SRC_URI[aarch64_ant-commons-net.sha256sum] = "e9a2466f9f292342c04c0f4e4df2e27c8a51f094185dc93072cdf2d956d1ec78"

URI_aarch64_ant-imageio = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ant-imageio-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-imageio;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-imageio}"
SRC_URI[aarch64_ant-imageio.sha256sum] = "4e5f71f8c879a2e3824f5b0f6bf261e7fb95579946597cbd33b416713dfcc1e3"

URI_aarch64_ant-jakartamail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-jakartamail-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-jakartamail;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-jakartamail}"
SRC_URI[aarch64_ant-jakartamail.sha256sum] = "aeb7952467ec601b56459046b67e5ad8f3f220bccdeb9628286d125ebc804ba1"

URI_aarch64_ant-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ant-javadoc-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-javadoc}"
SRC_URI[aarch64_ant-javadoc.sha256sum] = "e4f0ea43448ab4e496d0f038b61ec55cfff8aba52d587b72fd118a749f19e23a"

URI_aarch64_ant-jdepend = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-jdepend-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-jdepend;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-jdepend}"
SRC_URI[aarch64_ant-jdepend.sha256sum] = "b11fd7fdb1af1a3e3f09f9b07412bfae89b29fc18effd72c8e94ebf258f6cfbe"

URI_aarch64_ant-jmf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-jmf-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-jmf;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-jmf}"
SRC_URI[aarch64_ant-jmf.sha256sum] = "a3359195c9edf7639e1abce9df2cef1cc45301a3307400186290f3a0487c7b24"

URI_aarch64_ant-jsch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-jsch-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-jsch;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-jsch}"
SRC_URI[aarch64_ant-jsch.sha256sum] = "d6407c7ca2000292c27eac7f12c2681b8b822616d3e2669ad093ab69bd0dcc32"

URI_aarch64_ant-junit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-junit-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-junit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-junit}"
SRC_URI[aarch64_ant-junit.sha256sum] = "c33b571af5834a05f6faa05d22f3ac68319a1107ff9bced7142902356547573a"

URI_aarch64_ant-junit5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-junit5-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-junit5;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-junit5}"
SRC_URI[aarch64_ant-junit5.sha256sum] = "b0f013a56757d73e7e2af05f24c3f76db3b5d2cde499bb15a586b351109e25b9"

URI_aarch64_ant-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-lib-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-lib}"
SRC_URI[aarch64_ant-lib.sha256sum] = "109b3aaaf7bf0dd198e7476f1ea9b13d0b1d82e029b03029eaf0b37a17e3714a"

URI_aarch64_ant-manual = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ant-manual-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-manual}"
SRC_URI[aarch64_ant-manual.sha256sum] = "51d4bfa98f52726d315ecc57d9aaca528af207f4d949f775510da1e7e238cddc"

URI_aarch64_ant-openjdk21 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ant-openjdk21-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-openjdk21;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-openjdk21}"
SRC_URI[aarch64_ant-openjdk21.sha256sum] = "00551f332862d854c7773f56cda47ec453d8fa615ae4ecd71ce9895533caa750"
RPROVIDES:ant-openjdk21:append:aarch64 = " virtual/ant-jdk-binding"

URI_aarch64_ant-swing = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-swing-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-swing;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-swing}"
SRC_URI[aarch64_ant-swing.sha256sum] = "d3fa20198bba13c68807dc487a89e5fcfbe222996730efed076abb3c3c42bf15"

URI_aarch64_ant-testutil = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-testutil-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-testutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-testutil}"
SRC_URI[aarch64_ant-testutil.sha256sum] = "ad15ff6bb4e9bc83b82d41f862c2785c30061ba9cba3f24a55f0221e310a9b9b"

URI_aarch64_ant-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-unbound-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-unbound}"
SRC_URI[aarch64_ant-unbound.sha256sum] = "b0432d7c68e4d65606a5bb4377a31889d748051f9560e369aae1240971ccf9a9"
RPROVIDES:ant-unbound:append:aarch64 = " virtual/ant-jdk-binding"

URI_aarch64_ant-xz = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ant-xz-1.10.15-1.el10.noarch.rpm;name=aarch64_ant-xz;unpack=0"
SRC_URI:append = " ${URI_aarch64_ant-xz}"
SRC_URI[aarch64_ant-xz.sha256sum] = "5bc5258bc4f5ac4debed6abc063728a8c3f1a42e51fa74227cb3ff3cb3e09b09"

RDEPENDS:ant = " \
 ant-lib \
 virtual/ant-jdk-binding \
 "
RDEPENDS:ant-antlr = " \
 ant \
 ant-lib \
 antlr-tool \
 javapackages-filesystem \
 "
RDEPENDS:ant-apache-bcel = " \
 ant \
 ant-lib \
 bcel \
 javapackages-filesystem \
 "
RDEPENDS:ant-apache-bsf = " \
 ant \
 ant-lib \
 bsf \
 javapackages-filesystem \
 "
RDEPENDS:ant-apache-oro = " \
 ant \
 ant-lib \
 jakarta-oro \
 javapackages-filesystem \
 "
RDEPENDS:ant-apache-regexp = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 regexp \
 "
RDEPENDS:ant-apache-resolver = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 xml-commons-resolver \
 "
RDEPENDS:ant-apache-xalan2 = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 xalan-j2 \
 "
RDEPENDS:ant-commons-logging = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 "
RDEPENDS:ant-commons-net = " \
 ant \
 ant-lib \
 apache-commons-net \
 javapackages-filesystem \
 "
RDEPENDS:ant-imageio = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 "
RDEPENDS:ant-jakartamail = " \
 ant \
 ant-lib \
 jakarta-mail \
 javapackages-filesystem \
 "
RDEPENDS:ant-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:ant-jdepend = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 jdepend \
 "
RDEPENDS:ant-jmf = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 "
RDEPENDS:ant-jsch = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 jsch \
 "
RDEPENDS:ant-junit = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 junit \
 "
RDEPENDS:ant-junit5 = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 junit5 \
 "
RDEPENDS:ant-lib = " \
 javapackages-filesystem \
 "
RDEPENDS:ant-manual = " \
 "
RDEPENDS:ant-openjdk21 = " \
 ant \
 java-21-openjdk-headless \
 javapackages-tools \
 "
RDEPENDS:ant-swing = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 "
RDEPENDS:ant-testutil = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 junit \
 "
RDEPENDS:ant-unbound = " \
 ant \
 javapackages-tools \
 "
RDEPENDS:ant-xz = " \
 ant \
 ant-lib \
 javapackages-filesystem \
 xz-java \
 "
