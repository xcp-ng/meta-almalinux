# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet10.0"
PV = "10.0.106"
PR = "1.el10_1"
PACKAGES = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-runtime-dbg-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-host \
 dotnet-hostfxr-10.0 \
 dotnet-runtime-10.0 \
 dotnet-runtime-dbg-10.0 \
 dotnet-sdk-10.0 \
 dotnet-sdk-10.0-source-built-artifacts \
 dotnet-sdk-aot-10.0 \
 dotnet-sdk-dbg-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet10.0-10.0.106-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e5de31fdf3aa377fdb5fc0f4dd0430fad7e11e2edc8c041035b638c2d2a9077"

URI_x86_64_v2_aspnetcore-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-10.0-10.0.6-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-10.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-10.0.sha256sum] = "281f331fc97d17a5dcc18f7012ced16edef8c458e0aa0def074e1b5ccb16363b"

URI_x86_64_v2_aspnetcore-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.6-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-10.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-10.0.sha256sum] = "0ddcc3180f96b15a1a4da4e91a0d95d6d7d6dc63bb16d63b0b0bbc9d9ce6bfec"

URI_x86_64_v2_aspnetcore-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-10.0-10.0.6-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-10.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-10.0.sha256sum] = "31b35fefcdb98f58d097e37c59fd8dec517c1a7e9f64e659e2d13dce70fa6587"

URI_x86_64_v2_dotnet-apphost-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-10.0-10.0.6-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-10.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-10.0.sha256sum] = "ec3376b43a03c1434d6d85e3abe3ea314ed2fc1f618d21fbea81916857746d78"

URI_x86_64_v2_dotnet-host = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-host-10.0.6-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-host;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-host}"
SRC_URI[x86_64_v2_dotnet-host.sha256sum] = "c85ed5f8448de777da7096f08069565844d6606fa00783bb4fd437ebef06c008"

URI_x86_64_v2_dotnet-hostfxr-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-10.0-10.0.6-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-10.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-10.0.sha256sum] = "932c282ebca08886643fc9f5420d0b48750fb1ad2152f5c7e0bbbe13399a0533"

URI_x86_64_v2_dotnet-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-10.0-10.0.6-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-10.0}"
SRC_URI[x86_64_v2_dotnet-runtime-10.0.sha256sum] = "5ee5f65e67d2220a1ddff632822ba7bd70583ddbef26aa0c296bc3197f641dbf"

URI_x86_64_v2_dotnet-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-10.0-10.0.6-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-10.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-10.0.sha256sum] = "2fb4dacb20c3f2aa47a3c6f236338549de551f101da1f0fec3810842176af593"

URI_x86_64_v2_dotnet-sdk-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-10.0-10.0.106-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-10.0}"
SRC_URI[x86_64_v2_dotnet-sdk-10.0.sha256sum] = "40fc554d601c6b07e459007ae8c8566768ceeea14b915e2c469250a51f20174a"

URI_x86_64_v2_dotnet-sdk-10.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.106-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-10.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "b93e901a3963909e55956b0f31e41ee7f11e21b26aa7f9dfca8fbd0003088c80"

URI_x86_64_v2_dotnet-sdk-aot-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-10.0-10.0.106-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-aot-10.0}"
SRC_URI[x86_64_v2_dotnet-sdk-aot-10.0.sha256sum] = "09a0c0b261578f217e6cde6468062fefd3e84ad3157eb8b29f1148e68e499abc"

URI_x86_64_v2_dotnet-sdk-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-10.0-10.0.106-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-10.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-10.0.sha256sum] = "cca994f3e361e1da636bbbc471ab533ded1bfcb843874a1fcbb50f6a51584bdd"

URI_x86_64_v2_dotnet-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-10.0-10.0.6-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-10.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-10.0.sha256sum] = "763cf85e324fdd5ee79dbbc4569dd3a66756e390b5002a2ea6a51cb69859758d"

URI_x86_64_v2_dotnet-templates-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-10.0-10.0.106-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-10.0}"
SRC_URI[x86_64_v2_dotnet-templates-10.0.sha256sum] = "a65cc2c9607b54550826a179c17fe29a7d3a2192d3c7cb3557f216ba2211495a"

URI_aarch64_aspnetcore-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-10.0-10.0.6-1.el10_1.aarch64.rpm;name=aarch64_aspnetcore-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-10.0}"
SRC_URI[aarch64_aspnetcore-runtime-10.0.sha256sum] = "ace4f694e452b83f30fead1843f1e58a751373fc10cf0223d0ed183b744844e3"

URI_aarch64_aspnetcore-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.6-1.el10_1.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-10.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-10.0.sha256sum] = "2bb244bd8e60cd08a8c2b5d43c31ee37a2cbd7bc5d50c43304316691bb1ff9db"

URI_aarch64_aspnetcore-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-10.0-10.0.6-1.el10_1.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-10.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-10.0.sha256sum] = "ed3dd1ebf2d06f0faf1c3eedba0601b413f0fd2d4b1d5d25b039c492f9b89417"

URI_aarch64_dotnet-apphost-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-10.0-10.0.6-1.el10_1.aarch64.rpm;name=aarch64_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-10.0}"
SRC_URI[aarch64_dotnet-apphost-pack-10.0.sha256sum] = "841302b671d62de8a967a0c7a240cfa9173d25fd03f34a7f82925bfd1192d32a"

URI_aarch64_dotnet-host = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-host-10.0.6-1.el10_1.aarch64.rpm;name=aarch64_dotnet-host;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-host}"
SRC_URI[aarch64_dotnet-host.sha256sum] = "7c29c6d770f9fec1f038fb68d69c847bdf9248c3ac714ab791c47fd52feb7c32"

URI_aarch64_dotnet-hostfxr-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-10.0-10.0.6-1.el10_1.aarch64.rpm;name=aarch64_dotnet-hostfxr-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-10.0}"
SRC_URI[aarch64_dotnet-hostfxr-10.0.sha256sum] = "a734f7d46ec75332c38a6761ecd629fe7f24718b6d6b001c045e32f1e030fb1b"

URI_aarch64_dotnet-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-10.0-10.0.6-1.el10_1.aarch64.rpm;name=aarch64_dotnet-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-10.0}"
SRC_URI[aarch64_dotnet-runtime-10.0.sha256sum] = "dfa44ca2f6a4ed9001d3f180b6925ffb690a19e6db158855d66aadd1fe1dfcba"

URI_aarch64_dotnet-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-10.0-10.0.6-1.el10_1.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-10.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-10.0.sha256sum] = "22775fedbc6c91cc28b69de7410b121fdec7adde4855420998b0ea65a98de6b1"

URI_aarch64_dotnet-sdk-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-10.0-10.0.106-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-10.0}"
SRC_URI[aarch64_dotnet-sdk-10.0.sha256sum] = "dbdc4aa3de543557cbef73bd99e2ddad5c46044be533314f202d89a9601cba16"

URI_aarch64_dotnet-sdk-10.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.106-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-10.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "6b0e006275d203f70b8407c3fb28f0b5ec35c1ddf0d22e149864874fcdea179f"

URI_aarch64_dotnet-sdk-aot-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-10.0-10.0.106-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-aot-10.0}"
SRC_URI[aarch64_dotnet-sdk-aot-10.0.sha256sum] = "cdba6fc4edcefc0ce6cc6c50d1af639649917b4ec62c15c1ed09f981b7de155d"

URI_aarch64_dotnet-sdk-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-10.0-10.0.106-1.el10_1.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-10.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-10.0.sha256sum] = "92724a4fb3142861b91b0ed484a07ae35b6dc0c48ea441adadfb84a95c591f2c"

URI_aarch64_dotnet-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-10.0-10.0.6-1.el10_1.aarch64.rpm;name=aarch64_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-10.0}"
SRC_URI[aarch64_dotnet-targeting-pack-10.0.sha256sum] = "431bbc17bcb693d78f7285fca9a44c845b41edca70958ae6d8c262650f02dd42"

URI_aarch64_dotnet-templates-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-10.0-10.0.106-1.el10_1.aarch64.rpm;name=aarch64_dotnet-templates-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-10.0}"
SRC_URI[aarch64_dotnet-templates-10.0.sha256sum] = "b4474085f393fea1741a67e53610349631afa67c37cd9223bd6f23ba40a970a3"

RDEPENDS:aspnetcore-runtime-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-10.0 = " \
 aspnetcore-runtime-10.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-10.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-host = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-hostfxr-10.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-10.0 = " \
 dotnet-hostfxr-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:dotnet-sdk-10.0 = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-runtime-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-sdk-10.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-10.0 = " \
 brotli-devel \
 clang \
 dotnet-sdk-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-10.0 = " \
 dotnet-sdk-10.0 \
 "
RDEPENDS:dotnet-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-10.0 = " \
 dotnet-host \
 "
