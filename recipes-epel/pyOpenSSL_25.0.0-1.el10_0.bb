# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyOpenSSL"
PV = "25.0.0"
PR = "1.el10_0"
PACKAGES = " \
 pyOpenSSL-doc \
 python3-pyOpenSSL \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pyOpenSSL-25.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1cdd898c3393eea56aea3904461fe641d67271e198108bde549f34741d5e5a9"

URI_x86_64_v2_pyOpenSSL-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyOpenSSL-doc-25.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pyOpenSSL-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyOpenSSL-doc}"
SRC_URI[x86_64_v2_pyOpenSSL-doc.sha256sum] = "5b6f076c282d3125d46295d8030107dca4f5e1e018a8e720066acbc8e9ecce4c"

URI_x86_64_v2_python3-pyOpenSSL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyOpenSSL-25.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyOpenSSL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyOpenSSL}"
SRC_URI[x86_64_v2_python3-pyOpenSSL.sha256sum] = "8af334c173b79680b3f7ed4373a28d6cbdcfcc44bf7dc5f19952c9ca49a462ee"

URI_aarch64_pyOpenSSL-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pyOpenSSL-doc-25.0.0-1.el10_0.noarch.rpm;name=aarch64_pyOpenSSL-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyOpenSSL-doc}"
SRC_URI[aarch64_pyOpenSSL-doc.sha256sum] = "54a8adc48e1e9e0f7dc2b6085db830e8fdf51c6d980fa1aa473dc4f3091a20e6"

URI_aarch64_python3-pyOpenSSL = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyOpenSSL-25.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-pyOpenSSL;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyOpenSSL}"
SRC_URI[aarch64_python3-pyOpenSSL.sha256sum] = "25ac1deeaeae771ee78bcd08ba80eac67cf109a58b39b1a1b034097b90171cdc"

RDEPENDS:pyOpenSSL-doc = " \
 "
RDEPENDS:python3-pyOpenSSL = " \
 python3 \
 python3-cryptography \
 python3-typing-extensions \
 "
