# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kapman"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kapman \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kapman-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8392d1976c2b1160b5c4728aad1c8aca5b9d2d58d3bf9c609037debebbd8ad02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kapman-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kapman;unpack=0"
SRC_URI[x86_64_v2_kapman.sha256sum] = "b22492096d4bfed132c6c15fbdcbcf481879e84ab056618c2e0618cddc3682fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kapman-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kapman;unpack=0"
SRC_URI[aarch64_kapman.sha256sum] = "6e3b7ba48ee98d4049da086286849d20eb5fcca003afa14a3c3e17b093512920"

RDEPENDS:kapman = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
