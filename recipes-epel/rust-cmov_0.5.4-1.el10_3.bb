# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cmov"
PV = "0.5.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-cmov+default-devel \
 rust-cmov-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cmov-0.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a9ffb3be70d2bf409744b8d7ca165ea12d10d722399c1221ff1dd414f0c19bd"

URI_x86_64_v2_rust-cmov+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmov+default-devel-0.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmov+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmov+default-devel}"
SRC_URI[x86_64_v2_rust-cmov+default-devel.sha256sum] = "dc94851582515eaafe9d3b8cdf9e8a05b7df865239dd39c4a21b2297e1087730"

URI_x86_64_v2_rust-cmov-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmov-devel-0.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmov-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmov-devel}"
SRC_URI[x86_64_v2_rust-cmov-devel.sha256sum] = "74e453851b3a28ba926154cf3b9e4d09b98666224ab0f5b84ee890e9f37e1be4"

URI_aarch64_rust-cmov+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmov+default-devel-0.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-cmov+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmov+default-devel}"
SRC_URI[aarch64_rust-cmov+default-devel.sha256sum] = "1b7da9665614ba02bcc1f655ad3577ffb80b32b91ff4c5c72bd80d2e97f544b6"

URI_aarch64_rust-cmov-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmov-devel-0.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-cmov-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmov-devel}"
SRC_URI[aarch64_rust-cmov-devel.sha256sum] = "f11aef3ce138d1dc0b7d76b9411dbe4bf288516ecf50e3436d388968f7411555"

RDEPENDS:rust-cmov+default-devel = " \
 cargo \
 rust-cmov-devel \
 "
RDEPENDS:rust-cmov-devel = " \
 cargo \
 rust \
 "
