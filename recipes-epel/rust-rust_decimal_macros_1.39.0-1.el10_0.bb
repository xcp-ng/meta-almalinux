# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust_decimal_macros"
PV = "1.39.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rust_decimal_macros+default-devel \
 rust-rust_decimal_macros+reexportable-devel \
 rust-rust_decimal_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust_decimal_macros-1.39.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e63e5462d12ba8eb55acaed5f4f8c047c236fa8caf6024df4fcd37c4835986f7"

URI_x86_64_v2_rust-rust_decimal_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros+default-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal_macros+default-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal_macros+default-devel.sha256sum] = "2805c31a3185b004ad6b0690f09772fb3e9ac1c479a689a55d5c9a78a71ac27d"

URI_x86_64_v2_rust-rust_decimal_macros+reexportable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros+reexportable-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros+reexportable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal_macros+reexportable-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal_macros+reexportable-devel.sha256sum] = "87c2b3eb44972b5b73cf35a05ed17c060ebcd7f69d86a9222a7ea41fcbe26658"

URI_x86_64_v2_rust-rust_decimal_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal_macros-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal_macros-devel.sha256sum] = "3ad6e579f6b313a66afb15fd0f216b2e858d682ae9a2630325df0102b463f7fd"

URI_aarch64_rust-rust_decimal_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros+default-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal_macros+default-devel}"
SRC_URI[aarch64_rust-rust_decimal_macros+default-devel.sha256sum] = "45be0b0a0eb0925292c27ec5bb1329002abfe4998c4a93e2672f40fd216476fe"

URI_aarch64_rust-rust_decimal_macros+reexportable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros+reexportable-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal_macros+reexportable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal_macros+reexportable-devel}"
SRC_URI[aarch64_rust-rust_decimal_macros+reexportable-devel.sha256sum] = "1dedd5ded7c0a90be8b451a00342643c60a370374d1c196d9f8ab5e95d9b798d"

URI_aarch64_rust-rust_decimal_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal_macros-devel}"
SRC_URI[aarch64_rust-rust_decimal_macros-devel.sha256sum] = "67499b787461ebcdb75851ea2f89fea93a2034f0b0d88728769d178da9885804"

RDEPENDS:rust-rust_decimal_macros+default-devel = " \
 cargo \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal_macros+reexportable-devel = " \
 cargo \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal_macros-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
