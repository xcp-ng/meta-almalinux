# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-siguldry"
PV = "0.8.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-siguldry+cli-devel \
 rust-siguldry+default-devel \
 rust-siguldry+server-devel \
 rust-siguldry+sigul-client-devel \
 rust-siguldry-devel \
 siguldry \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-siguldry-0.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dde84848025bc881b0981843d27db1a0f9f9c217528cc1b8134f6eda97d92d8"

URI_x86_64_v2_rust-siguldry+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+cli-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry+cli-devel}"
SRC_URI[x86_64_v2_rust-siguldry+cli-devel.sha256sum] = "bf64f9667014ec1a149c79adcd5b19463d5474e88877358042a976cbbfeb3f94"

URI_x86_64_v2_rust-siguldry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+default-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry+default-devel}"
SRC_URI[x86_64_v2_rust-siguldry+default-devel.sha256sum] = "688bdfcce2a3cc53a163278a39da89084fe0b67f83814321c40c478c7d298809"

URI_x86_64_v2_rust-siguldry+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+server-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry+server-devel}"
SRC_URI[x86_64_v2_rust-siguldry+server-devel.sha256sum] = "e6549037c64825e34175b699790109458aec19d99afae59a35347a5ab09defa6"

URI_x86_64_v2_rust-siguldry+sigul-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry+sigul-client-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry+sigul-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry+sigul-client-devel}"
SRC_URI[x86_64_v2_rust-siguldry+sigul-client-devel.sha256sum] = "d923e1a0ab6a17119dda09e8036bdffc2bc42417ffec5d66f8982de39bddfb68"

URI_x86_64_v2_rust-siguldry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siguldry-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siguldry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siguldry-devel}"
SRC_URI[x86_64_v2_rust-siguldry-devel.sha256sum] = "28b783903aec5bda42ca9168fd4d2ab7351ca89d6b138ab53faa33a7bd749736"

URI_x86_64_v2_siguldry = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/siguldry-0.8.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_siguldry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_siguldry}"
SRC_URI[x86_64_v2_siguldry.sha256sum] = "abb92aa5227b1000ba86e68d617c4c87d3b3605fe187acef0e14b1430183d631"

URI_aarch64_rust-siguldry+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+cli-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry+cli-devel}"
SRC_URI[aarch64_rust-siguldry+cli-devel.sha256sum] = "5d27c46303d509cf48c5be437feac993c44ff977f4baf6a5ad73589753b5e347"

URI_aarch64_rust-siguldry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+default-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry+default-devel}"
SRC_URI[aarch64_rust-siguldry+default-devel.sha256sum] = "1eaa36cb4a3864c5180391b3285d23953d8839e4625472461f44681a296dcc2e"

URI_aarch64_rust-siguldry+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+server-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry+server-devel}"
SRC_URI[aarch64_rust-siguldry+server-devel.sha256sum] = "30e0e95e75021f6f955d2c6d90544fcd88e5dba99f008584f31ba1c96259f2ec"

URI_aarch64_rust-siguldry+sigul-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry+sigul-client-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry+sigul-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry+sigul-client-devel}"
SRC_URI[aarch64_rust-siguldry+sigul-client-devel.sha256sum] = "c487cbeec36bbbd6959dcbca7a166c79d4915103661eaac729a3b4d107d049a7"

URI_aarch64_rust-siguldry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siguldry-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-siguldry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siguldry-devel}"
SRC_URI[aarch64_rust-siguldry-devel.sha256sum] = "662ae2090f2b75b2ec5471a6b9fcea34f4ddc60e09c659f5a84266f27a4355c5"

URI_aarch64_siguldry = "${EPEL_MIRROR}/aarch64/Packages/s/siguldry-0.8.0-1.el10_3.aarch64.rpm;name=aarch64_siguldry;unpack=0"
SRC_URI:append = " ${URI_aarch64_siguldry}"
SRC_URI[aarch64_siguldry.sha256sum] = "5bd187f4d83f4c019367b449f7a6c2a6489ed3c503b9849d6779624a6c6bb90d"

RDEPENDS:rust-siguldry+cli-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+error-context-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+usage-devel \
 rust-clap-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+process-devel \
 rust-rustix+stdio-devel \
 rust-rustix+termios-devel \
 rust-siguldry-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-siguldry+default-devel = " \
 cargo \
 rust-siguldry+cli-devel \
 rust-siguldry+server-devel \
 rust-siguldry-devel \
 "
RDEPENDS:rust-siguldry+server-devel = " \
 cargo \
 rust-cryptoki+default-devel \
 rust-rustix+default-devel \
 rust-rustix+stdio-devel \
 rust-rustix+termios-devel \
 rust-siguldry-devel \
 rust-sqlx+default-devel \
 rust-sqlx+macros-devel \
 rust-sqlx+migrate-devel \
 rust-sqlx+runtime-tokio-devel \
 rust-sqlx+sqlite-unbundled-devel \
 "
RDEPENDS:rust-siguldry+sigul-client-devel = " \
 cargo \
 rust-siguldry-devel \
 "
RDEPENDS:rust-siguldry-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-asn1+default-devel \
 rust-bytes+default-devel \
 rust-hex+default-devel \
 rust-libc+default-devel \
 rust-openssl+default-devel \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-openpgp-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+signal-devel \
 rust-tokio+time-devel \
 rust-tokio-openssl+default-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util+rt-devel \
 rust-toml+default-devel \
 rust-tracing+default-devel \
 rust-uuid+default-devel \
 rust-uuid+serde-devel \
 rust-uuid+v7-devel \
 rust-zerocopy+default-devel \
 rust-zerocopy+derive-devel \
 rust-zerocopy+std-devel \
 "
RDEPENDS:siguldry = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
