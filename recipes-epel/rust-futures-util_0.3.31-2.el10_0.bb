# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-util"
PV = "0.3.31"
PR = "2.el10_0"
PACKAGES = " \
 rust-futures-util+alloc-devel \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+bilock-devel \
 rust-futures-util+cfg-target-has-atomic-devel \
 rust-futures-util+channel-devel \
 rust-futures-util+default-devel \
 rust-futures-util+futures-channel-devel \
 rust-futures-util+futures-io-devel \
 rust-futures-util+futures-macro-devel \
 rust-futures-util+futures-sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+memchr-devel \
 rust-futures-util+portable-atomic-devel \
 rust-futures-util+sink-devel \
 rust-futures-util+slab-devel \
 rust-futures-util+std-devel \
 rust-futures-util+unstable-devel \
 rust-futures-util+write-all-vectored-devel \
 rust-futures-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-util-0.3.31-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cbb43f56d457db9da9f8e4c93a3c2f56cdcac6c2b774a9805928cd62fbac2ec"

URI_x86_64_v2_rust-futures-util+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+alloc-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-util+alloc-devel.sha256sum] = "00415119c9eccc9af597d4fea13fb4cd8d296618c992fbd253e2f1ab94f58a6e"

URI_x86_64_v2_rust-futures-util+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+async-await-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+async-await-devel}"
SRC_URI[x86_64_v2_rust-futures-util+async-await-devel.sha256sum] = "e904e4c8fb47ec9ffc2a1f8efa52149d2de90a6f7465b6a595ac0c6fde3afa34"

URI_x86_64_v2_rust-futures-util+async-await-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+async-await-macro-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+async-await-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+async-await-macro-devel}"
SRC_URI[x86_64_v2_rust-futures-util+async-await-macro-devel.sha256sum] = "abe68e70207daa16ddec219ad1f625cacdb303207da96ce856d0b956cfa1f7f8"

URI_x86_64_v2_rust-futures-util+bilock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+bilock-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+bilock-devel}"
SRC_URI[x86_64_v2_rust-futures-util+bilock-devel.sha256sum] = "c425e4e79956d45391248460fc732fcd7547aefea47befe863814633f64166ec"

URI_x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+cfg-target-has-atomic-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel.sha256sum] = "5f5d2168c12c870c09a33648605156173de8bb7e0d3b07d763f7ed0b9686fdc1"

URI_x86_64_v2_rust-futures-util+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+channel-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+channel-devel}"
SRC_URI[x86_64_v2_rust-futures-util+channel-devel.sha256sum] = "3a4ea3028fd52983ae5df6e1c572934335b7267b6761de2c385f3dfe99249548"

URI_x86_64_v2_rust-futures-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+default-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+default-devel}"
SRC_URI[x86_64_v2_rust-futures-util+default-devel.sha256sum] = "20e2ae992a90b93fd687c73bdf00c0417d17c599654eaab5b1ab6007a2e45297"

URI_x86_64_v2_rust-futures-util+futures-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-channel-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-channel-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-channel-devel.sha256sum] = "873df4f18814942a88b4bd130830d8e527ce339b9260c8bf6195bb975473ab54"

URI_x86_64_v2_rust-futures-util+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-io-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-io-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-io-devel.sha256sum] = "9324ccddfc74e36d93ee90201d85336b3e2795af20d221db319794916a8c84a7"

URI_x86_64_v2_rust-futures-util+futures-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-macro-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-macro-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-macro-devel.sha256sum] = "d93ee0834a14600d1468b4d8e2c076a5477fd9b3fef464f6837445672c180e2a"

URI_x86_64_v2_rust-futures-util+futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-sink-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-sink-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-sink-devel.sha256sum] = "95d1b3242fb919f9ce2bc819ad5a4f783b17e12bf7af8966c5e7ebfcae6c3d08"

URI_x86_64_v2_rust-futures-util+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+io-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+io-devel}"
SRC_URI[x86_64_v2_rust-futures-util+io-devel.sha256sum] = "ab7fc17889dc8c92a93dfd0bfe5d9f965013fae9d7e583a5e3fd7b563a52083c"

URI_x86_64_v2_rust-futures-util+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+memchr-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+memchr-devel}"
SRC_URI[x86_64_v2_rust-futures-util+memchr-devel.sha256sum] = "f9f3de0c3c0cc398e2441dcaf7c0c6397697a934540dc89f0955bc295a993428"

URI_x86_64_v2_rust-futures-util+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable-atomic-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-util+portable-atomic-devel.sha256sum] = "5146aecd32817304bc4eac6426f10ee84a9ff6e9a27c90a22dfa459a7457f7ff"

URI_x86_64_v2_rust-futures-util+sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+sink-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+sink-devel}"
SRC_URI[x86_64_v2_rust-futures-util+sink-devel.sha256sum] = "8a1da4911a09feb9e7c99212f74fa599b81b797f3bf6a4e85088b37b9918514e"

URI_x86_64_v2_rust-futures-util+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+slab-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+slab-devel}"
SRC_URI[x86_64_v2_rust-futures-util+slab-devel.sha256sum] = "c8aab6c21a7577af564b37ddfc629833c80776f8c73d37f5d2171f6724c264a6"

URI_x86_64_v2_rust-futures-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+std-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+std-devel}"
SRC_URI[x86_64_v2_rust-futures-util+std-devel.sha256sum] = "50226f83ed19edc5df54c1c992f948b70ab3defad916688fe2cf26b8748539d0"

URI_x86_64_v2_rust-futures-util+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+unstable-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-util+unstable-devel.sha256sum] = "a2b2a207fdc26e44ff361d26b143c43d865aed6dee33bc91883ae5cd6b9e1571"

URI_x86_64_v2_rust-futures-util+write-all-vectored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+write-all-vectored-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+write-all-vectored-devel}"
SRC_URI[x86_64_v2_rust-futures-util+write-all-vectored-devel.sha256sum] = "b0572fb85bb2af2eb53dbc610f80bbe97b81c7ac61249b6c1b0b284b8abbd419"

URI_x86_64_v2_rust-futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util-devel-0.3.31-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util-devel}"
SRC_URI[x86_64_v2_rust-futures-util-devel.sha256sum] = "507fe7f00ca92efa77c988b333e4cecdda816f0448e7ba4416dc016272e8db05"

URI_aarch64_rust-futures-util+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+alloc-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+alloc-devel}"
SRC_URI[aarch64_rust-futures-util+alloc-devel.sha256sum] = "8c0e4ccfcfa0f1d806b9f5ebfbd46bfc0ee632c4b7959a13c64dc0ae1ce24ba2"

URI_aarch64_rust-futures-util+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+async-await-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+async-await-devel}"
SRC_URI[aarch64_rust-futures-util+async-await-devel.sha256sum] = "dcc1bf24d781dfb41be5c7f1f2fc349b35db7f0dac5f3f9e53a50c4b3c565633"

URI_aarch64_rust-futures-util+async-await-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+async-await-macro-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+async-await-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+async-await-macro-devel}"
SRC_URI[aarch64_rust-futures-util+async-await-macro-devel.sha256sum] = "f2bf5b15214b22fb00a5286cc0999ae19c9183dfc4abeb57903a312c3c624745"

URI_aarch64_rust-futures-util+bilock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+bilock-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+bilock-devel}"
SRC_URI[aarch64_rust-futures-util+bilock-devel.sha256sum] = "4a5fda3ef438e8144466d199e388a28554c9b0de38a5456ca8e0049d913d20e2"

URI_aarch64_rust-futures-util+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+cfg-target-has-atomic-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-util+cfg-target-has-atomic-devel.sha256sum] = "10feace9d4cb9617281522123a8dd7241f8a9d8d7e3bdf4129bd2b1dfcd93879"

URI_aarch64_rust-futures-util+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+channel-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+channel-devel}"
SRC_URI[aarch64_rust-futures-util+channel-devel.sha256sum] = "5abcbd156c40c1d0eab60e7f5f8840c8f52694727d495e5b28339b70a03693bc"

URI_aarch64_rust-futures-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+default-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+default-devel}"
SRC_URI[aarch64_rust-futures-util+default-devel.sha256sum] = "80d29e77d5910f34f7aa904be575173000752cc66868c86aeb8a03239132c377"

URI_aarch64_rust-futures-util+futures-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-channel-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-channel-devel}"
SRC_URI[aarch64_rust-futures-util+futures-channel-devel.sha256sum] = "78b5a18e907c1aab34fe26f358a1469b0c3e7b6b82947a5674f6e8c546092078"

URI_aarch64_rust-futures-util+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-io-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-io-devel}"
SRC_URI[aarch64_rust-futures-util+futures-io-devel.sha256sum] = "c16cfe518db4a0816f46a0ec66a02c477023e9dbe7bd9730ec777fcf7626fab7"

URI_aarch64_rust-futures-util+futures-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-macro-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-macro-devel}"
SRC_URI[aarch64_rust-futures-util+futures-macro-devel.sha256sum] = "c00ee3edab9cdc5764cc16e52cb5992f297ba1fc680b7e412c181e95d5cc4042"

URI_aarch64_rust-futures-util+futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-sink-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-sink-devel}"
SRC_URI[aarch64_rust-futures-util+futures-sink-devel.sha256sum] = "c88285fc4eec3604c7f79b3fdbceba26846517752f4b91a1a57b4d9ea1f7053c"

URI_aarch64_rust-futures-util+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+io-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+io-devel}"
SRC_URI[aarch64_rust-futures-util+io-devel.sha256sum] = "7bbb98c235b1309e3adbe76ca4f08cd48e94ffbed20e682331fcc1c8f22fca52"

URI_aarch64_rust-futures-util+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+memchr-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+memchr-devel}"
SRC_URI[aarch64_rust-futures-util+memchr-devel.sha256sum] = "14b0b33102b2c3911cd719cd413638e7a12221c0d85e3ff66fe166ccbe1cf5dc"

URI_aarch64_rust-futures-util+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable-atomic-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+portable-atomic-devel}"
SRC_URI[aarch64_rust-futures-util+portable-atomic-devel.sha256sum] = "b53d7e03a62070a05a39ae602d1ae6b24331b3e254fa2aa47b2a06f71113cc5f"

URI_aarch64_rust-futures-util+sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+sink-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+sink-devel}"
SRC_URI[aarch64_rust-futures-util+sink-devel.sha256sum] = "eeca8cd4b1f701fd00cfb83d2ea4e12a4ec9322d389ff95331e723208fa4b578"

URI_aarch64_rust-futures-util+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+slab-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+slab-devel}"
SRC_URI[aarch64_rust-futures-util+slab-devel.sha256sum] = "bc36253001776c883ff419b0aac5d71f9ae5e15d0ecaf0a8eb39003ec96fd09a"

URI_aarch64_rust-futures-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+std-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+std-devel}"
SRC_URI[aarch64_rust-futures-util+std-devel.sha256sum] = "c5274df6846aea83151ac4296c57d4408745d6d7ad0d4d76f649bb8cf94e1e97"

URI_aarch64_rust-futures-util+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+unstable-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+unstable-devel}"
SRC_URI[aarch64_rust-futures-util+unstable-devel.sha256sum] = "8eab4026ba334eb3b0b1cfe1ac23f61cee3314c3ed854a5860db745f5aa9ea86"

URI_aarch64_rust-futures-util+write-all-vectored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+write-all-vectored-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+write-all-vectored-devel}"
SRC_URI[aarch64_rust-futures-util+write-all-vectored-devel.sha256sum] = "38d57160251767859257baa7e4c39fde84eb68fa2f0aac2827c895839563d6eb"

URI_aarch64_rust-futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util-devel-0.3.31-2.el10_0.noarch.rpm;name=aarch64_rust-futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util-devel}"
SRC_URI[aarch64_rust-futures-util-devel.sha256sum] = "5d0e76eab6ed42a23fca7eff54ce7df8329dd7f182c14f852502fd3977dcf205"

RDEPENDS:rust-futures-util+alloc-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-task+alloc-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+async-await-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+async-await-macro-devel = " \
 cargo \
 rust-futures-util+async-await-devel \
 rust-futures-util+futures-macro-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+bilock-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+channel-devel = " \
 cargo \
 rust-futures-util+futures-channel-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+default-devel = " \
 cargo \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-channel-devel = " \
 cargo \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-io-devel = " \
 cargo \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-macro-devel = " \
 cargo \
 rust-futures-macro-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-sink-devel = " \
 cargo \
 rust-futures-sink-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+io-devel = " \
 cargo \
 rust-futures-util+futures-io-devel \
 rust-futures-util+memchr-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+memchr-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-futures-util+portable-atomic-devel = " \
 cargo \
 rust-futures-core+portable-atomic-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+sink-devel = " \
 cargo \
 rust-futures-util+futures-sink-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+slab-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-slab+default-devel \
 "
RDEPENDS:rust-futures-util+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-task+std-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util+slab-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+unstable-devel = " \
 cargo \
 rust-futures-core+unstable-devel \
 rust-futures-task+unstable-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+write-all-vectored-devel = " \
 cargo \
 rust-futures-util+io-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-task-devel \
 rust-pin-project-lite+default-devel \
 rust-pin-utils+default-devel \
 "
