# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "almalinux-release"
PV = "10.0"
PR = "32.el10"
PACKAGES = " \
 almalinux-gpg-keys \
 almalinux-release \
 almalinux-repos \
 almalinux-sb-certs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/almalinux-release-10.0-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d392c3d5a83207f66c65055f9f67c6b0358d69e58d1744f89f42c98686e53b1"

URI_x86_64_v2_almalinux-gpg-keys = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/almalinux-gpg-keys-10.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-gpg-keys}"
SRC_URI[x86_64_v2_almalinux-gpg-keys.sha256sum] = "b6564216425e3ffc1e6bcc9c9afb029eabe76f3a1de524ed8b81dc9ec20080de"

URI_x86_64_v2_almalinux-release = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/almalinux-release-10.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-release;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-release}"
SRC_URI[x86_64_v2_almalinux-release.sha256sum] = "f569e53d7d90f58a8ce202af34fe6e01b426893b677e0bfeb063ab744399acf4"

URI_x86_64_v2_almalinux-repos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/almalinux-repos-10.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-repos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-repos}"
SRC_URI[x86_64_v2_almalinux-repos.sha256sum] = "f3e6b7d69a8d060b8e538f037901040f08839302b3e89e90cc51aaa377802579"

URI_x86_64_v2_almalinux-sb-certs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/almalinux-sb-certs-10.0-32.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-sb-certs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-sb-certs}"
SRC_URI[x86_64_v2_almalinux-sb-certs.sha256sum] = "4030b61906da8e67b3c27cdf4e3ec31ce757436a920d08abdc48d6272d59da33"

URI_aarch64_almalinux-gpg-keys = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/almalinux-gpg-keys-10.0-32.el10.aarch64.rpm;name=aarch64_almalinux-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-gpg-keys}"
SRC_URI[aarch64_almalinux-gpg-keys.sha256sum] = "e5f831e05bc5fcfe801bf6eebf4e7b20966ed2eace7aa4cfc0c03803c246d42f"

URI_aarch64_almalinux-release = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/almalinux-release-10.0-32.el10.aarch64.rpm;name=aarch64_almalinux-release;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-release}"
SRC_URI[aarch64_almalinux-release.sha256sum] = "96f43dc39c8b69497f9e9965dc0585552ceadad2556e4e4c174bd9a16804cc1d"

URI_aarch64_almalinux-repos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/almalinux-repos-10.0-32.el10.aarch64.rpm;name=aarch64_almalinux-repos;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-repos}"
SRC_URI[aarch64_almalinux-repos.sha256sum] = "a2a012b4f42da6af99463dfc0187d8ad54c27b3c235ae4b03231cffc77c623de"

URI_aarch64_almalinux-sb-certs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/almalinux-sb-certs-10.0-32.el10.aarch64.rpm;name=aarch64_almalinux-sb-certs;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-sb-certs}"
SRC_URI[aarch64_almalinux-sb-certs.sha256sum] = "f53d67ecaca1635de53d6425eeffc1f28e1a9c2f6de8c78a377b8446a134f699"

RDEPENDS:almalinux-gpg-keys = " \
 "
RDEPENDS:almalinux-release = " \
 almalinux-repos \
 "
RDEPENDS:almalinux-repos = " \
 almalinux-gpg-keys \
 almalinux-release \
 "
RDEPENDS:almalinux-sb-certs = " \
 "
