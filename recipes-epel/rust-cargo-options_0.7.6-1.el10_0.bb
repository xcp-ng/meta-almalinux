# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-options"
PV = "0.7.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-cargo-options+default-devel \
 rust-cargo-options+serde-devel \
 rust-cargo-options-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-options-0.7.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4d970d1e22ed0f211a236ef5ce7035bf9b1bb8039792de7d339389f2c4c8062"

URI_x86_64_v2_rust-cargo-options+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-options+default-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-options+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-options+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-options+default-devel.sha256sum] = "dc5630d4babc67f346650f6249491bcfbf57834456873bbeb47414483ae76b67"

URI_x86_64_v2_rust-cargo-options+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-options+serde-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-options+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-options+serde-devel}"
SRC_URI[x86_64_v2_rust-cargo-options+serde-devel.sha256sum] = "86ac26bccac3a20c2903a05cf316be123f40cd9dabe06cbdd99dcb5a26dcebe8"

URI_x86_64_v2_rust-cargo-options-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-options-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-options-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-options-devel}"
SRC_URI[x86_64_v2_rust-cargo-options-devel.sha256sum] = "2931b58f77803d98668a20d6123d756596ac11fd7f3e5e8984a46792f2906d11"

URI_aarch64_rust-cargo-options+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-options+default-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-options+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-options+default-devel}"
SRC_URI[aarch64_rust-cargo-options+default-devel.sha256sum] = "0075f809295a56dc520d9f5c38db35e5cfd0009bb46ca715b734e55e74d04dc9"

URI_aarch64_rust-cargo-options+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-options+serde-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-options+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-options+serde-devel}"
SRC_URI[aarch64_rust-cargo-options+serde-devel.sha256sum] = "8ef6a10dd3215fb19c67cdc8614d28a030f7698693b4df1541901c39b14fce04"

URI_aarch64_rust-cargo-options-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-options-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-cargo-options-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-options-devel}"
SRC_URI[aarch64_rust-cargo-options-devel.sha256sum] = "69e91e21debce02552a0d5b5e7303e6b1973aa5dfbd2ca38d8136f05c416cf69"

RDEPENDS:rust-cargo-options+default-devel = " \
 cargo \
 rust-cargo-options-devel \
 "
RDEPENDS:rust-cargo-options+serde-devel = " \
 cargo \
 rust-cargo-options-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-cargo-options-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+env-devel \
 rust-clap+unstable-styles-devel \
 rust-clap+wrap_help-devel \
 "
