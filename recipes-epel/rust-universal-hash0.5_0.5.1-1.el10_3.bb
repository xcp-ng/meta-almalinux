# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-universal-hash0.5"
PV = "0.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-universal-hash0.5+default-devel \
 rust-universal-hash0.5+std-devel \
 rust-universal-hash0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-universal-hash0.5-0.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e043ca498e0156e1b5da18c4ed43065a63405ab6eee7204061f0c38f9419c07"

URI_x86_64_v2_rust-universal-hash0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-universal-hash0.5+default-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-universal-hash0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-universal-hash0.5+default-devel}"
SRC_URI[x86_64_v2_rust-universal-hash0.5+default-devel.sha256sum] = "1d54ecb9840c1767b839c25ad15c4342f623b858202cf909cc70b6324724c7f7"

URI_x86_64_v2_rust-universal-hash0.5+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-universal-hash0.5+std-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-universal-hash0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-universal-hash0.5+std-devel}"
SRC_URI[x86_64_v2_rust-universal-hash0.5+std-devel.sha256sum] = "d8a5a52562c03945dbdb38b1c2eb767f170bd9c3355fe2c08914a4c03098b3ac"

URI_x86_64_v2_rust-universal-hash0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-universal-hash0.5-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-universal-hash0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-universal-hash0.5-devel}"
SRC_URI[x86_64_v2_rust-universal-hash0.5-devel.sha256sum] = "a1ab5b4609d3dcaada0b46932092c7a75133b112ee1e17cfd9e6b73ac89df74a"

URI_aarch64_rust-universal-hash0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-universal-hash0.5+default-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-universal-hash0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-universal-hash0.5+default-devel}"
SRC_URI[aarch64_rust-universal-hash0.5+default-devel.sha256sum] = "7ae91ad61ddbe7b0286804afabcf5bb540b99b6193f7246d518fe6dd8600c44d"

URI_aarch64_rust-universal-hash0.5+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-universal-hash0.5+std-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-universal-hash0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-universal-hash0.5+std-devel}"
SRC_URI[aarch64_rust-universal-hash0.5+std-devel.sha256sum] = "9367b10dabed8752bfc7e0fac4c71a66a2fa4bef7888a35e3e74a14d236b7e64"

URI_aarch64_rust-universal-hash0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-universal-hash0.5-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-universal-hash0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-universal-hash0.5-devel}"
SRC_URI[aarch64_rust-universal-hash0.5-devel.sha256sum] = "44f9bc22f9d309cd375e5a99f56a1eae97db42dad8835a33fcdc33fd25135a96"

RDEPENDS:rust-universal-hash0.5+default-devel = " \
 cargo \
 rust-universal-hash0.5-devel \
 "
RDEPENDS:rust-universal-hash0.5+std-devel = " \
 cargo \
 rust-crypto-common0.1+std-devel \
 rust-universal-hash0.5-devel \
 "
RDEPENDS:rust-universal-hash0.5-devel = " \
 cargo \
 rust \
 rust-crypto-common0.1+default-devel \
 rust-subtle-devel \
 "
