# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spin_on"
PV = "0.1.1"
PR = "11.el10_0"
PACKAGES = " \
 rust-spin_on+default-devel \
 rust-spin_on-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spin_on-0.1.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe9b0d6d766b7181e3ad50072fddf8fdc7868cd0c241a043a5246d3454a53079"

URI_x86_64_v2_rust-spin_on+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin_on+default-devel-0.1.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin_on+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin_on+default-devel}"
SRC_URI[x86_64_v2_rust-spin_on+default-devel.sha256sum] = "71ba000fefb7edc3649de5be55bee5aa5a6a5679bd43827e75f657529be24f56"

URI_x86_64_v2_rust-spin_on-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spin_on-devel-0.1.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spin_on-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spin_on-devel}"
SRC_URI[x86_64_v2_rust-spin_on-devel.sha256sum] = "bcd790bef72b282f30682ff79669b4b72385ee38a9a5da88422873c3f3c87c77"

URI_aarch64_rust-spin_on+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin_on+default-devel-0.1.1-11.el10_0.noarch.rpm;name=aarch64_rust-spin_on+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin_on+default-devel}"
SRC_URI[aarch64_rust-spin_on+default-devel.sha256sum] = "6603bef03d363ac74a2b5d885520235caead9938e136e283d404532f8459f277"

URI_aarch64_rust-spin_on-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spin_on-devel-0.1.1-11.el10_0.noarch.rpm;name=aarch64_rust-spin_on-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spin_on-devel}"
SRC_URI[aarch64_rust-spin_on-devel.sha256sum] = "d666e2c7b48d859afda0d182cd037182d043c4e3a3b5bb0757bfa97fd435bd7d"

RDEPENDS:rust-spin_on+default-devel = " \
 cargo \
 rust-spin_on-devel \
 "
RDEPENDS:rust-spin_on-devel = " \
 cargo \
 rust-pin-utils+default-devel \
 "
