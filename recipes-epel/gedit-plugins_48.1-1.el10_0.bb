# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gedit-plugins"
PV = "48.1"
PR = "1.el10_0"
PACKAGES = " \
 gedit-plugin-bookmarks \
 gedit-plugin-bracketcompletion \
 gedit-plugin-codecomment \
 gedit-plugin-colorpicker \
 gedit-plugin-drawspaces \
 gedit-plugin-joinlines \
 gedit-plugin-multiedit \
 gedit-plugin-sessionsaver \
 gedit-plugin-smartspaces \
 gedit-plugin-terminal \
 gedit-plugin-wordcompletion \
 gedit-plugins \
 gedit-plugins-data \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gedit-plugins-48.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "82169c7f11a8a62a370467fb32a06b198dda09969f09951db91b096e5757bc92"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-bookmarks-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-bookmarks;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-bookmarks.sha256sum] = "04233dea8637296040a057e998715a40477448ff013425175417c5fbf7c736b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-bracketcompletion-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-bracketcompletion;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-bracketcompletion.sha256sum] = "4218511aea3ccba888eb9b91c4f4e698b8704a1001a4c4149900b012735e535e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-codecomment-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-codecomment;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-codecomment.sha256sum] = "4fa82d1fc13fd8314ba6e0085d636cc6b1d66cc711048a2327f9d618f16bc76a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-colorpicker-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-colorpicker;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-colorpicker.sha256sum] = "917b493f16b5dbe0d8377405b90553129dc74b69671350b4ff220c9f45c188bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-drawspaces-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-drawspaces;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-drawspaces.sha256sum] = "79e27d6585c23176edd6c188e93574500db7486b97831fcd5df88bbed9b89b29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-joinlines-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-joinlines;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-joinlines.sha256sum] = "6d09e620bd265dbd2a97dbb9c8aec247c739b68e62e275cf5e908a64ad003d23"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-multiedit-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-multiedit;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-multiedit.sha256sum] = "5f92e521db0e8554622739f51c7f8c9b5a53903475cfab914d8275d1afddd80b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-sessionsaver-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-sessionsaver;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-sessionsaver.sha256sum] = "a05ee75f1022250866a8ea6212b0828f2d634dcc02287627c5c7bcb1f856feee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-smartspaces-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-smartspaces;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-smartspaces.sha256sum] = "30fd3f69ac53a86e24a7235664b32da4b66884b952c03e0aa55136a127afd7dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-terminal-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-terminal;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-terminal.sha256sum] = "e60e0a533cf2a51fdbf0b0516e6cd1b11600bafab9b3714c3aa4aedcf858d002"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugin-wordcompletion-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugin-wordcompletion;unpack=0"
SRC_URI[x86_64_v2_gedit-plugin-wordcompletion.sha256sum] = "144790e5b047c5f1836e6fccbdda8e23aa42750f5a128b78728a65b2f83931cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugins-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugins;unpack=0"
SRC_URI[x86_64_v2_gedit-plugins.sha256sum] = "6b875c0305966ceac3be203523366ab25bb1a44c34e2dff46daebab1cbbde783"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-plugins-data-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-plugins-data;unpack=0"
SRC_URI[x86_64_v2_gedit-plugins-data.sha256sum] = "4eb5e00caf9e00d822a25d5e8ddbb640e8571ec21a40a7b4bea134417bb5c3d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-bookmarks-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-bookmarks;unpack=0"
SRC_URI[aarch64_gedit-plugin-bookmarks.sha256sum] = "49597ca98766396460d6c7ea6fc2df6592a453116a91cd2ba8c17d3c89106bda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-bracketcompletion-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-bracketcompletion;unpack=0"
SRC_URI[aarch64_gedit-plugin-bracketcompletion.sha256sum] = "2ac6fda3c3ea83ab12121e8efa0de93ec32cd9dcd9eae2954d9bd13c15ea93a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-codecomment-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-codecomment;unpack=0"
SRC_URI[aarch64_gedit-plugin-codecomment.sha256sum] = "e688db01af26896e4a54281dc5aca168e192f48296f11ac39b3c3d2a80555e4e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-colorpicker-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-colorpicker;unpack=0"
SRC_URI[aarch64_gedit-plugin-colorpicker.sha256sum] = "1274f1e91168420e3b0bab864c20e7c8a4797419efc548982f619fed81f88fa9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-drawspaces-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-drawspaces;unpack=0"
SRC_URI[aarch64_gedit-plugin-drawspaces.sha256sum] = "217f8c014961785da244d43b9fbbc4e792e52c1c31050ef95e4893209354359b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-joinlines-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-joinlines;unpack=0"
SRC_URI[aarch64_gedit-plugin-joinlines.sha256sum] = "a27a1117ac6491787c024ef824ddef0fcb0e76f4c5848333566868daa7afb7a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-multiedit-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-multiedit;unpack=0"
SRC_URI[aarch64_gedit-plugin-multiedit.sha256sum] = "4eab1877ce83613d8014b9fbfc31d071f36389dee79926269f794f97b7ff8d22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-sessionsaver-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-sessionsaver;unpack=0"
SRC_URI[aarch64_gedit-plugin-sessionsaver.sha256sum] = "bf0adc97fe7190a1eec4d6a560ddc0ddaed854617e45d9fffb5dc6bf36e23ac9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-smartspaces-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-smartspaces;unpack=0"
SRC_URI[aarch64_gedit-plugin-smartspaces.sha256sum] = "82e5e82542f5d8a5a4b6a8c34df93e3625d9ecdbc6ebeee45c8e20b3603444f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-terminal-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-terminal;unpack=0"
SRC_URI[aarch64_gedit-plugin-terminal.sha256sum] = "9e5b6b332b63b75b517d77a66fe7a87f748baeec081768c403eee57613b95ad6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugin-wordcompletion-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugin-wordcompletion;unpack=0"
SRC_URI[aarch64_gedit-plugin-wordcompletion.sha256sum] = "20ee05aed1b4eb5d2ca50a8906df421f9b041de3a83b11ad48ed7a0fc5d95f92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugins-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugins;unpack=0"
SRC_URI[aarch64_gedit-plugins.sha256sum] = "2abbc3192b4564c55b3bbec9c8663d4bdd0ebf9a52f70cf3bfb15295ce0003f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gedit-plugins-data-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-plugins-data;unpack=0"
SRC_URI[aarch64_gedit-plugins-data.sha256sum] = "25267917f6bbb8909116228d7141e53f6dc5a2e7cf16950309bca5236873b614"

RDEPENDS:gedit-plugin-bookmarks = " \
 gedit \
 gedit-plugins-data \
 glib2 \
 glibc \
 gtk3 \
 libgedit-gtksourceview \
 libpeas1 \
 "
RDEPENDS:gedit-plugin-bracketcompletion = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-codecomment = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-colorpicker = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-drawspaces = " \
 gedit \
 gedit-plugins-data \
 glib2 \
 glibc \
 libgedit-gtksourceview \
 libgedit-tepl \
 libpeas1 \
 libpeas1-gtk \
 "
RDEPENDS:gedit-plugin-joinlines = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-multiedit = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-sessionsaver = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-smartspaces = " \
 gedit \
 gedit-plugins-data \
 glib2 \
 glibc \
 libgedit-gtksourceview \
 libpeas1 \
 libpeas1-loader-python3 \
 "
RDEPENDS:gedit-plugin-terminal = " \
 gedit-plugins-data \
 libpeas1-loader-python3 \
 vte291 \
 "
RDEPENDS:gedit-plugin-wordcompletion = " \
 gedit \
 gedit-plugins-data \
 glib2 \
 glibc \
 gtk3 \
 libgedit-gtksourceview \
 libpeas1 \
 libpeas1-gtk \
 "
RDEPENDS:gedit-plugins = " \
 gedit-plugin-bookmarks \
 gedit-plugin-bracketcompletion \
 gedit-plugin-codecomment \
 gedit-plugin-colorpicker \
 gedit-plugin-drawspaces \
 gedit-plugin-joinlines \
 gedit-plugin-multiedit \
 gedit-plugin-sessionsaver \
 gedit-plugin-smartspaces \
 gedit-plugin-terminal \
 gedit-plugin-wordcompletion \
 "
RDEPENDS:gedit-plugins-data = " \
 gedit \
 python3-gobject \
 "
