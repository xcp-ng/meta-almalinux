# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yggdrasil"
PV = "0.4.9.2"
PR = "1.el10_2.2"
PACKAGES = " \
 yggdrasil \
 yggdrasil-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/yggdrasil-0.4.9.2-1.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caff49626d591b50a35b406417826c79478e88aeb0b570053365331602beed61"

URI_x86_64_v2_yggdrasil = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/yggdrasil-0.4.9.2-1.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_yggdrasil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil}"
SRC_URI[x86_64_v2_yggdrasil.sha256sum] = "3ff2c82a6f0e353b9fb9632cff6a89d06e767ddcf7bc4089345e3ef8665f7ef1"

URI_x86_64_v2_yggdrasil-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/yggdrasil-devel-0.4.9.2-1.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_yggdrasil-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yggdrasil-devel}"
SRC_URI[x86_64_v2_yggdrasil-devel.sha256sum] = "f323a9d66af7dc52fd2450201ffeec1e3b8dd07c4f6e5575e046d8a6750bf4d8"

URI_aarch64_yggdrasil = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/yggdrasil-0.4.9.2-1.el10_2.2.aarch64.rpm;name=aarch64_yggdrasil;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil}"
SRC_URI[aarch64_yggdrasil.sha256sum] = "15015f4482bdc52efa73db6c5ac8ba3dc0174805246d90b333ffa5068b4390cd"

URI_aarch64_yggdrasil-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/yggdrasil-devel-0.4.9.2-1.el10_2.2.aarch64.rpm;name=aarch64_yggdrasil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yggdrasil-devel}"
SRC_URI[aarch64_yggdrasil-devel.sha256sum] = "8729eb65f7deb77253c9cd56d6834503ad234da230ed63b7a71d43f73c4a3d68"

RDEPENDS:yggdrasil = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:yggdrasil-devel = " \
 pkgconf-pkg-config \
 "
