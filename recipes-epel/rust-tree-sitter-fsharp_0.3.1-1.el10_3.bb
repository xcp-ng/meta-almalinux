# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-fsharp"
PV = "0.3.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-fsharp+default-devel \
 rust-tree-sitter-fsharp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-fsharp-0.3.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "225b2973fcd61f84f90f39be4ef45476b5161f1d178416af776896baca7b2c64"

URI_x86_64_v2_rust-tree-sitter-fsharp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-fsharp+default-devel-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-fsharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-fsharp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-fsharp+default-devel.sha256sum] = "0eaf3e13c6bfe0118953f1016d24a091727fb14f773c7ec90f3e810df1274917"

URI_x86_64_v2_rust-tree-sitter-fsharp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-fsharp-devel-0.3.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-fsharp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-fsharp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-fsharp-devel.sha256sum] = "c2116a3f76147f2ff9eeb08726c5173b0b440a82511ff0df0c7c2700c2c5d8f5"

URI_aarch64_rust-tree-sitter-fsharp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-fsharp+default-devel-0.3.1-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-fsharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-fsharp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-fsharp+default-devel.sha256sum] = "92e6454c6da71c5a54f36fce3f02f1d4d567342411eae55cb171bd9dce830f96"

URI_aarch64_rust-tree-sitter-fsharp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-fsharp-devel-0.3.1-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-fsharp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-fsharp-devel}"
SRC_URI[aarch64_rust-tree-sitter-fsharp-devel.sha256sum] = "acf7aa363f898de82e0e0726c107f8cabd40ed0806fdce3acf8d7a872d61b8e6"

RDEPENDS:rust-tree-sitter-fsharp+default-devel = " \
 cargo \
 rust-tree-sitter-fsharp-devel \
 "
RDEPENDS:rust-tree-sitter-fsharp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
