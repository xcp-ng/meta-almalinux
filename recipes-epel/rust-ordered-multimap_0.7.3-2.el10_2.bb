# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordered-multimap"
PV = "0.7.3"
PR = "2.el10_2"
PACKAGES = " \
 rust-ordered-multimap+default-devel \
 rust-ordered-multimap+serde-devel \
 rust-ordered-multimap+std-devel \
 rust-ordered-multimap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordered-multimap-0.7.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e1611911f0218a495d1be970c55ba287ea5b7315faa7d5d15cb4504eeab95fb"

URI_x86_64_v2_rust-ordered-multimap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-multimap+default-devel-0.7.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-multimap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-multimap+default-devel}"
SRC_URI[x86_64_v2_rust-ordered-multimap+default-devel.sha256sum] = "ce112c8873cf9b38bd838c84f810bc124d414c7c075a172c195d956beedb1f8e"

URI_x86_64_v2_rust-ordered-multimap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-multimap+serde-devel-0.7.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-multimap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-multimap+serde-devel}"
SRC_URI[x86_64_v2_rust-ordered-multimap+serde-devel.sha256sum] = "7fa0e8f615dfb35a7a2731154c52ce8e6a0ced36c75867a58e43e6335c714f6a"

URI_x86_64_v2_rust-ordered-multimap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-multimap+std-devel-0.7.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-multimap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-multimap+std-devel}"
SRC_URI[x86_64_v2_rust-ordered-multimap+std-devel.sha256sum] = "470d6d1704e5fb088536e3ce9562ce263d0e896bba58dc9556be8c9a864c5408"

URI_x86_64_v2_rust-ordered-multimap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-multimap-devel-0.7.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-multimap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-multimap-devel}"
SRC_URI[x86_64_v2_rust-ordered-multimap-devel.sha256sum] = "4de63bd0424b75014a91d087bb27426909ea5d47ed1620bcba59c103fdf53c67"

URI_aarch64_rust-ordered-multimap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-multimap+default-devel-0.7.3-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-multimap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-multimap+default-devel}"
SRC_URI[aarch64_rust-ordered-multimap+default-devel.sha256sum] = "c21910a469c00bef45860516b01892a3d7482f4afe8265aca39011ed8e863d6e"

URI_aarch64_rust-ordered-multimap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-multimap+serde-devel-0.7.3-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-multimap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-multimap+serde-devel}"
SRC_URI[aarch64_rust-ordered-multimap+serde-devel.sha256sum] = "ce7a01d678987beb48d41be52035526c074a5b46c80b76b1837b5c81d1ec8768"

URI_aarch64_rust-ordered-multimap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-multimap+std-devel-0.7.3-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-multimap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-multimap+std-devel}"
SRC_URI[aarch64_rust-ordered-multimap+std-devel.sha256sum] = "0ce447694082724f2320b3a9d65d883b069fddd6e8b366c792d426d9e87d4e08"

URI_aarch64_rust-ordered-multimap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-multimap-devel-0.7.3-2.el10_2.noarch.rpm;name=aarch64_rust-ordered-multimap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-multimap-devel}"
SRC_URI[aarch64_rust-ordered-multimap-devel.sha256sum] = "3f9021e4a18594fc09103e089dc8a3592a878e3b1009be36cdc472e8de9e3d01"

RDEPENDS:rust-ordered-multimap+default-devel = " \
 cargo \
 rust-ordered-multimap+std-devel \
 rust-ordered-multimap-devel \
 "
RDEPENDS:rust-ordered-multimap+serde-devel = " \
 cargo \
 rust-ordered-multimap-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ordered-multimap+std-devel = " \
 cargo \
 rust-dlv-list+std-devel \
 rust-ordered-multimap-devel \
 "
RDEPENDS:rust-ordered-multimap-devel = " \
 cargo \
 rust \
 rust-dlv-list-devel \
 rust-hashbrown0.14-devel \
 "
