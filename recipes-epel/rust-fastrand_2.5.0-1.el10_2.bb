# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fastrand"
PV = "2.5.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-fastrand+alloc-devel \
 rust-fastrand+default-devel \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fastrand-2.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7d7cb4bba0056ea0010007c0ae56dae66438819f841399ef2d6f13518d44d95"

URI_x86_64_v2_rust-fastrand+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand+alloc-devel-2.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fastrand+alloc-devel}"
SRC_URI[x86_64_v2_rust-fastrand+alloc-devel.sha256sum] = "e79f6a194941ebae8ceae15cfb2ec68f8564a7b5876be5baf2c3827563508333"

URI_x86_64_v2_rust-fastrand+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand+default-devel-2.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fastrand+default-devel}"
SRC_URI[x86_64_v2_rust-fastrand+default-devel.sha256sum] = "5e928f7676ed116d48c5d6c187773f1eb79f709aa8b2a6f34480e455139bec37"

URI_x86_64_v2_rust-fastrand+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand+std-devel-2.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fastrand+std-devel}"
SRC_URI[x86_64_v2_rust-fastrand+std-devel.sha256sum] = "d94d8a396f0bb807a4181cb1377d3a2767c1f39f59660254ed30d300a608e834"

URI_x86_64_v2_rust-fastrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fastrand-devel-2.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fastrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fastrand-devel}"
SRC_URI[x86_64_v2_rust-fastrand-devel.sha256sum] = "ba046b37e84922d61f5dba603ec28a30719aa4e76b0a37e0f763df403a1e2ed4"

URI_aarch64_rust-fastrand+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand+alloc-devel-2.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-fastrand+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fastrand+alloc-devel}"
SRC_URI[aarch64_rust-fastrand+alloc-devel.sha256sum] = "00146884ad1d9f5470c284e941181045c05d99c7fcb73ca405960f7a0ac7ad2b"

URI_aarch64_rust-fastrand+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand+default-devel-2.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-fastrand+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fastrand+default-devel}"
SRC_URI[aarch64_rust-fastrand+default-devel.sha256sum] = "b9233cd59ca300e89dbbd7a7b25d55159f77e43ca262b1ed8098df4c1d224650"

URI_aarch64_rust-fastrand+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand+std-devel-2.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-fastrand+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fastrand+std-devel}"
SRC_URI[aarch64_rust-fastrand+std-devel.sha256sum] = "7829a613b0cb990c60992724576af77cfaf06bbe2d6709678bd0214f00171dcc"

URI_aarch64_rust-fastrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fastrand-devel-2.5.0-1.el10_2.noarch.rpm;name=aarch64_rust-fastrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fastrand-devel}"
SRC_URI[aarch64_rust-fastrand-devel.sha256sum] = "3bcd3c89ffcfe58291151aecefca03032720e41eb6c20368c13af9859966f246"

RDEPENDS:rust-fastrand+alloc-devel = " \
 cargo \
 rust-fastrand-devel \
 "
RDEPENDS:rust-fastrand+default-devel = " \
 cargo \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 "
RDEPENDS:rust-fastrand+std-devel = " \
 cargo \
 rust-fastrand+alloc-devel \
 rust-fastrand-devel \
 "
RDEPENDS:rust-fastrand-devel = " \
 cargo \
 rust \
 "
