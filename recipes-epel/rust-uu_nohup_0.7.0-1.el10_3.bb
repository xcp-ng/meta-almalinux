# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_nohup"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_nohup+default-devel \
 rust-uu_nohup-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_nohup-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6aff92ade3c15f10875813a212564ba953ddab4fa023e6cb6326090158aeb2f7"

URI_x86_64_v2_rust-uu_nohup+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_nohup+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_nohup+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_nohup+default-devel}"
SRC_URI[x86_64_v2_rust-uu_nohup+default-devel.sha256sum] = "5b967322dbc19c4248f1ce6705ba42d0c4282d60fcf900d7d89d2c69b30ff1ea"

URI_x86_64_v2_rust-uu_nohup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_nohup-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_nohup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_nohup-devel}"
SRC_URI[x86_64_v2_rust-uu_nohup-devel.sha256sum] = "25d79da11b7b44e33e363a44fcbdab887dfb19233d0eb246bc31881deb283e81"

URI_aarch64_rust-uu_nohup+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_nohup+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_nohup+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_nohup+default-devel}"
SRC_URI[aarch64_rust-uu_nohup+default-devel.sha256sum] = "4b48edd2bd6156918bdacb3972152ef3ad44b88b9670485169975eaf49de8494"

URI_aarch64_rust-uu_nohup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_nohup-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_nohup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_nohup-devel}"
SRC_URI[aarch64_rust-uu_nohup-devel.sha256sum] = "5519d1f83a242264482e2727a50b13166fe2c2d12113f4ea4ffaf583300ac27f"

RDEPENDS:rust-uu_nohup+default-devel = " \
 cargo \
 rust-uu_nohup-devel \
 "
RDEPENDS:rust-uu_nohup-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 "
