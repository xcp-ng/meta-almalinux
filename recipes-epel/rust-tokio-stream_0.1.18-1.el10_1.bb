# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-stream"
PV = "0.1.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+fs-devel \
 rust-tokio-stream+full-devel \
 rust-tokio-stream+io-util-devel \
 rust-tokio-stream+net-devel \
 rust-tokio-stream+signal-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-stream+time-devel \
 rust-tokio-stream+tokio-util-devel \
 rust-tokio-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-stream-0.1.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ee6f281134759b386d00bb7f25dc2cdc4214a3751cf428d9f5a649166b40abb"

URI_x86_64_v2_rust-tokio-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+default-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+default-devel.sha256sum] = "649a4343102ae4b767fe35396b3cbc24e0f10fc35e42ee8140c5065887401628"

URI_x86_64_v2_rust-tokio-stream+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+fs-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+fs-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+fs-devel.sha256sum] = "9617a8a28ebfe8195475c3c5ef522423e566e8853846ffcf9ca0a42954f110bc"

URI_x86_64_v2_rust-tokio-stream+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+full-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+full-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+full-devel.sha256sum] = "09b64637388ebbce90d248e7cdee49ca896781ffe55986d778e786a0c0250192"

URI_x86_64_v2_rust-tokio-stream+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+io-util-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+io-util-devel.sha256sum] = "d33246fc8fcd0c8369be536d964b1d9d3c5dcda436c68a4b5072af2f98c929a9"

URI_x86_64_v2_rust-tokio-stream+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+net-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+net-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+net-devel.sha256sum] = "c0357682ea68c7e2ae4d7f9235aadea8db5ec1e632fe308671e82618c223d4a4"

URI_x86_64_v2_rust-tokio-stream+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+signal-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+signal-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+signal-devel.sha256sum] = "733c99efd4dd8a0e8b54a21390477c0f8e581bf410d6daa347a8f5fffaa60f22"

URI_x86_64_v2_rust-tokio-stream+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+sync-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+sync-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+sync-devel.sha256sum] = "f1676436c52dd3471df95a506cf203e54ac4306054b27aefc0d2697b31cbeaa2"

URI_x86_64_v2_rust-tokio-stream+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+time-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+time-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+time-devel.sha256sum] = "71f0c1e754b63deb1a4be7af1edfed86c1293e5b954be06139fbee8a3564023e"

URI_x86_64_v2_rust-tokio-stream+tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream+tokio-util-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream+tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream+tokio-util-devel.sha256sum] = "b1a682de63da0461d8046b83551bd8f4e1609e8c3a752656fcdaa0bc6cb997b0"

URI_x86_64_v2_rust-tokio-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-stream-devel-0.1.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-stream-devel}"
SRC_URI[x86_64_v2_rust-tokio-stream-devel.sha256sum] = "483f94f65a71d6d47b7ba4c10f392e4041d1844f64437053bbb2fa5e52dbd61d"

URI_aarch64_rust-tokio-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+default-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+default-devel}"
SRC_URI[aarch64_rust-tokio-stream+default-devel.sha256sum] = "8be5a9ef2cfa29e9f2a58f32dc377f0bc04a04445798b3515893b41785c64ae3"

URI_aarch64_rust-tokio-stream+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+fs-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+fs-devel}"
SRC_URI[aarch64_rust-tokio-stream+fs-devel.sha256sum] = "74ee260e98aa46ea460107475c0ed70d3fd1f1a9bd23075647262733b111bb3b"

URI_aarch64_rust-tokio-stream+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+full-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+full-devel}"
SRC_URI[aarch64_rust-tokio-stream+full-devel.sha256sum] = "5aaaf72dc583ff30f78f05757e6eab538c95d59389337ad097d169d0e216adb0"

URI_aarch64_rust-tokio-stream+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+io-util-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+io-util-devel}"
SRC_URI[aarch64_rust-tokio-stream+io-util-devel.sha256sum] = "a0ef2ed4ce934f96cfb14768236b7fd021e2fa23aca9add1ed177fb81062a3f6"

URI_aarch64_rust-tokio-stream+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+net-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+net-devel}"
SRC_URI[aarch64_rust-tokio-stream+net-devel.sha256sum] = "9daab0e18009bf86c24076cae9f149a93a5842166fba433f829089a124ff1d80"

URI_aarch64_rust-tokio-stream+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+signal-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+signal-devel}"
SRC_URI[aarch64_rust-tokio-stream+signal-devel.sha256sum] = "a867b7e828c3afe257b6c026a3d435be7282b8b7b902fb0beabf17c495927329"

URI_aarch64_rust-tokio-stream+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+sync-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+sync-devel}"
SRC_URI[aarch64_rust-tokio-stream+sync-devel.sha256sum] = "c98504be0855f6076d26b0fb7ee3f54e26936cc129d0641c9c760bd0b710cdd5"

URI_aarch64_rust-tokio-stream+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+time-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+time-devel}"
SRC_URI[aarch64_rust-tokio-stream+time-devel.sha256sum] = "cbabb462f5d76425ee3b3be8b570a957a1b4b39a3184fcf4deb6b582d8aed6b6"

URI_aarch64_rust-tokio-stream+tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream+tokio-util-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream+tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream+tokio-util-devel}"
SRC_URI[aarch64_rust-tokio-stream+tokio-util-devel.sha256sum] = "6cb9ef0f165e8af8ab47ee76c20d17bdec4a41b4ee6a4982ccb85fdd3666a7ed"

URI_aarch64_rust-tokio-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-stream-devel-0.1.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-stream-devel}"
SRC_URI[aarch64_rust-tokio-stream-devel.sha256sum] = "280767a185b2c1337abf68f0a5e69af5c122c935bc3315a2baea84b275a1ca86"

RDEPENDS:rust-tokio-stream+default-devel = " \
 cargo \
 rust-tokio-stream+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+fs-devel = " \
 cargo \
 rust-tokio+fs-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+full-devel = " \
 cargo \
 rust-tokio-stream+fs-devel \
 rust-tokio-stream+io-util-devel \
 rust-tokio-stream+net-devel \
 rust-tokio-stream+signal-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-stream+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+io-util-devel = " \
 cargo \
 rust-tokio+io-util-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+net-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+signal-devel = " \
 cargo \
 rust-tokio+signal-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+sync-devel = " \
 cargo \
 rust-tokio+sync-devel \
 rust-tokio-stream+tokio-util-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+time-devel = " \
 cargo \
 rust-tokio+time-devel \
 rust-tokio-stream-devel \
 "
RDEPENDS:rust-tokio-stream+tokio-util-devel = " \
 cargo \
 rust-tokio-stream-devel \
 rust-tokio-util+default-devel \
 "
RDEPENDS:rust-tokio-stream-devel = " \
 cargo \
 rust \
 rust-futures-core+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
