# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-filesystem \
 kf6-rpm-macros \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cc82ba45aa63d3eb7aee0f96c7cf05d1381815820bf47c3092f4324d8d3fd137"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-filesystem-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-filesystem;unpack=0"
SRC_URI[x86_64_v2_kf6-filesystem.sha256sum] = "dac822711f9f521ffe3db099865cd546fef8318da6d8a9763ce9d4d58029522d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-rpm-macros-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-rpm-macros;unpack=0"
SRC_URI[x86_64_v2_kf6-rpm-macros.sha256sum] = "a52f7fa8e04c8dbdf54212d124b68dfc4cca6ecc73fe760950dd7919c67a2483"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-filesystem-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-filesystem;unpack=0"
SRC_URI[aarch64_kf6-filesystem.sha256sum] = "2b314ff2d742db7371442bc2086808f0f1098cb8bbc4ca8be20d8fd8ef08e79d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-rpm-macros-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-rpm-macros;unpack=0"
SRC_URI[aarch64_kf6-rpm-macros.sha256sum] = "df22bc266410824314ca8b81f295b8d88d33b3af866a462892a409bc54141a38"

RDEPENDS:kf6-filesystem = " \
 kde-filesystem \
 "
RDEPENDS:kf6-rpm-macros = " \
 cmake \
 doxygen \
 gcc-c++ \
 kde-qdoc-common \
 qt6-doc-devel \
 qt6-qttools-devel \
 qt6-rpm-macros \
 "
