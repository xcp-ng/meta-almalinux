# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prettyplease"
PV = "0.2.37"
PR = "1.el10_1"
PACKAGES = " \
 rust-prettyplease+default-devel \
 rust-prettyplease+verbatim-devel \
 rust-prettyplease-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prettyplease-0.2.37-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c2ade06a4f08144e5d041996ba592c2229af219e86b79dca52239c1fa01a6e5"

URI_x86_64_v2_rust-prettyplease+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prettyplease+default-devel-0.2.37-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prettyplease+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prettyplease+default-devel}"
SRC_URI[x86_64_v2_rust-prettyplease+default-devel.sha256sum] = "372cad30e1970f9747d7b27acbbc93d3ee1c5821b56eb1c7a6b7098f96ba8941"

URI_x86_64_v2_rust-prettyplease+verbatim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prettyplease+verbatim-devel-0.2.37-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prettyplease+verbatim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prettyplease+verbatim-devel}"
SRC_URI[x86_64_v2_rust-prettyplease+verbatim-devel.sha256sum] = "07b67b70a2e4a4aba7867a0eacfca5478d8171b3bf948782fae7d8bdb407f319"

URI_x86_64_v2_rust-prettyplease-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prettyplease-devel-0.2.37-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prettyplease-devel}"
SRC_URI[x86_64_v2_rust-prettyplease-devel.sha256sum] = "0148be388512729aa2a43d8ac625bcd9f71457ff1bbfd7504d9237b3d3a50da9"

URI_aarch64_rust-prettyplease+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prettyplease+default-devel-0.2.37-1.el10_1.noarch.rpm;name=aarch64_rust-prettyplease+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prettyplease+default-devel}"
SRC_URI[aarch64_rust-prettyplease+default-devel.sha256sum] = "0fe4f6d220edf264b9997995600d4f2de75ec8e8e323209ef06d7d9d6438e4f9"

URI_aarch64_rust-prettyplease+verbatim-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prettyplease+verbatim-devel-0.2.37-1.el10_1.noarch.rpm;name=aarch64_rust-prettyplease+verbatim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prettyplease+verbatim-devel}"
SRC_URI[aarch64_rust-prettyplease+verbatim-devel.sha256sum] = "d7e0f9e51a3c5903633292ec0cd99d5e870fe06f1b570f64cbf2535126bae12c"

URI_aarch64_rust-prettyplease-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prettyplease-devel-0.2.37-1.el10_1.noarch.rpm;name=aarch64_rust-prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prettyplease-devel}"
SRC_URI[aarch64_rust-prettyplease-devel.sha256sum] = "26bccb622ae20a0b3d30ab944dbdad99786e03308f1a56525ab3489c9876df98"

RDEPENDS:rust-prettyplease+default-devel = " \
 cargo \
 rust-prettyplease-devel \
 "
RDEPENDS:rust-prettyplease+verbatim-devel = " \
 cargo \
 rust-prettyplease-devel \
 rust-syn+parsing-devel \
 "
RDEPENDS:rust-prettyplease-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-syn+full-devel \
 rust-syn-devel \
 "
