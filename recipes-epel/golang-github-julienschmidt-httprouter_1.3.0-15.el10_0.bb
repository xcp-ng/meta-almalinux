# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-julienschmidt-httprouter"
PV = "1.3.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-julienschmidt-httprouter-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-julienschmidt-httprouter-1.3.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b7e23001d4520270f656273019be32d96495d649c132739fb03cb4a515ba982"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-julienschmidt-httprouter-devel-1.3.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-julienschmidt-httprouter-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-julienschmidt-httprouter-devel.sha256sum] = "0b943073fc4075969f9eba3d86e9c036aa04eabd8f9db10abdd90e0fa6de1d01"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-julienschmidt-httprouter-devel-1.3.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-julienschmidt-httprouter-devel;unpack=0"
SRC_URI[aarch64_golang-github-julienschmidt-httprouter-devel.sha256sum] = "9bc93dcfa7399bacb77bb500c96d6493ee1c868dfb09ab0ec31b9a2f551955de"

RDEPENDS:golang-github-julienschmidt-httprouter-devel = " \
 go-filesystem \
 "
