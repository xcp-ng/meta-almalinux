# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-vividcortex-gohistogram"
PV = "1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-vividcortex-gohistogram-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-vividcortex-gohistogram-1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21bd832514cdacdf0173358d72d626610fa3b66f230217b7aa66afeb23b34e27"

URI_x86_64_v2_golang-github-vividcortex-gohistogram-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-vividcortex-gohistogram-devel-1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-vividcortex-gohistogram-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-vividcortex-gohistogram-devel}"
SRC_URI[x86_64_v2_golang-github-vividcortex-gohistogram-devel.sha256sum] = "594f0cbabff95931f8ce46ed0ec63ddf99bbf2f10e5ec2c63d4bdf2c775a8b3f"

URI_aarch64_golang-github-vividcortex-gohistogram-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-vividcortex-gohistogram-devel-1.0.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-vividcortex-gohistogram-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-vividcortex-gohistogram-devel}"
SRC_URI[aarch64_golang-github-vividcortex-gohistogram-devel.sha256sum] = "067cc8525bfa843e47a7090d51a239fd043ef2e656c63a5dc112d36bc2a85532"

RDEPENDS:golang-github-vividcortex-gohistogram-devel = " \
 go-filesystem \
 "
