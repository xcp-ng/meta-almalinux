# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libselinux"
PV = "3.9"
PR = "1.el10"
PACKAGES = " \
 libselinux \
 libselinux-devel \
 libselinux-ruby \
 libselinux-static \
 libselinux-utils \
 python3-libselinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libselinux-3.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d901ea3a2ecf0d38f9c4db561b4d03275937c345979462450056db8f6681674"

URI_x86_64_v2_libselinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux}"
SRC_URI[x86_64_v2_libselinux.sha256sum] = "288e06e91638c2cba54439141145f0a719052352d89d1f25160db19ce12072bf"

URI_x86_64_v2_libselinux-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-devel-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-devel}"
SRC_URI[x86_64_v2_libselinux-devel.sha256sum] = "edcdcfa9f1528c3f190b970effc3118a9e338b0abf4967098408e91f00086c04"

URI_x86_64_v2_libselinux-ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-ruby-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-ruby}"
SRC_URI[x86_64_v2_libselinux-ruby.sha256sum] = "edee0bf554e7e687f39992a9211b1026f9ee007f16895af7d04da7b842c75f58"

URI_x86_64_v2_libselinux-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libselinux-static-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-static}"
SRC_URI[x86_64_v2_libselinux-static.sha256sum] = "88b31deecc3035ac1e8cef019181f77dac1a91454d5ca9919d0c85eea392d1ad"

URI_x86_64_v2_libselinux-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-utils-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-utils}"
SRC_URI[x86_64_v2_libselinux-utils.sha256sum] = "495b41a1f5d5e301671dd602316e097eba9b48ff7076b87507882b0f50750800"

URI_x86_64_v2_python3-libselinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libselinux-3.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libselinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libselinux}"
SRC_URI[x86_64_v2_python3-libselinux.sha256sum] = "12cd5ff984df945f64cbc1b24ef91aee0b628b7cab9289e69bc7198057bf2ef3"

URI_aarch64_libselinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-3.9-1.el10.aarch64.rpm;name=aarch64_libselinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux}"
SRC_URI[aarch64_libselinux.sha256sum] = "e4af34dc8c1ab74dadd5553045d3d6d1c2d6124f0afe6f4b9e276601695e2ee5"

URI_aarch64_libselinux-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-devel-3.9-1.el10.aarch64.rpm;name=aarch64_libselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-devel}"
SRC_URI[aarch64_libselinux-devel.sha256sum] = "787d418a46306c58c259a0aac120339076f9cef7661690476f96c10c0e1f7e62"

URI_aarch64_libselinux-ruby = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-ruby-3.9-1.el10.aarch64.rpm;name=aarch64_libselinux-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-ruby}"
SRC_URI[aarch64_libselinux-ruby.sha256sum] = "c39b632fcbc89548094874f31f0bf95e1008b3be37d5cf42998c97e17ad1d878"

URI_aarch64_libselinux-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libselinux-static-3.9-1.el10.aarch64.rpm;name=aarch64_libselinux-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-static}"
SRC_URI[aarch64_libselinux-static.sha256sum] = "9354d7c3ea23927010dd34cbb048ac41052ed93d5dff5b4a5b83f24e85a64b75"

URI_aarch64_libselinux-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-utils-3.9-1.el10.aarch64.rpm;name=aarch64_libselinux-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-utils}"
SRC_URI[aarch64_libselinux-utils.sha256sum] = "32625601de7bd4901fba558bce226dc7c316e75686c872aafc2c898da2383869"

URI_aarch64_python3-libselinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libselinux-3.9-1.el10.aarch64.rpm;name=aarch64_python3-libselinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libselinux}"
SRC_URI[aarch64_python3-libselinux.sha256sum] = "cb4f34d25c119a310ca8bc7d4a4a72c7ea62707859f922a518e6c3a29b8aa02e"

RDEPENDS:libselinux = " \
 glibc \
 libsepol \
 pcre2 \
 "
RDEPENDS:libselinux-devel = " \
 libselinux \
 libsepol-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libselinux-ruby = " \
 glibc \
 libselinux \
 ruby-libs \
 "
RDEPENDS:libselinux-static = " \
 libselinux-devel \
 "
RDEPENDS:libselinux-utils = " \
 glibc \
 libselinux \
 libsepol \
 pcre2 \
 "
RDEPENDS:python3-libselinux = " \
 glibc \
 libselinux \
 python3 \
 "
