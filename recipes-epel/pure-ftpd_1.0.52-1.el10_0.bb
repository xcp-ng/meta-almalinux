# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pure-ftpd"
PV = "1.0.52"
PR = "1.el10_0"
PACKAGES = " \
 pure-ftpd \
 pure-ftpd-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pure-ftpd-1.0.52-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c032c371a5734cad0844b16f6353473ec261e1056c3198d86db31d32021e06c3"

URI_x86_64_v2_pure-ftpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pure-ftpd-1.0.52-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pure-ftpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pure-ftpd}"
SRC_URI[x86_64_v2_pure-ftpd.sha256sum] = "89105c7628221b5bbc6d8cb920de3e3fb110785b47d707f63e037be76d4f9279"

URI_x86_64_v2_pure-ftpd-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pure-ftpd-selinux-1.0.52-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pure-ftpd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pure-ftpd-selinux}"
SRC_URI[x86_64_v2_pure-ftpd-selinux.sha256sum] = "ddfc29b5f64ef65b53526450e0f8c1a1e3843d153fd6c1ea8730dd5396635bd9"

URI_aarch64_pure-ftpd = "${EPEL_MIRROR}/aarch64/Packages/p/pure-ftpd-1.0.52-1.el10_0.aarch64.rpm;name=aarch64_pure-ftpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pure-ftpd}"
SRC_URI[aarch64_pure-ftpd.sha256sum] = "f92310a837febbe1c5004dc2a2d6fb0e7b3020b51ccb22ba152743fe0dd2da41"

URI_aarch64_pure-ftpd-selinux = "${EPEL_MIRROR}/aarch64/Packages/p/pure-ftpd-selinux-1.0.52-1.el10_0.aarch64.rpm;name=aarch64_pure-ftpd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_pure-ftpd-selinux}"
SRC_URI[aarch64_pure-ftpd-selinux.sha256sum] = "22912295e6f71c1be22bc48577eef1999fefc0ac913c42ddcaf613c7c8ebf78c"

RDEPENDS:pure-ftpd = " \
 bash \
 glibc \
 libcap \
 libpq \
 libxcrypt \
 logrotate \
 mariadb-connector-c \
 openldap \
 openssl-libs \
 pam-libs \
 sscg \
 systemd \
 "
RDEPENDS:pure-ftpd-selinux = " \
 bash \
 policycoreutils \
 pure-ftpd \
 "
