# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcapi"
PV = "1.5.0"
PR = "3.el10"
PACKAGES = " \
 libkcapi \
 libkcapi-hasher \
 libkcapi-hmaccalc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libkcapi-1.5.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8db4b9d9cb2f52a5d1a7bd1d3cee72399ebdec7979c174e8c7c2a6d66db8c90"

URI_x86_64_v2_libkcapi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkcapi-1.5.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libkcapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcapi}"
SRC_URI[x86_64_v2_libkcapi.sha256sum] = "2bd4305a36ea8879935756b37ba71add69b4b2bc204514beafa94a7408dee263"

URI_x86_64_v2_libkcapi-hasher = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkcapi-hasher-1.5.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libkcapi-hasher;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcapi-hasher}"
SRC_URI[x86_64_v2_libkcapi-hasher.sha256sum] = "9df87a347b79eb056a4f1f18ab8b0e49477b3acf6760e2453c104fd414cbabfd"

URI_x86_64_v2_libkcapi-hmaccalc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkcapi-hmaccalc-1.5.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libkcapi-hmaccalc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcapi-hmaccalc}"
SRC_URI[x86_64_v2_libkcapi-hmaccalc.sha256sum] = "53009a44d6274f2790c3445e142df7b2506b56c84c57ad07d799b40a32d4a84f"

URI_aarch64_libkcapi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkcapi-1.5.0-3.el10.aarch64.rpm;name=aarch64_libkcapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcapi}"
SRC_URI[aarch64_libkcapi.sha256sum] = "8d4b4524aa5bbdbbe8c665146732f3d0b798baf85850c08bd01185d5d6c06a4d"

URI_aarch64_libkcapi-hasher = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkcapi-hasher-1.5.0-3.el10.aarch64.rpm;name=aarch64_libkcapi-hasher;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcapi-hasher}"
SRC_URI[aarch64_libkcapi-hasher.sha256sum] = "b03b34d07b2b58c847b7a236627228bf88d11c8a07c7508083591e5e254cf94c"

URI_aarch64_libkcapi-hmaccalc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkcapi-hmaccalc-1.5.0-3.el10.aarch64.rpm;name=aarch64_libkcapi-hmaccalc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcapi-hmaccalc}"
SRC_URI[aarch64_libkcapi-hmaccalc.sha256sum] = "f265f4a320c0c7a86b691437b238646431ef864daf25c276c1d9101bae0894b3"

RDEPENDS:libkcapi = " \
 glibc \
 systemd \
 "
RDEPENDS:libkcapi-hasher = " \
 glibc \
 libkcapi \
 "
RDEPENDS:libkcapi-hmaccalc = " \
 libkcapi-hasher \
 "
