# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-qtl"
PV = "1.74"
PR = "7.el10_2"
PACKAGES = " \
 R-qtl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-qtl-1.74-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3885620a28259ccc10b493987677e20db1e5f67d52091c9a59614a17bb0aae6"

URI_x86_64_v2_R-qtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-qtl-1.74-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-qtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-qtl}"
SRC_URI[x86_64_v2_R-qtl.sha256sum] = "1ad106940ea9f722183aabc474e1e5d419af1f79cab40c72da06b6f51d25acca"

URI_aarch64_R-qtl = "${EPEL_MIRROR}/aarch64/Packages/r/R-qtl-1.74-7.el10_2.aarch64.rpm;name=aarch64_R-qtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-qtl}"
SRC_URI[aarch64_R-qtl.sha256sum] = "a69f99511003abe35d316a8755e8354bc49b068666b3c7d78007b9fef0d24a6b"

RDEPENDS:R-qtl = " \
 R-core \
 bash \
 flexiblas-netlib \
 glibc \
 ruby \
 "
