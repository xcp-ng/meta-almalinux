# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdal-epel"
PV = "3.10.3"
PR = "7.el10_2"
PACKAGES = " \
 gdal-java \
 gdal-javadoc \
 gdal-python-tools \
 python3-gdal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gdal-epel-3.10.3-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b50004cdbb80c8a007529752d3281b887542127f71123936fa19dc029fb5f01"

URI_x86_64_v2_gdal-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal-java-3.10.3-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-java}"
SRC_URI[x86_64_v2_gdal-java.sha256sum] = "6feada2543b1f02c086ebdc96af73fdce2cc0daec82f977e5adbf3e803b365d5"

URI_x86_64_v2_gdal-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal-javadoc-3.10.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gdal-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-javadoc}"
SRC_URI[x86_64_v2_gdal-javadoc.sha256sum] = "bb61466a07ded560380c84de9f6a5d638f2ea7704c75b89224381f9a5aa7eab4"

URI_x86_64_v2_gdal-python-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdal-python-tools-3.10.3-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdal-python-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdal-python-tools}"
SRC_URI[x86_64_v2_gdal-python-tools.sha256sum] = "e7d57c418022f2e9101de89ce8176ea3b7932c6d0cfb30106ffabe2fda272dcd"

URI_x86_64_v2_python3-gdal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gdal-3.10.3-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-gdal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gdal}"
SRC_URI[x86_64_v2_python3-gdal.sha256sum] = "b8db9e116865238ab22b59746343dbba1ed44e2ec7296e78b0cfda6e7f921d27"

URI_aarch64_gdal-java = "${EPEL_MIRROR}/aarch64/Packages/g/gdal-java-3.10.3-7.el10_2.aarch64.rpm;name=aarch64_gdal-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-java}"
SRC_URI[aarch64_gdal-java.sha256sum] = "18ef11e94177537857e4168d2aed61618e2332a6e77f3874709605639fbbf2e7"

URI_aarch64_gdal-javadoc = "${EPEL_MIRROR}/aarch64/Packages/g/gdal-javadoc-3.10.3-7.el10_2.noarch.rpm;name=aarch64_gdal-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-javadoc}"
SRC_URI[aarch64_gdal-javadoc.sha256sum] = "4b0b8dee7546bc1e6cfb711044b1946678f53e462da57c2d118281ed72e230ca"

URI_aarch64_gdal-python-tools = "${EPEL_MIRROR}/aarch64/Packages/g/gdal-python-tools-3.10.3-7.el10_2.aarch64.rpm;name=aarch64_gdal-python-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdal-python-tools}"
SRC_URI[aarch64_gdal-python-tools.sha256sum] = "f535966776d7c8bea39c25138720218ae923c9875eb1b2d9a7c44f230a4ee7f7"

URI_aarch64_python3-gdal = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gdal-3.10.3-7.el10_2.aarch64.rpm;name=aarch64_python3-gdal;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gdal}"
SRC_URI[aarch64_python3-gdal.sha256sum] = "ed427877963cd556e1df1081ac59f00ec97f1b478f7d1e8ed49ea6cff1e7d970"

RDEPENDS:gdal-java = " \
 gdal-libs \
 giflib \
 glibc \
 javapackages-tools \
 liblerc \
 libpng \
 libpq \
 libstdc++ \
 mariadb-connector-c \
 openjpeg2 \
 "
RDEPENDS:gdal-javadoc = " \
 javapackages-tools \
 "
RDEPENDS:gdal-python-tools = " \
 python3 \
 python3-gdal \
 "
RDEPENDS:python3-gdal = " \
 gdal-libs \
 giflib \
 glibc \
 libgcc \
 liblerc \
 libpng \
 libpq \
 libstdc++ \
 mariadb-connector-c \
 openjpeg2 \
 python3 \
 python3-numpy \
 "
