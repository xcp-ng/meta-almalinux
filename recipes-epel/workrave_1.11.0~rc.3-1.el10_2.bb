# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "workrave"
PV = "1.11.0~rc.3"
PR = "1.el10_2"
PACKAGES = " \
 workrave \
 workrave-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/workrave-1.11.0~rc.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5be9721bf31f65df66783723ec6b047a19cfbb840cf437424ef7f3972c7b797e"

URI_x86_64_v2_workrave = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/workrave-1.11.0~rc.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_workrave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_workrave}"
SRC_URI[x86_64_v2_workrave.sha256sum] = "db7a6f8214caead5eeb356adc40b9daf8fb1c6fa6d7e3ad26b822a160eda65fe"

URI_x86_64_v2_workrave-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/workrave-common-1.11.0~rc.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_workrave-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_workrave-common}"
SRC_URI[x86_64_v2_workrave-common.sha256sum] = "dc5a4205a792ee5ed9b4b4326a527dfef8e0b9992b73b8eb710826715925907b"

URI_aarch64_workrave = "${EPEL_MIRROR}/aarch64/Packages/w/workrave-1.11.0~rc.3-1.el10_2.aarch64.rpm;name=aarch64_workrave;unpack=0"
SRC_URI:append = " ${URI_aarch64_workrave}"
SRC_URI[aarch64_workrave.sha256sum] = "3eee6cd0c965a679fdde28ab1f02f57c6f95fa1a21401014fea46c9e0a6bb538"

URI_aarch64_workrave-common = "${EPEL_MIRROR}/aarch64/Packages/w/workrave-common-1.11.0~rc.3-1.el10_2.noarch.rpm;name=aarch64_workrave-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_workrave-common}"
SRC_URI[aarch64_workrave-common.sha256sum] = "c1612c7f9c589aa0066238fb11b7e41ae578170daab8917cc1e465336e2f1781"

RDEPENDS:workrave = " \
 atkmm \
 cairo \
 cairomm \
 dbus-common \
 fmt \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 glibmm2.4 \
 gstreamer1 \
 gtk3 \
 gtkmm3.0 \
 hicolor-icon-theme \
 libX11 \
 libXScrnSaver \
 libXtst \
 libayatana-appindicator-gtk3 \
 libdbusmenu \
 libgcc \
 libsigc++20 \
 libstdc++ \
 libwayland-client \
 pango \
 pangomm \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 spdlog \
 workrave-common \
 "
RDEPENDS:workrave-common = " \
 "
