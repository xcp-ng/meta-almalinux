# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wlroots"
PV = "0.18.2"
PR = "1.el10_0"
PACKAGES = " \
 wlroots \
 wlroots-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wlroots-0.18.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23e1c15fcac65a8eb0b65858cc3c3cbe29eaa2e3f069ae1c6e8ba479a7e001f2"

URI_x86_64_v2_wlroots = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlroots-0.18.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlroots;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wlroots}"
SRC_URI[x86_64_v2_wlroots.sha256sum] = "87b2e0efa8bbb7d40e5edb1e1c8e44a23da325e42913497b626c4d76a0d47e10"

URI_x86_64_v2_wlroots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wlroots-devel-0.18.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wlroots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wlroots-devel}"
SRC_URI[x86_64_v2_wlroots-devel.sha256sum] = "df17074f3daca661d5d0148a5bf5bc6a16b85e0fadbefb8ccd44275d0eedbf5a"

URI_aarch64_wlroots = "${EPEL_MIRROR}/aarch64/Packages/w/wlroots-0.18.2-1.el10_0.aarch64.rpm;name=aarch64_wlroots;unpack=0"
SRC_URI:append = " ${URI_aarch64_wlroots}"
SRC_URI[aarch64_wlroots.sha256sum] = "66a8d9ec98c31e0d3504718e4edc79cec6903a93c1ce19a8dfb7381bbd8872ca"

URI_aarch64_wlroots-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wlroots-devel-0.18.2-1.el10_0.aarch64.rpm;name=aarch64_wlroots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wlroots-devel}"
SRC_URI[aarch64_wlroots-devel.sha256sum] = "216be734be39db2c4adc5fdfabe41a92470ce4ebbf3f8a4e8485bc342546b773"

RDEPENDS:wlroots = " \
 glibc \
 lcms2 \
 libdisplay-info \
 libdrm \
 libglvnd-egl \
 libglvnd-gles \
 libinput \
 libliftoff \
 libseat \
 libwayland-client \
 libwayland-server \
 libxcb \
 libxkbcommon \
 mesa-libgbm \
 pixman \
 systemd-libs \
 vulkan-loader \
 xcb-util-errors \
 xcb-util-renderutil \
 xcb-util-wm \
 "
RDEPENDS:wlroots-devel = " \
 lcms2-devel \
 libdisplay-info-devel \
 libdrm-devel \
 libglvnd-devel \
 libinput-devel \
 libliftoff-devel \
 libseat-devel \
 libxcb-devel \
 libxkbcommon-devel \
 mesa-libgbm-devel \
 pixman-devel \
 pkgconf-pkg-config \
 systemd-devel \
 vulkan-loader-devel \
 wayland-devel \
 wlroots \
 xcb-util-errors-devel \
 xcb-util-renderutil-devel \
 xcb-util-wm-devel \
 "
