# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros0.26"
PV = "0.26.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-pyo3-macros0.26+default-devel \
 rust-pyo3-macros0.26+experimental-async-devel \
 rust-pyo3-macros0.26+experimental-inspect-devel \
 rust-pyo3-macros0.26+multiple-pymethods-devel \
 rust-pyo3-macros0.26-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros0.26-0.26.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20a8eb045dcf6174ee2aa982a54d9682b1b13a9c84901da62f1ecabbdfa87f69"

URI_x86_64_v2_rust-pyo3-macros0.26+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.26+default-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.26+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.26+default-devel.sha256sum] = "4a0b2ee08dd865f12546881110531f68f86d5e9d1e634362e6c06f04414fedf4"

URI_x86_64_v2_rust-pyo3-macros0.26+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.26+experimental-async-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.26+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.26+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.26+experimental-async-devel.sha256sum] = "291035e3aa87a9a5dded83d36d31f4d7a9aa87525ac0806e8776d993333152eb"

URI_x86_64_v2_rust-pyo3-macros0.26+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.26+experimental-inspect-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.26+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.26+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.26+experimental-inspect-devel.sha256sum] = "95905dcf92c84807d61365c324d1241f1f18b8424c6e2b55dd6ffdbe83575548"

URI_x86_64_v2_rust-pyo3-macros0.26+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.26+multiple-pymethods-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.26+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.26+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.26+multiple-pymethods-devel.sha256sum] = "c16388513253374b4619938cbaadd544ad3cb9f9ffd064ea3c2d348f176fb43a"

URI_x86_64_v2_rust-pyo3-macros0.26-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros0.26-devel-0.26.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros0.26-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros0.26-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros0.26-devel.sha256sum] = "c7141fb175408ce1e490e236e054f134cc7c3f47b9d49bf34af731519ac3bce1"

URI_aarch64_rust-pyo3-macros0.26+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.26+default-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.26+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.26+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.26+default-devel.sha256sum] = "4f878ff2b53757c3891a953c1cb854ad31c10b419d5b89f24def0b47cab49eb9"

URI_aarch64_rust-pyo3-macros0.26+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.26+experimental-async-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.26+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.26+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.26+experimental-async-devel.sha256sum] = "0554a0e180cc533d728df05fc3ad7759be601541aef27a2a292ed7797233b8f4"

URI_aarch64_rust-pyo3-macros0.26+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.26+experimental-inspect-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.26+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.26+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.26+experimental-inspect-devel.sha256sum] = "5f25fafa0bb45ba81a979cbf9e31b2004b52a8dc244f5b8e37dd3b777bd18979"

URI_aarch64_rust-pyo3-macros0.26+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.26+multiple-pymethods-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.26+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.26+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.26+multiple-pymethods-devel.sha256sum] = "29d04de4a6aabb11e96877829c2f22c0ab2890438c0a389a45d275ff13538e24"

URI_aarch64_rust-pyo3-macros0.26-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros0.26-devel-0.26.0-1.el10_2.noarch.rpm;name=aarch64_rust-pyo3-macros0.26-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros0.26-devel}"
SRC_URI[aarch64_rust-pyo3-macros0.26-devel.sha256sum] = "ac7689e6d9649f572c89ac538b526e826482281d83748d6872548d69ec80f640"

RDEPENDS:rust-pyo3-macros0.26+default-devel = " \
 cargo \
 rust-pyo3-macros0.26-devel \
 "
RDEPENDS:rust-pyo3-macros0.26+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.26+experimental-async-devel \
 rust-pyo3-macros0.26-devel \
 "
RDEPENDS:rust-pyo3-macros0.26+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-macros-backend0.26+experimental-inspect-devel \
 rust-pyo3-macros0.26-devel \
 "
RDEPENDS:rust-pyo3-macros0.26+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3-macros0.26-devel \
 "
RDEPENDS:rust-pyo3-macros0.26-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-pyo3-macros-backend0.26+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 "
