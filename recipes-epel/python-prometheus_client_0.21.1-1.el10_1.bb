# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-prometheus_client"
PV = "0.21.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-prometheus_client \
 python3-prometheus_client+twisted \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-prometheus_client-0.21.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0f1eb541700c1aaa00b003f885dc4f7acf19faf998169b106e752de6c0773af"

URI_x86_64_v2_python3-prometheus_client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-prometheus_client-0.21.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-prometheus_client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-prometheus_client}"
SRC_URI[x86_64_v2_python3-prometheus_client.sha256sum] = "6a1a518dbf1ac440c3d3c4ed22838fae55614d98db63947b696a1bf78b6964d2"

URI_x86_64_v2_python3-prometheus_client+twisted = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-prometheus_client+twisted-0.21.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-prometheus_client+twisted;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-prometheus_client+twisted}"
SRC_URI[x86_64_v2_python3-prometheus_client+twisted.sha256sum] = "2734053f656e068d3a2f833ef283a846afbadb3bd687d753e02286acad969b65"

URI_aarch64_python3-prometheus_client = "${EPEL_MIRROR}/aarch64/Packages/p/python3-prometheus_client-0.21.1-1.el10_1.noarch.rpm;name=aarch64_python3-prometheus_client;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-prometheus_client}"
SRC_URI[aarch64_python3-prometheus_client.sha256sum] = "b4e0c73a5db3d0654773015d2bc008a0066cbf52f4aa07464cca6a039ac12856"

URI_aarch64_python3-prometheus_client+twisted = "${EPEL_MIRROR}/aarch64/Packages/p/python3-prometheus_client+twisted-0.21.1-1.el10_1.noarch.rpm;name=aarch64_python3-prometheus_client+twisted;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-prometheus_client+twisted}"
SRC_URI[aarch64_python3-prometheus_client+twisted.sha256sum] = "c35b9216c3da7034e44a38a7705a253a7f21e9125651fea2b6abf58607dafb04"

RDEPENDS:python3-prometheus_client = " \
 python3 \
 python3-decorator \
 "
RDEPENDS:python3-prometheus_client+twisted = " \
 python3 \
 python3-prometheus_client \
 python3-twisted \
 "
