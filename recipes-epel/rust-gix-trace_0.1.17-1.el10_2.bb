# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-trace"
PV = "0.1.17"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-trace+default-devel \
 rust-gix-trace+document-features-devel \
 rust-gix-trace+tracing-detail-devel \
 rust-gix-trace+tracing-devel \
 rust-gix-trace-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-trace-0.1.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed089a9fc05ae562bfca077e859bd46f9aee6d04bf5fd35af1f191da06aeac3d"

URI_x86_64_v2_rust-gix-trace+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+default-devel-0.1.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+default-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+default-devel.sha256sum] = "1b2b7957c6c53becf95618f744e09cf4cca4a3d8fc6cd5fbb33d0a3ecd09afcb"

URI_x86_64_v2_rust-gix-trace+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+document-features-devel-0.1.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+document-features-devel.sha256sum] = "240d8fc72476726cb7aff64c4ee4c402e21c004be00f8aee889289359235c22b"

URI_x86_64_v2_rust-gix-trace+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+tracing-detail-devel-0.1.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+tracing-detail-devel.sha256sum] = "93436611a9f23598ea7bd09037f5e8877b9c37d3d5909a6d3c8bc1a520331e1d"

URI_x86_64_v2_rust-gix-trace+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+tracing-devel-0.1.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+tracing-devel.sha256sum] = "960d8e8b08e92722d05dfdece7f1c9c3e7e5d39a5555f3809fab7dcfa8efa43e"

URI_x86_64_v2_rust-gix-trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace-devel-0.1.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace-devel}"
SRC_URI[x86_64_v2_rust-gix-trace-devel.sha256sum] = "0a230aa5c7e84b9150bf2c3ae43186bb730a4d1eeb1a3dd084217dfc9a615be2"

URI_aarch64_rust-gix-trace+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+default-devel-0.1.17-1.el10_2.noarch.rpm;name=aarch64_rust-gix-trace+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+default-devel}"
SRC_URI[aarch64_rust-gix-trace+default-devel.sha256sum] = "180614ee5a37e945f1199cbd50c5665c0f347918fa60385ff03cb7d1e94692e6"

URI_aarch64_rust-gix-trace+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+document-features-devel-0.1.17-1.el10_2.noarch.rpm;name=aarch64_rust-gix-trace+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+document-features-devel}"
SRC_URI[aarch64_rust-gix-trace+document-features-devel.sha256sum] = "bc516014e2a612207257674832ef4f8475b614e78dc5b5ebd4c771d5c79368d4"

URI_aarch64_rust-gix-trace+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+tracing-detail-devel-0.1.17-1.el10_2.noarch.rpm;name=aarch64_rust-gix-trace+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix-trace+tracing-detail-devel.sha256sum] = "07807ad4022bf80a6cc805ee7b1ca0f6b1200a2e03c6fbbfc7323c66a5a9cb62"

URI_aarch64_rust-gix-trace+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+tracing-devel-0.1.17-1.el10_2.noarch.rpm;name=aarch64_rust-gix-trace+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+tracing-devel}"
SRC_URI[aarch64_rust-gix-trace+tracing-devel.sha256sum] = "af5b3592a25173a4452eaf49bbb60f07007acaca24bbf7a29d4eb939bd7dfe48"

URI_aarch64_rust-gix-trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace-devel-0.1.17-1.el10_2.noarch.rpm;name=aarch64_rust-gix-trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace-devel}"
SRC_URI[aarch64_rust-gix-trace-devel.sha256sum] = "1713d6b3282e8ca8731d1954815e61db913d87a71124285bc6c324e4d0c03d21"

RDEPENDS:rust-gix-trace+default-devel = " \
 cargo \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+tracing-detail-devel = " \
 cargo \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+tracing-devel = " \
 cargo \
 rust-gix-trace-devel \
 rust-tracing-core+default-devel \
 "
RDEPENDS:rust-gix-trace-devel = " \
 cargo \
 rust \
 "
