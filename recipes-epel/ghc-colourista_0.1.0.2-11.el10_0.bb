# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-colourista"
PV = "0.1.0.2"
PR = "11.el10_0"
PACKAGES = " \
 ghc-colourista \
 ghc-colourista-devel \
 ghc-colourista-doc \
 ghc-colourista-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-colourista-0.1.0.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47726e09cfd32f5135055d058a9114802aa09e676b2101d5d4ce0de77b1e9264"

URI_x86_64_v2_ghc-colourista = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-colourista-0.1.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-colourista;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-colourista}"
SRC_URI[x86_64_v2_ghc-colourista.sha256sum] = "233537885e15c168a9d88b31a35e9c897fda444f5c90871183f0d59b39c48848"

URI_x86_64_v2_ghc-colourista-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-colourista-devel-0.1.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-colourista-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-colourista-devel}"
SRC_URI[x86_64_v2_ghc-colourista-devel.sha256sum] = "7697a92b745f04cc9b0f1dd5955f182f3d7dc5c1e800df0a8c79d39ecf54d02d"

URI_x86_64_v2_ghc-colourista-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-colourista-doc-0.1.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-colourista-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-colourista-doc}"
SRC_URI[x86_64_v2_ghc-colourista-doc.sha256sum] = "d3ac5a7c95f5ac3b5f917dfb5ad22ff984e813d279090f0a6877a82f2a81cdcb"

URI_x86_64_v2_ghc-colourista-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-colourista-prof-0.1.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-colourista-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-colourista-prof}"
SRC_URI[x86_64_v2_ghc-colourista-prof.sha256sum] = "8b75ff17ff54de9ac73faaeec22e323446582b65a5a8b19c8a55caf23239ef6a"

URI_aarch64_ghc-colourista = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-colourista-0.1.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-colourista;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-colourista}"
SRC_URI[aarch64_ghc-colourista.sha256sum] = "2e90eaf1a478920f33558914764666f091effd4b6105c674acff5b81af5f86fc"

URI_aarch64_ghc-colourista-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-colourista-devel-0.1.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-colourista-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-colourista-devel}"
SRC_URI[aarch64_ghc-colourista-devel.sha256sum] = "9b309dd8dd30c31b7aad44f976a8854460a85aa33c95edfaa189e53d55279322"

URI_aarch64_ghc-colourista-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-colourista-doc-0.1.0.2-11.el10_0.noarch.rpm;name=aarch64_ghc-colourista-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-colourista-doc}"
SRC_URI[aarch64_ghc-colourista-doc.sha256sum] = "0ed3cdf140915a76603380f63dd47bbc0afb8c5fb068b71c6c409897cc9b4ecc"

URI_aarch64_ghc-colourista-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-colourista-prof-0.1.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-colourista-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-colourista-prof}"
SRC_URI[aarch64_ghc-colourista-prof.sha256sum] = "f0a91e6e5dfdd1ad1cd6dc8ece7dca7efeba941d133d23d4128bfe8cf165db7e"

RDEPENDS:ghc-colourista = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-colourista-devel = " \
 ghc-ansi-terminal-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-colourista \
 ghc-compiler \
 ghc-text-devel \
 "
RDEPENDS:ghc-colourista-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-colourista-prof = " \
 ghc-ansi-terminal-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-colourista-devel \
 ghc-text-prof \
 "
