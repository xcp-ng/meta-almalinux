# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sg3_utils"
PV = "1.48"
PR = "11.el10"
PACKAGES = " \
 sg3_utils \
 sg3_utils-devel \
 sg3_utils-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sg3_utils-1.48-11.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "118ec7fa38670a54f8ed463f816684f1eb8891d514b77fe6d99306b340886530"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sg3_utils-1.48-11.el10.x86_64_v2.rpm;name=x86_64_v2_sg3_utils;unpack=0"
SRC_URI[x86_64_v2_sg3_utils.sha256sum] = "920e4df767d9462f35f538a9223a9290619c125e619d40767f90e67757d0497e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sg3_utils-devel-1.48-11.el10.x86_64_v2.rpm;name=x86_64_v2_sg3_utils-devel;unpack=0"
SRC_URI[x86_64_v2_sg3_utils-devel.sha256sum] = "70202ccebe12b444b108a808f994cb7f93b79bc46462651c78e89af78ac7ea32"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sg3_utils-libs-1.48-11.el10.x86_64_v2.rpm;name=x86_64_v2_sg3_utils-libs;unpack=0"
SRC_URI[x86_64_v2_sg3_utils-libs.sha256sum] = "37fabab3fa4a156bc4b4d9b5279e13fef1ff53df79540a5ab8f85a6ea0bb67b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sg3_utils-1.48-11.el10.aarch64.rpm;name=aarch64_sg3_utils;unpack=0"
SRC_URI[aarch64_sg3_utils.sha256sum] = "6b09b997e672d07356ecbf6963b30959e8edbb6cb3f649a9522335c0a207c026"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sg3_utils-devel-1.48-11.el10.aarch64.rpm;name=aarch64_sg3_utils-devel;unpack=0"
SRC_URI[aarch64_sg3_utils-devel.sha256sum] = "5007a3667f62c2977d8ecb0d6352fba37344b4720cab12c99b9c38847c42170b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sg3_utils-libs-1.48-11.el10.aarch64.rpm;name=aarch64_sg3_utils-libs;unpack=0"
SRC_URI[aarch64_sg3_utils-libs.sha256sum] = "d8d16497b843cf6093eb31c6e462c686cfed665de4e2ed023186dcb8e3808f5b"

RDEPENDS:sg3_utils = " \
 bash \
 glibc \
 libgcc \
 sg3_utils-libs \
 "
RDEPENDS:sg3_utils-devel = " \
 sg3_utils-libs \
 "
RDEPENDS:sg3_utils-libs = " \
 glibc \
 "
