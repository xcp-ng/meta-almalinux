# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aho-corasick"
PV = "1.1.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-aho-corasick+default-devel \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aho-corasick-1.1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa857ba9aab44c68bd8bc9d5fb579d6f72b56803e10814d6120185b2dbb16882"

URI_x86_64_v2_rust-aho-corasick+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+default-devel-1.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+default-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+default-devel.sha256sum] = "0b9563e1cd7f35c306890e4446ca16afb1cf1c2f20ad9a57e6965275165f1a47"

URI_x86_64_v2_rust-aho-corasick+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+logging-devel-1.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+logging-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+logging-devel.sha256sum] = "71a3b66df64ee2ab088a3a9f1e5e855141cb4c9733fb66cd9dd6da010c37035e"

URI_x86_64_v2_rust-aho-corasick+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+perf-literal-devel-1.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+perf-literal-devel.sha256sum] = "4a8ea4141fe603e66d330c3b81ff3fe0abdf6c8d7a0200a8c8db8443b1a83a3f"

URI_x86_64_v2_rust-aho-corasick+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+std-devel-1.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+std-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+std-devel.sha256sum] = "e785914c4be0514bad3c5192665b6c288c251c49456433cdf768025733ef68e3"

URI_x86_64_v2_rust-aho-corasick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick-devel-1.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick-devel.sha256sum] = "9d4217d633c6a16aa5df2a9f1e1e6e6682f065622b8a4ab2342008f7d42c9bbc"

URI_aarch64_rust-aho-corasick+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+default-devel-1.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-aho-corasick+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+default-devel}"
SRC_URI[aarch64_rust-aho-corasick+default-devel.sha256sum] = "db6a30435ed40634124de132317e80a9f83a8f298e598f0ba6c55be35b918035"

URI_aarch64_rust-aho-corasick+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+logging-devel-1.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-aho-corasick+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+logging-devel}"
SRC_URI[aarch64_rust-aho-corasick+logging-devel.sha256sum] = "95269168e703e31cdfec9bcdb2731210be9040aab4c4b707e8fe0b8f70ed2245"

URI_aarch64_rust-aho-corasick+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+perf-literal-devel-1.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-aho-corasick+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+perf-literal-devel}"
SRC_URI[aarch64_rust-aho-corasick+perf-literal-devel.sha256sum] = "379735515767749241a4a1f651c71a17023ebd05bb577b46f462b6bb8a182847"

URI_aarch64_rust-aho-corasick+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+std-devel-1.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-aho-corasick+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+std-devel}"
SRC_URI[aarch64_rust-aho-corasick+std-devel.sha256sum] = "c7984a7435c2253681fa3c2b60cdc3d0cfbd5f90da385622ceb63957abac7fdb"

URI_aarch64_rust-aho-corasick-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick-devel-1.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-aho-corasick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick-devel}"
SRC_URI[aarch64_rust-aho-corasick-devel.sha256sum] = "060d1a4c00dbdf4832dc9293d53ccc33a2579e0e8b94737213967247f6196fe5"

RDEPENDS:rust-aho-corasick+default-devel = " \
 cargo \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 "
RDEPENDS:rust-aho-corasick+logging-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-aho-corasick+perf-literal-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-aho-corasick+std-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-aho-corasick-devel = " \
 cargo \
 rust \
 "
