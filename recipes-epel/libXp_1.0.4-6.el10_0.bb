# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXp"
PV = "1.0.4"
PR = "6.el10_0"
PACKAGES = " \
 libXp \
 libXp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libXp-1.0.4-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8be157246f91bd83786d06700300ef365581a8c9ccc084b4bbe97d47fee2412e"

URI_x86_64_v2_libXp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXp-1.0.4-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXp}"
SRC_URI[x86_64_v2_libXp.sha256sum] = "fa07ff65640734f5b61c3ff29d59c66476d6d44427d9c15ffa8adce3e4be38cf"

URI_x86_64_v2_libXp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXp-devel-1.0.4-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXp-devel}"
SRC_URI[x86_64_v2_libXp-devel.sha256sum] = "3a664462f7f18ca8239e329e42290ed1b81d0d65a01ea9cf70ae79e597ad69b4"

URI_aarch64_libXp = "${EPEL_MIRROR}/aarch64/Packages/l/libXp-1.0.4-6.el10_0.aarch64.rpm;name=aarch64_libXp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXp}"
SRC_URI[aarch64_libXp.sha256sum] = "5ba65c26e106c3d2d0609f2078bb0fa27e03b322564d67ef550e5f51329b783f"

URI_aarch64_libXp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXp-devel-1.0.4-6.el10_0.aarch64.rpm;name=aarch64_libXp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXp-devel}"
SRC_URI[aarch64_libXp-devel.sha256sum] = "a9f1a861938aff9a39a4556b9300e5e6df719725d75ddc16faaae5a621615105"

RDEPENDS:libXp = " \
 glibc \
 libX11 \
 libXau \
 libXext \
 "
RDEPENDS:libXp-devel = " \
 libX11-devel \
 libXau-devel \
 libXext-devel \
 libXp \
 libXp-devel \
 pkgconf-pkg-config \
 "
