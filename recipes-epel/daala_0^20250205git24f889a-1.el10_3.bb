# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "daala"
PV = "0^20250205git24f889a"
PR = "1.el10_3"
PACKAGES = " \
 daala-devel \
 daala-libs \
 daala-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/daala-0^20250205git24f889a-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "943131e7392a05d824adb40198ae658a75c8f18cfbc8db8e819958ea5278c596"

URI_x86_64_v2_daala-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-devel-0^20250205git24f889a-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-devel}"
SRC_URI[x86_64_v2_daala-devel.sha256sum] = "696776688efa4c437f33d7e1b282a0df080b39960297e4bc3e4d6800b0eeff3b"

URI_x86_64_v2_daala-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-libs-0^20250205git24f889a-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-libs}"
SRC_URI[x86_64_v2_daala-libs.sha256sum] = "8217918b4c149ae360a74659f834848c8953601fba9a85650033ef0aa47b136e"

URI_x86_64_v2_daala-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daala-tools-0^20250205git24f889a-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daala-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daala-tools}"
SRC_URI[x86_64_v2_daala-tools.sha256sum] = "6c3b46a1d747ed22785b00e7adff4947410103cb74766bff239802eb8b535187"

URI_aarch64_daala-devel = "${EPEL_MIRROR}/aarch64/Packages/d/daala-devel-0^20250205git24f889a-1.el10_3.aarch64.rpm;name=aarch64_daala-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-devel}"
SRC_URI[aarch64_daala-devel.sha256sum] = "0d5b31fbd72e4a7ccd1d5fe323b8337ff1c2ba2d04b8949c587aeb379d375e15"

URI_aarch64_daala-libs = "${EPEL_MIRROR}/aarch64/Packages/d/daala-libs-0^20250205git24f889a-1.el10_3.aarch64.rpm;name=aarch64_daala-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-libs}"
SRC_URI[aarch64_daala-libs.sha256sum] = "3a868d7586dec62327e1901f90ea3d0ead68d0f60f42668928236d3deecac953"

URI_aarch64_daala-tools = "${EPEL_MIRROR}/aarch64/Packages/d/daala-tools-0^20250205git24f889a-1.el10_3.aarch64.rpm;name=aarch64_daala-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_daala-tools}"
SRC_URI[aarch64_daala-tools.sha256sum] = "1b4c3f566e40bf889b666ba72386340f7410078675a928ba37b61963e180f641"

RDEPENDS:daala-devel = " \
 daala-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:daala-libs = " \
 glibc \
 "
RDEPENDS:daala-tools = " \
 daala-libs \
 glibc \
 libgcc \
 libgomp \
 libjpeg-turbo \
 libogg \
 libpng \
 "
