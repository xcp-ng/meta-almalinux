# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tog-pegasus"
PE = "2"
PV = "2.14.1"
PR = "78.el10"
PACKAGES = " \
 tog-pegasus \
 tog-pegasus-devel \
 tog-pegasus-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tog-pegasus-2.14.1-78.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3603fcc3445941b17fcf59016bb5b93b985cea3a23605689fb330aa719506cad"

URI_x86_64_v2_tog-pegasus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tog-pegasus-2.14.1-78.el10.x86_64_v2.rpm;name=x86_64_v2_tog-pegasus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tog-pegasus}"
SRC_URI[x86_64_v2_tog-pegasus.sha256sum] = "8fe016e0b2147ceb10f3ba502abb2b86d8d60b8617ec0fee29416972d895d24d"
RPROVIDES:tog-pegasus:append:x86_64_v2 = " virtual/cim-server"

URI_x86_64_v2_tog-pegasus-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tog-pegasus-devel-2.14.1-78.el10.x86_64_v2.rpm;name=x86_64_v2_tog-pegasus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tog-pegasus-devel}"
SRC_URI[x86_64_v2_tog-pegasus-devel.sha256sum] = "e2e779d6d0b407ee4ad8040a8c4187089c8286d161d45ef7bde547abfb42d522"

URI_x86_64_v2_tog-pegasus-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tog-pegasus-libs-2.14.1-78.el10.x86_64_v2.rpm;name=x86_64_v2_tog-pegasus-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tog-pegasus-libs}"
SRC_URI[x86_64_v2_tog-pegasus-libs.sha256sum] = "271ed420985a1175b9ec830a2c2828cf331d5aa547bf3519c8b9d55b06bf4681"

URI_aarch64_tog-pegasus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tog-pegasus-2.14.1-78.el10.aarch64.rpm;name=aarch64_tog-pegasus;unpack=0"
SRC_URI:append = " ${URI_aarch64_tog-pegasus}"
SRC_URI[aarch64_tog-pegasus.sha256sum] = "9aee3f7282a576c320830dea86dd6a5d702c84cb1989e776743ad159b7122ef1"
RPROVIDES:tog-pegasus:append:aarch64 = " virtual/cim-server"

URI_aarch64_tog-pegasus-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tog-pegasus-devel-2.14.1-78.el10.aarch64.rpm;name=aarch64_tog-pegasus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tog-pegasus-devel}"
SRC_URI[aarch64_tog-pegasus-devel.sha256sum] = "e30a4e5654ccac2309a268d5a08c72b7c4cf28f94e55c812b4aa75a65a11a227"

URI_aarch64_tog-pegasus-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tog-pegasus-libs-2.14.1-78.el10.aarch64.rpm;name=aarch64_tog-pegasus-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_tog-pegasus-libs}"
SRC_URI[aarch64_tog-pegasus-libs.sha256sum] = "bcc51ba57e90e099f84cc92640ed6a7aabc795023fdea46512ac34c334523621"

RDEPENDS:tog-pegasus = " \
 bash \
 ca-certificates \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 net-snmp-libs \
 openssl \
 policycoreutils \
 tog-pegasus-libs \
 "
RDEPENDS:tog-pegasus-devel = " \
 bash \
 tog-pegasus \
 "
RDEPENDS:tog-pegasus-libs = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 net-snmp-libs \
 openslp \
 openssl-libs \
 pam-libs \
 shadow-utils \
 "
