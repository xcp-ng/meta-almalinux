# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcab"
PV = "1.6"
PR = "7.el10"
PACKAGES = " \
 libgcab1 \
 libgcab1-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/gcab-1.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "966602a4aeb2b2e837a7d8476239ab05d6b4b0a706bda13cbb24927a74e7b6c7"

URI_x86_64_v2_libgcab1 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libgcab1-1.6-7.el10.x86_64_v2.rpm;name=x86_64_v2_libgcab1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcab1}"
SRC_URI[x86_64_v2_libgcab1.sha256sum] = "e299c703082959203c738e3ebd1ad96549b4bc4e96afaaf123b5c90d09abede6"

URI_x86_64_v2_libgcab1-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgcab1-devel-1.6-7.el10.x86_64_v2.rpm;name=x86_64_v2_libgcab1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgcab1-devel}"
SRC_URI[x86_64_v2_libgcab1-devel.sha256sum] = "1dd8a65b29a4316afc91cbae80695ab786357008bf8b8a563d4a7ac5d988fe07"

URI_aarch64_libgcab1 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libgcab1-1.6-7.el10.aarch64.rpm;name=aarch64_libgcab1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcab1}"
SRC_URI[aarch64_libgcab1.sha256sum] = "ffd8f27becb7c34237d75aa07b216a698f638545dd3acd956f09ba5cb8414c22"

URI_aarch64_libgcab1-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgcab1-devel-1.6-7.el10.aarch64.rpm;name=aarch64_libgcab1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgcab1-devel}"
SRC_URI[aarch64_libgcab1-devel.sha256sum] = "12727b28b0029ccf71bf497b04cf66abd1ad5239e1e2462da3ecd5326ff07681"

RDEPENDS:libgcab1 = " \
 glib2 \
 glibc \
 libgcc \
 zlib-ng-compat \
 "
RDEPENDS:libgcab1-devel = " \
 glib2-devel \
 libgcab1 \
 pkgconf-pkg-config \
 "
