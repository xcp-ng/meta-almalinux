# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-InstallPaths"
PV = "0.014"
PR = "1.el10_0"
PACKAGES = " \
 perl-ExtUtils-InstallPaths \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-InstallPaths-0.014-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "effbd739349dc03d45f39cb9638aba0ed406384d6da9d964b925c72dfd3aa533"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-InstallPaths-0.014-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-InstallPaths;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-InstallPaths.sha256sum] = "96bc31e61eaecf71f02fa0b8f709465c9d5e6ca1f5a32cbb910e733d6dba82ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-InstallPaths-0.014-1.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-InstallPaths;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-InstallPaths.sha256sum] = "f414b9b7996474bfcf652e3c99762be79e0ab1ad511bbdf05b4365fd4cf30b5b"

RDEPENDS:perl-ExtUtils-InstallPaths = " \
 perl-Carp \
 perl-ExtUtils-Config \
 perl-PathTools \
 perl-libs \
 "
