# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wsproto"
PV = "1.2.0"
PR = "9.el10_0"
PACKAGES = " \
 python3-wsproto \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-wsproto-1.2.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eccbb77d7ed7ea87a6c45dfdb5bb02f94083d1999ce60100bf7f19561e08491f"

URI_x86_64_v2_python3-wsproto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wsproto-1.2.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-wsproto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wsproto}"
SRC_URI[x86_64_v2_python3-wsproto.sha256sum] = "ce40d078a62afe5657b3329ed5710f78840b2162c38a1c5a72e6ce3b6893683f"

URI_aarch64_python3-wsproto = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wsproto-1.2.0-9.el10_0.noarch.rpm;name=aarch64_python3-wsproto;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wsproto}"
SRC_URI[aarch64_python3-wsproto.sha256sum] = "dfbdfdb11458b950269e860285f14afe2ee834427e5bb86bbe3e601f79931d15"

RDEPENDS:python3-wsproto = " \
 python3 \
 python3-h11 \
 "
