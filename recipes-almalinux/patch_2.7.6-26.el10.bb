# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "patch"
PV = "2.7.6"
PR = "26.el10"
PACKAGES = " \
 patch \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/patch-2.7.6-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cebd8ef0f014e785c108483b962ea65be750f91d98d2e2941184a6774d880ec8"

URI_x86_64_v2_patch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/patch-2.7.6-26.el10.x86_64_v2.rpm;name=x86_64_v2_patch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_patch}"
SRC_URI[x86_64_v2_patch.sha256sum] = "846bc4b572b149918471edfdfe6fbd4cf0d5174f6e262ca24aee9177f62aae9e"

URI_aarch64_patch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/patch-2.7.6-26.el10.aarch64.rpm;name=aarch64_patch;unpack=0"
SRC_URI:append = " ${URI_aarch64_patch}"
SRC_URI[aarch64_patch.sha256sum] = "e2b9344530e980e72aaab80f3eab37923a32cc50128208aa11ef936a90dfd3d0"

RDEPENDS:patch = " \
 ed \
 glibc \
 libattr \
 libselinux \
 "
