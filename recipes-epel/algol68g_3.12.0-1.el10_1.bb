# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "algol68g"
PV = "3.12.0"
PR = "1.el10_1"
PACKAGES = " \
 algol68g \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/algol68g-3.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "535f57f3fced9f80400fb23a87ef5a3212d5d5f02c6fa416aee9a6374e9f30b0"

URI_x86_64_v2_algol68g = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/algol68g-3.12.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_algol68g;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_algol68g}"
SRC_URI[x86_64_v2_algol68g.sha256sum] = "7009dfdbf37705e42e272961ccb778c02a7053804d303d303e7cea1d92edda66"

URI_aarch64_algol68g = "${EPEL_MIRROR}/aarch64/Packages/a/algol68g-3.12.0-1.el10_1.aarch64.rpm;name=aarch64_algol68g;unpack=0"
SRC_URI:append = " ${URI_aarch64_algol68g}"
SRC_URI[aarch64_algol68g.sha256sum] = "f43e3f9f28534cad0db4c3dd30b2b5d2a20ea57ce14f0f14f338590e79b69bad"

RDEPENDS:algol68g:x86_64_v2 = " \
 glibc \
 gmp \
 gsl \
 libRmath \
 libpq \
 libquadmath \
 mpfr \
 ncurses-libs \
 plotutils \
"
RDEPENDS:algol68g:aarch64 = " \
 glibc \
 gsl \
 libRmath \
 libpq \
 ncurses-libs \
 plotutils \
"
