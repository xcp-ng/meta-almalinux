# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi0.23"
PV = "0.23.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-ffi0.23+abi3-devel \
 rust-pyo3-ffi0.23+abi3-py310-devel \
 rust-pyo3-ffi0.23+abi3-py311-devel \
 rust-pyo3-ffi0.23+abi3-py312-devel \
 rust-pyo3-ffi0.23+abi3-py37-devel \
 rust-pyo3-ffi0.23+abi3-py38-devel \
 rust-pyo3-ffi0.23+abi3-py39-devel \
 rust-pyo3-ffi0.23+default-devel \
 rust-pyo3-ffi0.23+extension-module-devel \
 rust-pyo3-ffi0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi0.23-0.23.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43e37ae45a0697eef92fd2ba6b49d0066ac0c59d5187e4e88ae06026a311e7b6"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-devel.sha256sum] = "1432a3001c90b42c9c947edd736c1df993fd9b3c3457817498ae63624fd39f01"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py310-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py310-devel.sha256sum] = "ccac18497c48ea62421c99675fc8c16f5f6f7425b037a8e449b7c450e45176b2"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py311-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py311-devel.sha256sum] = "6e42415c0aac1593fc096334860d503667bd093d5e25dffdc0ac47f36871caca"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py312-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py312-devel.sha256sum] = "0dfee12282e38b1038c35b33c0e23e905fa58a2a8d6bf5805ecd6c14184671be"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py37-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py37-devel.sha256sum] = "03ef0a675350977d81765fbec9ca24a35a7dcc26aee2b09522426cbf952d2bde"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py38-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py38-devel.sha256sum] = "ac3b20c89dd348392d35ae060cbcb6f7cdd443a17820c12c2ed0367caff4ab5a"

URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+abi3-py39-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+abi3-py39-devel.sha256sum] = "d1ecec81111e30799971285a0c056ebb7294bbd2e689778867287e0408a5b0fa"

URI_x86_64_v2_rust-pyo3-ffi0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+default-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+default-devel.sha256sum] = "f21dbc6e71238774c64581a0d0be6667681ef47b5ac0420b3dffe29392703549"

URI_x86_64_v2_rust-pyo3-ffi0.23+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23+extension-module-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23+extension-module-devel.sha256sum] = "affe2b03a81cbcc3b1782fb3776c6bb30e70811ff0f2c36fe8d1572c593bf1cc"

URI_x86_64_v2_rust-pyo3-ffi0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.23-devel-0.23.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.23-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.23-devel.sha256sum] = "b28ce3d5668cf2660d2e80237f42b6b44bd9c5f59d9b8269a18dee75eac5c6a9"

URI_aarch64_rust-pyo3-ffi0.23+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-devel.sha256sum] = "3052922ef5270720270395e3a041578130af0ecaf21062ec66604aa8be36ebd3"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py310-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py310-devel.sha256sum] = "922e25aed1b404fcd1ad85d0575bb419b3d887d59ba273307c6127ecfa5c4f05"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py311-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py311-devel.sha256sum] = "6461393a1f2312e80dd4ff896b4854e7ab5ad55858c498957ab0dde7c0d1c7b4"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py312-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py312-devel.sha256sum] = "271d18b830304a0a4514c55818b90e5e28b9f1f6077bcb700feefe58e216f374"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py37-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py37-devel.sha256sum] = "a66d7473fbe4fb2195993d471bb1e42c4799d7a9e1a1272f1c2e7a9c6e54085b"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py38-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py38-devel.sha256sum] = "7dc983b5db807b0fcb79be41021141c947f3043bdffbbb7fb79d2b5dbf2ea731"

URI_aarch64_rust-pyo3-ffi0.23+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+abi3-py39-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+abi3-py39-devel.sha256sum] = "159ae69d45cc0598b7f86bfcdeb345bc5cff81f3de76689a8b71b6e5b8faf2b3"

URI_aarch64_rust-pyo3-ffi0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+default-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+default-devel.sha256sum] = "12ced28afee865161d2eeea781685f81742770014ea0d3048ff3fdb2097e7c7c"

URI_aarch64_rust-pyo3-ffi0.23+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23+extension-module-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23+extension-module-devel.sha256sum] = "cef374ae3f9adb7b6692595b5ea002ccbb617c3725f96e2c562d661ad0ef786c"

URI_aarch64_rust-pyo3-ffi0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.23-devel-0.23.5-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.23-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.23-devel.sha256sum] = "f2c48b694235952878dacf2e2b576c1f6b1399aba50eb40a26a49579fc184efe"

RDEPENDS:rust-pyo3-ffi0.23+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py311-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py312-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py38-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py39-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.23+abi3-py310-devel \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+default-devel = " \
 cargo \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.23-devel \
 "
RDEPENDS:rust-pyo3-ffi0.23-devel = " \
 cargo \
 python3-devel \
 rust \
 rust-libc+default-devel \
 rust-pyo3-build-config0.23+default-devel \
 rust-pyo3-build-config0.23+resolve-config-devel \
 "
