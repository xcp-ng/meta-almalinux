# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fuzzy-matcher"
PV = "0.3.7"
PR = "12.el10_0"
PACKAGES = " \
 rust-fuzzy-matcher+compact-devel \
 rust-fuzzy-matcher+default-devel \
 rust-fuzzy-matcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fuzzy-matcher-0.3.7-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cc9580cf7f833735f6e2ec308ac9aa5521e710f74fe5adc3c203621c17579bd"

URI_x86_64_v2_rust-fuzzy-matcher+compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fuzzy-matcher+compact-devel-0.3.7-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fuzzy-matcher+compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fuzzy-matcher+compact-devel}"
SRC_URI[x86_64_v2_rust-fuzzy-matcher+compact-devel.sha256sum] = "caf04164624ae226efb3354279a9eb6a2887f572f469dde5d8aa1063a0299fdc"

URI_x86_64_v2_rust-fuzzy-matcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fuzzy-matcher+default-devel-0.3.7-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fuzzy-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fuzzy-matcher+default-devel}"
SRC_URI[x86_64_v2_rust-fuzzy-matcher+default-devel.sha256sum] = "3ad443ed44f3c5cccb291e62017dd865dfd970a8aa208221c9ba97f69dc4c908"

URI_x86_64_v2_rust-fuzzy-matcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fuzzy-matcher-devel-0.3.7-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fuzzy-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fuzzy-matcher-devel}"
SRC_URI[x86_64_v2_rust-fuzzy-matcher-devel.sha256sum] = "470b0f34dcb7e47c1edd5cb34f449a9df92dfda0e4412cc357b0ce21d6d42641"

URI_aarch64_rust-fuzzy-matcher+compact-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fuzzy-matcher+compact-devel-0.3.7-12.el10_0.noarch.rpm;name=aarch64_rust-fuzzy-matcher+compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fuzzy-matcher+compact-devel}"
SRC_URI[aarch64_rust-fuzzy-matcher+compact-devel.sha256sum] = "6417a25dcb0b7c487b6785d043276172d3fbf3cbb671f222c1f478cd1288dca8"

URI_aarch64_rust-fuzzy-matcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fuzzy-matcher+default-devel-0.3.7-12.el10_0.noarch.rpm;name=aarch64_rust-fuzzy-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fuzzy-matcher+default-devel}"
SRC_URI[aarch64_rust-fuzzy-matcher+default-devel.sha256sum] = "14bb5f305d8e2171dee1eb5085180f52a1922d22c89773bfa94f399d9fa1f9d0"

URI_aarch64_rust-fuzzy-matcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fuzzy-matcher-devel-0.3.7-12.el10_0.noarch.rpm;name=aarch64_rust-fuzzy-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fuzzy-matcher-devel}"
SRC_URI[aarch64_rust-fuzzy-matcher-devel.sha256sum] = "22c1d4601e95a0b68ac4905098f149acf1cebbb79d35fd2e121b88dfdf9f88c5"

RDEPENDS:rust-fuzzy-matcher+compact-devel = " \
 cargo \
 rust-fuzzy-matcher-devel \
 "
RDEPENDS:rust-fuzzy-matcher+default-devel = " \
 cargo \
 rust-fuzzy-matcher-devel \
 "
RDEPENDS:rust-fuzzy-matcher-devel = " \
 cargo \
 rust-thread_local+default-devel \
 "
