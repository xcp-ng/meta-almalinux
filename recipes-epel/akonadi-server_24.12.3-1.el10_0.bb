# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-server"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 akonadi-server \
 akonadi-server-devel \
 akonadi-server-doc \
 akonadi-server-mysql \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-server-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1032955ebac81559166ceb2ed3ec4786b9b772b695c769bc0c43b263a4da0d7e"

URI_x86_64_v2_akonadi-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server}"
SRC_URI[x86_64_v2_akonadi-server.sha256sum] = "b9f98a6ef947f26bfa2c122b4867c5d79ab5011c7c07cc774bfe0028b2b1b923"

URI_x86_64_v2_akonadi-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-devel}"
SRC_URI[x86_64_v2_akonadi-server-devel.sha256sum] = "3fa7a5c5fddb32cdf04b24d607492180d813685a9e1d7ab9bc43efd31b7deb6c"

URI_x86_64_v2_akonadi-server-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-server-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-doc}"
SRC_URI[x86_64_v2_akonadi-server-doc.sha256sum] = "84f776d7d5c6de9a3f74d6b740350e19bf5b212296366f5984f6dcdb4c7f3ae5"

URI_x86_64_v2_akonadi-server-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-mysql-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-mysql}"
SRC_URI[x86_64_v2_akonadi-server-mysql.sha256sum] = "6d69b42e594db3515d1a7db4c3d357349ad944fd4ad1371567d220ab835d5bb8"

URI_aarch64_akonadi-server = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server}"
SRC_URI[aarch64_akonadi-server.sha256sum] = "3e04d3c2797fa79ffbf35ef8c22c14e6012c4f9d32ec7b5acff8b3a700b523e2"

URI_aarch64_akonadi-server-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-devel}"
SRC_URI[aarch64_akonadi-server-devel.sha256sum] = "79e711dab2c376821b0aaa45e5bb48ae5bb2ae24f4cf7ec40cc94a7fa43c5860"

URI_aarch64_akonadi-server-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_akonadi-server-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-doc}"
SRC_URI[aarch64_akonadi-server-doc.sha256sum] = "aba7eb50faec7ab9361c2434ac7c9519df814af7a12ad0d07445c85185c7522a"

URI_aarch64_akonadi-server-mysql = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-mysql-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-server-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-mysql}"
SRC_URI[aarch64_akonadi-server-mysql.sha256sum] = "8fcbac99a04b0e424ff69eb9bf60d97823c34c9d10270f7cb81ae38cf5f98fcd"

RDEPENDS:akonadi-server = " \
 alternatives \
 bash \
 glibc \
 kaccounts-integration-qt6 \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libaccounts-qt6 \
 libgcc \
 libstdc++ \
 libxml2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 xz-libs \
 "
RDEPENDS:akonadi-server-devel = " \
 akonadi-server \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kcoreaddons-devel \
 kf6-kio-devel \
 kf6-kitemmodels-devel \
 kf6-kxmlgui-devel \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-server-doc = " \
 "
RDEPENDS:akonadi-server-mysql = " \
 akonadi-server \
 alternatives \
 bash \
 mariadb-server \
 qt6-qtbase-mysql \
 "
