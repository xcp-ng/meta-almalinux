# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-link-section"
PV = "0.19.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-link-section+default-devel \
 rust-link-section+proc_macro-devel \
 rust-link-section+std-devel \
 rust-link-section-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-link-section-0.19.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76cc8355cf88fe463ba6f7a8293be7867a48fe1894b0e1ff3c0b65604f9aa0ee"

URI_x86_64_v2_rust-link-section+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-section+default-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-section+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-section+default-devel}"
SRC_URI[x86_64_v2_rust-link-section+default-devel.sha256sum] = "5488eaa48e7807679a3af523d0b8ba65758f1dca09d4e764737d20ceec398821"

URI_x86_64_v2_rust-link-section+proc_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-section+proc_macro-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-section+proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-section+proc_macro-devel}"
SRC_URI[x86_64_v2_rust-link-section+proc_macro-devel.sha256sum] = "9cbb024fed9f5ec58224975ea548fbcbb25069e329eb299a458e5660bca1334f"

URI_x86_64_v2_rust-link-section+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-section+std-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-section+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-section+std-devel}"
SRC_URI[x86_64_v2_rust-link-section+std-devel.sha256sum] = "92ea2db556337d4abc196c9d4851cf37b9c1f4ff923b4159eaf4af3d316eadfe"

URI_x86_64_v2_rust-link-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-section-devel-0.19.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-section-devel}"
SRC_URI[x86_64_v2_rust-link-section-devel.sha256sum] = "1bf92714252dc56c110f5e95ebe9cdac4afe9f06b2f307e95898a0f9dea9b172"

URI_aarch64_rust-link-section+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-section+default-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-link-section+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-section+default-devel}"
SRC_URI[aarch64_rust-link-section+default-devel.sha256sum] = "47b250df735dc334233a9b44a4986d28c12890d3d1fbd9f37a75796d9e52d457"

URI_aarch64_rust-link-section+proc_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-section+proc_macro-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-link-section+proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-section+proc_macro-devel}"
SRC_URI[aarch64_rust-link-section+proc_macro-devel.sha256sum] = "39df2cf87f348875ddb5eef601fa316a9a7cfed207c6d81b9996b11ebe2dc1db"

URI_aarch64_rust-link-section+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-section+std-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-link-section+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-section+std-devel}"
SRC_URI[aarch64_rust-link-section+std-devel.sha256sum] = "51e6a0029747b0719424f147d94fa8b30c05794b755d8b66e8b1d88cee4a0ac8"

URI_aarch64_rust-link-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-section-devel-0.19.0-2.el10_3.noarch.rpm;name=aarch64_rust-link-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-section-devel}"
SRC_URI[aarch64_rust-link-section-devel.sha256sum] = "d01ae8b439e5ed28b616edca7aea2fb249724924832e746d2b2c1b5a113beac7"

RDEPENDS:rust-link-section+default-devel = " \
 cargo \
 rust-link-section+proc_macro-devel \
 rust-link-section+std-devel \
 rust-link-section-devel \
 "
RDEPENDS:rust-link-section+proc_macro-devel = " \
 cargo \
 rust-link-section-devel \
 rust-linktime-proc-macro+default-devel \
 rust-linktime-proc-macro+link_section-devel \
 "
RDEPENDS:rust-link-section+std-devel = " \
 cargo \
 rust-link-section-devel \
 "
RDEPENDS:rust-link-section-devel = " \
 cargo \
 rust \
 "
