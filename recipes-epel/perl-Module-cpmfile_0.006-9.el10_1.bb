# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-cpmfile"
PV = "0.006"
PR = "9.el10_1"
PACKAGES = " \
 perl-Module-cpmfile \
 perl-Module-cpmfile-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-cpmfile-0.006-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d03b9d3315fd760c3d1e54f79b6a6520277c51f97fab7bee41367d8c7bdc173"

URI_x86_64_v2_perl-Module-cpmfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-cpmfile-0.006-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-cpmfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-cpmfile}"
SRC_URI[x86_64_v2_perl-Module-cpmfile.sha256sum] = "5cc778ab6b92650afff6b74192bf77163a415b23db885c4641e9548b0fe84f92"

URI_x86_64_v2_perl-Module-cpmfile-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-cpmfile-tests-0.006-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-cpmfile-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-cpmfile-tests}"
SRC_URI[x86_64_v2_perl-Module-cpmfile-tests.sha256sum] = "253c00defb502ce69de658dce95d91d3c91b957892bca3e0d6f8137dccbab084"

URI_aarch64_perl-Module-cpmfile = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-cpmfile-0.006-9.el10_1.noarch.rpm;name=aarch64_perl-Module-cpmfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-cpmfile}"
SRC_URI[aarch64_perl-Module-cpmfile.sha256sum] = "96054223567329b79a547aed87bc9ef5c15aabb1c858df8d8acb3b5f3f45dbfe"

URI_aarch64_perl-Module-cpmfile-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-cpmfile-tests-0.006-9.el10_1.noarch.rpm;name=aarch64_perl-Module-cpmfile-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-cpmfile-tests}"
SRC_URI[aarch64_perl-Module-cpmfile-tests.sha256sum] = "5b378a23e81b2d62a784c7cc999a24179f50819b995e376000c5399682a321d1"

RDEPENDS:perl-Module-cpmfile = " \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-YAML-PP \
 perl-libs \
 "
RDEPENDS:perl-Module-cpmfile-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Module-CPANfile \
 perl-Module-cpmfile \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
