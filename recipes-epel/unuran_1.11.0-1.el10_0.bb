# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unuran"
PV = "1.11.0"
PR = "1.el10_0"
PACKAGES = " \
 unuran \
 unuran-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/unuran-1.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5da02acef561e9e907a21980110c46be87a7c27ff5785f9fd7034069691b5961"

URI_x86_64_v2_unuran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unuran-1.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unuran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unuran}"
SRC_URI[x86_64_v2_unuran.sha256sum] = "efec611545782ce3a5aff6773f0fe73ec523b19abd22504d21f2420ed68cfae7"

URI_x86_64_v2_unuran-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/unuran-devel-1.11.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_unuran-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unuran-devel}"
SRC_URI[x86_64_v2_unuran-devel.sha256sum] = "e1746f318c1b8bed6f51f1ffc1478c616734e588e8a1b9ae6849d8e5d7474baf"

URI_aarch64_unuran = "${EPEL_MIRROR}/aarch64/Packages/u/unuran-1.11.0-1.el10_0.aarch64.rpm;name=aarch64_unuran;unpack=0"
SRC_URI:append = " ${URI_aarch64_unuran}"
SRC_URI[aarch64_unuran.sha256sum] = "8e965a67aa1310428a285f362009d8521aab8c110e005ec7f2b2d102c4183283"

URI_aarch64_unuran-devel = "${EPEL_MIRROR}/aarch64/Packages/u/unuran-devel-1.11.0-1.el10_0.aarch64.rpm;name=aarch64_unuran-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_unuran-devel}"
SRC_URI[aarch64_unuran-devel.sha256sum] = "9859ed3c1b7b3daeb6bdf292c138b62a9c38f1769887b7529393d065ea93550a"

RDEPENDS:unuran = " \
 glibc \
 "
RDEPENDS:unuran-devel = " \
 unuran \
 "
