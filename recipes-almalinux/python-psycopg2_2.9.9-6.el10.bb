# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-psycopg2"
PV = "2.9.9"
PR = "6.el10"
PACKAGES = " \
 python3-psycopg2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-psycopg2-2.9.9-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50a8ea985eb90a0ee2ac0eb7bd2ce5a12b0200122d78a98e1d384fcc5b22f5af"

URI_x86_64_v2_python3-psycopg2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-psycopg2-2.9.9-6.el10.x86_64_v2.rpm;name=x86_64_v2_python3-psycopg2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-psycopg2}"
SRC_URI[x86_64_v2_python3-psycopg2.sha256sum] = "35c842c88be0be8a4fe9d7aa785838218676331015b8451ab1ca8453b5eca6e5"

URI_aarch64_python3-psycopg2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-psycopg2-2.9.9-6.el10.aarch64.rpm;name=aarch64_python3-psycopg2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-psycopg2}"
SRC_URI[aarch64_python3-psycopg2.sha256sum] = "f7a78a4841de540c292e1da1a498175885cfdb5b588ee444bc49ec422c4eb4ab"

RDEPENDS:python3-psycopg2 = " \
 glibc \
 libpq \
 python3 \
 "
