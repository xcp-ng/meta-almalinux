# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-language-javascript"
PV = "0.7.1.0"
PR = "17.el10_0"
PACKAGES = " \
 ghc-language-javascript \
 ghc-language-javascript-devel \
 ghc-language-javascript-doc \
 ghc-language-javascript-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-language-javascript-0.7.1.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e647598eccf75df162f166120c9c9b5da4e1de9acde86576169a9aa8647b1ec3"

URI_x86_64_v2_ghc-language-javascript = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-javascript-0.7.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-language-javascript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-javascript}"
SRC_URI[x86_64_v2_ghc-language-javascript.sha256sum] = "3a8abe417fb178b1f763b22b15936640a7c284aa5c964cb22a6d4266c580d49e"

URI_x86_64_v2_ghc-language-javascript-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-javascript-devel-0.7.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-language-javascript-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-javascript-devel}"
SRC_URI[x86_64_v2_ghc-language-javascript-devel.sha256sum] = "a96790fefdd8704cea1be12e92da7c88adafc2c8773e75b1bc71bc6c4adfffc8"

URI_x86_64_v2_ghc-language-javascript-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-javascript-doc-0.7.1.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-language-javascript-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-javascript-doc}"
SRC_URI[x86_64_v2_ghc-language-javascript-doc.sha256sum] = "7be1ea12589a8fea85352ab2d67761c993dc06b3eb9237b652c6286bfead9f21"

URI_x86_64_v2_ghc-language-javascript-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-javascript-prof-0.7.1.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-language-javascript-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-javascript-prof}"
SRC_URI[x86_64_v2_ghc-language-javascript-prof.sha256sum] = "4ef86a1c4c5a0f64342f6f0a040f6e762de1b1406e75c642864a238ecae33738"

URI_aarch64_ghc-language-javascript = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-javascript-0.7.1.0-17.el10_0.aarch64.rpm;name=aarch64_ghc-language-javascript;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-javascript}"
SRC_URI[aarch64_ghc-language-javascript.sha256sum] = "5f78342414409a32b2632c4554fd0b9b2e32aa4188a5b9f2ac1b14860d74dcc3"

URI_aarch64_ghc-language-javascript-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-javascript-devel-0.7.1.0-17.el10_0.aarch64.rpm;name=aarch64_ghc-language-javascript-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-javascript-devel}"
SRC_URI[aarch64_ghc-language-javascript-devel.sha256sum] = "82a083f3c41a404901da1a8599899f865ac779641a3457daed3c180ae42d457a"

URI_aarch64_ghc-language-javascript-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-javascript-doc-0.7.1.0-17.el10_0.noarch.rpm;name=aarch64_ghc-language-javascript-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-javascript-doc}"
SRC_URI[aarch64_ghc-language-javascript-doc.sha256sum] = "588320a7b7b590e180e4e424bd38744b57a3dbda53c3efc4471a4e09d51237f5"

URI_aarch64_ghc-language-javascript-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-javascript-prof-0.7.1.0-17.el10_0.aarch64.rpm;name=aarch64_ghc-language-javascript-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-javascript-prof}"
SRC_URI[aarch64_ghc-language-javascript-prof.sha256sum] = "3ebbe5dcc107169778eaefa6bcb9323b974c64b380765ee9e20ffd89444937cf"

RDEPENDS:ghc-language-javascript = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-utf8-string \
 glibc \
 gmp \
 "
RDEPENDS:ghc-language-javascript-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-blaze-builder-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-language-javascript \
 ghc-mtl-devel \
 ghc-text-devel \
 ghc-utf8-string-devel \
 "
RDEPENDS:ghc-language-javascript-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-language-javascript-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-blaze-builder-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-language-javascript-devel \
 ghc-mtl-prof \
 ghc-text-prof \
 ghc-utf8-string-prof \
 "
