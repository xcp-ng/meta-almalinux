# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fwupd-efi"
PV = "1.8"
PR = "1.el10.alma.1"
PACKAGES = " \
 fwupd-efi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/fwupd-efi-1.8-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2449f1f51d13d0e47e2b1e1e6bc2ba96aebee18b7edefefc704b7db264fa3741"

URI_x86_64_v2_fwupd-efi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/fwupd-efi-1.8-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_fwupd-efi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd-efi}"
SRC_URI[x86_64_v2_fwupd-efi.sha256sum] = "0ec9bf7ebb81ba4b8107c1299219e53af13e67b5588f211c5f74f041564e993a"

URI_aarch64_fwupd-efi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/fwupd-efi-1.8-1.el10.alma.1.aarch64.rpm;name=aarch64_fwupd-efi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd-efi}"
SRC_URI[aarch64_fwupd-efi.sha256sum] = "cd8a5028af3c8dfb5bc92560d6de7c5c7e0f2262b25e7ff7f358b5d9867451a7"

RDEPENDS:fwupd-efi = " \
 pkgconf-pkg-config \
 "
