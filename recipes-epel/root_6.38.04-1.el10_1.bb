# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "root"
PV = "6.38.04"
PR = "1.el10_1"
PACKAGES = " \
 python3-distrdf \
 python3-jupyroot \
 python3-root \
 root \
 root-cli \
 root-cling \
 root-core \
 root-fftw \
 root-foam \
 root-font-files \
 root-fumili \
 root-gdml \
 root-genetic \
 root-genvector \
 root-geom \
 root-geom-builder \
 root-geom-checker \
 root-geom-painter \
 root-geom-webviewer \
 root-graf \
 root-graf-asimage \
 root-graf-fitsio \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-graf-gviz \
 root-graf-postscript \
 root-graf-primitives \
 root-graf-x11 \
 root-graf3d \
 root-graf3d-csg \
 root-graf3d-eve \
 root-graf3d-eve7 \
 root-graf3d-gl \
 root-graf3d-gviz3d \
 root-graf3d-x3d \
 root-gui \
 root-gui-browsable \
 root-gui-browsable-v7 \
 root-gui-browserv7 \
 root-gui-browserv7-v7 \
 root-gui-builder \
 root-gui-canvaspainter \
 root-gui-fitpanel \
 root-gui-fitpanelv7 \
 root-gui-ged \
 root-gui-html \
 root-gui-qt6webdisplay \
 root-gui-recorder \
 root-gui-treemap \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-hbook \
 root-hist \
 root-hist-factory \
 root-hist-painter \
 root-histv7 \
 root-icons \
 root-io \
 root-io-dcache \
 root-io-sql \
 root-io-xml \
 root-io-xmlparser \
 root-mathcore \
 root-mathmore \
 root-matrix \
 root-minuit \
 root-minuit2 \
 root-mlp \
 root-montecarlo-eg \
 root-montecarlo-pythia8 \
 root-multiproc \
 root-net \
 root-net-auth \
 root-net-davix \
 root-net-http \
 root-net-httpsniff \
 root-net-rpdutils \
 root-netx \
 root-physics \
 root-quadp \
 root-r \
 root-r-tools \
 root-roofit \
 root-roofit-batchcompute \
 root-roofit-codegen \
 root-roofit-core \
 root-roofit-hs3 \
 root-roofit-jsoninterface \
 root-roofit-more \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-roostats \
 root-smatrix \
 root-spectrum \
 root-spectrum-painter \
 root-splot \
 root-sql-sqlite \
 root-testsupport \
 root-tmva \
 root-tmva-gui \
 root-tmva-python \
 root-tmva-r \
 root-tmva-sofie \
 root-tmva-sofie-parser \
 root-tmva-utils \
 root-tpython \
 root-tree \
 root-tree-dataframe \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 root-tree-ntuple-utils \
 root-tree-player \
 root-tree-viewer \
 root-tree-webviewer \
 root-tutorial \
 root-unfold \
 root-unuran \
 root-vecops \
 root-xroofit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/root-6.38.04-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cee49ffc61b4b37c1dc03cc79833a8c6cb87d470367717b53bd4c2a28d0afd31"

URI_x86_64_v2_python3-distrdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-distrdf-6.38.04-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-distrdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-distrdf}"
SRC_URI[x86_64_v2_python3-distrdf.sha256sum] = "b7e5a1b3bb89e4f997ef92e3932d34d3bd83009837d8b8f82e83baff4037cbd1"

URI_x86_64_v2_python3-jupyroot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jupyroot-6.38.04-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jupyroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jupyroot}"
SRC_URI[x86_64_v2_python3-jupyroot.sha256sum] = "0bc68474fa3ead244caf352dca50db382a9012637d4a99daca4905b42744e0e9"

URI_x86_64_v2_python3-root = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-root-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-root;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-root}"
SRC_URI[x86_64_v2_python3-root.sha256sum] = "b34b653870012631f84d3375dc32c020340eb7176c179fb42fa278000c8343d5"

URI_x86_64_v2_root = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root}"
SRC_URI[x86_64_v2_root.sha256sum] = "8fe6490631b34cb951d4db2157f7ae1ef376b66d6d71c3ccf1a4a2b5e9189e1e"

URI_x86_64_v2_root-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cli-6.38.04-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_root-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-cli}"
SRC_URI[x86_64_v2_root-cli.sha256sum] = "ffa098ef146b167252b9eb3c754a3289bf392ad61b29abb9cd3422ad4a8dac2f"

URI_x86_64_v2_root-cling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-cling-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-cling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-cling}"
SRC_URI[x86_64_v2_root-cling.sha256sum] = "89e200bddddbc3c5ac9b06caefb99b818364232a2473f42066660fe6ae6b424e"

URI_x86_64_v2_root-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-core-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-core}"
SRC_URI[x86_64_v2_root-core.sha256sum] = "51c02e7a35cf5619565c3b3a8cfce762bf618b5ed18ef4c67cc71874ad4f6387"

URI_x86_64_v2_root-fftw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fftw-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fftw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-fftw}"
SRC_URI[x86_64_v2_root-fftw.sha256sum] = "f9e573da63e86da3169c55ae7fcb055fdcf8a0443e6c724c9fe021ca4b4c9cf2"

URI_x86_64_v2_root-foam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-foam-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-foam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-foam}"
SRC_URI[x86_64_v2_root-foam.sha256sum] = "c746d3f4bb77f01ac82ece1a9befa3fdf814f3531ba678d21ba521cc355be76d"

URI_x86_64_v2_root-font-files = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-font-files-6.38.04-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_root-font-files;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-font-files}"
SRC_URI[x86_64_v2_root-font-files.sha256sum] = "3c01c5d575db08f31f9c3ce580e2765aa868960674b6d9e1ec5d808eb7975619"

URI_x86_64_v2_root-fumili = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-fumili-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-fumili;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-fumili}"
SRC_URI[x86_64_v2_root-fumili.sha256sum] = "2ae4b38702a76da703fcc160e62c2d11a99fdbf483509f42c26f198edc68a335"

URI_x86_64_v2_root-gdml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gdml-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gdml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gdml}"
SRC_URI[x86_64_v2_root-gdml.sha256sum] = "2bf4f5a505521d4712f9a40036e715a6d677f3aced44c703945ac0e06f859a30"

URI_x86_64_v2_root-genetic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genetic-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genetic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-genetic}"
SRC_URI[x86_64_v2_root-genetic.sha256sum] = "0c2bdb9ccd541078ac972369f472d77b9fd69dc5c98441a8bd401d63e5381b9f"

URI_x86_64_v2_root-genvector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-genvector-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-genvector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-genvector}"
SRC_URI[x86_64_v2_root-genvector.sha256sum] = "10bc16456ff710dfe73f4faf430139840abd96cf0213630a9dd0296e3bf84d6f"

URI_x86_64_v2_root-geom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom}"
SRC_URI[x86_64_v2_root-geom.sha256sum] = "d6c2e1f9ed0a5fef99469e9ba9342cc930c4516fca2ea3de9bb5b7d103fb2530"

URI_x86_64_v2_root-geom-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-builder-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-builder}"
SRC_URI[x86_64_v2_root-geom-builder.sha256sum] = "12cdb26a07adb0d4f6eb08fabc8f8947c8cdc9e9a75b42318a0a339183040a12"

URI_x86_64_v2_root-geom-checker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-checker-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-checker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-checker}"
SRC_URI[x86_64_v2_root-geom-checker.sha256sum] = "f0a3c2928ad865506cec91a2c2219c7607384cce2885097cba37c7b2b4bfbe34"

URI_x86_64_v2_root-geom-painter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-painter-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-painter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-painter}"
SRC_URI[x86_64_v2_root-geom-painter.sha256sum] = "ea26c2c9d354d1023192f0067d0ce858657d890d5273edf407c9a5b205c89b0f"

URI_x86_64_v2_root-geom-webviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-geom-webviewer-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-geom-webviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-geom-webviewer}"
SRC_URI[x86_64_v2_root-geom-webviewer.sha256sum] = "8b5fae0122fdfef1d5acab0d3feb2c271ee4ac1a796e0db9c46c0590c98949ed"

URI_x86_64_v2_root-graf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf}"
SRC_URI[x86_64_v2_root-graf.sha256sum] = "0c682fb4ae95c01e9d6a230bd90799475beed4808c3f592c973b0124f3937c03"

URI_x86_64_v2_root-graf-asimage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-asimage-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-asimage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-asimage}"
SRC_URI[x86_64_v2_root-graf-asimage.sha256sum] = "690784bbfbadb52b388c015352997ff75fc4bf8ccdfb67e67de52408ff5d130c"

URI_x86_64_v2_root-graf-fitsio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-fitsio-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-fitsio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-fitsio}"
SRC_URI[x86_64_v2_root-graf-fitsio.sha256sum] = "9177d460bdcc802d1f713f7afffe5c90895b73669c71fd5a174207dda1d1ed81"

URI_x86_64_v2_root-graf-gpad = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpad-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-gpad}"
SRC_URI[x86_64_v2_root-graf-gpad.sha256sum] = "41d69f6f8b33b1cbf6ab01d608cbd9ed6c61f1c7935dc160276637718931780f"

URI_x86_64_v2_root-graf-gpadv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gpadv7-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gpadv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-gpadv7}"
SRC_URI[x86_64_v2_root-graf-gpadv7.sha256sum] = "18ced230489aa924abbc87a4b9a854a2e586d174e929290ff65651939e10d40f"

URI_x86_64_v2_root-graf-gviz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-gviz-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-gviz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-gviz}"
SRC_URI[x86_64_v2_root-graf-gviz.sha256sum] = "184b6afd9ebe947b20981c4c754493e9122fd206077896c35eb4f3083ecbdd6f"

URI_x86_64_v2_root-graf-postscript = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-postscript-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-postscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-postscript}"
SRC_URI[x86_64_v2_root-graf-postscript.sha256sum] = "02306c732e9b62e5734586ceecad3dfd861b9cd00afcfa56557d21de4da61785"

URI_x86_64_v2_root-graf-primitives = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-primitives-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-primitives;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-primitives}"
SRC_URI[x86_64_v2_root-graf-primitives.sha256sum] = "3fbbf4ec3d5922b8b755014d232b0c5afaf59a655ea9c5d0dcb9d5f3bce68bdb"

URI_x86_64_v2_root-graf-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf-x11-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf-x11}"
SRC_URI[x86_64_v2_root-graf-x11.sha256sum] = "e35403f1b2aceacb9ec41cddc29288befa4672fc6819167e3ff27eaefbc216b2"

URI_x86_64_v2_root-graf3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d}"
SRC_URI[x86_64_v2_root-graf3d.sha256sum] = "1eaf6c3823c872359749be7324518fd82f815bb841ba431f4cf18f646d196139"

URI_x86_64_v2_root-graf3d-csg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-csg-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-csg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-csg}"
SRC_URI[x86_64_v2_root-graf3d-csg.sha256sum] = "82a6898e8c3b4fd1d84e1851ee76deb12d249f16bd2c7c7544cf866f1bfb7875"

URI_x86_64_v2_root-graf3d-eve = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-eve}"
SRC_URI[x86_64_v2_root-graf3d-eve.sha256sum] = "cc0504d35b9283c5c435b8ab252dfe4e4767339f9ea3a9809eb24b00a7e379ca"

URI_x86_64_v2_root-graf3d-eve7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-eve7-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-eve7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-eve7}"
SRC_URI[x86_64_v2_root-graf3d-eve7.sha256sum] = "31db1d59480073c65d114f6c82b1edcfa63a1d980250526e8097af16604a0e0b"

URI_x86_64_v2_root-graf3d-gl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gl-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-gl}"
SRC_URI[x86_64_v2_root-graf3d-gl.sha256sum] = "89f2e090add423b78ce672c5b064b0c162f0516860c2c929da4f25b017c339dc"

URI_x86_64_v2_root-graf3d-gviz3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-gviz3d-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-gviz3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-gviz3d}"
SRC_URI[x86_64_v2_root-graf3d-gviz3d.sha256sum] = "51c0f837acb34b218c904cdea80f29b2b55fc27c7038e1409f6845e4c4ea8545"

URI_x86_64_v2_root-graf3d-x3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-graf3d-x3d-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-graf3d-x3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-graf3d-x3d}"
SRC_URI[x86_64_v2_root-graf3d-x3d.sha256sum] = "22b57cc2d8905cfbf8b87add44dd188dd99739603bd6b4a8f772e2e86f2cdad7"

URI_x86_64_v2_root-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui}"
SRC_URI[x86_64_v2_root-gui.sha256sum] = "e83d2002f6b71e01b4a0cd95f59b13a48ce00a2c147c85d01c120d0a1e2005e0"

URI_x86_64_v2_root-gui-browsable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browsable}"
SRC_URI[x86_64_v2_root-gui-browsable.sha256sum] = "3cfea902442c346a46bc8cac1c579fc45947acf0c66d1f4e1d721eec71a73258"

URI_x86_64_v2_root-gui-browsable-v7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browsable-v7-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browsable-v7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browsable-v7}"
SRC_URI[x86_64_v2_root-gui-browsable-v7.sha256sum] = "74c54ca76ddc5855a7505952201a329382331f386dbd07ed218402bff49c427f"

URI_x86_64_v2_root-gui-browserv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browserv7}"
SRC_URI[x86_64_v2_root-gui-browserv7.sha256sum] = "8c02bcfc682a4461042f9e40bfd0a3ba8d5dea6d20b2bb1647376960b78cb814"

URI_x86_64_v2_root-gui-browserv7-v7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-browserv7-v7-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-browserv7-v7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-browserv7-v7}"
SRC_URI[x86_64_v2_root-gui-browserv7-v7.sha256sum] = "d23684fd60b3973945f8fb28b8933536c19f2e847173342610886c8769f5983d"

URI_x86_64_v2_root-gui-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-builder-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-builder}"
SRC_URI[x86_64_v2_root-gui-builder.sha256sum] = "f17334781f11c085e72d1bef3ac572bb25e52a8ed5552fa46fbf7e17c2e73e9f"

URI_x86_64_v2_root-gui-canvaspainter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-canvaspainter-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-canvaspainter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-canvaspainter}"
SRC_URI[x86_64_v2_root-gui-canvaspainter.sha256sum] = "ebc55d132330452f4c8721bbfaa1c9dfb1370f4d6d32b2a2dded7691b3bdfcef"

URI_x86_64_v2_root-gui-fitpanel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanel-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-fitpanel}"
SRC_URI[x86_64_v2_root-gui-fitpanel.sha256sum] = "8b8df0afc9d7761657015bcb544ac261806b61609a90533c0f923506d0caf7a3"

URI_x86_64_v2_root-gui-fitpanelv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-fitpanelv7-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-fitpanelv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-fitpanelv7}"
SRC_URI[x86_64_v2_root-gui-fitpanelv7.sha256sum] = "3c9b77cecc3728211f4058179d5352738cedee9f14d902750419bb94c9cac130"

URI_x86_64_v2_root-gui-ged = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-ged-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-ged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-ged}"
SRC_URI[x86_64_v2_root-gui-ged.sha256sum] = "23b85ce421939608877af42ba84f683025af545c61ee7bb7f027440aa6b68cfc"

URI_x86_64_v2_root-gui-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-html-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-html}"
SRC_URI[x86_64_v2_root-gui-html.sha256sum] = "64fc24353a20d4a4a22fa17bb87f9ac8e23dbedba5f89b15daeacf23609028f1"

URI_x86_64_v2_root-gui-qt6webdisplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-qt6webdisplay-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-qt6webdisplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-qt6webdisplay}"
SRC_URI[x86_64_v2_root-gui-qt6webdisplay.sha256sum] = "7e665afc4a3c34a78670ceadc13b9bbc2bb69fb190df38c20530ccfe047cf4f3"

URI_x86_64_v2_root-gui-recorder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-recorder-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-recorder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-recorder}"
SRC_URI[x86_64_v2_root-gui-recorder.sha256sum] = "7f881c0103b23099b878c50494b8fb05374e77b816a5d7122a8a57b50617037c"

URI_x86_64_v2_root-gui-treemap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-treemap-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-treemap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-treemap}"
SRC_URI[x86_64_v2_root-gui-treemap.sha256sum] = "95070a8ed0552ee10b1f4c2649ccbf15af40786b19ed49e9256c292783f7d30d"

URI_x86_64_v2_root-gui-webdisplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webdisplay-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webdisplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-webdisplay}"
SRC_URI[x86_64_v2_root-gui-webdisplay.sha256sum] = "49460545e0ec95925251daa74f0b0c68785757a7a9b66c8b4b1163b1bf9154bb"

URI_x86_64_v2_root-gui-webgui6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-gui-webgui6-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-gui-webgui6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-gui-webgui6}"
SRC_URI[x86_64_v2_root-gui-webgui6.sha256sum] = "94a8e4a2f591230bf3cc676c1e9b96f3aee5a3f040a074620173f77d9b37db85"

URI_x86_64_v2_root-hbook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hbook-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hbook}"
SRC_URI[x86_64_v2_root-hbook.sha256sum] = "9d5562c11bcfd259ac5684907068843f02c7d1e137501485759c7d567e8b0419"

URI_x86_64_v2_root-hist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hist}"
SRC_URI[x86_64_v2_root-hist.sha256sum] = "0617dbd47d855085fafb59a81e0974ed6c7035d9b0251407908bef0f13433b2a"

URI_x86_64_v2_root-hist-factory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-factory-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-factory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hist-factory}"
SRC_URI[x86_64_v2_root-hist-factory.sha256sum] = "a641230515a72014b59eda3645ac11c01049987aaecea0552b30a350d01c42ec"

URI_x86_64_v2_root-hist-painter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-hist-painter-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-hist-painter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-hist-painter}"
SRC_URI[x86_64_v2_root-hist-painter.sha256sum] = "55a99372adeb3be151bda9d0ac9e260f9ff10c61fe2321b8afd4a0eefbecffa0"

URI_x86_64_v2_root-histv7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-histv7-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-histv7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-histv7}"
SRC_URI[x86_64_v2_root-histv7.sha256sum] = "dcdaf11f59fd1c710b18f02162b653fda887dd0f3911b7eee71b0a9b914306b9"

URI_x86_64_v2_root-icons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-icons-6.38.04-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_root-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-icons}"
SRC_URI[x86_64_v2_root-icons.sha256sum] = "bb5d4718c371fd8772e93cf16518c839cb1871c1b3d8fbd65927a68100c1affe"

URI_x86_64_v2_root-io = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io}"
SRC_URI[x86_64_v2_root-io.sha256sum] = "f0c9620b1ebbfc6320fd22b300b9ef7ee7f24cf2b6fe54ef29e684db1e69595d"

URI_x86_64_v2_root-io-dcache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-dcache-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-dcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-dcache}"
SRC_URI[x86_64_v2_root-io-dcache.sha256sum] = "6ea7368d2bb4aea3c22d4f5e7725c5e4fd8cfd995655da6791bf9e5bcdc51abc"

URI_x86_64_v2_root-io-sql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-sql-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-sql}"
SRC_URI[x86_64_v2_root-io-sql.sha256sum] = "f20d506617937e0545ecd6a052b96b40df5158f119a1f538c595f92c07d11b8d"

URI_x86_64_v2_root-io-xml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xml-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-xml}"
SRC_URI[x86_64_v2_root-io-xml.sha256sum] = "365053dd1f746bb0be3f135b58a72614616c5c9d09b08fa6df1328f5a183c476"

URI_x86_64_v2_root-io-xmlparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-io-xmlparser-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-io-xmlparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-io-xmlparser}"
SRC_URI[x86_64_v2_root-io-xmlparser.sha256sum] = "08da278d6670a6540375ab30dc8c8e04171bab7f35203642268d6bef2d4e23b3"

URI_x86_64_v2_root-mathcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathcore-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-mathcore}"
SRC_URI[x86_64_v2_root-mathcore.sha256sum] = "bbbce771fb38d603130293d113e9ba4d8fdd634279d16f24e4c1b13d9511d949"

URI_x86_64_v2_root-mathmore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mathmore-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mathmore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-mathmore}"
SRC_URI[x86_64_v2_root-mathmore.sha256sum] = "5e51ec9a749d15bb9004b1230f2f0ae1efaea704a7820608bc79f573812a4b5d"

URI_x86_64_v2_root-matrix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-matrix-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-matrix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-matrix}"
SRC_URI[x86_64_v2_root-matrix.sha256sum] = "7af68927cf91501c9ebf50e4abecd2395f31c00d9b4fa3fac988f57dc57bba3c"

URI_x86_64_v2_root-minuit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-minuit}"
SRC_URI[x86_64_v2_root-minuit.sha256sum] = "e39f4b37a9ade2fc44bfc6b5ab66459cd3f20a5d0796db4c6b44b280d56452e4"

URI_x86_64_v2_root-minuit2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-minuit2-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-minuit2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-minuit2}"
SRC_URI[x86_64_v2_root-minuit2.sha256sum] = "24bb84d129234586b418fb72baa696af492e934f83ff0b50199ec7d4a5a0ca0e"

URI_x86_64_v2_root-mlp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-mlp-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-mlp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-mlp}"
SRC_URI[x86_64_v2_root-mlp.sha256sum] = "adc28f212e50a13fc1f9782316a67996743d51cb7d6bb4dfcd9225144b88be31"

URI_x86_64_v2_root-montecarlo-eg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-eg-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-eg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-montecarlo-eg}"
SRC_URI[x86_64_v2_root-montecarlo-eg.sha256sum] = "d4553d753da05ede8e518c61b79d70ce27442a87b47b7d3b1f3361c280bc86e3"

URI_x86_64_v2_root-montecarlo-pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-montecarlo-pythia8-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-montecarlo-pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-montecarlo-pythia8}"
SRC_URI[x86_64_v2_root-montecarlo-pythia8.sha256sum] = "3337d36f7aa50c152ca0ba9a6c905f36b9b123af6f99c45b853df5382f612dfe"

URI_x86_64_v2_root-multiproc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-multiproc-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-multiproc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-multiproc}"
SRC_URI[x86_64_v2_root-multiproc.sha256sum] = "be940c5464dc5ba1a5acce40660c0250e4cc2a7f2afeb68095f4af6a1600ea0c"

URI_x86_64_v2_root-net = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net}"
SRC_URI[x86_64_v2_root-net.sha256sum] = "a2d9314e7288fc5fef4451cfd30e378abec91bf2df3c8f7b297045ec405c017a"

URI_x86_64_v2_root-net-auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-auth-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-auth}"
SRC_URI[x86_64_v2_root-net-auth.sha256sum] = "2faa98bf7376f49adce2b8a854ba14d1048226a4251453ac0e39d79979963ac9"

URI_x86_64_v2_root-net-davix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-davix-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-davix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-davix}"
SRC_URI[x86_64_v2_root-net-davix.sha256sum] = "1412ad644ddb5f5a3c78eb5f7bbb99af5babdcc888cc4215f0db8717198be789"

URI_x86_64_v2_root-net-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-http-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-http}"
SRC_URI[x86_64_v2_root-net-http.sha256sum] = "ef10aac5fec6694b72a90daaa035485fa1afaa4ac5caaa6e439cfb6b2c609f34"

URI_x86_64_v2_root-net-httpsniff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-httpsniff-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-httpsniff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-httpsniff}"
SRC_URI[x86_64_v2_root-net-httpsniff.sha256sum] = "c55df3386cb0d63e8c95babcd4e9fceb0880605a619593194e98d801174e0e41"

URI_x86_64_v2_root-net-rpdutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-net-rpdutils-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-net-rpdutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-net-rpdutils}"
SRC_URI[x86_64_v2_root-net-rpdutils.sha256sum] = "62623d8468e3f50d4531fc1b84cdaf498573135abe5b6e90bef0f7e19c9bdbdc"

URI_x86_64_v2_root-netx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-netx-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-netx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-netx}"
SRC_URI[x86_64_v2_root-netx.sha256sum] = "c35e0f78077e66e85fbf27bed46abebcdced0796b88457198e0ea0c716f69507"

URI_x86_64_v2_root-physics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-physics-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-physics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-physics}"
SRC_URI[x86_64_v2_root-physics.sha256sum] = "c8bd70290568a51a827564738075b8dc74d18aea0239ac81250c427a35dcff4d"

URI_x86_64_v2_root-quadp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-quadp-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-quadp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-quadp}"
SRC_URI[x86_64_v2_root-quadp.sha256sum] = "e091a31364e1ba46bffeb74078b0198f6acefc7a2448fa30297dfb721aaa2e94"

URI_x86_64_v2_root-r = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-r}"
SRC_URI[x86_64_v2_root-r.sha256sum] = "4f00a664a18065b8b72e1cc5b1b416907cfa85893aae8c5e611ad499895c7b60"

URI_x86_64_v2_root-r-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-r-tools-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-r-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-r-tools}"
SRC_URI[x86_64_v2_root-r-tools.sha256sum] = "e0f4dad0f54c6e6fd1aef227dd7b09a9284a81210e980fbf1fb0359f392242e5"

URI_x86_64_v2_root-roofit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit}"
SRC_URI[x86_64_v2_root-roofit.sha256sum] = "ca10bbfb165aa3889c1c692ec056a7b039b01273ba84bb53a849376c5bad378a"

URI_x86_64_v2_root-roofit-batchcompute = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-batchcompute-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-batchcompute;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-batchcompute}"
SRC_URI[x86_64_v2_root-roofit-batchcompute.sha256sum] = "7c5f95f3e226e73829acca48514a450399b815e35d3668bc5a93975b2a24abf4"

URI_x86_64_v2_root-roofit-codegen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-codegen-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-codegen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-codegen}"
SRC_URI[x86_64_v2_root-roofit-codegen.sha256sum] = "0e06a3237717ee4c2fa0461a79251a1f2ccc899ea4c5112141d9acdc0f9c3a16"

URI_x86_64_v2_root-roofit-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-core-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-core}"
SRC_URI[x86_64_v2_root-roofit-core.sha256sum] = "2cb07da73524fe4d88b79e2e3d6ce408290a1cfdc51b95830f6d6eecd7cd0e27"

URI_x86_64_v2_root-roofit-hs3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-hs3-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-hs3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-hs3}"
SRC_URI[x86_64_v2_root-roofit-hs3.sha256sum] = "16e784988f2f6b1f22de2e871fb165a59f61ac954a579796d9cffe7aa0ef1398"

URI_x86_64_v2_root-roofit-jsoninterface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-jsoninterface-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-jsoninterface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-jsoninterface}"
SRC_URI[x86_64_v2_root-roofit-jsoninterface.sha256sum] = "4b70dcc6460a57176effa50a55afe5ddd7b253e391e0238b7c42bd2994dd65fe"

URI_x86_64_v2_root-roofit-more = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-more-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-more;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-more}"
SRC_URI[x86_64_v2_root-roofit-more.sha256sum] = "c7c94ca9e6818713ae77a40a76eabb7cd2c93b237a6e760202b8d8981a6ec256"

URI_x86_64_v2_root-roofit-multiprocess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-multiprocess-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-multiprocess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-multiprocess}"
SRC_URI[x86_64_v2_root-roofit-multiprocess.sha256sum] = "82e84993be5f60fbd37aa0b37cf8f18c3172323f166f084dc2df6aedfaa677a6"

URI_x86_64_v2_root-roofit-zmq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roofit-zmq-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roofit-zmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roofit-zmq}"
SRC_URI[x86_64_v2_root-roofit-zmq.sha256sum] = "8552ec23ebd589312497b0ce1f12e81351d9e0f29a99e2e1c872623bf6ef23f6"

URI_x86_64_v2_root-roostats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-roostats-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-roostats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-roostats}"
SRC_URI[x86_64_v2_root-roostats.sha256sum] = "de2d74cdc77e2d1ee0caffd17669c0d002b75f7e6dfe36b4c333531814a4f8b8"

URI_x86_64_v2_root-smatrix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-smatrix-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-smatrix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-smatrix}"
SRC_URI[x86_64_v2_root-smatrix.sha256sum] = "ef46c3acfc50f1b7fa4f4ba5dbc6c0555c03290b5931feaa9c7532d158365ebe"

URI_x86_64_v2_root-spectrum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-spectrum}"
SRC_URI[x86_64_v2_root-spectrum.sha256sum] = "6180e64168de3fd62754d43d7565b6e17df571c5f0dc2ace7b3e8343ce70c7f4"

URI_x86_64_v2_root-spectrum-painter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-spectrum-painter-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-spectrum-painter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-spectrum-painter}"
SRC_URI[x86_64_v2_root-spectrum-painter.sha256sum] = "99ddaffa6438e74be881cda3d363405be03843126d8808ffdffc2a720c8d048a"

URI_x86_64_v2_root-splot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-splot-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-splot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-splot}"
SRC_URI[x86_64_v2_root-splot.sha256sum] = "7e7337645a5cc9bada6d8ef6395f77d72867c0062a474ed1dcb5df8cb0ed86e0"

URI_x86_64_v2_root-sql-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-sql-sqlite-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-sql-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-sql-sqlite}"
SRC_URI[x86_64_v2_root-sql-sqlite.sha256sum] = "0618601f7245b2bc443e1acc72aa2676b7e44136dedcbf552c22e1c2a51c0e6c"

URI_x86_64_v2_root-testsupport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-testsupport-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-testsupport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-testsupport}"
SRC_URI[x86_64_v2_root-testsupport.sha256sum] = "83a80595ef15047582466f44cef8f943c40e765b15a2e849508d68e5d6c0977e"

URI_x86_64_v2_root-tmva = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva}"
SRC_URI[x86_64_v2_root-tmva.sha256sum] = "4473afafe982eae066cf334d4f55db1fc3c9c1457267e06134b0398bee076672"

URI_x86_64_v2_root-tmva-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-gui-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-gui}"
SRC_URI[x86_64_v2_root-tmva-gui.sha256sum] = "bae82e0debc10ef4da719faeeef9eb2661e0724e0cb641c415059c73017fce2c"

URI_x86_64_v2_root-tmva-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-python-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-python}"
SRC_URI[x86_64_v2_root-tmva-python.sha256sum] = "5ae793b28751633ce94923a6444ed9e7ded76900403d388e1f03fb41d6b57a62"

URI_x86_64_v2_root-tmva-r = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-r-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-r;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-r}"
SRC_URI[x86_64_v2_root-tmva-r.sha256sum] = "537c082130d948754fabc2e7b0585cf7d51714365651ddfaaba110605496c28a"

URI_x86_64_v2_root-tmva-sofie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-sofie}"
SRC_URI[x86_64_v2_root-tmva-sofie.sha256sum] = "809e6dd4540917317c84d172456450ecefbf153fb0c207bb14f47c8ca60be1e5"

URI_x86_64_v2_root-tmva-sofie-parser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-sofie-parser-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-sofie-parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-sofie-parser}"
SRC_URI[x86_64_v2_root-tmva-sofie-parser.sha256sum] = "2dceb8322e76d84db0465ecb078c8af30f26468d471fd4c4c3d0411d2d75ca65"

URI_x86_64_v2_root-tmva-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tmva-utils-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tmva-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tmva-utils}"
SRC_URI[x86_64_v2_root-tmva-utils.sha256sum] = "b2832dda6ea7a23a9d548af079e24400668d29fde1b1e3d8d483958bbe872d32"

URI_x86_64_v2_root-tpython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tpython-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tpython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tpython}"
SRC_URI[x86_64_v2_root-tpython.sha256sum] = "1688efd1d9b975ac7bb997b030f9e629a0f21e666007d576d60c353a8774e8a9"

URI_x86_64_v2_root-tree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree}"
SRC_URI[x86_64_v2_root-tree.sha256sum] = "9180fbaf830db1b118c0498655defa79c3f0e9b9b2e66ab46ada3e29348c12c4"

URI_x86_64_v2_root-tree-dataframe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-dataframe-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-dataframe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-dataframe}"
SRC_URI[x86_64_v2_root-tree-dataframe.sha256sum] = "6f59cee19d3a07202522c933998e7a85d547515af04771a239096dd159fa8d0f"

URI_x86_64_v2_root-tree-ntuple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ntuple}"
SRC_URI[x86_64_v2_root-tree-ntuple.sha256sum] = "401f1d4195d1820cff6d99a8ff988c82d32427af816fbf4870b2848c1130038e"

URI_x86_64_v2_root-tree-ntuple-browse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-browse-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-browse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ntuple-browse}"
SRC_URI[x86_64_v2_root-tree-ntuple-browse.sha256sum] = "6b9ede10805c4b0ed2a9c00c601ec5d4c1cc411052d835fb2c322f9e7a125f0a"

URI_x86_64_v2_root-tree-ntuple-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-ntuple-utils-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-ntuple-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-ntuple-utils}"
SRC_URI[x86_64_v2_root-tree-ntuple-utils.sha256sum] = "e8ea9ac29600d32d84d7c19ea642273bf766cb803bff07ffdceb1adebf816610"

URI_x86_64_v2_root-tree-player = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-player-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-player;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-player}"
SRC_URI[x86_64_v2_root-tree-player.sha256sum] = "b9d8682c36a192bd7abfaf19d32cb3968bf106eb578940bbe2caed997c9e0c65"

URI_x86_64_v2_root-tree-viewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-viewer-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-viewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-viewer}"
SRC_URI[x86_64_v2_root-tree-viewer.sha256sum] = "f667add503bf9d58e52d0c11945c3b1382ea8a4c62f39e9c0c3ba0b43409289e"

URI_x86_64_v2_root-tree-webviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tree-webviewer-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-tree-webviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tree-webviewer}"
SRC_URI[x86_64_v2_root-tree-webviewer.sha256sum] = "18b32bba4e9b8d1ea4e1b8fd0a929c99d0b43d7b7f8ede336f6ccda14a6895ac"

URI_x86_64_v2_root-tutorial = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-tutorial-6.38.04-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_root-tutorial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-tutorial}"
SRC_URI[x86_64_v2_root-tutorial.sha256sum] = "f8fad0eb6223a9572446b2a7ec7632c423bcde4d694ce983a867ad0f10be6cde"

URI_x86_64_v2_root-unfold = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unfold-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unfold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-unfold}"
SRC_URI[x86_64_v2_root-unfold.sha256sum] = "6bb35c38bec4ae2aee3a0d27c17ca692740a9ba36cd7dbeb43b02a4bbe2d966a"

URI_x86_64_v2_root-unuran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-unuran-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-unuran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-unuran}"
SRC_URI[x86_64_v2_root-unuran.sha256sum] = "f680ef7848b250ec5e706f7936b699ac7c34bb59e0b5289940d385f35c71a2d6"

URI_x86_64_v2_root-vecops = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-vecops-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-vecops;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-vecops}"
SRC_URI[x86_64_v2_root-vecops.sha256sum] = "f32d4e5563e2c116518d1692fb2736afbcca736c78338caded995e10882fda47"

URI_x86_64_v2_root-xroofit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/root-xroofit-6.38.04-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_root-xroofit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_root-xroofit}"
SRC_URI[x86_64_v2_root-xroofit.sha256sum] = "45a47881a303cfadd1d0d8b2aa7f9e35048ab4500e84483a3b2be96ac44e269b"

URI_aarch64_python3-distrdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-distrdf-6.38.04-1.el10_1.noarch.rpm;name=aarch64_python3-distrdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-distrdf}"
SRC_URI[aarch64_python3-distrdf.sha256sum] = "06aa21d9c9dbb270140debd8644e3fa8b5ac3dc7fdbe7a10c94fae847dc47abe"

URI_aarch64_python3-jupyroot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jupyroot-6.38.04-1.el10_1.noarch.rpm;name=aarch64_python3-jupyroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jupyroot}"
SRC_URI[aarch64_python3-jupyroot.sha256sum] = "dfbc57e764f53a5441408e0423b088779bc1a150a1b67ee3bcc60a388fa60682"

URI_aarch64_python3-root = "${EPEL_MIRROR}/aarch64/Packages/p/python3-root-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_python3-root;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-root}"
SRC_URI[aarch64_python3-root.sha256sum] = "bf5d8d8f18499d0236e33b97cced821fe8f089dec2c50ca1486f498cc4e1c320"

URI_aarch64_root = "${EPEL_MIRROR}/aarch64/Packages/r/root-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root;unpack=0"
SRC_URI:append = " ${URI_aarch64_root}"
SRC_URI[aarch64_root.sha256sum] = "fbf4746e11a4c22426cafe0bc931d5a7c93fdd48e754c5eb6a7eda63427258b9"

URI_aarch64_root-cli = "${EPEL_MIRROR}/aarch64/Packages/r/root-cli-6.38.04-1.el10_1.noarch.rpm;name=aarch64_root-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-cli}"
SRC_URI[aarch64_root-cli.sha256sum] = "d96e546c8269b307556f8a2f7c61a214292591794ecf73f8cc4a84b99a7a56a7"

URI_aarch64_root-cling = "${EPEL_MIRROR}/aarch64/Packages/r/root-cling-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-cling;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-cling}"
SRC_URI[aarch64_root-cling.sha256sum] = "365f1ad37ea27e1d355d8cac57363452e9257f98158ce8e29ddef19d6f08d688"

URI_aarch64_root-core = "${EPEL_MIRROR}/aarch64/Packages/r/root-core-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-core}"
SRC_URI[aarch64_root-core.sha256sum] = "0cbca99e372f69f6cb769fa7c297f7493a1a5f5487eae91a9f328105a9633aea"

URI_aarch64_root-fftw = "${EPEL_MIRROR}/aarch64/Packages/r/root-fftw-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-fftw;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-fftw}"
SRC_URI[aarch64_root-fftw.sha256sum] = "c5eebfed6be988676817b8f77b8a710ca8e01e2ac6c838e31fe711960d353e89"

URI_aarch64_root-foam = "${EPEL_MIRROR}/aarch64/Packages/r/root-foam-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-foam;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-foam}"
SRC_URI[aarch64_root-foam.sha256sum] = "a0f06630ee2d165064da9139f5068269a7de3bfd61b697f480dc02808472d3e7"

URI_aarch64_root-font-files = "${EPEL_MIRROR}/aarch64/Packages/r/root-font-files-6.38.04-1.el10_1.noarch.rpm;name=aarch64_root-font-files;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-font-files}"
SRC_URI[aarch64_root-font-files.sha256sum] = "a3d79fbe0bd06d8546392684d078b13dbee43c0bf8ab97af0cf52c80399b23de"

URI_aarch64_root-fumili = "${EPEL_MIRROR}/aarch64/Packages/r/root-fumili-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-fumili;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-fumili}"
SRC_URI[aarch64_root-fumili.sha256sum] = "be5e3851bf2a2f365e71b1a9524cd5349614b3fa5072f5fe81f27b0965d6f8fe"

URI_aarch64_root-gdml = "${EPEL_MIRROR}/aarch64/Packages/r/root-gdml-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gdml;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gdml}"
SRC_URI[aarch64_root-gdml.sha256sum] = "efaa01fe9ce54a02c6b4e2650fb28002d0754d754bb592a65a88a1caf3c0f88e"

URI_aarch64_root-genetic = "${EPEL_MIRROR}/aarch64/Packages/r/root-genetic-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-genetic;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-genetic}"
SRC_URI[aarch64_root-genetic.sha256sum] = "cbeec6a4bee0829df0c27183c77d6189158be4749b49c9e936902283d26e8711"

URI_aarch64_root-genvector = "${EPEL_MIRROR}/aarch64/Packages/r/root-genvector-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-genvector;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-genvector}"
SRC_URI[aarch64_root-genvector.sha256sum] = "5803cdeaeaaf3d893fc660aabc924b07058b4429ee8221c0f98ad85d8b74c906"

URI_aarch64_root-geom = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-geom;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom}"
SRC_URI[aarch64_root-geom.sha256sum] = "1297d89010e06384b8dcdb10682176b49c399612d38a8b200e721561aa2fbb6c"

URI_aarch64_root-geom-builder = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-builder-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-geom-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-builder}"
SRC_URI[aarch64_root-geom-builder.sha256sum] = "6ed3a02d1e5ef2ec5a1f6103a5355d21a233e7b12bf3993c11250cc052bfc49a"

URI_aarch64_root-geom-checker = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-checker-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-geom-checker;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-checker}"
SRC_URI[aarch64_root-geom-checker.sha256sum] = "e093a6b845528386d5c6f6636c64e403913143d688f532ac6977a4ec4c3b84ee"

URI_aarch64_root-geom-painter = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-painter-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-geom-painter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-painter}"
SRC_URI[aarch64_root-geom-painter.sha256sum] = "439d3104306574b0f636e2de7b60751bb4d445f12aee274ad43dcb521244ad95"

URI_aarch64_root-geom-webviewer = "${EPEL_MIRROR}/aarch64/Packages/r/root-geom-webviewer-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-geom-webviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-geom-webviewer}"
SRC_URI[aarch64_root-geom-webviewer.sha256sum] = "6cdb1a649569b26f192132db8641f82df4bb792a4679ec6dc624d4691a999777"

URI_aarch64_root-graf = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf}"
SRC_URI[aarch64_root-graf.sha256sum] = "a6c495e9a1dfe154fc6d1a7b4afad4c7d2206562c268939fee8b7d942564a34c"

URI_aarch64_root-graf-asimage = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-asimage-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf-asimage;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-asimage}"
SRC_URI[aarch64_root-graf-asimage.sha256sum] = "c968e57bcd562ab78616b5dddbb1ebcd73fc3f49294be1c55056cfe60aeb12fc"

URI_aarch64_root-graf-fitsio = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-fitsio-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf-fitsio;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-fitsio}"
SRC_URI[aarch64_root-graf-fitsio.sha256sum] = "417be23e083fe48193384779e40039aec3196eeff233d932d74d69724ad7b2ab"

URI_aarch64_root-graf-gpad = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpad-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf-gpad;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-gpad}"
SRC_URI[aarch64_root-graf-gpad.sha256sum] = "b8a7305dda5c94ed71902cedc59817641ccde3e07361f4aef69fdb7616426762"

URI_aarch64_root-graf-gpadv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gpadv7-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf-gpadv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-gpadv7}"
SRC_URI[aarch64_root-graf-gpadv7.sha256sum] = "73afe8d1f3e7bf95e69176f0330ee0182618021409d3d292dcef4ebc34777dba"

URI_aarch64_root-graf-gviz = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-gviz-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf-gviz;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-gviz}"
SRC_URI[aarch64_root-graf-gviz.sha256sum] = "0c082ce2805cf01aa71ecaa265f34bc92ed7fa0475caacd776a0d9d674bfca34"

URI_aarch64_root-graf-postscript = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-postscript-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf-postscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-postscript}"
SRC_URI[aarch64_root-graf-postscript.sha256sum] = "62843cbe760e6984018aaf73c56df4257d9ff36d5b7f7418d45bc5679a37b352"

URI_aarch64_root-graf-primitives = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-primitives-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf-primitives;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-primitives}"
SRC_URI[aarch64_root-graf-primitives.sha256sum] = "0701c7cb6a05a73ecce5daa04bdf2ea8716911f9063b0190ee5ce489b7dcb0fe"

URI_aarch64_root-graf-x11 = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf-x11-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf-x11}"
SRC_URI[aarch64_root-graf-x11.sha256sum] = "3623c187c2403b45c58af0d24856c51e41872589b4173263ae3d55aa8359dd6a"

URI_aarch64_root-graf3d = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d}"
SRC_URI[aarch64_root-graf3d.sha256sum] = "7c57e4f611c486bd74f86eb1276677f21bc9f3881367e57d016719115126e49e"

URI_aarch64_root-graf3d-csg = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-csg-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf3d-csg;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-csg}"
SRC_URI[aarch64_root-graf3d-csg.sha256sum] = "b0b09f5e14055152211d3749abcb6be0ada8e3a6ab27172f70e9b1a45f26414e"

URI_aarch64_root-graf3d-eve = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf3d-eve;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-eve}"
SRC_URI[aarch64_root-graf3d-eve.sha256sum] = "10dd981271e0f0ab322ba92a57e7797eeda99841a6160765872a60d6af73e039"

URI_aarch64_root-graf3d-eve7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-eve7-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf3d-eve7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-eve7}"
SRC_URI[aarch64_root-graf3d-eve7.sha256sum] = "1b31c6d884e2b74fc01935fcf2f02e76c16512643dcf7435117cf5303b83c375"

URI_aarch64_root-graf3d-gl = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gl-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf3d-gl;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-gl}"
SRC_URI[aarch64_root-graf3d-gl.sha256sum] = "a9e69bf76200eaceb7083f6919d4ee69b3a257bf2dbc1a57e1b25f284f697a22"

URI_aarch64_root-graf3d-gviz3d = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-gviz3d-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf3d-gviz3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-gviz3d}"
SRC_URI[aarch64_root-graf3d-gviz3d.sha256sum] = "910789fe104929299bdc4f3d63231d64c05b08454634c7c289e5f770488e3827"

URI_aarch64_root-graf3d-x3d = "${EPEL_MIRROR}/aarch64/Packages/r/root-graf3d-x3d-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-graf3d-x3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-graf3d-x3d}"
SRC_URI[aarch64_root-graf3d-x3d.sha256sum] = "9af7cb799d09a9b78326a057a59a557da98e7f8ce43b0e006dc81695f80a7f04"

URI_aarch64_root-gui = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui}"
SRC_URI[aarch64_root-gui.sha256sum] = "ed4024aa5330bc1e3a5c60f0fce6cb1107f6bd400cd909b717c578df1b05ceed"

URI_aarch64_root-gui-browsable = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-browsable;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browsable}"
SRC_URI[aarch64_root-gui-browsable.sha256sum] = "6ee2bd95306d302fd2811f063333e60080d5ff8b59d29d5de5df200139e7c405"

URI_aarch64_root-gui-browsable-v7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browsable-v7-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-browsable-v7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browsable-v7}"
SRC_URI[aarch64_root-gui-browsable-v7.sha256sum] = "f170fa1f8843838536908bf70b4fdc215af8b93c936f1edfbc2dace7cca22b9f"

URI_aarch64_root-gui-browserv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-browserv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browserv7}"
SRC_URI[aarch64_root-gui-browserv7.sha256sum] = "988d5cc5454d00839889e717c01ee2463ea6f5df2442e324a7c164dd3aa17f28"

URI_aarch64_root-gui-browserv7-v7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-browserv7-v7-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-browserv7-v7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-browserv7-v7}"
SRC_URI[aarch64_root-gui-browserv7-v7.sha256sum] = "a88721e79be0c5a664897deccd112d31900e985a159667512b9c89364b9243f0"

URI_aarch64_root-gui-builder = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-builder-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-builder}"
SRC_URI[aarch64_root-gui-builder.sha256sum] = "fb21829458143d558b08db10701538385e3a53ef0cd6a42c7048848a615aa020"

URI_aarch64_root-gui-canvaspainter = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-canvaspainter-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-canvaspainter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-canvaspainter}"
SRC_URI[aarch64_root-gui-canvaspainter.sha256sum] = "4123de08fbb31c9c10b3069f33a88ff55e5ef4aaa783ceba2ea9516ae4bf0f06"

URI_aarch64_root-gui-fitpanel = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanel-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-fitpanel;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-fitpanel}"
SRC_URI[aarch64_root-gui-fitpanel.sha256sum] = "9d7b5827f51fb053978cdabbf8d638af896ae1f733cbb87a403eee7ca683b461"

URI_aarch64_root-gui-fitpanelv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-fitpanelv7-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-fitpanelv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-fitpanelv7}"
SRC_URI[aarch64_root-gui-fitpanelv7.sha256sum] = "f4b70376347b418e57641372c6735013308a4ce9953e81636cbc07bb3964181c"

URI_aarch64_root-gui-ged = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-ged-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-ged;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-ged}"
SRC_URI[aarch64_root-gui-ged.sha256sum] = "3200588b871e962c8ce1af543df08391e2d134d746efe80dff854ca59a0e89ff"

URI_aarch64_root-gui-html = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-html-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-html}"
SRC_URI[aarch64_root-gui-html.sha256sum] = "213e674271e8d1cdd6bd4bc39c7d18dfe7793e6766619a294c6fedbc95a8a2df"

URI_aarch64_root-gui-qt6webdisplay = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-qt6webdisplay-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-qt6webdisplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-qt6webdisplay}"
SRC_URI[aarch64_root-gui-qt6webdisplay.sha256sum] = "17fe051a50adb23245107c51f010dae356b775c5d41e5a06eaa4b1068bb26de2"

URI_aarch64_root-gui-recorder = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-recorder-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-recorder;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-recorder}"
SRC_URI[aarch64_root-gui-recorder.sha256sum] = "4003811b48963741650929a85217fd542e062c386247648a3a93a21db5a6fa11"

URI_aarch64_root-gui-treemap = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-treemap-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-treemap;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-treemap}"
SRC_URI[aarch64_root-gui-treemap.sha256sum] = "c1f40d1f40e6b762d3b67da60e9ec93b8f8122ad5c774fa875797e3b429c6aab"

URI_aarch64_root-gui-webdisplay = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webdisplay-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-webdisplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-webdisplay}"
SRC_URI[aarch64_root-gui-webdisplay.sha256sum] = "ca6c70d9188a912ee134e954e0e9cf02a8e3e56cfb1d1c4ad52300c561ed2512"

URI_aarch64_root-gui-webgui6 = "${EPEL_MIRROR}/aarch64/Packages/r/root-gui-webgui6-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-gui-webgui6;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-gui-webgui6}"
SRC_URI[aarch64_root-gui-webgui6.sha256sum] = "6274bdcf04985aee2288f28a7f61378360c47c489c23a3fa47ebe1cd13d78b9b"

URI_aarch64_root-hbook = "${EPEL_MIRROR}/aarch64/Packages/r/root-hbook-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-hbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hbook}"
SRC_URI[aarch64_root-hbook.sha256sum] = "49a2a2f13d1f182be797fbf727848c4af0298107b82c0e42d09b7bb2fc5fe255"

URI_aarch64_root-hist = "${EPEL_MIRROR}/aarch64/Packages/r/root-hist-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-hist;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hist}"
SRC_URI[aarch64_root-hist.sha256sum] = "39c86b065ad55662660ad56a58b9dfcd9fd581ee8ef444f9055595e17510e6fc"

URI_aarch64_root-hist-factory = "${EPEL_MIRROR}/aarch64/Packages/r/root-hist-factory-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-hist-factory;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hist-factory}"
SRC_URI[aarch64_root-hist-factory.sha256sum] = "8988164bb80565513b9814cb93330b1dd8618fa20f7041d112e683dc1979a1e5"

URI_aarch64_root-hist-painter = "${EPEL_MIRROR}/aarch64/Packages/r/root-hist-painter-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-hist-painter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-hist-painter}"
SRC_URI[aarch64_root-hist-painter.sha256sum] = "92498f53b43866ebe0484b8f908c151ebbc7e4dfb4a3c4774a4de09eb05a55ab"

URI_aarch64_root-histv7 = "${EPEL_MIRROR}/aarch64/Packages/r/root-histv7-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-histv7;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-histv7}"
SRC_URI[aarch64_root-histv7.sha256sum] = "f7d5dc8abad2632f5a128a7ca0a87acc0035362c32e5893db85feb3f1f0869ea"

URI_aarch64_root-icons = "${EPEL_MIRROR}/aarch64/Packages/r/root-icons-6.38.04-1.el10_1.noarch.rpm;name=aarch64_root-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-icons}"
SRC_URI[aarch64_root-icons.sha256sum] = "eaee5e0589c6ee0548b8b7371bf03c5e4cb29ad87cba7ad152a8bc9838f8e0cf"

URI_aarch64_root-io = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-io;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io}"
SRC_URI[aarch64_root-io.sha256sum] = "3df9f90c3b508f8f6fd8eca89bdad91d109f697f7e3a90c523238fe5d73cf8b3"

URI_aarch64_root-io-dcache = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-dcache-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-io-dcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-dcache}"
SRC_URI[aarch64_root-io-dcache.sha256sum] = "57e11e37d9153755a1b1eb05ab01422a0a1bef77a404dcdd0dc07bc244b2a834"

URI_aarch64_root-io-sql = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-sql-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-io-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-sql}"
SRC_URI[aarch64_root-io-sql.sha256sum] = "e7e59bd76db21030812b6f33ad03f04238ffc2c93a48c4a2d6da9a07edb02c0d"

URI_aarch64_root-io-xml = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-xml-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-io-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-xml}"
SRC_URI[aarch64_root-io-xml.sha256sum] = "400b5ea20047f04a65b44b9f778637b666345b97f141f8b14c9bea8158407d95"

URI_aarch64_root-io-xmlparser = "${EPEL_MIRROR}/aarch64/Packages/r/root-io-xmlparser-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-io-xmlparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-io-xmlparser}"
SRC_URI[aarch64_root-io-xmlparser.sha256sum] = "2ee39e4be5f2bcbc5e045cff317ec07a1aabe1c649800ccb3819f2277d519d97"

URI_aarch64_root-mathcore = "${EPEL_MIRROR}/aarch64/Packages/r/root-mathcore-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-mathcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-mathcore}"
SRC_URI[aarch64_root-mathcore.sha256sum] = "3718d723c5389ea6fec729188411ce834955a32b571eb9fd70f49cdcba7d65b5"

URI_aarch64_root-mathmore = "${EPEL_MIRROR}/aarch64/Packages/r/root-mathmore-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-mathmore;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-mathmore}"
SRC_URI[aarch64_root-mathmore.sha256sum] = "c022608991336e43246fb942c9b343ca7bee3eb9e3c0a09fd1506785fd298dfc"

URI_aarch64_root-matrix = "${EPEL_MIRROR}/aarch64/Packages/r/root-matrix-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-matrix;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-matrix}"
SRC_URI[aarch64_root-matrix.sha256sum] = "915a19ea8ed18115c83f3999c3a89a4f30ff58971216c200e4bbb45052672495"

URI_aarch64_root-minuit = "${EPEL_MIRROR}/aarch64/Packages/r/root-minuit-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-minuit;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-minuit}"
SRC_URI[aarch64_root-minuit.sha256sum] = "49e3a89fdf61dff93e81e658d7eae8ea98548d4519500d480a230b34078ae29c"

URI_aarch64_root-minuit2 = "${EPEL_MIRROR}/aarch64/Packages/r/root-minuit2-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-minuit2;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-minuit2}"
SRC_URI[aarch64_root-minuit2.sha256sum] = "5937abb9d90398f87601f420aa8a4a12e184a69cd18863c8e1801ca270fb052e"

URI_aarch64_root-mlp = "${EPEL_MIRROR}/aarch64/Packages/r/root-mlp-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-mlp;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-mlp}"
SRC_URI[aarch64_root-mlp.sha256sum] = "b5fbf0ec263d1be1df34ccb6e3c2cd2c6b0c5e707165f91823ed05ed8ebb05a7"

URI_aarch64_root-montecarlo-eg = "${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-eg-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-montecarlo-eg;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-montecarlo-eg}"
SRC_URI[aarch64_root-montecarlo-eg.sha256sum] = "a9e8a73427976a0f185b91ef9cf518c766f5b9497990ac14b5455c508d3bb128"

URI_aarch64_root-montecarlo-pythia8 = "${EPEL_MIRROR}/aarch64/Packages/r/root-montecarlo-pythia8-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-montecarlo-pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-montecarlo-pythia8}"
SRC_URI[aarch64_root-montecarlo-pythia8.sha256sum] = "56490dd279abc8bf3c5bbee457d9c10d57caff8a37d38c0bb793e5024a86d6c2"

URI_aarch64_root-multiproc = "${EPEL_MIRROR}/aarch64/Packages/r/root-multiproc-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-multiproc;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-multiproc}"
SRC_URI[aarch64_root-multiproc.sha256sum] = "d8c951fe78a1089129332c3bf2736cb7f7c64483d54e8f7a1ccc059a4f1556a8"

URI_aarch64_root-net = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-net;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net}"
SRC_URI[aarch64_root-net.sha256sum] = "d6a10a46944fb0d780c5f739fe3ec38a6ce678fec857375f13b2704c643b432f"

URI_aarch64_root-net-auth = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-auth-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-net-auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-auth}"
SRC_URI[aarch64_root-net-auth.sha256sum] = "6509ef6feb4388068bb2066da90bee169e98bbaffc606ce60748c35fda1a0ac8"

URI_aarch64_root-net-davix = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-davix-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-net-davix;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-davix}"
SRC_URI[aarch64_root-net-davix.sha256sum] = "4837f25bb52dc330d6b225379d8e9515489cd57fd2a5917e83f2a0592dd650d0"

URI_aarch64_root-net-http = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-http-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-net-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-http}"
SRC_URI[aarch64_root-net-http.sha256sum] = "f6da1e58b4a5a1243cf7a6f3d230395793bfc5860020151fcbac4809b03c195c"

URI_aarch64_root-net-httpsniff = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-httpsniff-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-net-httpsniff;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-httpsniff}"
SRC_URI[aarch64_root-net-httpsniff.sha256sum] = "a885b8db31f386249b75f8706324660b2be2e5653419bdc3682e8e02f931e0ed"

URI_aarch64_root-net-rpdutils = "${EPEL_MIRROR}/aarch64/Packages/r/root-net-rpdutils-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-net-rpdutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-net-rpdutils}"
SRC_URI[aarch64_root-net-rpdutils.sha256sum] = "acc44c3fb8bc56e051b2d8651b970e1a0a7b10b89b4c50caf895ec4dc51ca118"

URI_aarch64_root-netx = "${EPEL_MIRROR}/aarch64/Packages/r/root-netx-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-netx;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-netx}"
SRC_URI[aarch64_root-netx.sha256sum] = "c8dfe5dafdcbe43c5136813fa9ee8d848469304bc8cb131ae430ba19341d9728"

URI_aarch64_root-physics = "${EPEL_MIRROR}/aarch64/Packages/r/root-physics-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-physics;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-physics}"
SRC_URI[aarch64_root-physics.sha256sum] = "71f952e40c155ad3fdf96771d51d7c3bef6a519bde56e9ff44f2dc2a293f81e4"

URI_aarch64_root-quadp = "${EPEL_MIRROR}/aarch64/Packages/r/root-quadp-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-quadp;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-quadp}"
SRC_URI[aarch64_root-quadp.sha256sum] = "12c364e57328752723473c35e963d615d1a2f64a927c18e4638745ac8a98cedc"

URI_aarch64_root-r = "${EPEL_MIRROR}/aarch64/Packages/r/root-r-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-r;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-r}"
SRC_URI[aarch64_root-r.sha256sum] = "3d8507484e1d92b7bdab108deecfecd07bcf8709c6d5253c2df58ecf9ca1ffaf"

URI_aarch64_root-r-tools = "${EPEL_MIRROR}/aarch64/Packages/r/root-r-tools-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-r-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-r-tools}"
SRC_URI[aarch64_root-r-tools.sha256sum] = "afd5c6f60df163db527098b5da112faee02214cb47d3400b49c0871725cd46a7"

URI_aarch64_root-roofit = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roofit;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit}"
SRC_URI[aarch64_root-roofit.sha256sum] = "6524bfc1403462a9235fe38d2a91ea4d86ad66d5969f1a985158e9b0e74a0d2f"

URI_aarch64_root-roofit-batchcompute = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-batchcompute-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roofit-batchcompute;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-batchcompute}"
SRC_URI[aarch64_root-roofit-batchcompute.sha256sum] = "9d50e2e57f301b546fd2ac1fa0393f9bbffe309c1dd20fd61e3ea8f661c72473"

URI_aarch64_root-roofit-codegen = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-codegen-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roofit-codegen;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-codegen}"
SRC_URI[aarch64_root-roofit-codegen.sha256sum] = "eadb6e533512ea2d65667eaf24b7ae91d264bc0e5450af16dd2c280035606de4"

URI_aarch64_root-roofit-core = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-core-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roofit-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-core}"
SRC_URI[aarch64_root-roofit-core.sha256sum] = "6959788f825b45a0701f412e159e20b75ed85245fa20c4b93beea626f39b6513"

URI_aarch64_root-roofit-hs3 = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-hs3-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roofit-hs3;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-hs3}"
SRC_URI[aarch64_root-roofit-hs3.sha256sum] = "d39a221cbb0d230785df9e40fea9901125616a4b38778beb9df95001d6105908"

URI_aarch64_root-roofit-jsoninterface = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-jsoninterface-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roofit-jsoninterface;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-jsoninterface}"
SRC_URI[aarch64_root-roofit-jsoninterface.sha256sum] = "bd83f066bcff1472a38354dd9b819faf3a5a9da730fe7d17d88bc1838bee60b3"

URI_aarch64_root-roofit-more = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-more-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roofit-more;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-more}"
SRC_URI[aarch64_root-roofit-more.sha256sum] = "fe02f7410e0dc71756503d26b38e4782927feb17c03257b88d1b90bc16ea36d2"

URI_aarch64_root-roofit-multiprocess = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-multiprocess-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roofit-multiprocess;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-multiprocess}"
SRC_URI[aarch64_root-roofit-multiprocess.sha256sum] = "8a406e0800179bb439c1c61ad08e38dd04900bc1b94445890779ecbf06c05e01"

URI_aarch64_root-roofit-zmq = "${EPEL_MIRROR}/aarch64/Packages/r/root-roofit-zmq-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roofit-zmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roofit-zmq}"
SRC_URI[aarch64_root-roofit-zmq.sha256sum] = "83fb83acf497bbd8eca7244b65c77966979ee136a9be425c1e6ff0600cca0541"

URI_aarch64_root-roostats = "${EPEL_MIRROR}/aarch64/Packages/r/root-roostats-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-roostats;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-roostats}"
SRC_URI[aarch64_root-roostats.sha256sum] = "70c702017296cd3ea557de66bfe1d756e998c6af306a7d2f4b5df5c6d119ae9c"

URI_aarch64_root-smatrix = "${EPEL_MIRROR}/aarch64/Packages/r/root-smatrix-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-smatrix;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-smatrix}"
SRC_URI[aarch64_root-smatrix.sha256sum] = "c55bc5810d981adf59a6f33a376cbdfc2783fda72749741ee6dfc465cea8e80d"

URI_aarch64_root-spectrum = "${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-spectrum;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-spectrum}"
SRC_URI[aarch64_root-spectrum.sha256sum] = "64f70af3e49355467de6c40d052d95a2ff52d609fa52d4fca63506e301f25b57"

URI_aarch64_root-spectrum-painter = "${EPEL_MIRROR}/aarch64/Packages/r/root-spectrum-painter-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-spectrum-painter;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-spectrum-painter}"
SRC_URI[aarch64_root-spectrum-painter.sha256sum] = "f2f0f577fec36f2d0079dfaf3aefb1aa598789347b556dce8aaad6484dd109cc"

URI_aarch64_root-splot = "${EPEL_MIRROR}/aarch64/Packages/r/root-splot-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-splot;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-splot}"
SRC_URI[aarch64_root-splot.sha256sum] = "8c64045442899ef2c31a1536a9eb3611f713ef053dad5f960a9028ef9a3cfd14"

URI_aarch64_root-sql-sqlite = "${EPEL_MIRROR}/aarch64/Packages/r/root-sql-sqlite-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-sql-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-sql-sqlite}"
SRC_URI[aarch64_root-sql-sqlite.sha256sum] = "1f6f393cb712baceba4c850a0a620320b064f29a020fdcb4da24496bcbeab5b5"

URI_aarch64_root-testsupport = "${EPEL_MIRROR}/aarch64/Packages/r/root-testsupport-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-testsupport;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-testsupport}"
SRC_URI[aarch64_root-testsupport.sha256sum] = "39b171c74dd9a41790e500d38251d98e4ce306284df9b091036a462e19820389"

URI_aarch64_root-tmva = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tmva;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva}"
SRC_URI[aarch64_root-tmva.sha256sum] = "7838ed1af768d6330a91239a14acb892249ead503c347d899359d5454bc2dde8"

URI_aarch64_root-tmva-gui = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-gui-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tmva-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-gui}"
SRC_URI[aarch64_root-tmva-gui.sha256sum] = "e7389406b8a58f0afa24f72bb2b44b094d5cc7433d26b2d5e0c10a559803b349"

URI_aarch64_root-tmva-python = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-python-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tmva-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-python}"
SRC_URI[aarch64_root-tmva-python.sha256sum] = "06d1c0b4291f8314bea648036133d8eab042538d26deebe0f94582b73646e1a0"

URI_aarch64_root-tmva-r = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-r-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tmva-r;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-r}"
SRC_URI[aarch64_root-tmva-r.sha256sum] = "d6447c6d87ed545438037993ccd56a128a9781a8b800d12e10e1a559f90424c9"

URI_aarch64_root-tmva-sofie = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tmva-sofie;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-sofie}"
SRC_URI[aarch64_root-tmva-sofie.sha256sum] = "aaf5ce392fc7f12d24db7dae3197ed543b469addcb32e5c145acc7e3b648b31e"

URI_aarch64_root-tmva-sofie-parser = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-sofie-parser-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tmva-sofie-parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-sofie-parser}"
SRC_URI[aarch64_root-tmva-sofie-parser.sha256sum] = "ea6ffca8080b7d02bd12555d126ab8449281831c82b0d3d2f5a529d5adcfe576"

URI_aarch64_root-tmva-utils = "${EPEL_MIRROR}/aarch64/Packages/r/root-tmva-utils-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tmva-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tmva-utils}"
SRC_URI[aarch64_root-tmva-utils.sha256sum] = "1c5058c73140caba2bce4221ec29ab627180b0735bcac2470ed8e917c5feb3f8"

URI_aarch64_root-tpython = "${EPEL_MIRROR}/aarch64/Packages/r/root-tpython-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tpython;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tpython}"
SRC_URI[aarch64_root-tpython.sha256sum] = "14a44bce609f56153e0c15e911abef5721f293d87baa64081b03e6e60e07d177"

URI_aarch64_root-tree = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tree;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree}"
SRC_URI[aarch64_root-tree.sha256sum] = "7e553ca99a63e826c6b4a00aacb9b359b8942b6b30b2270d51652779cc007bc2"

URI_aarch64_root-tree-dataframe = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-dataframe-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tree-dataframe;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-dataframe}"
SRC_URI[aarch64_root-tree-dataframe.sha256sum] = "aa961c884faeeef788b7049fb03d6f9d1e546cdffb661d4155e2c1883a5fb995"

URI_aarch64_root-tree-ntuple = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tree-ntuple;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ntuple}"
SRC_URI[aarch64_root-tree-ntuple.sha256sum] = "600a28bf8451a31391587be32b9db64794c350b9b4de384eafc8b322451f3d50"

URI_aarch64_root-tree-ntuple-browse = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-browse-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tree-ntuple-browse;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ntuple-browse}"
SRC_URI[aarch64_root-tree-ntuple-browse.sha256sum] = "9b86c12a1c3866f324dbcc42917c1054ff10001a2d7c18781901496a8391eb31"

URI_aarch64_root-tree-ntuple-utils = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-ntuple-utils-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tree-ntuple-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-ntuple-utils}"
SRC_URI[aarch64_root-tree-ntuple-utils.sha256sum] = "59a900431848907fec296e51907cc0ef2cb92462f8be461dfcd38846580614f6"

URI_aarch64_root-tree-player = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-player-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tree-player;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-player}"
SRC_URI[aarch64_root-tree-player.sha256sum] = "14ce2f00d5cf8154ecaed238ce5a03c08551e50d9f0bdd7771566bc25ff3e4d4"

URI_aarch64_root-tree-viewer = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-viewer-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tree-viewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-viewer}"
SRC_URI[aarch64_root-tree-viewer.sha256sum] = "7830cfc76fdc40e4c13da8381aceef9a144d931f06e1e1fa05b4b60ef2ae7bd2"

URI_aarch64_root-tree-webviewer = "${EPEL_MIRROR}/aarch64/Packages/r/root-tree-webviewer-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-tree-webviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tree-webviewer}"
SRC_URI[aarch64_root-tree-webviewer.sha256sum] = "3f6bc300983ff88ee7926c5079c7c1241e43f483cea95ceedc324d63604b09ef"

URI_aarch64_root-tutorial = "${EPEL_MIRROR}/aarch64/Packages/r/root-tutorial-6.38.04-1.el10_1.noarch.rpm;name=aarch64_root-tutorial;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-tutorial}"
SRC_URI[aarch64_root-tutorial.sha256sum] = "706d218eeeb060573865d8c1c34f2e8eabd06afdc1e7728742f28e8926142426"

URI_aarch64_root-unfold = "${EPEL_MIRROR}/aarch64/Packages/r/root-unfold-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-unfold;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-unfold}"
SRC_URI[aarch64_root-unfold.sha256sum] = "c45bba19f79a7d0b5c39bb7888460f3a2fb2c1b02c7e62cea0607c4a1ab72156"

URI_aarch64_root-unuran = "${EPEL_MIRROR}/aarch64/Packages/r/root-unuran-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-unuran;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-unuran}"
SRC_URI[aarch64_root-unuran.sha256sum] = "8eaa40003bd22c8efd4a1239b014bbd3c1202d86f385591adbdb604f1a9ab6ea"

URI_aarch64_root-vecops = "${EPEL_MIRROR}/aarch64/Packages/r/root-vecops-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-vecops;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-vecops}"
SRC_URI[aarch64_root-vecops.sha256sum] = "7b8cf71a601f2579de22b49fbeec9fbb5fa5c7468af25a8ba32f183026033d13"

URI_aarch64_root-xroofit = "${EPEL_MIRROR}/aarch64/Packages/r/root-xroofit-6.38.04-1.el10_1.aarch64.rpm;name=aarch64_root-xroofit;unpack=0"
SRC_URI:append = " ${URI_aarch64_root-xroofit}"
SRC_URI[aarch64_root-xroofit.sha256sum] = "b799c27bab0399d3f3e764711478f086971adb405972090c8b32aa170d327850"

RDEPENDS:python3-distrdf = " \
 python3 \
 python3-root \
 root-tree-dataframe \
 "
RDEPENDS:python3-jupyroot = " \
 bash \
 js-jsroot \
 python-jupyter-filesystem \
 python3 \
 python3-ipython \
 python3-metakernel \
 python3-notebook \
 python3-root \
 root-core \
 "
RDEPENDS:python3-root = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-io \
 root-tree \
 "
RDEPENDS:root = " \
 bash \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 liburing \
 root-core \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 "
RDEPENDS:root-cli = " \
 python3 \
 python3-root \
 "
RDEPENDS:root-cling = " \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 python3 \
 redhat-rpm-config \
 root-core \
 root-io \
 zlib-ng-compat \
 "
RDEPENDS:root-core = " \
 bash \
 glibc \
 gnu-free-mono-fonts \
 gnu-free-sans-fonts \
 gnu-free-serif-fonts \
 google-droid-sans-fonts \
 json-devel \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 pcre2 \
 root-cling \
 root-font-files \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf-postscript \
 root-graf3d \
 root-hist \
 root-icons \
 root-io \
 root-mathcore \
 root-matrix \
 root-multiproc \
 root-net \
 root-physics \
 root-tree \
 root-tree-dataframe \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 root-tree-player \
 root-vecops \
 tbb \
 urw-base35-d050000l-fonts \
 urw-base35-standard-symbols-ps-fonts \
 urw-base35-z003-fonts \
 xorg-x11-fonts-ISO8859-1-75dpi \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:root-fftw = " \
 fftw-libs-double \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-foam = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-font-files = " \
 root-core \
 "
RDEPENDS:root-fumili = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-gdml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-hist \
 root-io-xml \
 "
RDEPENDS:root-genetic = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-tmva \
 "
RDEPENDS:root-genvector = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-geom = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-geom-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-geom-checker = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-geom-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 "
RDEPENDS:root-geom-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-painter \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-graf = " \
 fontconfig \
 freetype \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-asimage = " \
 fontconfig \
 freetype \
 giflib \
 glibc \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-postscript \
 root-gui \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-fitsio = " \
 cfitsio \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-matrix \
 "
RDEPENDS:root-graf-gpad = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-postscript \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-graf-gpadv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf-gviz = " \
 glibc \
 graphviz \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
 "
RDEPENDS:root-graf-postscript = " \
 fontconfig \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 zlib-ng-compat \
 "
RDEPENDS:root-graf-primitives = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 "
RDEPENDS:root-graf-x11 = " \
 freetype \
 glibc \
 libX11 \
 libXext \
 libXft \
 libXpm \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-graf3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-graf3d-csg = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-graf3d-eve = " \
 glibc \
 libgcc \
 libglvnd-opengl \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-geom \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-eve7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf \
 root-graf3d \
 root-graf3d-csg \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 root-montecarlo-eg \
 root-net-http \
 root-physics \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-graf3d-gl = " \
 fontconfig \
 ftgl \
 gl2ps \
 glibc \
 libGLEW \
 libX11 \
 libgcc \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 mesa-libGLU \
 root-core \
 root-graf \
 root-graf-asimage \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-csg \
 root-gui \
 root-gui-ged \
 root-hist \
 root-mathcore \
 root-tree \
 "
RDEPENDS:root-graf3d-gviz3d = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-graf-gpad \
 root-graf3d \
 root-graf3d-gl \
 root-gui \
 root-gui-ged \
 "
RDEPENDS:root-graf3d-x3d = " \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 root-core \
 root-graf3d \
 root-gui \
 "
RDEPENDS:root-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf-x11 \
 root-gui-ged \
 root-io \
 root-mathcore \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browsable-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-treemap \
 root-hist \
 root-tree \
 root-tree-ntuple \
 root-tree-ntuple-browse \
 "
RDEPENDS:root-gui-browserv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-geom \
 root-geom-webviewer \
 root-graf-gpad \
 root-gui-browsable \
 root-gui-webdisplay \
 root-gui-webgui6 \
 root-io \
 root-tree \
 root-tree-webviewer \
 "
RDEPENDS:root-gui-browserv7-v7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-browsable \
 root-gui-browserv7 \
 "
RDEPENDS:root-gui-builder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-mathcore \
 "
RDEPENDS:root-gui-canvaspainter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-io \
 "
RDEPENDS:root-gui-fitpanel = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-fitpanelv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-graf-gpadv7 \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-mathcore \
 "
RDEPENDS:root-gui-ged = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-gui-html = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-gui \
 root-net \
 "
RDEPENDS:root-gui-qt6webdisplay = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 root-core \
 root-gui-webdisplay \
 root-net-http \
 "
RDEPENDS:root-gui-recorder = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf-gpad \
 root-gui \
 root-io \
 root-tree \
 "
RDEPENDS:root-gui-treemap = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 "
RDEPENDS:root-gui-webdisplay = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-mathcore \
 root-net \
 root-net-http \
 "
RDEPENDS:root-gui-webgui6 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-net-http \
 "
RDEPENDS:root-hbook = " \
 glibc \
 libgcc \
 libgfortran \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-hist = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-painter \
 root-io \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-hist-factory = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-io-xmlparser \
 root-roofit \
 root-roofit-core \
 root-roostats \
 "
RDEPENDS:root-hist-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-histv7 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-icons = " \
 root-core \
 "
RDEPENDS:root-io = " \
 glibc \
 libgcc \
 libstdc++ \
 liburing \
 liburing-devel \
 root-core \
 "
RDEPENDS:root-io-dcache = " \
 dcap-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-sql = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-io-xml = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-io-xmlparser = " \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 root-core \
 "
RDEPENDS:root-mathcore = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathmore \
 root-minuit2 \
 "
RDEPENDS:root-mathmore = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-matrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 "
RDEPENDS:root-minuit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-minuit2 = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 "
RDEPENDS:root-mlp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-mathcore \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-montecarlo-eg = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-mathcore \
 "
RDEPENDS:root-montecarlo-pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 root-core \
 root-montecarlo-eg \
 "
RDEPENDS:root-multiproc = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-net = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 root-core \
 root-io \
 "
RDEPENDS:root-net-auth = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-net-davix = " \
 davix-libs \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-net-http = " \
 bash \
 fcgi \
 glibc \
 js-jsroot \
 libgcc \
 libstdc++ \
 openssl-libs \
 root-core \
 root-io \
 "
RDEPENDS:root-net-httpsniff = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-net-http \
 root-tree \
 "
RDEPENDS:root-net-rpdutils = " \
 glibc \
 libgcc \
 libstdc++ \
 libxcrypt \
 root-core \
 root-net \
 "
RDEPENDS:root-netx = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:root-physics = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 "
RDEPENDS:root-quadp = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r = " \
 R-RInside \
 R-Rcpp \
 R-core \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 readline \
 root-core \
 root-matrix \
 "
RDEPENDS:root-r-tools = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-matrix \
 root-r \
 "
RDEPENDS:root-roofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit-batchcompute \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-roofit-batchcompute = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-roofit-codegen = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist-factory \
 root-roofit \
 root-roofit-core \
 "
RDEPENDS:root-roofit-core = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-foam \
 root-graf \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit2 \
 root-roofit-batchcompute \
 root-roofit-multiprocess \
 root-roofit-zmq \
 root-tree \
 zeromq \
 "
RDEPENDS:root-roofit-hs3 = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-hist-factory \
 root-matrix \
 root-roofit \
 root-roofit-core \
 root-roofit-jsoninterface \
 "
RDEPENDS:root-roofit-jsoninterface = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-roofit-more = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-mathcore \
 root-mathmore \
 root-roofit-core \
 "
RDEPENDS:root-roofit-multiprocess = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-roofit-zmq \
 zeromq \
 "
RDEPENDS:root-roofit-zmq = " \
 glibc \
 libgcc \
 libstdc++ \
 zeromq \
 "
RDEPENDS:root-roostats = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-roofit \
 root-roofit-core \
 root-tree \
 "
RDEPENDS:root-smatrix = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-spectrum = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 "
RDEPENDS:root-spectrum-painter = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-hist \
 "
RDEPENDS:root-splot = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-matrix \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-sql-sqlite = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-net \
 sqlite-libs \
 "
RDEPENDS:root-testsupport = " \
 root-core \
 "
RDEPENDS:root-tmva = " \
 glibc \
 gsl \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-hist \
 root-io \
 root-io-xml \
 root-mathcore \
 root-matrix \
 root-minuit \
 root-mlp \
 root-multiproc \
 root-net \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tmva-gui = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-hist \
 root-io \
 root-io-xml \
 root-matrix \
 root-tmva \
 root-tree \
 root-tree-viewer \
 "
RDEPENDS:root-tmva-python = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-numpy \
 root-core \
 root-tmva \
 root-tmva-sofie \
 root-tree \
 "
RDEPENDS:root-tmva-r = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-matrix \
 root-r \
 root-tmva \
 "
RDEPENDS:root-tmva-sofie = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tmva-sofie-parser = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 root-core \
 root-tmva-sofie \
 "
RDEPENDS:root-tmva-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 "
RDEPENDS:root-tpython = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 python3-root \
 root-core \
 "
RDEPENDS:root-tree = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-io \
 root-net \
 "
RDEPENDS:root-tree-dataframe = " \
 glibc \
 libarrow \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-ntuple \
 root-tree-player \
 root-vecops \
 sqlite-libs \
 "
RDEPENDS:root-tree-ntuple = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 root-core \
 root-io \
 xxhash-libs \
 "
RDEPENDS:root-tree-ntuple-browse = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui-treemap \
 root-hist \
 root-io \
 root-tree-ntuple \
 root-tree-ntuple-utils \
 "
RDEPENDS:root-tree-ntuple-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io \
 root-tree \
 root-tree-ntuple \
 "
RDEPENDS:root-tree-player = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-graf3d \
 root-hist \
 root-io \
 root-mathcore \
 root-multiproc \
 root-net \
 root-tree \
 "
RDEPENDS:root-tree-viewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-ged \
 root-hist \
 root-io \
 root-mathcore \
 root-tree \
 root-tree-player \
 "
RDEPENDS:root-tree-webviewer = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-gui-webdisplay \
 root-hist \
 root-io \
 root-tree \
 "
RDEPENDS:root-tutorial = " \
 root \
 "
RDEPENDS:root-unfold = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-io-xmlparser \
 root-matrix \
 "
RDEPENDS:root-unuran = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-hist \
 root-mathcore \
 unuran \
 "
RDEPENDS:root-vecops = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 "
RDEPENDS:root-xroofit = " \
 glibc \
 libgcc \
 libstdc++ \
 root-core \
 root-graf \
 root-graf-gpad \
 root-gui \
 root-gui-fitpanel \
 root-gui-ged \
 root-hist \
 root-hist-factory \
 root-io \
 root-mathcore \
 root-matrix \
 root-roofit \
 root-roofit-core \
 root-roofit-hs3 \
 root-roostats \
 root-tree \
 "
