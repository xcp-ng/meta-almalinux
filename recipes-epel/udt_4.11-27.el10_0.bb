# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "udt"
PV = "4.11"
PR = "27.el10_0"
PACKAGES = " \
 udt \
 udt-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/udt-4.11-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "01d14a1138fa77da757036194cb9c5e15264803393e3452fe962ff4c46fe78e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/udt-4.11-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_udt;unpack=0"
SRC_URI[x86_64_v2_udt.sha256sum] = "0a2c0cf2504447ceb849be310140685c2e3e5ffeab02691e13c7dd8d087cb4ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/udt-devel-4.11-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_udt-devel;unpack=0"
SRC_URI[x86_64_v2_udt-devel.sha256sum] = "6d6e336c4aa2f479c601bd7cad23acba5d7482f71e0f4319b806730b5000d7d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/udt-4.11-27.el10_0.aarch64.rpm;name=aarch64_udt;unpack=0"
SRC_URI[aarch64_udt.sha256sum] = "0fa35aa2a6b316b02f50a137cdac38d9bf3a86ee43bc5148d497228a068c9adc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/udt-devel-4.11-27.el10_0.aarch64.rpm;name=aarch64_udt-devel;unpack=0"
SRC_URI[aarch64_udt-devel.sha256sum] = "9f200caa118c4b3158d40778c60ebc00fba88c1adfab7cf0fe2f206c79002aa4"

RDEPENDS:udt = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:udt-devel = " \
 udt \
 "
