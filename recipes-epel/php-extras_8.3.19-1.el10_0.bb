# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-extras"
PV = "8.3.19"
PR = "1.el10_0"
PACKAGES = " \
 php-pdo-dblib \
 php-pspell \
 php-sodium \
 php-tidy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-extras-8.3.19-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc01d79519b9da8e895b98b176b4e2b67ce23f9e9300d54a30929b637dcde90e"

URI_x86_64_v2_php-pdo-dblib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pdo-dblib-8.3.19-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo-dblib}"
SRC_URI[x86_64_v2_php-pdo-dblib.sha256sum] = "4baec525b9905fe22d407495133809407a9c8ad38a376ad9e373a4bd2ce7fec6"

URI_x86_64_v2_php-pspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pspell-8.3.19-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pspell}"
SRC_URI[x86_64_v2_php-pspell.sha256sum] = "6942fc5a7c9c8cb6b89ca6054db74c2783d0cf6c1f58fe09e2f8e5fea7d85bf2"

URI_x86_64_v2_php-sodium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-sodium-8.3.19-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-sodium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-sodium}"
SRC_URI[x86_64_v2_php-sodium.sha256sum] = "3677d8271a1c2a116523c104d1434ae55fcbafe6ef7a17a99f10a57bf0d60016"

URI_x86_64_v2_php-tidy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-tidy-8.3.19-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-tidy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-tidy}"
SRC_URI[x86_64_v2_php-tidy.sha256sum] = "195b4bf10341df45fa2facb2273bc3ea91bf4c0ee24cfe7766c13b6c262c0875"

URI_aarch64_php-pdo-dblib = "${EPEL_MIRROR}/aarch64/Packages/p/php-pdo-dblib-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo-dblib}"
SRC_URI[aarch64_php-pdo-dblib.sha256sum] = "555577644d6652a4ecff982f49815283139c066b8ad9ab9f82c7e347a68466ce"

URI_aarch64_php-pspell = "${EPEL_MIRROR}/aarch64/Packages/p/php-pspell-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-pspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pspell}"
SRC_URI[aarch64_php-pspell.sha256sum] = "8efa8a59795f4f2d22a1c8fb775705f2669959595763d8441a61241f359b70d1"

URI_aarch64_php-sodium = "${EPEL_MIRROR}/aarch64/Packages/p/php-sodium-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-sodium;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-sodium}"
SRC_URI[aarch64_php-sodium.sha256sum] = "9ab008292ef46980ed2617e519307b66e8cdc03adced47a657d1aad7a2e95cff"

URI_aarch64_php-tidy = "${EPEL_MIRROR}/aarch64/Packages/p/php-tidy-8.3.19-1.el10_0.aarch64.rpm;name=aarch64_php-tidy;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-tidy}"
SRC_URI[aarch64_php-tidy.sha256sum] = "e997f86d8f02b01515530b349263f74453ae0a332d29fd2d3d0895dbbbe7c4a9"

RDEPENDS:php-pdo-dblib = " \
 freetds-libs \
 glibc \
 php-common \
 php-pdo \
 "
RDEPENDS:php-pspell = " \
 aspell \
 glibc \
 php-common \
 "
RDEPENDS:php-sodium = " \
 glibc \
 libsodium \
 php-common \
 "
RDEPENDS:php-tidy = " \
 glibc \
 libtidy \
 php-common \
 "
