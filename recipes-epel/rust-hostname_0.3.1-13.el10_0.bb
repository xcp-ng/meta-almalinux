# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hostname"
PV = "0.3.1"
PR = "13.el10_0"
PACKAGES = " \
 rust-hostname+default-devel \
 rust-hostname+set-devel \
 rust-hostname-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hostname-0.3.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77e169c6a71574419aaff647432dd1ed27f09ea8273f495b602ea930aed6669b"

URI_x86_64_v2_rust-hostname+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hostname+default-devel-0.3.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hostname+default-devel}"
SRC_URI[x86_64_v2_rust-hostname+default-devel.sha256sum] = "cc9f55210d179d348b37479b6fe679d86a85afd60d42811039f43b3fbd346445"

URI_x86_64_v2_rust-hostname+set-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hostname+set-devel-0.3.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hostname+set-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hostname+set-devel}"
SRC_URI[x86_64_v2_rust-hostname+set-devel.sha256sum] = "639b6b7b4cf79993124686f9a71e4a328568d6b0a35ab54e7b782ebe835b0b11"

URI_x86_64_v2_rust-hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hostname-devel-0.3.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hostname-devel}"
SRC_URI[x86_64_v2_rust-hostname-devel.sha256sum] = "c7be922d320b1efa3e4424537ccb9e9ea803e50fe2a753a3ce1dd870faeac1f4"

URI_aarch64_rust-hostname+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hostname+default-devel-0.3.1-13.el10_0.noarch.rpm;name=aarch64_rust-hostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hostname+default-devel}"
SRC_URI[aarch64_rust-hostname+default-devel.sha256sum] = "4b8a213cf8b4b4573ed452b27ef27310c05947c69a33ab0c573dd744831e7985"

URI_aarch64_rust-hostname+set-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hostname+set-devel-0.3.1-13.el10_0.noarch.rpm;name=aarch64_rust-hostname+set-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hostname+set-devel}"
SRC_URI[aarch64_rust-hostname+set-devel.sha256sum] = "08ffd24ed32b24de06d363c9c8fe3a254ef22f42bdb3f5c8d3b4142b7bcad2af"

URI_aarch64_rust-hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hostname-devel-0.3.1-13.el10_0.noarch.rpm;name=aarch64_rust-hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hostname-devel}"
SRC_URI[aarch64_rust-hostname-devel.sha256sum] = "3aa67b3f27e474452183d39f10ebb5853d1b52c27a2fab550234da420f1db19a"

RDEPENDS:rust-hostname+default-devel = " \
 cargo \
 rust-hostname-devel \
 "
RDEPENDS:rust-hostname+set-devel = " \
 cargo \
 rust-hostname-devel \
 "
RDEPENDS:rust-hostname-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
