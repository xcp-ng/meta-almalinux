# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-DBus"
PV = "1.2.0"
PR = "17.el10_0"
PACKAGES = " \
 perl-Net-DBus \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-DBus-1.2.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd54ebad854c457da41e4cdcb4e1477d2a08bbb0b578f8f3b1fc3750f1180547"

URI_x86_64_v2_perl-Net-DBus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-DBus-1.2.0-17.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Net-DBus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-DBus}"
SRC_URI[x86_64_v2_perl-Net-DBus.sha256sum] = "8e2451d88b1e8a0327a8839bfb652563d29500ad27476bede451b137680b1cbe"

URI_aarch64_perl-Net-DBus = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-DBus-1.2.0-17.el10_0.aarch64.rpm;name=aarch64_perl-Net-DBus;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-DBus}"
SRC_URI[aarch64_perl-Net-DBus.sha256sum] = "b228fc227c22fe06f4e445f4ebf6edacfd0a5b7a47f3697ca4399738fc64be23"

RDEPENDS:perl-Net-DBus = " \
 dbus-libs \
 glibc \
 perl-Exporter \
 perl-Net-DBus \
 perl-Time-HiRes \
 perl-XML-Twig \
 perl-base \
 perl-libs \
 perl-overload \
 perl-vars \
 "
