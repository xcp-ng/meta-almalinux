# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-proc-macro2"
PV = "1.0.107"
PR = "1.el10_3"
PACKAGES = " \
 rust-proc-macro2+default-devel \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-proc-macro2-1.0.107-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2dee8fdb5133e1bd3707b14e7a8cf78b263e168cbdc78d3185e019b7a9352fbe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+default-devel-1.0.107-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro2+default-devel.sha256sum] = "b272e740710770d835a0a6d52e73aa73fd82c6475b6ae0080d0e055344ed535b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+proc-macro-devel-1.0.107-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro2+proc-macro-devel.sha256sum] = "33f986997bdac27ebaeaf51289d75bea972515db8f37f9eac91429b09b5cb96d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2+span-locations-devel-1.0.107-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro2+span-locations-devel.sha256sum] = "15dbba1aa4d81e3b90ea4a15581a753eed989248b0b71a1a0d18abac9e8603e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-proc-macro2-devel-1.0.107-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-proc-macro2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-proc-macro2-devel.sha256sum] = "1a0bc53f4220c327d1087c7f6e52fef7e1ee05ad7dfc5da69a75be67a52b73e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+default-devel-1.0.107-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro2+default-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro2+default-devel.sha256sum] = "2d17db9f1191e7916cab93492ac7176cfdf0c9d3604b139e5e18ef9f1672e54d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+proc-macro-devel-1.0.107-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro2+proc-macro-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro2+proc-macro-devel.sha256sum] = "d6532d9498da5f0671dbb543e421f4a00fd1b0af8e89c0a08c17e128ed1a7b5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2+span-locations-devel-1.0.107-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro2+span-locations-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro2+span-locations-devel.sha256sum] = "1e04468e486ab3e967cfbc6ee83e572747f7d43c9c5b7976d1ff37821442a26d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-proc-macro2-devel-1.0.107-1.el10_3.noarch.rpm;name=aarch64_rust-proc-macro2-devel;unpack=0"
SRC_URI[aarch64_rust-proc-macro2-devel.sha256sum] = "ec91890a22b82e577524a9e32da534336581b7a4d336bf399073fb02fcac99bb"

RDEPENDS:rust-proc-macro2+default-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+proc-macro-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2+span-locations-devel = " \
 cargo \
 rust-proc-macro2-devel \
 "
RDEPENDS:rust-proc-macro2-devel = " \
 cargo \
 rust \
 rust-unicode-ident+default-devel \
 "
