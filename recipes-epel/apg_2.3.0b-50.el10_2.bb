# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apg"
PV = "2.3.0b"
PR = "50.el10_2"
PACKAGES = " \
 apg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apg-2.3.0b-50.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e4a311bc989f4cdf7caedcf0516607dac6db02796aa3899bb5cf3a02b7e06f6"

URI_x86_64_v2_apg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apg-2.3.0b-50.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apg}"
SRC_URI[x86_64_v2_apg.sha256sum] = "b6f751a11ae6c7e177aa4921c16e9184eb2ea3595bf9edd2acc12cae2777f28e"

URI_aarch64_apg = "${EPEL_MIRROR}/aarch64/Packages/a/apg-2.3.0b-50.el10_2.aarch64.rpm;name=aarch64_apg;unpack=0"
SRC_URI:append = " ${URI_aarch64_apg}"
SRC_URI[aarch64_apg.sha256sum] = "6a67195922e1a4cb84bff6b2c845c3f4a4e7d860348af2165348f34854139ecd"

RDEPENDS:apg = " \
 bash \
 glibc \
 grep \
 libxcrypt \
 systemd \
 "
