# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parse-CPAN-Packages"
PV = "2.40"
PR = "32.el10_2"
PACKAGES = " \
 perl-Parse-CPAN-Packages \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Parse-CPAN-Packages-2.40-32.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "304689e97935825dd1d24bb8f10b9cbf7327d459d8d7f575f5384edc301047b4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parse-CPAN-Packages-2.40-32.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parse-CPAN-Packages;unpack=0"
SRC_URI[x86_64_v2_perl-Parse-CPAN-Packages.sha256sum] = "ae013bdbea0f7554d01a3e587995b1d70473e5951199a59a6e9d8f2a6a016acc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Parse-CPAN-Packages-2.40-32.el10_2.noarch.rpm;name=aarch64_perl-Parse-CPAN-Packages;unpack=0"
SRC_URI[aarch64_perl-Parse-CPAN-Packages.sha256sum] = "cebbd4c80fa559ad7191b56e060bdb8b9d528a8f74a498c9f0e96703615f3ca7"

RDEPENDS:perl-Parse-CPAN-Packages = " \
 perl-Archive-Peek \
 perl-CPAN-DistnameInfo \
 perl-File-Slurp \
 perl-IO-Compress \
 perl-Moo \
 perl-PPI \
 perl-Path-Class \
 perl-Type-Tiny \
 perl-libs \
 perl-version \
 "
