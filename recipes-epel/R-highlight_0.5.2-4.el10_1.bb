# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-highlight"
PV = "0.5.2"
PR = "4.el10_1"
PACKAGES = " \
 R-highlight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-highlight-0.5.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92a08930deab4d9a6a3ea0e9dcf2f58bb82360037f17f698a91dd1dc18a94e2a"

URI_x86_64_v2_R-highlight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-highlight-0.5.2-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-highlight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-highlight}"
SRC_URI[x86_64_v2_R-highlight.sha256sum] = "edbd123210e9d00a563abc818b8d43ae4c79dd0cb1d49b7e3ec3a92020a27997"

URI_aarch64_R-highlight = "${EPEL_MIRROR}/aarch64/Packages/r/R-highlight-0.5.2-4.el10_1.aarch64.rpm;name=aarch64_R-highlight;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-highlight}"
SRC_URI[aarch64_R-highlight.sha256sum] = "05d25f44adb50061b49deca71846dde49db794c267153bd76d5de4ef72720531"

RDEPENDS:R-highlight = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 "
