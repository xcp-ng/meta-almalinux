# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytemuck"
PV = "1.25.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-bytemuck+aarch64_simd-devel \
 rust-bytemuck+align_offset-devel \
 rust-bytemuck+alloc_uninit-devel \
 rust-bytemuck+avx512_simd-devel \
 rust-bytemuck+bytemuck_derive-devel \
 rust-bytemuck+const_zeroed-devel \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-bytemuck+extern_crate_std-devel \
 rust-bytemuck+impl_core_error-devel \
 rust-bytemuck+min_const_generics-devel \
 rust-bytemuck+must_cast-devel \
 rust-bytemuck+must_cast_extra-devel \
 rust-bytemuck+nightly_stdsimd-devel \
 rust-bytemuck+track_caller-devel \
 rust-bytemuck+transparentwrapper_extra-devel \
 rust-bytemuck+unsound_ptr_pod_impl-devel \
 rust-bytemuck+zeroable_atomics-devel \
 rust-bytemuck+zeroable_maybe_uninit-devel \
 rust-bytemuck+zeroable_unwind_fn-devel \
 rust-bytemuck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytemuck-1.25.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a5eb9b4fe7c84f2bb2c64b455dcf0b7bbd6cad9de2d2ec664abe4fdfedf7a9f"

URI_x86_64_v2_rust-bytemuck+aarch64_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+aarch64_simd-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+aarch64_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+aarch64_simd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+aarch64_simd-devel.sha256sum] = "d5173b2067f682709ff6edaeaa5ad4df81c2a5418337ea058e176953cd77160d"

URI_x86_64_v2_rust-bytemuck+align_offset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+align_offset-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+align_offset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+align_offset-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+align_offset-devel.sha256sum] = "166ab4fff7268a7c7d7bd463b37d9f8e48a548e485ced4f422b9334fb1f11c1f"

URI_x86_64_v2_rust-bytemuck+alloc_uninit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+alloc_uninit-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+alloc_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+alloc_uninit-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+alloc_uninit-devel.sha256sum] = "e8dc87c0a0011bb4d6e546cdf40557197d945a271d37bc4a43b4f8b0df3ec086"

URI_x86_64_v2_rust-bytemuck+avx512_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+avx512_simd-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+avx512_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+avx512_simd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+avx512_simd-devel.sha256sum] = "49375c3233ad7b098aa0a75725920f35e064623ebb24cdc126f3b7ffae0f93db"

URI_x86_64_v2_rust-bytemuck+bytemuck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+bytemuck_derive-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+bytemuck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+bytemuck_derive-devel.sha256sum] = "6c41402671c8f459d148e9601c82c2f0968f102d8f1289ddbe40e4093daca5bd"

URI_x86_64_v2_rust-bytemuck+const_zeroed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+const_zeroed-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+const_zeroed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+const_zeroed-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+const_zeroed-devel.sha256sum] = "169cb5e5400f820f05436da64e5eb8e373d1a9861297c06da4c7ace6d8b2ec91"

URI_x86_64_v2_rust-bytemuck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+default-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+default-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+default-devel.sha256sum] = "4689d49c29b238481f93b40e1f39bf8cf2342beada5660c838ef15fab4d6b5ba"

URI_x86_64_v2_rust-bytemuck+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+derive-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+derive-devel.sha256sum] = "3811ae857df4d8d832ddd6d349fb21e3ab87432e5bec14b19b9ece9a6cd8ce3d"

URI_x86_64_v2_rust-bytemuck+extern_crate_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+extern_crate_alloc-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+extern_crate_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+extern_crate_alloc-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+extern_crate_alloc-devel.sha256sum] = "13ffacc8c248dc4c664b2e940977d17b90498735ff19e014dc7a27685535d8c2"

URI_x86_64_v2_rust-bytemuck+extern_crate_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+extern_crate_std-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+extern_crate_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+extern_crate_std-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+extern_crate_std-devel.sha256sum] = "75943590fd17bb52aa37e976162410b7869d5f426dac426a6df1e3f50e2a779d"

URI_x86_64_v2_rust-bytemuck+impl_core_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+impl_core_error-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+impl_core_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+impl_core_error-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+impl_core_error-devel.sha256sum] = "a8625269d7657bd483a289e33a16c2f2c027a155132db374a86887a407ef39a4"

URI_x86_64_v2_rust-bytemuck+min_const_generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+min_const_generics-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+min_const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+min_const_generics-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+min_const_generics-devel.sha256sum] = "557e43cbe10220d1949e19eb31eb5ed40f81e96c0a39c3b42def5f2934cde32b"

URI_x86_64_v2_rust-bytemuck+must_cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+must_cast-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+must_cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+must_cast-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+must_cast-devel.sha256sum] = "930dfb2ae84d328c503dade13e92307d0396bc02b249bf6eec014379a3d2770f"

URI_x86_64_v2_rust-bytemuck+must_cast_extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+must_cast_extra-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+must_cast_extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+must_cast_extra-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+must_cast_extra-devel.sha256sum] = "a5d6682e7243722c81fd11c936ac805c0e4f38f1068de2a3a58c2db718ff0bbe"

URI_x86_64_v2_rust-bytemuck+nightly_stdsimd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+nightly_stdsimd-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+nightly_stdsimd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+nightly_stdsimd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+nightly_stdsimd-devel.sha256sum] = "09561c5795811df7eb52aff6ed43e8641d9d41e4424ed0a3cd1fd34dc653d3fc"

URI_x86_64_v2_rust-bytemuck+track_caller-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+track_caller-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+track_caller-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+track_caller-devel.sha256sum] = "8d70ba5894b52cfc303fd40b11faf7f22ae53a7c5daf6a98d6dca65f1d355bfc"

URI_x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+transparentwrapper_extra-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel.sha256sum] = "b6831e54aca197a285e7d93175da250176c05f9379c8eb8ab3f4e2f7d8a283fb"

URI_x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+unsound_ptr_pod_impl-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel.sha256sum] = "eebb1802c234419346d6a29f709216ebd4c128f7cc4269a4dfae52f87b62cbd6"

URI_x86_64_v2_rust-bytemuck+zeroable_atomics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_atomics-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_atomics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_atomics-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_atomics-devel.sha256sum] = "ff82cae32a8fde2399db03928309d22d9db74c58d1f64cee57eb1cbf3fa9ff97"

URI_x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_maybe_uninit-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel.sha256sum] = "c1113be9d7330521d856bdcaa9fc0b2018e87c2b31ddef39b850718b81be0d85"

URI_x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_unwind_fn-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel.sha256sum] = "f5e944b5b77cd347e8838a8dea86f5a845dba28addc74bb2dbb9a47b6f67536c"

URI_x86_64_v2_rust-bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck-devel-1.25.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck-devel}"
SRC_URI[x86_64_v2_rust-bytemuck-devel.sha256sum] = "87ee28ecd4f6d1753835886854b11e60edd9b05592b337937e6a6570ddd391a4"

URI_aarch64_rust-bytemuck+aarch64_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+aarch64_simd-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+aarch64_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+aarch64_simd-devel}"
SRC_URI[aarch64_rust-bytemuck+aarch64_simd-devel.sha256sum] = "eb9a21d7f7b4dfb8655f2c1a52b44ea4349b1af15cfa9e8f88ed7466a86ea370"

URI_aarch64_rust-bytemuck+align_offset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+align_offset-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+align_offset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+align_offset-devel}"
SRC_URI[aarch64_rust-bytemuck+align_offset-devel.sha256sum] = "067d0764ed229a60b82bedf2643f5e016baef16d894ae5d87607d6a9606eba84"

URI_aarch64_rust-bytemuck+alloc_uninit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+alloc_uninit-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+alloc_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+alloc_uninit-devel}"
SRC_URI[aarch64_rust-bytemuck+alloc_uninit-devel.sha256sum] = "e79ae0b8de16e70dd25347e4fe70285a130a806ea5346b3a109d06bd892dd26a"

URI_aarch64_rust-bytemuck+avx512_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+avx512_simd-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+avx512_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+avx512_simd-devel}"
SRC_URI[aarch64_rust-bytemuck+avx512_simd-devel.sha256sum] = "d2533b38ef1cd8efb25bdea1a6c3ffb0524366b3a7cfe3871287b6f88b396bff"

URI_aarch64_rust-bytemuck+bytemuck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+bytemuck_derive-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+bytemuck_derive-devel}"
SRC_URI[aarch64_rust-bytemuck+bytemuck_derive-devel.sha256sum] = "db9ceada03d307d0e0c093dc007b22497c52b811a40194d677592e9c1443db17"

URI_aarch64_rust-bytemuck+const_zeroed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+const_zeroed-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+const_zeroed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+const_zeroed-devel}"
SRC_URI[aarch64_rust-bytemuck+const_zeroed-devel.sha256sum] = "d9fed5c7eaef6a189729b21be3f25d85d7a419b46a634b7fdbf239192aa32021"

URI_aarch64_rust-bytemuck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+default-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+default-devel}"
SRC_URI[aarch64_rust-bytemuck+default-devel.sha256sum] = "b59d7bd1c598b42479c2c5ac9b76227fb31eaa7a4281824854fbf89b147b5eff"

URI_aarch64_rust-bytemuck+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+derive-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+derive-devel}"
SRC_URI[aarch64_rust-bytemuck+derive-devel.sha256sum] = "0ad639033c4e08ffed3a8cba6ad14cae29d5e21f4611e44830da27c2c7c3979c"

URI_aarch64_rust-bytemuck+extern_crate_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+extern_crate_alloc-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+extern_crate_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+extern_crate_alloc-devel}"
SRC_URI[aarch64_rust-bytemuck+extern_crate_alloc-devel.sha256sum] = "010a1b8d94a563e9d7a4704c7a6c5766b375a116931843241159c0cb3d04cca7"

URI_aarch64_rust-bytemuck+extern_crate_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+extern_crate_std-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+extern_crate_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+extern_crate_std-devel}"
SRC_URI[aarch64_rust-bytemuck+extern_crate_std-devel.sha256sum] = "6d4ab976ff5e6e41831d20ba052ec1c7645ed6bfd881cf3796a94785f8ee7110"

URI_aarch64_rust-bytemuck+impl_core_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+impl_core_error-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+impl_core_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+impl_core_error-devel}"
SRC_URI[aarch64_rust-bytemuck+impl_core_error-devel.sha256sum] = "8fbd485804260d3b0fab8a2b364c3f35a355f3e661a703744b1f8e1d3d4bbc47"

URI_aarch64_rust-bytemuck+min_const_generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+min_const_generics-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+min_const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+min_const_generics-devel}"
SRC_URI[aarch64_rust-bytemuck+min_const_generics-devel.sha256sum] = "2ad0167724cdd2484017422cce6210e9721a7fcf85d1955f9efe8724bd397a75"

URI_aarch64_rust-bytemuck+must_cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+must_cast-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+must_cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+must_cast-devel}"
SRC_URI[aarch64_rust-bytemuck+must_cast-devel.sha256sum] = "91ebf012da989267bbfab1f105cd86eaf9e06cb0407221ef73fe139b8255b62c"

URI_aarch64_rust-bytemuck+must_cast_extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+must_cast_extra-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+must_cast_extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+must_cast_extra-devel}"
SRC_URI[aarch64_rust-bytemuck+must_cast_extra-devel.sha256sum] = "2ca28ab02da8b6b21b16adf9c8ddf41acae7ec2a1609652add9978a4d9259869"

URI_aarch64_rust-bytemuck+nightly_stdsimd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+nightly_stdsimd-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+nightly_stdsimd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+nightly_stdsimd-devel}"
SRC_URI[aarch64_rust-bytemuck+nightly_stdsimd-devel.sha256sum] = "d1e50c38015eada649ca24c0eeab32bd0cc23c3ec8842edb0043d2ceb83f6e01"

URI_aarch64_rust-bytemuck+track_caller-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+track_caller-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+track_caller-devel}"
SRC_URI[aarch64_rust-bytemuck+track_caller-devel.sha256sum] = "5f5d5ac6835190d1f2a83cad451b262e666a46ce1538f8a3cb29f993c3dc191f"

URI_aarch64_rust-bytemuck+transparentwrapper_extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+transparentwrapper_extra-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+transparentwrapper_extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+transparentwrapper_extra-devel}"
SRC_URI[aarch64_rust-bytemuck+transparentwrapper_extra-devel.sha256sum] = "1d746683ad98a5d52138298e381e5f4b78e1e0caa0bfe5275d7a06d85ee4e5f6"

URI_aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+unsound_ptr_pod_impl-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel}"
SRC_URI[aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel.sha256sum] = "b8650390424936584e3755ce9bf0c0381f3b50755c841b8af591a8deb1f33324"

URI_aarch64_rust-bytemuck+zeroable_atomics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_atomics-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_atomics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_atomics-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_atomics-devel.sha256sum] = "ba14d4ce07ed05c2572b2ac33d35a78b6dacdb81568822bf3aee9508e7144d2a"

URI_aarch64_rust-bytemuck+zeroable_maybe_uninit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_maybe_uninit-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_maybe_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_maybe_uninit-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_maybe_uninit-devel.sha256sum] = "1a9ca598fef4eaf57ac47c6aba715d7e7de708e30c6ef653f586352c7537418e"

URI_aarch64_rust-bytemuck+zeroable_unwind_fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_unwind_fn-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_unwind_fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_unwind_fn-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_unwind_fn-devel.sha256sum] = "98f0425b809f8ce86e621de9e09fe016ea02e54f7b89ef7d5c7a715499fc28a1"

URI_aarch64_rust-bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck-devel-1.25.2-1.el10_3.noarch.rpm;name=aarch64_rust-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck-devel}"
SRC_URI[aarch64_rust-bytemuck-devel.sha256sum] = "a5332474eef9c3b7e280b932bcd780973f8b80bdd2c60e1007da4cfcb9b0f4e4"

RDEPENDS:rust-bytemuck+aarch64_simd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+align_offset-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+alloc_uninit-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+avx512_simd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+bytemuck_derive-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-bytemuck_derive+default-devel \
 "
RDEPENDS:rust-bytemuck+const_zeroed-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+default-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+derive-devel = " \
 cargo \
 rust-bytemuck+bytemuck_derive-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+extern_crate_alloc-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+extern_crate_std-devel = " \
 cargo \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+impl_core_error-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+min_const_generics-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+must_cast-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+must_cast_extra-devel = " \
 cargo \
 rust-bytemuck+must_cast-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+nightly_stdsimd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+track_caller-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+transparentwrapper_extra-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+unsound_ptr_pod_impl-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_atomics-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_maybe_uninit-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_unwind_fn-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck-devel = " \
 cargo \
 "
