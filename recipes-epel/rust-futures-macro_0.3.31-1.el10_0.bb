# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-macro"
PV = "0.3.31"
PR = "1.el10_0"
PACKAGES = " \
 rust-futures-macro+default-devel \
 rust-futures-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-macro-0.3.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80b1c1d27a08e7a4c983a2bc28de57d443c77c1a2ecc0b438ba8e90fbcc9f85b"

URI_x86_64_v2_rust-futures-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-macro+default-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-macro+default-devel}"
SRC_URI[x86_64_v2_rust-futures-macro+default-devel.sha256sum] = "c7e74ba50211cba981ccb68f884d54a2534915975789d37578747dd6c342dff0"

URI_x86_64_v2_rust-futures-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-macro-devel-0.3.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-macro-devel}"
SRC_URI[x86_64_v2_rust-futures-macro-devel.sha256sum] = "1da3a2ca35d47e1ebce0dfa4516a8417d939cbbf872ed9d53ad6ad1a055b2250"

URI_aarch64_rust-futures-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-macro+default-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-macro+default-devel}"
SRC_URI[aarch64_rust-futures-macro+default-devel.sha256sum] = "989c7557c4dbfdf0f2599d1827882aa85b336305e2e05f76defde3f09e887dc0"

URI_aarch64_rust-futures-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-macro-devel-0.3.31-1.el10_0.noarch.rpm;name=aarch64_rust-futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-macro-devel}"
SRC_URI[aarch64_rust-futures-macro-devel.sha256sum] = "d06e5a0e0d9ff33faa94c187e91b3e2b4238755ef898baadda8d1955a58e3711"

RDEPENDS:rust-futures-macro+default-devel = " \
 cargo \
 rust-futures-macro-devel \
 "
RDEPENDS:rust-futures-macro-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
