# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "asdcplib"
PV = "2.13.2"
PR = "1.el10_2"
PACKAGES = " \
 asdcplib \
 asdcplib-devel \
 asdcplib-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/asdcplib-2.13.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebf7db2b2156dc6b41ae232164a99dbef3e53cbdbc505c66f33def5c57aa66c7"

URI_x86_64_v2_asdcplib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-2.13.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asdcplib}"
SRC_URI[x86_64_v2_asdcplib.sha256sum] = "a1a54267feab66bdab83e2eea0df3d81342285f1b8d9ccc62d20860eb4b1e8c3"

URI_x86_64_v2_asdcplib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-devel-2.13.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asdcplib-devel}"
SRC_URI[x86_64_v2_asdcplib-devel.sha256sum] = "03ad9af1c9920ff0aac64201ce6d64780bdabb2aa070ad2f6b7591621222c72a"

URI_x86_64_v2_asdcplib-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-tools-2.13.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_asdcplib-tools}"
SRC_URI[x86_64_v2_asdcplib-tools.sha256sum] = "faf854b98deea8e78f692624b87c7b7f48a888b7dc9266775fc6a72e9c1ab5c5"

URI_aarch64_asdcplib = "${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-2.13.2-1.el10_2.aarch64.rpm;name=aarch64_asdcplib;unpack=0"
SRC_URI:append = " ${URI_aarch64_asdcplib}"
SRC_URI[aarch64_asdcplib.sha256sum] = "1e64fcbfa0b476a5665d87ccfb3e47cc43a664aa8bd9fe6d8057ffb8abafcb2b"

URI_aarch64_asdcplib-devel = "${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-devel-2.13.2-1.el10_2.aarch64.rpm;name=aarch64_asdcplib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_asdcplib-devel}"
SRC_URI[aarch64_asdcplib-devel.sha256sum] = "27cd81ccf0a3d0e1d485f2968d367aac41823b2e27d3155601b47000443e206b"

URI_aarch64_asdcplib-tools = "${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-tools-2.13.2-1.el10_2.aarch64.rpm;name=aarch64_asdcplib-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_asdcplib-tools}"
SRC_URI[aarch64_asdcplib-tools.sha256sum] = "cc9e49d6813c634bac1d896c19ba111763fb9911fdcfb693c8412a4ec916dcd7"

RDEPENDS:asdcplib = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 xerces-c \
 "
RDEPENDS:asdcplib-devel = " \
 asdcplib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:asdcplib-tools = " \
 asdcplib \
 glibc \
 libgcc \
 libstdc++ \
 "
