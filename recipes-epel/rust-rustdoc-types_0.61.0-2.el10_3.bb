# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustdoc-types"
PV = "0.61.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-rustdoc-types+default-devel \
 rust-rustdoc-types+rkyv_0_8-devel \
 rust-rustdoc-types+rustc-hash-devel \
 rust-rustdoc-types-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustdoc-types-0.61.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0911a845c95a28787899352631853752a95443e338a62e1a90d05f31c96d27d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types+default-devel-0.61.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types+default-devel.sha256sum] = "0c870cd0086245005f3c784b3a46e4772b03f985ab49e0191cc62373a997557b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types+rkyv_0_8-devel-0.61.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types+rkyv_0_8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types+rkyv_0_8-devel.sha256sum] = "8167e3a1dd013b979b8e36819cc7f72bed9995fffbc9f70fc11c6868cb1700cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types+rustc-hash-devel-0.61.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types+rustc-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types+rustc-hash-devel.sha256sum] = "137ffc20afe2b8efc9017717c921ed933d0844f90dd52e0128ccd49f7e96aca4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustdoc-types-devel-0.61.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustdoc-types-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustdoc-types-devel.sha256sum] = "ad051f8bd45289afe32c4d1cb503517d874b5b2d52aafb778272622051d32fad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types+default-devel-0.61.0-2.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types+default-devel.sha256sum] = "cf471ee9df0d6387c06174a253ae2d7663d04c97bf213c24a156a791a42bf271"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types+rkyv_0_8-devel-0.61.0-2.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types+rkyv_0_8-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types+rkyv_0_8-devel.sha256sum] = "13b107c24e68e7a778812259b79e9aa0fc5d75d9e566521dfd88742bd070f5ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types+rustc-hash-devel-0.61.0-2.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types+rustc-hash-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types+rustc-hash-devel.sha256sum] = "0cb0f752fde4276ce36101e1702a0d81b8059c9c000d5bd9466634b19c119469"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustdoc-types-devel-0.61.0-2.el10_3.noarch.rpm;name=aarch64_rust-rustdoc-types-devel;unpack=0"
SRC_URI[aarch64_rust-rustdoc-types-devel.sha256sum] = "b95547ab3a3d45df8018a73b69d1e490f23f766c225362a37e387bb4d742031a"

RDEPENDS:rust-rustdoc-types+default-devel = " \
 cargo \
 rust-rustdoc-types-devel \
 "
RDEPENDS:rust-rustdoc-types+rkyv_0_8-devel = " \
 cargo \
 rust-rkyv+default-devel \
 rust-rustdoc-types-devel \
 "
RDEPENDS:rust-rustdoc-types+rustc-hash-devel = " \
 cargo \
 rust-rustc-hash+default-devel \
 rust-rustdoc-types-devel \
 "
RDEPENDS:rust-rustdoc-types-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 "
