# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-const-str"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-const-str+all-devel \
 rust-const-str+case-devel \
 rust-const-str+default-devel \
 rust-const-str+http-devel \
 rust-const-str+proc-devel \
 rust-const-str+regex-devel \
 rust-const-str+std-devel \
 rust-const-str+unstable-devel \
 rust-const-str-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-const-str-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6724baaafa1c15f9e2435110fb453b5b321e48b324bf84909289093e7c1a0266"

URI_x86_64_v2_rust-const-str+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str+all-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str+all-devel}"
SRC_URI[x86_64_v2_rust-const-str+all-devel.sha256sum] = "6f178dafc95a8c6f4553e5481a109ecb49fdea9c5a47d3fbf8414e217c292ba7"

URI_x86_64_v2_rust-const-str+case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str+case-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str+case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str+case-devel}"
SRC_URI[x86_64_v2_rust-const-str+case-devel.sha256sum] = "cc81688b785e645298e2555b5befbcaeebbfe69d9b49ab29577b4105868b97d7"

URI_x86_64_v2_rust-const-str+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str+default-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str+default-devel}"
SRC_URI[x86_64_v2_rust-const-str+default-devel.sha256sum] = "b1eb065ffaefbf8b884fe6485b32f5c0814a28b81383008f19ac3646f8f4914a"

URI_x86_64_v2_rust-const-str+http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str+http-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str+http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str+http-devel}"
SRC_URI[x86_64_v2_rust-const-str+http-devel.sha256sum] = "c02a15c911c737ab6ef3be28725677382844221edb66fc8a4dc6d5309c508de4"

URI_x86_64_v2_rust-const-str+proc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str+proc-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str+proc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str+proc-devel}"
SRC_URI[x86_64_v2_rust-const-str+proc-devel.sha256sum] = "d094ef10402aad863e14bc37555106d260671b4c047dd4b4681cea7eaa46454f"

URI_x86_64_v2_rust-const-str+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str+regex-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str+regex-devel}"
SRC_URI[x86_64_v2_rust-const-str+regex-devel.sha256sum] = "65a57a8dddda943de85dd544deb5c49fbdc79dea52149e4304288d6eeae910e9"

URI_x86_64_v2_rust-const-str+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str+std-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str+std-devel}"
SRC_URI[x86_64_v2_rust-const-str+std-devel.sha256sum] = "1d942df16612a958ca565cda87541a88d796acb2e591593ba05fb3f78256622e"

URI_x86_64_v2_rust-const-str+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str+unstable-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str+unstable-devel}"
SRC_URI[x86_64_v2_rust-const-str+unstable-devel.sha256sum] = "7627c84de1e2f313d355a866d483004c6739ade186e6a336d424616152c6989a"

URI_x86_64_v2_rust-const-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-str-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-str-devel}"
SRC_URI[x86_64_v2_rust-const-str-devel.sha256sum] = "9a4d7b5821a9b5b48ad3eb51425fd70f22aa13f549ba48ea037609b223bd4316"

URI_aarch64_rust-const-str+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str+all-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str+all-devel}"
SRC_URI[aarch64_rust-const-str+all-devel.sha256sum] = "e2378f3f9f874a9f32182a4f31f56ce73ccc43acd46984f474a8a1eb8ca13b5a"

URI_aarch64_rust-const-str+case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str+case-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str+case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str+case-devel}"
SRC_URI[aarch64_rust-const-str+case-devel.sha256sum] = "53376b012cc5659c770b5db4c12415586b2757d760328ec81df698e9b79825a5"

URI_aarch64_rust-const-str+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str+default-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str+default-devel}"
SRC_URI[aarch64_rust-const-str+default-devel.sha256sum] = "61c82822eb3b54e83041a5797b44ab712779c3c390c786202d74159924acf568"

URI_aarch64_rust-const-str+http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str+http-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str+http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str+http-devel}"
SRC_URI[aarch64_rust-const-str+http-devel.sha256sum] = "75faae2873ca40b40e6843ac836de299cb73272c0972fdf14540add10acd08b4"

URI_aarch64_rust-const-str+proc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str+proc-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str+proc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str+proc-devel}"
SRC_URI[aarch64_rust-const-str+proc-devel.sha256sum] = "39fee95349ddab2ba3d44b47f6af553ae074e65d5a130ead711c09c261903739"

URI_aarch64_rust-const-str+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str+regex-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str+regex-devel}"
SRC_URI[aarch64_rust-const-str+regex-devel.sha256sum] = "60068cfe0495974a060497627981fde2170074dc0549021c4d9b574ec2f33aca"

URI_aarch64_rust-const-str+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str+std-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str+std-devel}"
SRC_URI[aarch64_rust-const-str+std-devel.sha256sum] = "b375f55faeb5e780a92749b218f6ee55984b46558d6be3b21916e7819cf8a1d0"

URI_aarch64_rust-const-str+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str+unstable-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str+unstable-devel}"
SRC_URI[aarch64_rust-const-str+unstable-devel.sha256sum] = "3dce6b52585953973c9c3c6cbd008d6983714929ec65d6eaff684e12d29c2b4f"

URI_aarch64_rust-const-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-str-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-const-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-str-devel}"
SRC_URI[aarch64_rust-const-str-devel.sha256sum] = "044cb0854cdd4f062c66576dd4b272a6efbfb944dc9fc85a4257b15ed5d915f0"

RDEPENDS:rust-const-str+all-devel = " \
 cargo \
 rust-const-str+case-devel \
 rust-const-str+http-devel \
 rust-const-str+proc-devel \
 rust-const-str+regex-devel \
 rust-const-str+std-devel \
 rust-const-str-devel \
 "
RDEPENDS:rust-const-str+case-devel = " \
 cargo \
 rust-const-str+proc-devel \
 rust-const-str-devel \
 rust-const-str-proc-macro+default-devel \
 rust-const-str-proc-macro+heck-devel \
 rust-heck+default-devel \
 "
RDEPENDS:rust-const-str+default-devel = " \
 cargo \
 rust-const-str-devel \
 "
RDEPENDS:rust-const-str+http-devel = " \
 cargo \
 rust-const-str+proc-devel \
 rust-const-str-devel \
 rust-const-str-proc-macro+default-devel \
 rust-const-str-proc-macro+http-devel \
 rust-http+default-devel \
 "
RDEPENDS:rust-const-str+proc-devel = " \
 cargo \
 rust-const-str-devel \
 rust-const-str-proc-macro+default-devel \
 "
RDEPENDS:rust-const-str+regex-devel = " \
 cargo \
 rust-const-str+proc-devel \
 rust-const-str-devel \
 rust-const-str-proc-macro+default-devel \
 rust-const-str-proc-macro+regex-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-const-str+std-devel = " \
 cargo \
 rust-const-str-devel \
 "
RDEPENDS:rust-const-str+unstable-devel = " \
 cargo \
 rust-const-str-devel \
 "
RDEPENDS:rust-const-str-devel = " \
 cargo \
 rust \
 "
