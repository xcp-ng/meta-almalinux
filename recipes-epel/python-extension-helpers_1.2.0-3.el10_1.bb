# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-extension-helpers"
PV = "1.2.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-extension-helpers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-extension-helpers-1.2.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ededc8a57b9b34a790ca6f6ec29a8423e5bed369ea2f45d3d83dde17ed4fbb74"

URI_x86_64_v2_python3-extension-helpers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-extension-helpers-1.2.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-extension-helpers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-extension-helpers}"
SRC_URI[x86_64_v2_python3-extension-helpers.sha256sum] = "b7103ab0a8605e89949eacbdf86791b418754a8093c00a8abdd2faa9fea5112f"

URI_aarch64_python3-extension-helpers = "${EPEL_MIRROR}/aarch64/Packages/p/python3-extension-helpers-1.2.0-3.el10_1.noarch.rpm;name=aarch64_python3-extension-helpers;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-extension-helpers}"
SRC_URI[aarch64_python3-extension-helpers.sha256sum] = "9b66660aa8593832daf1ef828aa9a81adf7e205e921fc6221a47ac46509e8b0c"

RDEPENDS:python3-extension-helpers = " \
 python3 \
 python3-setuptools \
 "
