# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konqueror"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 konqueror \
 konqueror-devel \
 konqueror-libs \
 kwebenginepart \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/konqueror-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e28a5205e2b24e734f79c89f52f705b945034320fa1ec72d788126de38352afa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror;unpack=0"
SRC_URI[x86_64_v2_konqueror.sha256sum] = "370a86052bb355be29f699e5d510a9688496d25880120ca69551037cbd396596"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-devel;unpack=0"
SRC_URI[x86_64_v2_konqueror-devel.sha256sum] = "a048d70c63cd33f1bf3e0e0dfc9ccab9fdfcfddecfcae4df184dd7f1541daccf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-libs;unpack=0"
SRC_URI[x86_64_v2_konqueror-libs.sha256sum] = "c449609c49e02abf2aba0c4030ceab93aa10a0caea3f8e8c7be70db0bd72afa7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwebenginepart-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwebenginepart;unpack=0"
SRC_URI[x86_64_v2_kwebenginepart.sha256sum] = "f319caddc540c8b517790572f4e13b153041d10cf82ac60c7b5992c7ce7b2978"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/konqueror-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_konqueror;unpack=0"
SRC_URI[aarch64_konqueror.sha256sum] = "1058b9ba05668114d3cb77a495bdb814e518f1eda403a3ecc5d26a5f406397cd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/konqueror-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_konqueror-devel;unpack=0"
SRC_URI[aarch64_konqueror-devel.sha256sum] = "4fae27dd19598b723220fd2b5eb73c52094b57a566e2962bc23aef55090ff6b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/konqueror-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_konqueror-libs;unpack=0"
SRC_URI[aarch64_konqueror-libs.sha256sum] = "886f75c269ad78fe325b7ae9f8ec0b88853be5d8019e5f98c279d7bd8edd6fa5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kwebenginepart-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kwebenginepart;unpack=0"
SRC_URI[aarch64_kwebenginepart.sha256sum] = "a246591c0a2e4c7db3fd821359f222529352c464148a93cede42aa9a80f2105e"

RDEPENDS:konqueror = " \
 glibc \
 hicolor-icon-theme \
 keditbookmarks \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 kwebenginepart \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:konqueror-devel = " \
 cmake-filesystem \
 konqueror \
 konqueror-libs \
 "
RDEPENDS:konqueror-libs = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdesu \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 konqueror \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 zlib-ng-compat \
 "
RDEPENDS:kwebenginepart = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
