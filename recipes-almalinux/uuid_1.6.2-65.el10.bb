# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uuid"
PV = "1.6.2"
PR = "65.el10"
PACKAGES = " \
 uuid \
 uuid-c++ \
 uuid-dce \
 uuid-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/uuid-1.6.2-65.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24225c54ea4e5df522e0ad322da23895133f81cdaef995058f85263e6dd88def"

URI_x86_64_v2_uuid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uuid-1.6.2-65.el10.x86_64_v2.rpm;name=x86_64_v2_uuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uuid}"
SRC_URI[x86_64_v2_uuid.sha256sum] = "ed43e78f7f90bec43e4e75f3c1ad057f11d5150df1d4f2dc397a44efed19cb51"

URI_x86_64_v2_uuid-c++ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uuid-c++-1.6.2-65.el10.x86_64_v2.rpm;name=x86_64_v2_uuid-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uuid-c++}"
SRC_URI[x86_64_v2_uuid-c++.sha256sum] = "16877775c6a98e95a18399eb712d3880bde1fe2a219833c3d72fb18e7eca876c"

URI_x86_64_v2_uuid-dce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uuid-dce-1.6.2-65.el10.x86_64_v2.rpm;name=x86_64_v2_uuid-dce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uuid-dce}"
SRC_URI[x86_64_v2_uuid-dce.sha256sum] = "0d3583d07f4caaeb0fd951d646d0aa86e72827ae83e70ab88099a5aeafcc5566"

URI_x86_64_v2_uuid-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/uuid-devel-1.6.2-65.el10.x86_64_v2.rpm;name=x86_64_v2_uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uuid-devel}"
SRC_URI[x86_64_v2_uuid-devel.sha256sum] = "518b70f99fa4a778fbb204961e9fe058fb04b7b2836e894b90733e1abbc5582c"

URI_aarch64_uuid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uuid-1.6.2-65.el10.aarch64.rpm;name=aarch64_uuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_uuid}"
SRC_URI[aarch64_uuid.sha256sum] = "263f47cccc317ccd35e910a17622f5c72f0606415f3618ceb7ef94a02c0d99f7"

URI_aarch64_uuid-c++ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uuid-c++-1.6.2-65.el10.aarch64.rpm;name=aarch64_uuid-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_uuid-c++}"
SRC_URI[aarch64_uuid-c++.sha256sum] = "829d67db0d594409b358b50c721e7abbd1bea90cb214ef0a01810a4ddb877f70"

URI_aarch64_uuid-dce = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uuid-dce-1.6.2-65.el10.aarch64.rpm;name=aarch64_uuid-dce;unpack=0"
SRC_URI:append = " ${URI_aarch64_uuid-dce}"
SRC_URI[aarch64_uuid-dce.sha256sum] = "321c82057301dc17314ce9755c950a629862c88835181c722f7feda52df604a2"

URI_aarch64_uuid-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/uuid-devel-1.6.2-65.el10.aarch64.rpm;name=aarch64_uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uuid-devel}"
SRC_URI[aarch64_uuid-devel.sha256sum] = "8310b046749f4928cafdcdecd72acdd520cf101c39de4d8b577fb51eab9ae1d3"

RDEPENDS:uuid = " \
 glibc \
 "
RDEPENDS:uuid-c++ = " \
 glibc \
 libgcc \
 libstdc++ \
 uuid \
 "
RDEPENDS:uuid-dce = " \
 glibc \
 uuid \
 "
RDEPENDS:uuid-devel = " \
 bash \
 pkgconf-pkg-config \
 uuid \
 "
