# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lagrange"
PV = "1.18.5"
PR = "1.el10_1"
PACKAGES = " \
 lagrange \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lagrange-1.18.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33dc13cd6ee19fb2dbcd0215adc935279ac6c746423faec55668fcfb93013e84"

URI_x86_64_v2_lagrange = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lagrange-1.18.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lagrange;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lagrange}"
SRC_URI[x86_64_v2_lagrange.sha256sum] = "8c1d838b06144b72e07acbbced2d8011a722ad0ecf30b3c56cf7a9a4b1755a8e"

URI_aarch64_lagrange = "${EPEL_MIRROR}/aarch64/Packages/l/lagrange-1.18.5-1.el10_1.aarch64.rpm;name=aarch64_lagrange;unpack=0"
SRC_URI:append = " ${URI_aarch64_lagrange}"
SRC_URI[aarch64_lagrange.sha256sum] = "887c64855e59d15266197c7219255e03cc887f29b93dda3d54bc077828391bf2"

RDEPENDS:lagrange = " \
 fribidi \
 glibc \
 harfbuzz \
 libgcc \
 libwebp \
 mpg123-libs \
 the_foundation \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
