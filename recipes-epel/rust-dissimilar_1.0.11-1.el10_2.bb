# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dissimilar"
PV = "1.0.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-dissimilar+default-devel \
 rust-dissimilar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dissimilar-1.0.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4430fbf6bde5b0873272a87df107ba8d53938b79c1995792ba7c6a2da88705ac"

URI_x86_64_v2_rust-dissimilar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dissimilar+default-devel-1.0.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dissimilar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dissimilar+default-devel}"
SRC_URI[x86_64_v2_rust-dissimilar+default-devel.sha256sum] = "15c00598ff87d76682cfe8ebbb8846936a2ad7ac982c4ad7e71b9c6510ce8098"

URI_x86_64_v2_rust-dissimilar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dissimilar-devel-1.0.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dissimilar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dissimilar-devel}"
SRC_URI[x86_64_v2_rust-dissimilar-devel.sha256sum] = "84e0dc94448da7a5d6c4310d8aa97ae92841a50f95c799ae3dda4f40f3eb090f"

URI_aarch64_rust-dissimilar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dissimilar+default-devel-1.0.11-1.el10_2.noarch.rpm;name=aarch64_rust-dissimilar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dissimilar+default-devel}"
SRC_URI[aarch64_rust-dissimilar+default-devel.sha256sum] = "fee18c52406a53eb33bcc6e8572f7c02c78f94635e3697098e3ee0edef043a2e"

URI_aarch64_rust-dissimilar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dissimilar-devel-1.0.11-1.el10_2.noarch.rpm;name=aarch64_rust-dissimilar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dissimilar-devel}"
SRC_URI[aarch64_rust-dissimilar-devel.sha256sum] = "18af1e5ae55a9f8ed88a1aae15ed4ec8741e9ff224f22b371cf44cc96dc050f2"

RDEPENDS:rust-dissimilar+default-devel = " \
 cargo \
 rust-dissimilar-devel \
 "
RDEPENDS:rust-dissimilar-devel = " \
 cargo \
 rust \
 "
