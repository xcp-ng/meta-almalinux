# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-block-buffer"
PV = "0.10.4"
PR = "4.el10_0"
PACKAGES = " \
 rust-block-buffer+default-devel \
 rust-block-buffer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-block-buffer-0.10.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9d8201e865023d2420cbceca743cc92405f995bdcd8bfcdf5c7f43af8204472"

URI_x86_64_v2_rust-block-buffer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer+default-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer+default-devel}"
SRC_URI[x86_64_v2_rust-block-buffer+default-devel.sha256sum] = "1e31e0bcfbf849485ddd9cdb84c0e8014fbcea1af3e4d158c9796867726ab9d1"

URI_x86_64_v2_rust-block-buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer-devel-0.10.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer-devel}"
SRC_URI[x86_64_v2_rust-block-buffer-devel.sha256sum] = "53de1bf999ae9e2819420e64334a600f5aa705e48a193867c0ac196463c68b45"

URI_aarch64_rust-block-buffer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer+default-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-block-buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer+default-devel}"
SRC_URI[aarch64_rust-block-buffer+default-devel.sha256sum] = "dd9f8fc6e575b6ef6ae34708f70f9a744d535eb1222e5338dda3191bb71af23b"

URI_aarch64_rust-block-buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer-devel-0.10.4-4.el10_0.noarch.rpm;name=aarch64_rust-block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer-devel}"
SRC_URI[aarch64_rust-block-buffer-devel.sha256sum] = "5bf5ec864e4f9241e6948693df349e8667f4fd665978bc8e56038d29bc2c7c51"

RDEPENDS:rust-block-buffer+default-devel = " \
 cargo \
 rust-block-buffer-devel \
 "
RDEPENDS:rust-block-buffer-devel = " \
 cargo \
 rust-generic-array+default-devel \
 "
