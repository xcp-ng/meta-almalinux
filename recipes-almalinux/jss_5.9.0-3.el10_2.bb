# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jss"
PV = "5.9.0"
PR = "3.el10_2"
PACKAGES = " \
 idm-jss \
 idm-jss-tomcat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jss-5.9.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ef6c02288667e411c29edf24ac7b8d9182b164b20b3c2df38561a0c92cff220"

URI_x86_64_v2_idm-jss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-5.9.0-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_idm-jss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-jss}"
SRC_URI[x86_64_v2_idm-jss.sha256sum] = "6739774c4cb8c7014ff27e0b1d9e6991755711846304498b53c36cf276bd5d27"

URI_x86_64_v2_idm-jss-tomcat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/idm-jss-tomcat-5.9.0-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_idm-jss-tomcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_idm-jss-tomcat}"
SRC_URI[x86_64_v2_idm-jss-tomcat.sha256sum] = "60b4e70a26bff29d678ef2130d7859c696146e82ee4bc20294418ce937ce193c"

URI_aarch64_idm-jss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-5.9.0-3.el10_2.aarch64.rpm;name=aarch64_idm-jss;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-jss}"
SRC_URI[aarch64_idm-jss.sha256sum] = "8438dfbdc02bb362bbc84493098c98d479ec5fd2384f44d33b43a2dfe4382405"

URI_aarch64_idm-jss-tomcat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/idm-jss-tomcat-5.9.0-3.el10_2.aarch64.rpm;name=aarch64_idm-jss-tomcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_idm-jss-tomcat}"
SRC_URI[aarch64_idm-jss-tomcat.sha256sum] = "7c1e823a17a3dc1313a55f206cbab21fd838909b1ba571d0052f2a1911066804"

RDEPENDS:idm-jss = " \
 apache-commons-lang3 \
 glibc \
 java-21-openjdk-headless \
 javapackages-filesystem \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 slf4j \
 slf4j-jdk14 \
 "
RDEPENDS:idm-jss-tomcat = " \
 idm-jss \
 javapackages-filesystem \
 tomcat9-lib \
 virtual/mvn_org.apache.tomcat_tomcat-catalina_ \
 virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 \
 virtual/mvn_org.apache.tomcat_tomcat-coyote_ \
 virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 \
 virtual/mvn_org.apache.tomcat_tomcat-juli_ \
 virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62 \
 "
