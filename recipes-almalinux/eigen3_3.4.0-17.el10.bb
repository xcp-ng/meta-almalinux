# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eigen3"
PV = "3.4.0"
PR = "17.el10"
PACKAGES = " \
 eigen3-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/eigen3-3.4.0-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f0ad2b555dd8c6ff0646a92098fff49d148d66b0225d2e5d87cae371c91161d"

URI_x86_64_v2_eigen3-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/eigen3-devel-3.4.0-17.el10.noarch.rpm;name=x86_64_v2_eigen3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eigen3-devel}"
SRC_URI[x86_64_v2_eigen3-devel.sha256sum] = "91ede5f5f43dbb74a98a4aeb6027bb80cc835c2b2254760cda5f451362588449"

URI_aarch64_eigen3-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/eigen3-devel-3.4.0-17.el10.noarch.rpm;name=aarch64_eigen3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_eigen3-devel}"
SRC_URI[aarch64_eigen3-devel.sha256sum] = "91ede5f5f43dbb74a98a4aeb6027bb80cc835c2b2254760cda5f451362588449"

RDEPENDS:eigen3-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
