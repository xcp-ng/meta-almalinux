# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfigwidgets"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kconfigwidgets \
 kf6-kconfigwidgets-devel \
 kf6-kconfigwidgets-doc \
 kf6-kconfigwidgets-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfigwidgets-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "456f173c93fb64a5a3a26ebc66ddf9f7d617886f57e2cc72ea8bb8bf352f5505"

URI_x86_64_v2_kf6-kconfigwidgets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets.sha256sum] = "4c371e82f7005d32cdd1051697dd22ea125bd3e697c9b3eaf26dbf1e5748e937"

URI_x86_64_v2_kf6-kconfigwidgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-devel}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-devel.sha256sum] = "275de62b2f6568fee74aff5b3aedb5ce075dc05310bbb4d360196bb630e3512c"

URI_x86_64_v2_kf6-kconfigwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-doc}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-doc.sha256sum] = "d2be7ab6c73bc72f075a9f5f7c44e6e0626850d3b3a4e630945411d7b8d22eca"

URI_x86_64_v2_kf6-kconfigwidgets-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfigwidgets-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kconfigwidgets-html}"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-html.sha256sum] = "054b5c00bc8cbf53c41dc1d24a46b707f2d7209be55ab9055efd09740a085f79"

URI_aarch64_kf6-kconfigwidgets = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kconfigwidgets;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets}"
SRC_URI[aarch64_kf6-kconfigwidgets.sha256sum] = "07cbee92945a8548d215d220a5d80363eaf13fad3c3f037d62f897c37742442b"

URI_aarch64_kf6-kconfigwidgets-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-devel}"
SRC_URI[aarch64_kf6-kconfigwidgets-devel.sha256sum] = "24034373590700860be0309700bce570f42e4f1148dcc0c70e16a90fec23caed"

URI_aarch64_kf6-kconfigwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-doc}"
SRC_URI[aarch64_kf6-kconfigwidgets-doc.sha256sum] = "8cdd5ecde503ac396292a43ebff4bcc622b4be62fd01a1376ada56b9b641ead6"

URI_aarch64_kf6-kconfigwidgets-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kconfigwidgets-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kconfigwidgets-html}"
SRC_URI[aarch64_kf6-kconfigwidgets-html.sha256sum] = "323a0e55b797010e82994cdac9af08da982292266befcba9e255753aaed57e0e"

RDEPENDS:kf6-kconfigwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth-devel \
 kf6-kcodecs-devel \
 kf6-kcolorscheme-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets \
 kf6-kwidgetsaddons-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-doc = " \
 "
RDEPENDS:kf6-kconfigwidgets-html = " \
 "
