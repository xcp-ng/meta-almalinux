# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dbl"
PV = "0.3.2"
PR = "6.el10_1"
PACKAGES = " \
 rust-dbl+default-devel \
 rust-dbl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dbl-0.3.2-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84e9628cf6a5f17e668d3b13d0b4388e061d3b58e79d40066c8710b50d4527df"

URI_x86_64_v2_rust-dbl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dbl+default-devel-0.3.2-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dbl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dbl+default-devel}"
SRC_URI[x86_64_v2_rust-dbl+default-devel.sha256sum] = "2a6ae4d441e8e88253ff5e4482d33ed10c9b0754b0a69ae6c74c3155d4b01548"

URI_x86_64_v2_rust-dbl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dbl-devel-0.3.2-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dbl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dbl-devel}"
SRC_URI[x86_64_v2_rust-dbl-devel.sha256sum] = "6d0f19ca19aa06ee9488b9730b453fcae465299e6f8c6403a15d20fe0e73cd7d"

URI_aarch64_rust-dbl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dbl+default-devel-0.3.2-6.el10_1.noarch.rpm;name=aarch64_rust-dbl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dbl+default-devel}"
SRC_URI[aarch64_rust-dbl+default-devel.sha256sum] = "a680b00b26882f18e46dc884bed29f50e192c0aa15aa45d6098a9fe6cb5eb44d"

URI_aarch64_rust-dbl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dbl-devel-0.3.2-6.el10_1.noarch.rpm;name=aarch64_rust-dbl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dbl-devel}"
SRC_URI[aarch64_rust-dbl-devel.sha256sum] = "06f2226be59da7937f634ec7670c52aa593a9d4efb7885f537ca7f43c4ef592e"

RDEPENDS:rust-dbl+default-devel = " \
 cargo \
 rust-dbl-devel \
 "
RDEPENDS:rust-dbl-devel = " \
 cargo \
 rust-generic-array+default-devel \
 "
