# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kscreen"
PE = "1"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kscreen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kscreen-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d20a9f3e2cb7d099b41d9da3d75ec5e41d1f8611c3c8eac4db25a9dfe1cbf5b8"

URI_x86_64_v2_kscreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kscreen-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kscreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kscreen}"
SRC_URI[x86_64_v2_kscreen.sha256sum] = "6ba21c9741ead9e2d88063a2061ea07b14ddd1d7f75a44d377c1847375b96264"

URI_aarch64_kscreen = "${EPEL_MIRROR}/aarch64/Packages/k/kscreen-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kscreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_kscreen}"
SRC_URI[aarch64_kscreen.sha256sum] = "5fa0c661145601116fd749274ebaaa04451207c57dbcbe05bcbe3df57d44eba2"

RDEPENDS:kscreen = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwindowsystem \
 layer-shell-qt \
 libX11 \
 libXi \
 libkscreen \
 libplasma \
 libstdc++ \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 "
