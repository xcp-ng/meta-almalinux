# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tmt"
PV = "1.67.0"
PR = "1.el10_2"
PACKAGES = " \
 tmt \
 tmt+all \
 tmt+export-polarion \
 tmt+link-jira \
 tmt+prepare-artifact \
 tmt+provision-beaker \
 tmt+provision-bootc \
 tmt+provision-container \
 tmt+provision-mock \
 tmt+provision-virtual \
 tmt+report-junit \
 tmt+report-polarion \
 tmt+test-convert \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tmt-1.67.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19f2f4d627e88da4ab25a6cbd1b8a662cfa30526b422c1ec5cb17a2457182e64"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - tmt: sshpass

URI_x86_64_v2_tmt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt}"
SRC_URI[x86_64_v2_tmt.sha256sum] = "b03914ace2cf7826629c3eeb5175b8c63590efa33fea7049cfe3152a040f5f94"

URI_x86_64_v2_tmt+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+all-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+all}"
SRC_URI[x86_64_v2_tmt+all.sha256sum] = "7508fb6af8eae3fe2fbd465b4a3d2e2b166ef1c075e7996743f601619cda0fe0"

URI_x86_64_v2_tmt+export-polarion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+export-polarion-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+export-polarion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+export-polarion}"
SRC_URI[x86_64_v2_tmt+export-polarion.sha256sum] = "33d89085e1d525f77fd5abd63f50a05ee9550fd10bca0519ff99852bf0ed4313"

URI_x86_64_v2_tmt+link-jira = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+link-jira-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+link-jira;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+link-jira}"
SRC_URI[x86_64_v2_tmt+link-jira.sha256sum] = "f9a5a9b68e653f7f983fd961acef448625341b73b656baf0a58b66652b6462ed"

URI_x86_64_v2_tmt+prepare-artifact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+prepare-artifact-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+prepare-artifact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+prepare-artifact}"
SRC_URI[x86_64_v2_tmt+prepare-artifact.sha256sum] = "479853031ca1aea465a1c432513b0a02f9eaa59be0f3e52f21e14bb12e9d0906"

URI_x86_64_v2_tmt+provision-beaker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-beaker-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-beaker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-beaker}"
SRC_URI[x86_64_v2_tmt+provision-beaker.sha256sum] = "897b6dc12c3ee33c5d7e8aaef110cf884340d50cfcfad468d309d88438eef939"

URI_x86_64_v2_tmt+provision-bootc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-bootc-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-bootc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-bootc}"
SRC_URI[x86_64_v2_tmt+provision-bootc.sha256sum] = "6470cf780d5c8806f4701fd8bd838a2da745d3dfaadc308ec621be494a6f9147"

URI_x86_64_v2_tmt+provision-container = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-container-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-container;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-container}"
SRC_URI[x86_64_v2_tmt+provision-container.sha256sum] = "25029a908a7584c494e49330ceea10513cf06072dcff74c3a72e20c93d37f8ae"

URI_x86_64_v2_tmt+provision-mock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-mock-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-mock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-mock}"
SRC_URI[x86_64_v2_tmt+provision-mock.sha256sum] = "305b8382d209fe1bd95bbb7af4c7e14f6539ad781698a35310170fe9421818dc"

URI_x86_64_v2_tmt+provision-virtual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+provision-virtual-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+provision-virtual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+provision-virtual}"
SRC_URI[x86_64_v2_tmt+provision-virtual.sha256sum] = "de3445d41d5cb54c055f95b7a93517c68d5be4f0da4241e985bca4b853ae2f99"

URI_x86_64_v2_tmt+report-junit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+report-junit-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+report-junit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+report-junit}"
SRC_URI[x86_64_v2_tmt+report-junit.sha256sum] = "6bac3b077a6438603f945236f7571ac1928525def723a3b2ed8f6e8074fe3f6a"

URI_x86_64_v2_tmt+report-polarion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+report-polarion-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+report-polarion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+report-polarion}"
SRC_URI[x86_64_v2_tmt+report-polarion.sha256sum] = "5a6b68d972a067fbaa10ec3edea82f1f4cc7a4102b604dba06780a75dc0860fe"

URI_x86_64_v2_tmt+test-convert = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmt+test-convert-1.67.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tmt+test-convert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmt+test-convert}"
SRC_URI[x86_64_v2_tmt+test-convert.sha256sum] = "2a9bf68c7f9e6275b2cd3e2b64079546d68ba55e67dba507d6919855185ead77"

URI_aarch64_tmt = "${EPEL_MIRROR}/aarch64/Packages/t/tmt-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt}"
SRC_URI[aarch64_tmt.sha256sum] = "641995cc45b244fe99bf054b8bce186d8d4cc239ed81e21d5cdaec69b82aae48"

URI_aarch64_tmt+all = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+all-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+all}"
SRC_URI[aarch64_tmt+all.sha256sum] = "9694175c3feeec14ae7de93954d2a313345b986687241f87423e87841bcbf2c7"

URI_aarch64_tmt+export-polarion = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+export-polarion-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+export-polarion;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+export-polarion}"
SRC_URI[aarch64_tmt+export-polarion.sha256sum] = "f0dfec021538d0fa4dbd02b9e6b6a8be373f6a02f3380e91911ac919adf7da7a"

URI_aarch64_tmt+link-jira = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+link-jira-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+link-jira;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+link-jira}"
SRC_URI[aarch64_tmt+link-jira.sha256sum] = "40e6115024b696238f94ed933804656d26566079e7d86159322c18e531304ead"

URI_aarch64_tmt+prepare-artifact = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+prepare-artifact-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+prepare-artifact;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+prepare-artifact}"
SRC_URI[aarch64_tmt+prepare-artifact.sha256sum] = "6b4b574f323f2a7c7f35cd15db506d17184323f059369c92a2d40be3453d00ac"

URI_aarch64_tmt+provision-beaker = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-beaker-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+provision-beaker;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-beaker}"
SRC_URI[aarch64_tmt+provision-beaker.sha256sum] = "33189d1bb2011a6b3d8ec250385832aab22e0b8f0e6e2b78b2f734e853eaedd3"

URI_aarch64_tmt+provision-bootc = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-bootc-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+provision-bootc;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-bootc}"
SRC_URI[aarch64_tmt+provision-bootc.sha256sum] = "9f20d1d76903ab121647794845912996d518fd73018e004e636a667212af4a0c"

URI_aarch64_tmt+provision-container = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-container-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+provision-container;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-container}"
SRC_URI[aarch64_tmt+provision-container.sha256sum] = "fff383d61b05bedce4ba86fabb583dc21b2f647290ad0aa8631baf0dd217c84b"

URI_aarch64_tmt+provision-mock = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-mock-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+provision-mock;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-mock}"
SRC_URI[aarch64_tmt+provision-mock.sha256sum] = "68ea2d39eb2d96df98b47449590f543c8533e5c801c22ec360e0726a15c16139"

URI_aarch64_tmt+provision-virtual = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+provision-virtual-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+provision-virtual;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+provision-virtual}"
SRC_URI[aarch64_tmt+provision-virtual.sha256sum] = "af5ca822fc375915043d3c6b81358fee9abcc8df01757ec49c6673645f86abb1"

URI_aarch64_tmt+report-junit = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+report-junit-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+report-junit;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+report-junit}"
SRC_URI[aarch64_tmt+report-junit.sha256sum] = "5db04ae0e4cc2a2dc5612587886d4a73621b6d39d6160d8890e6cd72156ed38a"

URI_aarch64_tmt+report-polarion = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+report-polarion-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+report-polarion;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+report-polarion}"
SRC_URI[aarch64_tmt+report-polarion.sha256sum] = "1659fe5165ba33dd04cd3d9ab5d7ba4bbaab95f2a3f01763d7664b2c85fddf3f"

URI_aarch64_tmt+test-convert = "${EPEL_MIRROR}/aarch64/Packages/t/tmt+test-convert-1.67.0-1.el10_2.noarch.rpm;name=aarch64_tmt+test-convert;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmt+test-convert}"
SRC_URI[aarch64_tmt+test-convert.sha256sum] = "0e74e9783934f25b2adc0ec684a76ae2a9fc624d77fcf6395417f682dd6f855a"

RDEPENDS:tmt:x86_64_v2 = " \
 bash \
 fmf \
 git-core \
 python3 \
 python3-click \
 python3-docutils \
 python3-jinja2 \
 python3-packaging \
 python3-pint \
 python3-pydantic \
 python3-pygments \
 python3-requests \
 python3-ruamel-yaml \
 python3-typing-extensions \
 python3-urllib3 \
 rsync \
"
RDEPENDS:tmt:aarch64 = " \
 bash \
 fmf \
 git-core \
 python3 \
 python3-click \
 python3-docutils \
 python3-jinja2 \
 python3-packaging \
 python3-pint \
 python3-pydantic \
 python3-pygments \
 python3-requests \
 python3-ruamel-yaml \
 python3-typing-extensions \
 python3-urllib3 \
 rsync \
 sshpass \
"
RDEPENDS:tmt+all = " \
 python3 \
 python3-bugzilla \
 python3-copr \
 python3-html2text \
 python3-jira \
 python3-koji \
 python3-lxml \
 python3-markdown \
 python3-mracklib \
 python3-nitrate \
 python3-pylero \
 python3-setuptools \
 python3-testcloud \
 tmt+export-polarion \
 tmt+prepare-artifact \
 tmt+provision-beaker \
 tmt+provision-container \
 tmt+provision-mock \
 tmt+provision-virtual \
 tmt+report-junit \
 tmt+report-polarion \
 tmt+test-convert \
 "
RDEPENDS:tmt+export-polarion = " \
 python3 \
 python3-pylero \
 tmt \
 "
RDEPENDS:tmt+link-jira = " \
 python3 \
 python3-jira \
 tmt \
 "
RDEPENDS:tmt+prepare-artifact = " \
 python3 \
 python3-copr \
 python3-koji \
 tmt \
 "
RDEPENDS:tmt+provision-beaker = " \
 python3 \
 python3-mrack-beaker \
 python3-mracklib \
 python3-setuptools \
 tmt \
 "
RDEPENDS:tmt+provision-bootc = " \
 podman \
 python3 \
 python3-testcloud \
 tmt \
 tmt+provision-virtual \
 "
RDEPENDS:tmt+provision-container = " \
 ansible-collection-containers-podman \
 podman \
 python3 \
 tmt \
 "
RDEPENDS:tmt+provision-mock = " \
 mock \
 python3 \
 tmt \
 "
RDEPENDS:tmt+provision-virtual = " \
 libvirt-daemon-config-network \
 openssh-clients \
 python3 \
 python3-testcloud \
 tmt \
 "
RDEPENDS:tmt+report-junit = " \
 python3 \
 python3-lxml \
 tmt \
 "
RDEPENDS:tmt+report-polarion = " \
 python3 \
 python3-lxml \
 python3-pylero \
 tmt \
 "
RDEPENDS:tmt+test-convert = " \
 make \
 python3 \
 python3-bugzilla \
 python3-html2text \
 python3-markdown \
 python3-nitrate \
 tmt \
 "
