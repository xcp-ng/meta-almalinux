# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spdx"
PV = "0.10.8"
PR = "2.el10_0"
PACKAGES = " \
 rust-spdx+default-devel \
 rust-spdx+text-devel \
 rust-spdx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spdx-0.10.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "087faf8c307bf48a2b52c30372f8d1c5fd10688cded8b7ab4ccb7a4248d66f2f"

URI_x86_64_v2_rust-spdx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+default-devel-0.10.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+default-devel}"
SRC_URI[x86_64_v2_rust-spdx+default-devel.sha256sum] = "25b738a63f43c1c1ea16eb282ed3e1dfc3e5486720f392eedcc5219fbc717e2d"

URI_x86_64_v2_rust-spdx+text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx+text-devel-0.10.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx+text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx+text-devel}"
SRC_URI[x86_64_v2_rust-spdx+text-devel.sha256sum] = "061bb02abbb090b4542dd6f459c615e4ea6ee82d66f8a12f06f750e47de0a288"

URI_x86_64_v2_rust-spdx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spdx-devel-0.10.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spdx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spdx-devel}"
SRC_URI[x86_64_v2_rust-spdx-devel.sha256sum] = "81d7048a319912a7e427ff3f42ad2ab3827c9c40cdd07fb1571bad37a92d0dfc"

URI_aarch64_rust-spdx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+default-devel-0.10.8-2.el10_0.noarch.rpm;name=aarch64_rust-spdx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+default-devel}"
SRC_URI[aarch64_rust-spdx+default-devel.sha256sum] = "1d8832db4b32f54e5b47f7dfc74949aa6644e93e8b56838bf77d4e8861bf6670"

URI_aarch64_rust-spdx+text-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx+text-devel-0.10.8-2.el10_0.noarch.rpm;name=aarch64_rust-spdx+text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx+text-devel}"
SRC_URI[aarch64_rust-spdx+text-devel.sha256sum] = "6a69c2a27d3501495aea330f084b1dd09378d3506bb841cff6b36bb18da41ebf"

URI_aarch64_rust-spdx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spdx-devel-0.10.8-2.el10_0.noarch.rpm;name=aarch64_rust-spdx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spdx-devel}"
SRC_URI[aarch64_rust-spdx-devel.sha256sum] = "6a9d961673730c98d50fb0119b242873bd956eb485a021475c9621fbfd6d51e6"

RDEPENDS:rust-spdx+default-devel = " \
 cargo \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx+text-devel = " \
 cargo \
 rust-spdx-devel \
 "
RDEPENDS:rust-spdx-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "
