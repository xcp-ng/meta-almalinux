# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-asm"
PV = "0.24.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-asm+default-devel \
 rust-tree-sitter-asm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-asm-0.24.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02951a003f1bccc49dec6280455c641a3751184e95006c634dd4953a0600f18e"

URI_x86_64_v2_rust-tree-sitter-asm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-asm+default-devel-0.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-asm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-asm+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-asm+default-devel.sha256sum] = "134157d658cd62a7a287e7c0647472d5744252005d82d1e58abc777f511cab7b"

URI_x86_64_v2_rust-tree-sitter-asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-asm-devel-0.24.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-asm-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-asm-devel.sha256sum] = "2262b9adb624fe95617bd475897f97491850803dd383f29de066da52c998c443"

URI_aarch64_rust-tree-sitter-asm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-asm+default-devel-0.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-asm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-asm+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-asm+default-devel.sha256sum] = "95d3a12b9a5f150d23d1294f63c070d5faeba25a9b772d6616be157fa4914c36"

URI_aarch64_rust-tree-sitter-asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-asm-devel-0.24.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-asm-devel}"
SRC_URI[aarch64_rust-tree-sitter-asm-devel.sha256sum] = "a0fe360e61eb44775fd454b919248726bf2d2e05bd864b1000827187e8591976"

RDEPENDS:rust-tree-sitter-asm+default-devel = " \
 cargo \
 rust-tree-sitter-asm-devel \
 "
RDEPENDS:rust-tree-sitter-asm-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
