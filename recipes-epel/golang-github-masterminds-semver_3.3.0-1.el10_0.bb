# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-masterminds-semver"
PV = "3.3.0"
PR = "1.el10_0"
PACKAGES = " \
 compat-golang-github-masterminds-semver-3-devel \
 golang-github-masterminds-semver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-masterminds-semver-3.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "232d2e6325ddb8c6e2fab7b54d2bea4d0e28c50835363086f20a9b2bc669758c"

URI_x86_64_v2_compat-golang-github-masterminds-semver-3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-masterminds-semver-3-devel-3.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-masterminds-semver-3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-masterminds-semver-3-devel}"
SRC_URI[x86_64_v2_compat-golang-github-masterminds-semver-3-devel.sha256sum] = "ac7981cf82a713881d84f6a534c0788ebbdda964e30af51f5a78fd931e1aee35"

URI_x86_64_v2_golang-github-masterminds-semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-masterminds-semver-devel-3.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-masterminds-semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-masterminds-semver-devel}"
SRC_URI[x86_64_v2_golang-github-masterminds-semver-devel.sha256sum] = "71ad71b2427318d795c167bdcc876a673bd0c4cf02907dfc122a26fc6bd79fbb"

URI_aarch64_compat-golang-github-masterminds-semver-3-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-masterminds-semver-3-devel-3.3.0-1.el10_0.noarch.rpm;name=aarch64_compat-golang-github-masterminds-semver-3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-masterminds-semver-3-devel}"
SRC_URI[aarch64_compat-golang-github-masterminds-semver-3-devel.sha256sum] = "f780bff95d87c94cfb162433c424796c9b9da514bebbef000ad65c5cebfe1d95"

URI_aarch64_golang-github-masterminds-semver-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-masterminds-semver-devel-3.3.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-masterminds-semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-masterminds-semver-devel}"
SRC_URI[aarch64_golang-github-masterminds-semver-devel.sha256sum] = "eb83feedda263f77b93db47fa6dd0231c73f4f2658f0d675a7ce596976e5305e"

RDEPENDS:compat-golang-github-masterminds-semver-3-devel = " \
 go-filesystem \
 golang-github-masterminds-semver-devel \
 "
RDEPENDS:golang-github-masterminds-semver-devel = " \
 go-filesystem \
 "
