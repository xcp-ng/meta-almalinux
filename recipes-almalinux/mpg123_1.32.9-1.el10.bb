# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mpg123"
PV = "1.32.9"
PR = "1.el10"
PACKAGES = " \
 mpg123 \
 mpg123-devel \
 mpg123-libs \
 mpg123-plugins-pulseaudio \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mpg123-1.32.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f8cb6a6cf890bf206d4e18c08d1646181c7ecc51d8f6a77ea7381aeb652809b"

URI_x86_64_v2_mpg123 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mpg123-1.32.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_mpg123;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpg123}"
SRC_URI[x86_64_v2_mpg123.sha256sum] = "3c7aa463f51b9b728234f3dd7e3b1948f234015a2fd2d96327f5c957dc2fe34c"

URI_x86_64_v2_mpg123-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mpg123-devel-1.32.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_mpg123-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpg123-devel}"
SRC_URI[x86_64_v2_mpg123-devel.sha256sum] = "2acf827dddd9211f0702d37ec2902e880abf792940d9fd468f048e4c1d01a83e"

URI_x86_64_v2_mpg123-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mpg123-libs-1.32.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_mpg123-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpg123-libs}"
SRC_URI[x86_64_v2_mpg123-libs.sha256sum] = "43042b8398b124eeb4ac113315079a1522de458673c72a2df067b79b8932effb"

URI_x86_64_v2_mpg123-plugins-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mpg123-plugins-pulseaudio-1.32.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_mpg123-plugins-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpg123-plugins-pulseaudio}"
SRC_URI[x86_64_v2_mpg123-plugins-pulseaudio.sha256sum] = "fa4ed16c579c966bddae5b38acb476f9861fede2d2636aa1f92daa2aeda4da46"

URI_aarch64_mpg123 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mpg123-1.32.9-1.el10.aarch64.rpm;name=aarch64_mpg123;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpg123}"
SRC_URI[aarch64_mpg123.sha256sum] = "c8f95e5d099e4ba54114b500af5c5a9f47a815071befd8d02d17753a44ee321f"

URI_aarch64_mpg123-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mpg123-devel-1.32.9-1.el10.aarch64.rpm;name=aarch64_mpg123-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpg123-devel}"
SRC_URI[aarch64_mpg123-devel.sha256sum] = "8789d418de5775037cc080955ecf4124abf785a255158731477c910be941ff96"

URI_aarch64_mpg123-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mpg123-libs-1.32.9-1.el10.aarch64.rpm;name=aarch64_mpg123-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpg123-libs}"
SRC_URI[aarch64_mpg123-libs.sha256sum] = "42db700d9ad1b7ebf738cb4c6e5fef0a3aa9b1002d6eec39a5526ba8ed30708f"

URI_aarch64_mpg123-plugins-pulseaudio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mpg123-plugins-pulseaudio-1.32.9-1.el10.aarch64.rpm;name=aarch64_mpg123-plugins-pulseaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpg123-plugins-pulseaudio}"
SRC_URI[aarch64_mpg123-plugins-pulseaudio.sha256sum] = "1f21d69c3518ad4ecf9eeb04cc1de46eadf31a815fc848d2b1c67c06131165e9"

RDEPENDS:mpg123 = " \
 alsa-lib \
 glibc \
 mpg123-libs \
 "
RDEPENDS:mpg123-devel = " \
 mpg123-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:mpg123-libs = " \
 glibc \
 "
RDEPENDS:mpg123-plugins-pulseaudio = " \
 glibc \
 mpg123 \
 pulseaudio-libs \
 "
