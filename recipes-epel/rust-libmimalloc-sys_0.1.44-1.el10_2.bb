# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libmimalloc-sys"
PV = "0.1.44"
PR = "1.el10_2"
PACKAGES = " \
 rust-libmimalloc-sys+arena-devel \
 rust-libmimalloc-sys+cty-devel \
 rust-libmimalloc-sys+debug-devel \
 rust-libmimalloc-sys+debug_in_debug-devel \
 rust-libmimalloc-sys+default-devel \
 rust-libmimalloc-sys+extended-devel \
 rust-libmimalloc-sys+local_dynamic_tls-devel \
 rust-libmimalloc-sys+no_thp-devel \
 rust-libmimalloc-sys+override-devel \
 rust-libmimalloc-sys+secure-devel \
 rust-libmimalloc-sys+v3-devel \
 rust-libmimalloc-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libmimalloc-sys-0.1.44-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45fdb0af25997acbaedf046b9b13ee7486e39a72c114be60d1833f5774bf53be"

URI_x86_64_v2_rust-libmimalloc-sys+arena-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+arena-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+arena-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+arena-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+arena-devel.sha256sum] = "96f9fa33f90c7e726be51bb73bdc8869969b8157b63f7d2a440ec1831ce8b9ab"

URI_x86_64_v2_rust-libmimalloc-sys+cty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+cty-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+cty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+cty-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+cty-devel.sha256sum] = "2c9457014f0fc27d3ae0e8752a8d445208e43015673f4720baccb6b1c9c5d299"

URI_x86_64_v2_rust-libmimalloc-sys+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+debug-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+debug-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+debug-devel.sha256sum] = "b85c60cd834cc8d1964e96f9a6a485a739f2db7047b5b608992e49057c9c3194"

URI_x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+debug_in_debug-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel.sha256sum] = "e61389e3d159be7686a861aec9f3269f77cb22d8ab1e2bdaeb614d3099e53cb8"

URI_x86_64_v2_rust-libmimalloc-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+default-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+default-devel.sha256sum] = "4359b908fa5fa71ed6de31d4fca944bfc7932c5e617413097d70ae953ea7aefb"

URI_x86_64_v2_rust-libmimalloc-sys+extended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+extended-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+extended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+extended-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+extended-devel.sha256sum] = "f8c87733ddc8ca77ea73a298dbfbfec26a1e4578fdcef7fc30f114d9a8193129"

URI_x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+local_dynamic_tls-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel.sha256sum] = "a7408ef23494b305a139f52f830b59a5092c313102c919db25a310583bbcecf9"

URI_x86_64_v2_rust-libmimalloc-sys+no_thp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+no_thp-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+no_thp-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+no_thp-devel.sha256sum] = "7fb061617e80331bc577d5911c3a3c8a1d26fce81e946f2e0ddf18c3fb3179c9"

URI_x86_64_v2_rust-libmimalloc-sys+override-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+override-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+override-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+override-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+override-devel.sha256sum] = "e83ff269f065476645a1565ea84b659b8e1a405dcb1e0e7a7cebe7573469aa43"

URI_x86_64_v2_rust-libmimalloc-sys+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+secure-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+secure-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+secure-devel.sha256sum] = "2bf66ba0fb353a0588b8d1e47ed44b271d239a61f69f32ef435f12c2ea296864"

URI_x86_64_v2_rust-libmimalloc-sys+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+v3-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+v3-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+v3-devel.sha256sum] = "c8890f20d503a9b27e9a5dca1388380ed6beac2f3b84800a194aff140f03e6b9"

URI_x86_64_v2_rust-libmimalloc-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys-devel.sha256sum] = "4db8081ecaeacda80887341a2b9e060c59e98aeff8ed0db834e06335df4299c6"

URI_aarch64_rust-libmimalloc-sys+arena-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+arena-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+arena-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+arena-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+arena-devel.sha256sum] = "bc636b6cf37175a95cee468de37eeee30e4e533429f7171a5ffc75bacbc28f27"

URI_aarch64_rust-libmimalloc-sys+cty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+cty-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+cty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+cty-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+cty-devel.sha256sum] = "36b43b94d2f4535bfd89051e1421b65f80bda470910206b4554d6fce9b730fa6"

URI_aarch64_rust-libmimalloc-sys+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+debug-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+debug-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+debug-devel.sha256sum] = "99fb8388a4cd548f4c4044dccd93cc632439c9b0a52fa98b3ece986bde918c87"

URI_aarch64_rust-libmimalloc-sys+debug_in_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+debug_in_debug-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+debug_in_debug-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+debug_in_debug-devel.sha256sum] = "12c4b82742205b0b38840f00d79e716b98fda71543d3a4607df7ce7840e0d5f3"

URI_aarch64_rust-libmimalloc-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+default-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+default-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+default-devel.sha256sum] = "c082f51041b31ef839698f6ebd0ef94fd6ef289ea099f9840e6639feb51bd1bc"

URI_aarch64_rust-libmimalloc-sys+extended-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+extended-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+extended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+extended-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+extended-devel.sha256sum] = "015f40d49258bf1e683e471252cb53b56d77c87048d7d932a4fcc317cd640d20"

URI_aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+local_dynamic_tls-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel.sha256sum] = "f58c5e357721708deee1e3e27f979dab8818b9c0c13627ceb2cd658833ecd643"

URI_aarch64_rust-libmimalloc-sys+no_thp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+no_thp-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+no_thp-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+no_thp-devel.sha256sum] = "e3f86c340cd23272a255e5535e6478e4775fe1706019f55b72747d9a7839ec9e"

URI_aarch64_rust-libmimalloc-sys+override-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+override-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+override-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+override-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+override-devel.sha256sum] = "89104868017602c95827eef2c06139815fb450bb467537c2da09efbdde2fd9fa"

URI_aarch64_rust-libmimalloc-sys+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+secure-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+secure-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+secure-devel.sha256sum] = "35974a7ae61bf8697699b366deb55ed4f811d2b5dc38ed5ce8a78d180aba08eb"

URI_aarch64_rust-libmimalloc-sys+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+v3-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+v3-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+v3-devel.sha256sum] = "c5db296755901397d70194a97260a197903e6486c747dc5261962d75ba59000b"

URI_aarch64_rust-libmimalloc-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-libmimalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys-devel.sha256sum] = "74d7e672faa9e774a8cca9736ad01de68d8d9cad9b8ddcb8497355a654c84383"

RDEPENDS:rust-libmimalloc-sys+arena-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+cty-devel = " \
 cargo \
 rust-cty+default-devel \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+debug-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+debug_in_debug-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+default-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+extended-devel = " \
 cargo \
 rust-libmimalloc-sys+cty-devel \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+local_dynamic_tls-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+no_thp-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+override-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+secure-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+v3-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-libc+default-devel \
 "
