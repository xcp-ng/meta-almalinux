# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-control-center"
PV = "47.7"
PR = "7.el10"
PACKAGES = " \
 gnome-control-center \
 gnome-control-center-filesystem \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-control-center-47.7-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a9cb9b63d930bbd0f00d38c0fd51c785b297c4ff57c0ebea536976f138a014d"

URI_x86_64_v2_gnome-control-center = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-47.7-7.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-control-center;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-control-center}"
SRC_URI[x86_64_v2_gnome-control-center.sha256sum] = "6460496bc074ce8c11618fc9994b6548325bd278b04b3b6e69c522d02b37f361"

URI_x86_64_v2_gnome-control-center-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-control-center-filesystem-47.7-7.el10.noarch.rpm;name=x86_64_v2_gnome-control-center-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-control-center-filesystem}"
SRC_URI[x86_64_v2_gnome-control-center-filesystem.sha256sum] = "c798d69cf20748c396bd6021984a6ed3aa75bf6c9f48b0adcb738d60a49f0e14"

URI_aarch64_gnome-control-center = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-47.7-7.el10.aarch64.rpm;name=aarch64_gnome-control-center;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-control-center}"
SRC_URI[aarch64_gnome-control-center.sha256sum] = "09f94f849d3362399389a0d865c046826b2e8cacc4499dfb7e4359e04cb68c25"

URI_aarch64_gnome-control-center-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-control-center-filesystem-47.7-7.el10.noarch.rpm;name=aarch64_gnome-control-center-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-control-center-filesystem}"
SRC_URI[aarch64_gnome-control-center-filesystem.sha256sum] = "c798d69cf20748c396bd6021984a6ed3aa75bf6c9f48b0adcb738d60a49f0e14"

RDEPENDS:gnome-control-center = " \
 ModemManager-glib \
 NetworkManager-libnm \
 accountsservice \
 accountsservice-libs \
 alsa-lib \
 cairo \
 colord \
 colord-gtk4 \
 colord-libs \
 cups-libs \
 cups-pk-helper \
 dbus \
 fontconfig \
 gcr-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-bluetooth-libs \
 gnome-control-center-filesystem \
 gnome-desktop4 \
 gnome-online-accounts \
 gnome-settings-daemon \
 gnutls \
 graphene \
 gsettings-desktop-schemas \
 gsound \
 gtk4 \
 ibus-libs \
 iso-codes \
 json-glib \
 krb5-libs \
 libX11 \
 libXi \
 libadwaita \
 libepoxy \
 libgcc \
 libgtop2 \
 libgudev \
 libnma-gtk4 \
 libpwquality \
 libsecret \
 libsmbclient \
 libsoup3 \
 libudisks2 \
 libwacom \
 libxml2 \
 pango \
 pkgconf-pkg-config \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 tecla \
 upower \
 upower-libs \
 "
RDEPENDS:gnome-control-center-filesystem = " \
 "
