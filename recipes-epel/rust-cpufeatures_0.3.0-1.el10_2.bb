# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cpufeatures"
PV = "0.3.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-cpufeatures+default-devel \
 rust-cpufeatures-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cpufeatures-0.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1b5142397428d10c013f3237a9264c7ad7a5f0eab71d9203e182164a30a8cbb"

URI_x86_64_v2_rust-cpufeatures+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpufeatures+default-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpufeatures+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpufeatures+default-devel}"
SRC_URI[x86_64_v2_rust-cpufeatures+default-devel.sha256sum] = "d6d9f2d5476db7049e8ae8c326fa092d33a4793ea339089e5e4a01623ebf9e54"

URI_x86_64_v2_rust-cpufeatures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpufeatures-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpufeatures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpufeatures-devel}"
SRC_URI[x86_64_v2_rust-cpufeatures-devel.sha256sum] = "4a0dc9edebe2946ff012f6ee8b462c5fdfa1a48cf64e460d3578f531ccce0f6d"

URI_aarch64_rust-cpufeatures+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpufeatures+default-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-cpufeatures+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpufeatures+default-devel}"
SRC_URI[aarch64_rust-cpufeatures+default-devel.sha256sum] = "300b612a15f783cea0b5b3f50252cf72ab0ac65785015d3c8fa6d012c8872e04"

URI_aarch64_rust-cpufeatures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpufeatures-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-cpufeatures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpufeatures-devel}"
SRC_URI[aarch64_rust-cpufeatures-devel.sha256sum] = "1f96f49018fcaaeaab6dbec88a122f4dbd1cd95912a298abdf8951e1cd58a906"

RDEPENDS:rust-cpufeatures+default-devel = " \
 cargo \
 rust-cpufeatures-devel \
 "
RDEPENDS:rust-cpufeatures-devel = " \
 cargo \
 rust \
 rust-libc-devel \
 "
