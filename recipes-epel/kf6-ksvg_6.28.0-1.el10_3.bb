# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ksvg"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ksvg \
 kf6-ksvg-devel \
 kf6-ksvg-doc \
 kf6-ksvg-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ksvg-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16470b05081337d948b6e82bcf1cd8b8b1825f5b5b63ad1d391d58936ee3d4ed"

URI_x86_64_v2_kf6-ksvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg}"
SRC_URI[x86_64_v2_kf6-ksvg.sha256sum] = "db2288d0cec9d31ecc69923225c50ce1fd55d330e2f467b3ae4a1c9868755b6b"

URI_x86_64_v2_kf6-ksvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-devel}"
SRC_URI[x86_64_v2_kf6-ksvg-devel.sha256sum] = "ab45c2cc14258761987937d98e4307682621c0a7d352c4d0c232f6ec8ca11c0f"

URI_x86_64_v2_kf6-ksvg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ksvg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-doc}"
SRC_URI[x86_64_v2_kf6-ksvg-doc.sha256sum] = "7aa4f6e96bdc09d461992fc812795a8d806342209d5e00ef81024811bf4b20c5"

URI_x86_64_v2_kf6-ksvg-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ksvg-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ksvg-html}"
SRC_URI[x86_64_v2_kf6-ksvg-html.sha256sum] = "b6570e31d88ecba99b3b634eaed3e99534ef9f240cb7266c420932f8fc7cea28"

URI_aarch64_kf6-ksvg = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ksvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg}"
SRC_URI[aarch64_kf6-ksvg.sha256sum] = "db4a90ce6a784628d190ede242e61f55b59e5c2de143cc77772450c6b22d01fa"

URI_aarch64_kf6-ksvg-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ksvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-devel}"
SRC_URI[aarch64_kf6-ksvg-devel.sha256sum] = "5a7a9d4f6b7accf118e4db847e93c35d3fa60ce735c0c4a52b4a097dae403918"

URI_aarch64_kf6-ksvg-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ksvg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-doc}"
SRC_URI[aarch64_kf6-ksvg-doc.sha256sum] = "7e80daecacfcadd575cc21a65ff6dfaf154aa450ee1e110e27a8ee216946b049"

URI_aarch64_kf6-ksvg-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ksvg-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ksvg-html}"
SRC_URI[aarch64_kf6-ksvg-html.sha256sum] = "a687379581ed08efd8bda7d4ddeebf9e3b40d7045944b02cdafa5297c679f199"

RDEPENDS:kf6-ksvg = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kirigami \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:kf6-ksvg-devel = " \
 cmake-filesystem \
 kf6-ksvg \
 "
RDEPENDS:kf6-ksvg-doc = " \
 "
RDEPENDS:kf6-ksvg-html = " \
 "
