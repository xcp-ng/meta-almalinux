# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stable_deref_trait"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-stable_deref_trait+alloc-devel \
 rust-stable_deref_trait+default-devel \
 rust-stable_deref_trait+std-devel \
 rust-stable_deref_trait-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stable_deref_trait-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b39e834e8c9d15b556408fdac1501cdf88644019791432fe8a468bb78ed2d7b"

URI_x86_64_v2_rust-stable_deref_trait+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait+alloc-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait+alloc-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait+alloc-devel.sha256sum] = "6f44c30f7f79447d47a90fb939b13e57ffd86ac181f380cb4aedba3915ac21ab"

URI_x86_64_v2_rust-stable_deref_trait+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait+default-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait+default-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait+default-devel.sha256sum] = "509529b0590e249bc1b4d4788eab0c9a21fcb9b4ba07f3fdefdab1862e109c77"

URI_x86_64_v2_rust-stable_deref_trait+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait+std-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait+std-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait+std-devel.sha256sum] = "5a4b119f143c4f4f44373f33a28ecf1b097a457317411213c036e2580c08df0e"

URI_x86_64_v2_rust-stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stable_deref_trait-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-stable_deref_trait-devel.sha256sum] = "f40115a0b74f69b5a2a07cadc7320dddd6d023abdcbfcceb377c238c63a62b9a"

URI_aarch64_rust-stable_deref_trait+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait+alloc-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-stable_deref_trait+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait+alloc-devel}"
SRC_URI[aarch64_rust-stable_deref_trait+alloc-devel.sha256sum] = "1e3ea9c140252c66bdb5cae33aa548ea55fa976f68fea82c4ad13ed43003775d"

URI_aarch64_rust-stable_deref_trait+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait+default-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-stable_deref_trait+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait+default-devel}"
SRC_URI[aarch64_rust-stable_deref_trait+default-devel.sha256sum] = "1c7fc2dba624d2e792870dc50602507b7de29767e1666be414d6e01f06d80391"

URI_aarch64_rust-stable_deref_trait+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait+std-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-stable_deref_trait+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait+std-devel}"
SRC_URI[aarch64_rust-stable_deref_trait+std-devel.sha256sum] = "9d384dd496f95ef95804dac07268e60b303d7ab8a55efe8359b363a8f66bb2e9"

URI_aarch64_rust-stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stable_deref_trait-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stable_deref_trait-devel}"
SRC_URI[aarch64_rust-stable_deref_trait-devel.sha256sum] = "a0899f250528241ad089f3b77bda25e7100f8600d6d8c650d04c45e35fce036b"

RDEPENDS:rust-stable_deref_trait+alloc-devel = " \
 cargo \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-stable_deref_trait+default-devel = " \
 cargo \
 rust-stable_deref_trait+std-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-stable_deref_trait+std-devel = " \
 cargo \
 rust-stable_deref_trait+alloc-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-stable_deref_trait-devel = " \
 cargo \
 "
