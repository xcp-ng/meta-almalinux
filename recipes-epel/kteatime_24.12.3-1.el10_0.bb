# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kteatime"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kteatime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kteatime-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8edd1605391fd5325224f355aeb96ddc7aeb8170a5d14bb2b32555e1fa00d91a"

URI_x86_64_v2_kteatime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kteatime-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kteatime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kteatime}"
SRC_URI[x86_64_v2_kteatime.sha256sum] = "0568944cc45b84a040e51a08a16114cca550bce0ef48ce08c8822921df2e00d0"

URI_aarch64_kteatime = "${EPEL_MIRROR}/aarch64/Packages/k/kteatime-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kteatime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kteatime}"
SRC_URI[aarch64_kteatime.sha256sum] = "7dbe46bc5c50e4460de5fea87ab98eb7ce353804366e13bcfcc4bd0f83980d9b"

RDEPENDS:kteatime = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-ktextwidgets \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
