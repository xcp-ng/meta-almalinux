# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtvirtualkeyboard"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtvirtualkeyboard \
 qt5-qtvirtualkeyboard-devel \
 qt5-qtvirtualkeyboard-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtvirtualkeyboard-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b10e55b625db640eb5f16f868c9dc0d9f40254326e589e6ae5e1ff15043d3026"

URI_x86_64_v2_qt5-qtvirtualkeyboard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard.sha256sum] = "3d9562df616c801d06e898707d6aa24a0518db41a7a569a5351344b5919a3ebf"

URI_x86_64_v2_qt5-qtvirtualkeyboard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard-devel}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard-devel.sha256sum] = "48a4149d601c25e21cf8330d3849e4a90820255d2d8ee989eefaf492ea45b618"

URI_x86_64_v2_qt5-qtvirtualkeyboard-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard-examples}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard-examples.sha256sum] = "da002469d580916caddb4a4cfb96d795264c9972b74a13b6cdccc06d10503c06"

URI_aarch64_qt5-qtvirtualkeyboard = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard.sha256sum] = "e096a155af1a5577255e38d9729b5c850b16540db0001e61effdf01cbb9c02ae"

URI_aarch64_qt5-qtvirtualkeyboard-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard-devel}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard-devel.sha256sum] = "6bdfd333efdd2bf11e60b632c8749d35495ef35883066d47229669fa599e017b"

URI_aarch64_qt5-qtvirtualkeyboard-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard-examples}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard-examples.sha256sum] = "776bde615c5a67fafa34ae69693ad7faddd383f3d366059b4d724f1acf9c608f"

RDEPENDS:qt5-qtvirtualkeyboard = " \
 glibc \
 hunspell \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtsvg \
 "
RDEPENDS:qt5-qtvirtualkeyboard-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtvirtualkeyboard \
 "
RDEPENDS:qt5-qtvirtualkeyboard-examples = " \
 qt5-qtvirtualkeyboard \
 "
