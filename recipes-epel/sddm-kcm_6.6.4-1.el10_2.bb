# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sddm-kcm"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 sddm-kcm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sddm-kcm-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66bd00c595e405af2c77aefb65ae6af3c23d588ce46b458372d7964c97e1319b"

URI_x86_64_v2_sddm-kcm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-kcm-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sddm-kcm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-kcm}"
SRC_URI[x86_64_v2_sddm-kcm.sha256sum] = "feb13663191b8d42fab2abc4dec1b2d5e0b68afe7af4be9e24d6fb016b8593a5"

URI_aarch64_sddm-kcm = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-kcm-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_sddm-kcm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-kcm}"
SRC_URI[aarch64_sddm-kcm.sha256sum] = "2ac946e659c16b862202f9d3c75d285e7db6f1e53c3facb0de961d8441f55231"

RDEPENDS:sddm-kcm = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 sddm \
 "
