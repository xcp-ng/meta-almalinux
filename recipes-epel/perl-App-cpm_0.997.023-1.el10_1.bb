# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-App-cpm"
PV = "0.997.023"
PR = "1.el10_1"
PACKAGES = " \
 perl-App-cpm \
 perl-App-cpm-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-App-cpm-0.997.023-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98fc0bd7f086c33c5414541e767c3c3ae9d7c5040a271859c74552d7d06ca7cf"

URI_x86_64_v2_perl-App-cpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-App-cpm-0.997.023-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-App-cpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-App-cpm}"
SRC_URI[x86_64_v2_perl-App-cpm.sha256sum] = "bf4b46f7513e1cc5124c7aefe7ac5a6904094eb362fe45e0c2fa25e234d7b78f"

URI_x86_64_v2_perl-App-cpm-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-App-cpm-tests-0.997.023-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-App-cpm-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-App-cpm-tests}"
SRC_URI[x86_64_v2_perl-App-cpm-tests.sha256sum] = "d5ceb7aa1cdd07b2b53750c2bb48679ccda4c721e4c23d3deaa86abfc2eca0b3"

URI_aarch64_perl-App-cpm = "${EPEL_MIRROR}/aarch64/Packages/p/perl-App-cpm-0.997.023-1.el10_1.noarch.rpm;name=aarch64_perl-App-cpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-App-cpm}"
SRC_URI[aarch64_perl-App-cpm.sha256sum] = "fe367f5878cd0b5de1ba40334cace180b73e8b5ff3cb2ef69616dc0de82ec7e0"

URI_aarch64_perl-App-cpm-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-App-cpm-tests-0.997.023-1.el10_1.noarch.rpm;name=aarch64_perl-App-cpm-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-App-cpm-tests}"
SRC_URI[aarch64_perl-App-cpm-tests.sha256sum] = "ef9ab967729ae9a7b57ac79180f88981337e4eb890094b5d677c7f2fd765a326"

RDEPENDS:perl-App-cpm = " \
 gzip \
 perl-App-cpm \
 perl-Archive-Tar \
 perl-Archive-Zip \
 perl-CPAN-02Packages-Search \
 perl-CPAN-DistnameInfo \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-CPAN-Meta-YAML \
 perl-Carton \
 perl-Command-Runner \
 perl-Darwin-InitObjC \
 perl-Digest-MD5 \
 perl-Exporter \
 perl-ExtUtils-Install \
 perl-ExtUtils-InstallPaths \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Copy-Recursive \
 perl-File-HomeDir \
 perl-File-Path \
 perl-File-Temp \
 perl-File-Which \
 perl-File-pushd \
 perl-Getopt-Long \
 perl-HTTP-Tinyish \
 perl-IO \
 perl-IPC-Run3 \
 perl-JSON-PP \
 perl-Menlo \
 perl-Menlo-Legacy \
 perl-Module-CPANfile \
 perl-Module-CoreList \
 perl-Module-Metadata \
 perl-Module-cpmfile \
 perl-POSIX \
 perl-Parallel-Pipes \
 perl-Parse-PMFile \
 perl-PathTools \
 perl-Proc-ForkSafe \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-YAML-PP \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-local-lib \
 perl-parent \
 perl-podlators \
 perl-version \
 "
RDEPENDS:perl-App-cpm-tests = " \
 bash \
 perl-App-cpm \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
