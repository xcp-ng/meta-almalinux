# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zanshin"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 zanshin \
 zanshin-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zanshin-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bb30a14a9346e7f357641d6d48224743ab9e88efdd175a295daa0e9591f3607"

URI_x86_64_v2_zanshin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zanshin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zanshin}"
SRC_URI[x86_64_v2_zanshin.sha256sum] = "3c5d5f66458293b83fd22835b7c89e9654741da86d0b984f0dc6c076d1b21f8a"

URI_x86_64_v2_zanshin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-common-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_zanshin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zanshin-common}"
SRC_URI[x86_64_v2_zanshin-common.sha256sum] = "7c3b9eec0df20bc6f78fa92e5b62c421a77357faa00c3dbb71b9aa55c33dd93a"

URI_aarch64_zanshin = "${EPEL_MIRROR}/aarch64/Packages/z/zanshin-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_zanshin;unpack=0"
SRC_URI:append = " ${URI_aarch64_zanshin}"
SRC_URI[aarch64_zanshin.sha256sum] = "22b7837ae326b05b931e36e32cc83947371a5f0d3bb51007b04b2756f8dcc863"

URI_aarch64_zanshin-common = "${EPEL_MIRROR}/aarch64/Packages/z/zanshin-common-26.04.3-1.el10_3.noarch.rpm;name=aarch64_zanshin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_zanshin-common}"
SRC_URI[aarch64_zanshin-common.sha256sum] = "bbee5b98bc1fcd7a37df357be726fbf15b3e0f1a769e8bd53227e98fb4b6e311"

RDEPENDS:zanshin = " \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-krunner \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kontactinterface \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 zanshin-common \
 "
RDEPENDS:zanshin-common = " \
 zanshin \
 "
