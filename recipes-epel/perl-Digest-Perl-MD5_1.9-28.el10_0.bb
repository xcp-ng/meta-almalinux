# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Digest-Perl-MD5"
PV = "1.9"
PR = "28.el10_0"
PACKAGES = " \
 perl-Digest-Perl-MD5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Digest-Perl-MD5-1.9-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fefbbaf9bd11a826f16fb34ad374f60851cd810d6909c3d84a36bc0bed927866"

URI_x86_64_v2_perl-Digest-Perl-MD5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Digest-Perl-MD5-1.9-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Digest-Perl-MD5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Digest-Perl-MD5}"
SRC_URI[x86_64_v2_perl-Digest-Perl-MD5.sha256sum] = "7895a4577e47f678b12a5131fe07133c5bb41bc886fda763de77cbe1d306ad12"

URI_aarch64_perl-Digest-Perl-MD5 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Digest-Perl-MD5-1.9-28.el10_0.noarch.rpm;name=aarch64_perl-Digest-Perl-MD5;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Digest-Perl-MD5}"
SRC_URI[aarch64_perl-Digest-Perl-MD5.sha256sum] = "f6c51529c75dc30f44119055c5a4472d1d39390926a50cb728c7169aa73d781b"

RDEPENDS:perl-Digest-Perl-MD5 = " \
 perl-Exporter \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
