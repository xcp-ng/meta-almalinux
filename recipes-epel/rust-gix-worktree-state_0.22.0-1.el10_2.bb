# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree-state"
PV = "0.22.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-worktree-state+default-devel \
 rust-gix-worktree-state-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-state-0.22.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e58b4cd9519e6d75733e82443aeac2c69cd3ec0c32705291ef72434b9d638694"

URI_x86_64_v2_rust-gix-worktree-state+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state+default-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state+default-devel.sha256sum] = "46c0f404a47da5f863c47b6fc689ca006ef17fefe78cc6e716a66b7e3eb36c42"

URI_x86_64_v2_rust-gix-worktree-state-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-state-devel-0.22.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-state-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-state-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-state-devel.sha256sum] = "d122764660ff358c02d913e7b2e317e4dcda4f23451115ad8de0d693780cc11d"

URI_aarch64_rust-gix-worktree-state+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state+default-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-worktree-state+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state+default-devel}"
SRC_URI[aarch64_rust-gix-worktree-state+default-devel.sha256sum] = "f695cc05aecad147c9e3a469829063735a4536cf74703a00d73b0b3a73b69a18"

URI_aarch64_rust-gix-worktree-state-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-state-devel-0.22.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-worktree-state-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-state-devel}"
SRC_URI[aarch64_rust-gix-worktree-state-devel.sha256sum] = "16a863860eab4aa02ceeb5eb661c7d363d4922572813f101628b1f4486ae5dbf"

RDEPENDS:rust-gix-worktree-state+default-devel = " \
 cargo \
 rust-gix-worktree-state-devel \
 "
RDEPENDS:rust-gix-worktree-state-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-io-close+default-devel \
 rust-thiserror+default-devel \
 "
