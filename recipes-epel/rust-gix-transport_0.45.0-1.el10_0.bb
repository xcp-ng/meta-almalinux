# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-transport"
PV = "0.45.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-transport+async-client-devel \
 rust-gix-transport+async-std-devel \
 rust-gix-transport+async-trait-devel \
 rust-gix-transport+base64-devel \
 rust-gix-transport+blocking-client-devel \
 rust-gix-transport+curl-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+document-features-devel \
 rust-gix-transport+futures-io-devel \
 rust-gix-transport+futures-lite-devel \
 rust-gix-transport+gix-credentials-devel \
 rust-gix-transport+http-client-curl-devel \
 rust-gix-transport+http-client-devel \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport+http-client-reqwest-native-tls-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel \
 rust-gix-transport+pin-project-lite-devel \
 rust-gix-transport+reqwest-devel \
 rust-gix-transport+serde-devel \
 rust-gix-transport-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-transport-0.45.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47f4fa37e656aeb0bc5433f9751c27fa262ce744f9616e55397da6f184306aff"

URI_x86_64_v2_rust-gix-transport+async-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-client-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-client-devel.sha256sum] = "848530d39ee49e84adef820fcd4b09b7fbc4148631159cf0ccc5b3491989e6ab"

URI_x86_64_v2_rust-gix-transport+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-std-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-std-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-std-devel.sha256sum] = "5b2bf8cb87b1e16f262152f964ae056f8c940664458881e3cb9bd933f7c7bf25"

URI_x86_64_v2_rust-gix-transport+async-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-trait-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-trait-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-trait-devel.sha256sum] = "ab25dd008a8b68b8b177d7180613ddf3705434fe45943e4724fd999cee535a22"

URI_x86_64_v2_rust-gix-transport+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+base64-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+base64-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+base64-devel.sha256sum] = "35019325b00c98e20fa3c58ccc29578d4811b7b4a17cd5df8bdf71cc9dff453e"

URI_x86_64_v2_rust-gix-transport+blocking-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+blocking-client-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+blocking-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+blocking-client-devel.sha256sum] = "79931dfbef37ca9238b61c7b4c0700e9053fe36d7a12c9965f8670116db8637a"

URI_x86_64_v2_rust-gix-transport+curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+curl-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+curl-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+curl-devel.sha256sum] = "cf8687f3f41a1f74b9f138e4faf579397dd284f95d049b0202380ac7b43b5186"

URI_x86_64_v2_rust-gix-transport+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+default-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+default-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+default-devel.sha256sum] = "d10d28ff031c005735354ba1c5d8eb56c57150bba76b306a4d824a4d85e29a5a"

URI_x86_64_v2_rust-gix-transport+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+document-features-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+document-features-devel.sha256sum] = "e6c9fd90e7567f2526a6ae0ad1deddf599fb2c8679b52b038b3333e0bbb751f2"

URI_x86_64_v2_rust-gix-transport+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+futures-io-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+futures-io-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+futures-io-devel.sha256sum] = "70da0827fdb8261655fb47358d148b992b3ba5799fcba6d77a218dbd0415b2f1"

URI_x86_64_v2_rust-gix-transport+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+futures-lite-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+futures-lite-devel.sha256sum] = "29b2d58dfe385beb2999a4c891ce0073bf33e98e075b32b1b4b1dbdf2104b556"

URI_x86_64_v2_rust-gix-transport+gix-credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+gix-credentials-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+gix-credentials-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+gix-credentials-devel.sha256sum] = "d3a07379149d8aed8a84dc12dc899d25f6940aa54fd8dc1c510252add417be32"

URI_x86_64_v2_rust-gix-transport+http-client-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-curl-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-curl-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-curl-devel.sha256sum] = "6b6730661e5588d55e01a95a9d3059f3db93e1ef6492041a6c2f5d2573ae2c5d"

URI_x86_64_v2_rust-gix-transport+http-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-devel.sha256sum] = "8409454bd2f2dadf86d882eb2427d8dd3a871178d54c30c362947d4f60fa954f"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-devel.sha256sum] = "da3eb1b6e00be29ca199c27bb1427dc80b477ba7369c006e3ff5f1b5899439af"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-native-tls-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel.sha256sum] = "6100727836c6ad7a8010bf0069b29ebb5232f26f2fce3d6312819b48d2d6b07b"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-rust-tls-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel.sha256sum] = "a9f524c7cd21ea05daab2182d5d587d293559dea6985ccde1188edf861454e8f"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel.sha256sum] = "27fad1b331ad4fce0567644f809066e6722979dc10196618f8c6bb27eda42c67"

URI_x86_64_v2_rust-gix-transport+pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+pin-project-lite-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+pin-project-lite-devel.sha256sum] = "9a60214b29f9c7712d8dcc7616afeed24b41d72ce8d5f3f18e47d0056985c3a2"

URI_x86_64_v2_rust-gix-transport+reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+reqwest-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+reqwest-devel.sha256sum] = "c482aca6b92ba4a16138080300295a1be50bfc387667cb9daa172c83417d1363"

URI_x86_64_v2_rust-gix-transport+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+serde-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+serde-devel.sha256sum] = "97e43feedece0fba8e198b2e6b4637855f4490e5e32f2d26ebbcabd1e914487f"

URI_x86_64_v2_rust-gix-transport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport-devel-0.45.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport-devel}"
SRC_URI[x86_64_v2_rust-gix-transport-devel.sha256sum] = "9c0fc9828e2432668f166e1011fb54ab675640d9ff2030b011fda5b559f4bfde"

URI_aarch64_rust-gix-transport+async-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-client-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-client-devel}"
SRC_URI[aarch64_rust-gix-transport+async-client-devel.sha256sum] = "3e7f0d66ccc1099177feefc33482c3fb3a35caa30968c281d3d6038db5c8b138"

URI_aarch64_rust-gix-transport+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-std-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-std-devel}"
SRC_URI[aarch64_rust-gix-transport+async-std-devel.sha256sum] = "1f6de5b09c8a070f7b141f57cd9b3c8d96f8539b0e76debb2d52924ad76d43c4"

URI_aarch64_rust-gix-transport+async-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-trait-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-trait-devel}"
SRC_URI[aarch64_rust-gix-transport+async-trait-devel.sha256sum] = "b26e34c690b54390007744dfb87051e3c9aeb6531e1ca9e26b98055ab24260d6"

URI_aarch64_rust-gix-transport+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+base64-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+base64-devel}"
SRC_URI[aarch64_rust-gix-transport+base64-devel.sha256sum] = "d1fbd0f6117a1857def85514e88e4fe3e74fd8cf5ca3017244da48f95ad085ab"

URI_aarch64_rust-gix-transport+blocking-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+blocking-client-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+blocking-client-devel}"
SRC_URI[aarch64_rust-gix-transport+blocking-client-devel.sha256sum] = "bf38a0b2e15b6464d292923d6de9ec53398276040e75a1e89182ee6bf465afe4"

URI_aarch64_rust-gix-transport+curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+curl-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+curl-devel}"
SRC_URI[aarch64_rust-gix-transport+curl-devel.sha256sum] = "051d7d72204361338450a5c2b00d8a5f679031d58e33bd2bc3fdcf6398a2ee31"

URI_aarch64_rust-gix-transport+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+default-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+default-devel}"
SRC_URI[aarch64_rust-gix-transport+default-devel.sha256sum] = "32c7533691a3ad78d4a3e54b31464f8bc6fcdc9ad14462957da31a5fdb9acab8"

URI_aarch64_rust-gix-transport+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+document-features-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+document-features-devel}"
SRC_URI[aarch64_rust-gix-transport+document-features-devel.sha256sum] = "d89cba36359af659edc2ce28da1a533e2ce7cbfeddd4b901131e62f96143e9ae"

URI_aarch64_rust-gix-transport+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+futures-io-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+futures-io-devel}"
SRC_URI[aarch64_rust-gix-transport+futures-io-devel.sha256sum] = "c97d7bd8bd465ff686c49d60e7d280c458d64f95879b2e9ee6fd1af8c639689b"

URI_aarch64_rust-gix-transport+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+futures-lite-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-transport+futures-lite-devel.sha256sum] = "479d86ba5a327ccf4e2afcacc5fa7ab5560433f2f2df6d4f38acd5fde7359d20"

URI_aarch64_rust-gix-transport+gix-credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+gix-credentials-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+gix-credentials-devel}"
SRC_URI[aarch64_rust-gix-transport+gix-credentials-devel.sha256sum] = "ae59bb2bb164d21cbf901da3f6a8dfd18730c85186c045fc423ff73a05310e62"

URI_aarch64_rust-gix-transport+http-client-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-curl-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+http-client-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-curl-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-curl-devel.sha256sum] = "eb80e893d03d3be9795c5d8a84d783cff0cc9d49c78eb883edd0f9922481ecf1"

URI_aarch64_rust-gix-transport+http-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+http-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-devel.sha256sum] = "2849af820c1100beacd9e08e5a2592ee9a56d31d753144dd14ba758e91891b8a"

URI_aarch64_rust-gix-transport+http-client-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-devel.sha256sum] = "62faa30669f90acd05a3f0b18d43a1331b5caa82f83b85afb38f9f7210de195f"

URI_aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-native-tls-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel.sha256sum] = "436bd120447247397a2446601107cd195547f37754744851f72c07dd239cfd29"

URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-rust-tls-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel.sha256sum] = "3abd89ad6dbd59875b7857ad2de806127c5db80fb861936f3ed8a47b5f1c6497"

URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel.sha256sum] = "cf71ce45d18cd0f4e45d0b6ac93da49bf89859a8952590e0c336bb67c6824cf2"

URI_aarch64_rust-gix-transport+pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+pin-project-lite-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+pin-project-lite-devel}"
SRC_URI[aarch64_rust-gix-transport+pin-project-lite-devel.sha256sum] = "81a5c8484d2cdd9237660b4b70135afe48482a05ae55962781831345d2b79b0b"

URI_aarch64_rust-gix-transport+reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+reqwest-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+reqwest-devel}"
SRC_URI[aarch64_rust-gix-transport+reqwest-devel.sha256sum] = "28a602f1672631254cfe0c17c7bd98c82752ca099a042528a3075228fb5446b8"

URI_aarch64_rust-gix-transport+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+serde-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+serde-devel}"
SRC_URI[aarch64_rust-gix-transport+serde-devel.sha256sum] = "9edfe2ac80214b7de2f622b42bca7218fb2bcacfbadcdd90fddd46a6fd888910"

URI_aarch64_rust-gix-transport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport-devel-0.45.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-transport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport-devel}"
SRC_URI[aarch64_rust-gix-transport-devel.sha256sum] = "c95950bb2fb9d3db2ea3ad975c63b37496ff5e8d250540fe3ddf0868178dced6"

RDEPENDS:rust-gix-transport+async-client-devel = " \
 cargo \
 rust-gix-packetline+async-io-devel \
 rust-gix-transport+async-trait-devel \
 rust-gix-transport+futures-io-devel \
 rust-gix-transport+futures-lite-devel \
 rust-gix-transport+pin-project-lite-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+async-trait-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+blocking-client-devel = " \
 cargo \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+curl-devel = " \
 cargo \
 rust-curl+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+default-devel = " \
 cargo \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+gix-credentials-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-curl-devel = " \
 cargo \
 rust-gix-transport+curl-devel \
 rust-gix-transport+http-client-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-devel = " \
 cargo \
 rust-gix-features+io-pipe-devel \
 rust-gix-transport+base64-devel \
 rust-gix-transport+blocking-client-devel \
 rust-gix-transport+gix-credentials-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-devel = " \
 cargo \
 rust-gix-transport+http-client-devel \
 rust-gix-transport+reqwest-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-native-tls-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+http2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-rust-tls-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest+trust-dns-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+pin-project-lite-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-gix-transport+reqwest-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+http2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+serde-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-transport-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-command+default-devel \
 rust-gix-features+default-devel \
 rust-gix-packetline+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
