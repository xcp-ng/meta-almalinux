# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oidc-agent"
PV = "5.3.3"
PR = "1.el10_0"
PACKAGES = " \
 oidc-agent-cli \
 oidc-agent-desktop \
 oidc-agent-devel \
 oidc-agent-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oidc-agent-5.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e363580a3c4dc95b0f7d2eb27a324a20e777ef4a07cad352e801ade08e19207"

URI_x86_64_v2_oidc-agent-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-cli-5.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-cli}"
SRC_URI[x86_64_v2_oidc-agent-cli.sha256sum] = "ed06489204d1bfaa41ea1ed7b3a86e16953f6d2e00a53358e13b83eac010dd8f"

URI_x86_64_v2_oidc-agent-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-desktop-5.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-desktop}"
SRC_URI[x86_64_v2_oidc-agent-desktop.sha256sum] = "a1fae42821419c42f5a6cfa7fff1e23bcc4bd36b5a98cb28938d22f425650ef4"

URI_x86_64_v2_oidc-agent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-devel-5.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-devel}"
SRC_URI[x86_64_v2_oidc-agent-devel.sha256sum] = "1946f39202bf1e70435d039cbc5ac934851427fdb1da7927609388f482130eeb"

URI_x86_64_v2_oidc-agent-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-libs-5.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-libs}"
SRC_URI[x86_64_v2_oidc-agent-libs.sha256sum] = "d9cc1065406832474303a6ccd3c1c9d072e73813ce236f3482ca1518d5735c4f"

URI_aarch64_oidc-agent-cli = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-cli-5.3.3-1.el10_0.aarch64.rpm;name=aarch64_oidc-agent-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-cli}"
SRC_URI[aarch64_oidc-agent-cli.sha256sum] = "26e42899a61a0c26ecb7663b19d70616860274d7e66c0199c398a42a55c26a3b"

URI_aarch64_oidc-agent-desktop = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-desktop-5.3.3-1.el10_0.aarch64.rpm;name=aarch64_oidc-agent-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-desktop}"
SRC_URI[aarch64_oidc-agent-desktop.sha256sum] = "8cb3b64f9656357ec7ac46d99cf7c985869cd5878f9e8eb711a57d3f39029874"

URI_aarch64_oidc-agent-devel = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-devel-5.3.3-1.el10_0.aarch64.rpm;name=aarch64_oidc-agent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-devel}"
SRC_URI[aarch64_oidc-agent-devel.sha256sum] = "fc695e96c4b7e21230accef398f12dde417faa7bb009a621b0fa50d425643796"

URI_aarch64_oidc-agent-libs = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-libs-5.3.3-1.el10_0.aarch64.rpm;name=aarch64_oidc-agent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-libs}"
SRC_URI[aarch64_oidc-agent-libs.sha256sum] = "e1052b0fe7824e6fa482eb40c4530248ba1fe07afccd7b637ff373affa217771"

RDEPENDS:oidc-agent-cli = " \
 bash \
 cjson \
 clibs-list \
 glibc \
 libmicrohttpd \
 libsodium \
 oidc-agent-libs \
 qrencode-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:oidc-agent-desktop = " \
 cjson \
 clibs-list \
 glib2 \
 glibc \
 gtk3 \
 javascriptcoregtk4.1 \
 libgcc \
 libsodium \
 libstdc++ \
 oidc-agent-cli \
 oidc-agent-libs \
 webkit2gtk4.1 \
 "
RDEPENDS:oidc-agent-devel = " \
 oidc-agent-libs \
 "
RDEPENDS:oidc-agent-libs = " \
 cjson \
 clibs-list \
 glibc \
 libsodium \
 "
