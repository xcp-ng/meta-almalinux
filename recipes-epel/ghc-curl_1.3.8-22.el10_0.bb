# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-curl"
PV = "1.3.8"
PR = "22.el10_0"
PACKAGES = " \
 ghc-curl \
 ghc-curl-devel \
 ghc-curl-doc \
 ghc-curl-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-curl-1.3.8-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f362babcd294f3b7e6f465bd126e28751ce5840dcb22dc9d4be8c827dbf99fa5"

URI_x86_64_v2_ghc-curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-curl-1.3.8-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-curl}"
SRC_URI[x86_64_v2_ghc-curl.sha256sum] = "9c03e8037d22728f87540edd4b91326e546f81744810a09524f3e41caabf98a0"

URI_x86_64_v2_ghc-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-curl-devel-1.3.8-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-curl-devel}"
SRC_URI[x86_64_v2_ghc-curl-devel.sha256sum] = "841c8ce396438aac9b70e228ebef52cd27c9cd4ac6f9421ac881e74210738394"

URI_x86_64_v2_ghc-curl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-curl-doc-1.3.8-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-curl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-curl-doc}"
SRC_URI[x86_64_v2_ghc-curl-doc.sha256sum] = "ac8054e41ce57813cf882f3499461f2f9ef84e3375810c545c0d52e71f92ac55"

URI_x86_64_v2_ghc-curl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-curl-prof-1.3.8-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-curl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-curl-prof}"
SRC_URI[x86_64_v2_ghc-curl-prof.sha256sum] = "cda91331c8af6897be436b8a0e31c626549230f2fb1ba96c0ad0f9bfefcebd13"

URI_aarch64_ghc-curl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-curl-1.3.8-22.el10_0.aarch64.rpm;name=aarch64_ghc-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-curl}"
SRC_URI[aarch64_ghc-curl.sha256sum] = "2e7612824177b746871dee6ba1648a170bafb8992d796234b98e66c68db2b95d"

URI_aarch64_ghc-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-curl-devel-1.3.8-22.el10_0.aarch64.rpm;name=aarch64_ghc-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-curl-devel}"
SRC_URI[aarch64_ghc-curl-devel.sha256sum] = "6fe5133674ef16e6d31ab9354db2b296261c34eecc063a83e9884addcdfdd70f"

URI_aarch64_ghc-curl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-curl-doc-1.3.8-22.el10_0.noarch.rpm;name=aarch64_ghc-curl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-curl-doc}"
SRC_URI[aarch64_ghc-curl-doc.sha256sum] = "89a24bfe571dc939538292244711cf0fc626d64f2f2d9693fc81e00196aaedc6"

URI_aarch64_ghc-curl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-curl-prof-1.3.8-22.el10_0.aarch64.rpm;name=aarch64_ghc-curl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-curl-prof}"
SRC_URI[aarch64_ghc-curl-prof.sha256sum] = "76423c9698d17124cb27715b525eaf6bb768c1e9dbf24bebba7e28e60c287f11"

RDEPENDS:ghc-curl = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:ghc-curl-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-curl \
 libcurl-devel \
 "
RDEPENDS:ghc-curl-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-curl-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-curl-devel \
 "
