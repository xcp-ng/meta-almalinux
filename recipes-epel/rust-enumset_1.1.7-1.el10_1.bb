# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enumset"
PV = "1.1.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-enumset+alloc-devel \
 rust-enumset+default-devel \
 rust-enumset+proc-macro-crate-devel \
 rust-enumset+serde-devel \
 rust-enumset+serde2-devel \
 rust-enumset+std-devel \
 rust-enumset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enumset-1.1.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd733ca6f2dca43145fba11d490fe61e3622f89a92b1f50d26898a9364bdcc0b"

URI_x86_64_v2_rust-enumset+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+alloc-devel-1.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+alloc-devel}"
SRC_URI[x86_64_v2_rust-enumset+alloc-devel.sha256sum] = "7f69d874a484d44c2bf108955c79efaceb010fdd2818167fcf429366420f661a"

URI_x86_64_v2_rust-enumset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+default-devel-1.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+default-devel}"
SRC_URI[x86_64_v2_rust-enumset+default-devel.sha256sum] = "cf792588bc5117995bd19c3c190e91840cce8059ac2407dc2b2690005ca5cf0f"

URI_x86_64_v2_rust-enumset+proc-macro-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+proc-macro-crate-devel-1.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+proc-macro-crate-devel}"
SRC_URI[x86_64_v2_rust-enumset+proc-macro-crate-devel.sha256sum] = "906a8ace01c10ab0a107145cb62749d2ccf2c4e3ee862a7fbf20fbef16fa9962"

URI_x86_64_v2_rust-enumset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+serde-devel-1.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+serde-devel}"
SRC_URI[x86_64_v2_rust-enumset+serde-devel.sha256sum] = "03234ecbe2d816b6293551f5bc018783ed9a39df7c592c97b1bf74c40dbee18b"

URI_x86_64_v2_rust-enumset+serde2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+serde2-devel-1.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+serde2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+serde2-devel}"
SRC_URI[x86_64_v2_rust-enumset+serde2-devel.sha256sum] = "12b9fb82480cd821a13793e52761fff7ff3ee030d4895790cf509001da267de8"

URI_x86_64_v2_rust-enumset+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset+std-devel-1.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset+std-devel}"
SRC_URI[x86_64_v2_rust-enumset+std-devel.sha256sum] = "701fdff8a5cf8aa756dbe7515406e5ae290b684fd78e593696d8e8ba0a32ad7a"

URI_x86_64_v2_rust-enumset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enumset-devel-1.1.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enumset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enumset-devel}"
SRC_URI[x86_64_v2_rust-enumset-devel.sha256sum] = "2d1b2202c2b351bce56d8be7b815442100ebdf5c859f1e1bcd0081c172bea7b8"

URI_aarch64_rust-enumset+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+alloc-devel-1.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-enumset+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+alloc-devel}"
SRC_URI[aarch64_rust-enumset+alloc-devel.sha256sum] = "d696479ea322ae5c2d0f2958dcb55c354b57a865247db113a26c2bd153a34af9"

URI_aarch64_rust-enumset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+default-devel-1.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-enumset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+default-devel}"
SRC_URI[aarch64_rust-enumset+default-devel.sha256sum] = "686a36802768a182af7c32729bf47968de29ed7955da7fc6cd384ddfa56f6c9f"

URI_aarch64_rust-enumset+proc-macro-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+proc-macro-crate-devel-1.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-enumset+proc-macro-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+proc-macro-crate-devel}"
SRC_URI[aarch64_rust-enumset+proc-macro-crate-devel.sha256sum] = "aa4a55d6c6360eac411ccad795096dea8073bedf2c508a8a98311a5e8e0dfed5"

URI_aarch64_rust-enumset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+serde-devel-1.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-enumset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+serde-devel}"
SRC_URI[aarch64_rust-enumset+serde-devel.sha256sum] = "d677c705899a3cf6bd933e9f2179409cd81a76cdf19d17ef2888398183db5332"

URI_aarch64_rust-enumset+serde2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+serde2-devel-1.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-enumset+serde2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+serde2-devel}"
SRC_URI[aarch64_rust-enumset+serde2-devel.sha256sum] = "db0e6979ceabf4adc1de42e34ef190fc5e800acca26e2149a1aa5daba28854aa"

URI_aarch64_rust-enumset+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset+std-devel-1.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-enumset+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset+std-devel}"
SRC_URI[aarch64_rust-enumset+std-devel.sha256sum] = "e74b190a38ff908ec999e1f0b695d926da7d660b34a19dcff842e04068993d7b"

URI_aarch64_rust-enumset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enumset-devel-1.1.7-1.el10_1.noarch.rpm;name=aarch64_rust-enumset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enumset-devel}"
SRC_URI[aarch64_rust-enumset-devel.sha256sum] = "03459a21550de79d03dde67c184d49cf963598cf5d2d9f4c77c25f01431a4a68"

RDEPENDS:rust-enumset+alloc-devel = " \
 cargo \
 rust-enumset-devel \
 "
RDEPENDS:rust-enumset+default-devel = " \
 cargo \
 rust-enumset-devel \
 "
RDEPENDS:rust-enumset+proc-macro-crate-devel = " \
 cargo \
 rust-enumset-devel \
 rust-enumset_derive+proc-macro-crate-devel \
 "
RDEPENDS:rust-enumset+serde-devel = " \
 cargo \
 rust-enumset-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-enumset+serde2-devel = " \
 cargo \
 rust-enumset-devel \
 rust-enumset_derive+serde2_deprecation_warning-devel \
 "
RDEPENDS:rust-enumset+std-devel = " \
 cargo \
 rust-enumset+alloc-devel \
 rust-enumset-devel \
 rust-enumset_derive+proc-macro-crate-devel \
 rust-enumset_derive+std_deprecation_warning-devel \
 "
RDEPENDS:rust-enumset-devel = " \
 cargo \
 rust \
 rust-enumset_derive+default-devel \
 "
