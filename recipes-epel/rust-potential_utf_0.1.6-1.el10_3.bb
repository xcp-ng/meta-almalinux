# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-potential_utf"
PV = "0.1.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-potential_utf+alloc-devel \
 rust-potential_utf+databake-devel \
 rust-potential_utf+default-devel \
 rust-potential_utf+serde-devel \
 rust-potential_utf+writeable-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-potential_utf-0.1.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ab5434912071100caed5ae5640a83cc6091c11fa947a5010153c383a8e9e184e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+alloc-devel-0.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-potential_utf+alloc-devel.sha256sum] = "53fd9a287a3cabd59cac11763bbfc9eab68fadee3fb1bdea99eeb3e26032a12f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+databake-devel-0.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+databake-devel;unpack=0"
SRC_URI[x86_64_v2_rust-potential_utf+databake-devel.sha256sum] = "8976c879ce4c96ccb8621ab6b91c80c64f7b7c2f6f8ed41bcb600a240d148a97"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+default-devel-0.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-potential_utf+default-devel.sha256sum] = "e98fec7216a53a28763119a588416126310d448fadb6469f1878eb2b888303a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+serde-devel-0.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-potential_utf+serde-devel.sha256sum] = "74f57fca3f1cd2456096ccf54dccf004f6c4e4e61cbc634d4ffac50d6178b56f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+writeable-devel-0.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+writeable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-potential_utf+writeable-devel.sha256sum] = "b0b11e5ce67f272324491ea948f25072bcb0a4c96b1e568d6c5a04217b0c9e8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf+zerovec-devel-0.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf+zerovec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-potential_utf+zerovec-devel.sha256sum] = "32481c6ff78e4e41c83b7cdfbdeb313651608968dc276c8c6223b449469419e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-potential_utf-devel-0.1.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-potential_utf-devel;unpack=0"
SRC_URI[x86_64_v2_rust-potential_utf-devel.sha256sum] = "7b889fbbdb3388466dde6a864587d9700fea5f73d29e60b86be5cdc7a0d109b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+alloc-devel-0.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-potential_utf+alloc-devel.sha256sum] = "4b6a647af3f784cdd9d17d7ca27452851e654a56d22404a608c31c0eff09533e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+databake-devel-0.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+databake-devel;unpack=0"
SRC_URI[aarch64_rust-potential_utf+databake-devel.sha256sum] = "eaab07d03cf80af7f36955dc39dbac4bca53b368d0f56a74a2391fb27060ee4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+default-devel-0.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+default-devel;unpack=0"
SRC_URI[aarch64_rust-potential_utf+default-devel.sha256sum] = "d34b6b4a9d5bbd0f9debb7d6ec08d28380a3b0727059813c6ee5e1a2ddb51bb8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+serde-devel-0.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+serde-devel;unpack=0"
SRC_URI[aarch64_rust-potential_utf+serde-devel.sha256sum] = "a91c1a6a72004b0fab7a2c2162cd45544cb1a3b09fc54f23e49d2c2c1958bf38"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+writeable-devel-0.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+writeable-devel;unpack=0"
SRC_URI[aarch64_rust-potential_utf+writeable-devel.sha256sum] = "9da06d2e1270a6e403b6ce67fc5167eaa455ad9b576a8ffd5465b4f91ebbf2ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf+zerovec-devel-0.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf+zerovec-devel;unpack=0"
SRC_URI[aarch64_rust-potential_utf+zerovec-devel.sha256sum] = "f5fef352d2431c4ebac5027ff7e809389ea15f66df3fca254bd56d642ebc10fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-potential_utf-devel-0.1.6-1.el10_3.noarch.rpm;name=aarch64_rust-potential_utf-devel;unpack=0"
SRC_URI[aarch64_rust-potential_utf-devel.sha256sum] = "88e093b9fe3cf7b6a4627e0613cea4be2e8472f6b22d3a888b40e6e8f824633a"

RDEPENDS:rust-potential_utf+alloc-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-writeable+alloc-devel \
 rust-writeable-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-potential_utf+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-potential_utf-devel \
 "
RDEPENDS:rust-potential_utf+default-devel = " \
 cargo \
 rust-potential_utf+alloc-devel \
 rust-potential_utf-devel \
 "
RDEPENDS:rust-potential_utf+serde-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-potential_utf+writeable-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-potential_utf+zerovec-devel = " \
 cargo \
 rust-potential_utf-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-potential_utf-devel = " \
 cargo \
 rust \
 "
