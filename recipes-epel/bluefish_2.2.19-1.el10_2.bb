# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluefish"
PV = "2.2.19"
PR = "1.el10_2"
PACKAGES = " \
 bluefish \
 bluefish-shared-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluefish-2.2.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c921551fbf380413b5ba0a0dd4c8ab3a6113f187df1dd18a7e62625b09f62802"

URI_x86_64_v2_bluefish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluefish-2.2.19-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluefish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluefish}"
SRC_URI[x86_64_v2_bluefish.sha256sum] = "46b0e3176c767be70ba9885515e0690554482a369b489b8a301f0cb7510257ec"

URI_x86_64_v2_bluefish-shared-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluefish-shared-data-2.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bluefish-shared-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluefish-shared-data}"
SRC_URI[x86_64_v2_bluefish-shared-data.sha256sum] = "c2f9198ca25fe3115264d150cf37aaf5c0df98a224db82ee404bec08cf894e54"

URI_aarch64_bluefish = "${EPEL_MIRROR}/aarch64/Packages/b/bluefish-2.2.19-1.el10_2.aarch64.rpm;name=aarch64_bluefish;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluefish}"
SRC_URI[aarch64_bluefish.sha256sum] = "2a65f0962e15d1256ab435952df828eb5f57881161a06208bbd94fc19849a966"

URI_aarch64_bluefish-shared-data = "${EPEL_MIRROR}/aarch64/Packages/b/bluefish-shared-data-2.2.19-1.el10_2.noarch.rpm;name=aarch64_bluefish-shared-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluefish-shared-data}"
SRC_URI[aarch64_bluefish-shared-data.sha256sum] = "8e2e32c44bf83ff17647e5264ec02a49c6cc4300b33eaffcef7e11a28601aedc"

RDEPENDS:bluefish = " \
 atk \
 bluefish-shared-data \
 cairo \
 cairo-gobject \
 enchant2 \
 findutils \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 grep \
 gtk3 \
 gucharmap-libs \
 harfbuzz \
 libxml2 \
 pango \
 pcre2 \
 python3-libs \
 xml-common \
 "
RDEPENDS:bluefish-shared-data = " \
 bash \
 bluefish \
 python3 \
 "
