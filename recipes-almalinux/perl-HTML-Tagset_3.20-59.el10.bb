# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-Tagset"
PV = "3.20"
PR = "59.el10"
PACKAGES = " \
 perl-HTML-Tagset \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-HTML-Tagset-3.20-59.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9107322eefe4937e1d399ae0e209d9b35a824a9f9b824765a3dcf43560e93650"

URI_x86_64_v2_perl-HTML-Tagset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-HTML-Tagset-3.20-59.el10.noarch.rpm;name=x86_64_v2_perl-HTML-Tagset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-Tagset}"
SRC_URI[x86_64_v2_perl-HTML-Tagset.sha256sum] = "57172b3cb26dac95dc94bad9b038b236bf892e0760b4d225438ae13f5d55a5f2"

URI_aarch64_perl-HTML-Tagset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-HTML-Tagset-3.20-59.el10.noarch.rpm;name=aarch64_perl-HTML-Tagset;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-Tagset}"
SRC_URI[aarch64_perl-HTML-Tagset.sha256sum] = "57172b3cb26dac95dc94bad9b038b236bf892e0760b4d225438ae13f5d55a5f2"

RDEPENDS:perl-HTML-Tagset = " \
 perl-libs \
 perl-vars \
 "
