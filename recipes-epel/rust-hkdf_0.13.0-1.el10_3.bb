# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hkdf"
PV = "0.13.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-hkdf+default-devel \
 rust-hkdf+kdf-devel \
 rust-hkdf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hkdf-0.13.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed1c457a2db912e2661dab8b0b32bef2f5a88859f3d3c66f59493a6236ca526e"

URI_x86_64_v2_rust-hkdf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hkdf+default-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hkdf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hkdf+default-devel}"
SRC_URI[x86_64_v2_rust-hkdf+default-devel.sha256sum] = "9f3409601bd78dc730d76f08fac27f4dab18523a371cba88abb5c14df5811b6e"

URI_x86_64_v2_rust-hkdf+kdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hkdf+kdf-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hkdf+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hkdf+kdf-devel}"
SRC_URI[x86_64_v2_rust-hkdf+kdf-devel.sha256sum] = "f7955e61eb69c1d5725ac25ada5f0914a1cf67df6033c8ba25d53390bcbd7c24"

URI_x86_64_v2_rust-hkdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hkdf-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hkdf-devel}"
SRC_URI[x86_64_v2_rust-hkdf-devel.sha256sum] = "162185f5cb0fb2caad4232d8d605978b5a9c75083ddcae3e4edd58e3a3ab148d"

URI_aarch64_rust-hkdf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hkdf+default-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-hkdf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hkdf+default-devel}"
SRC_URI[aarch64_rust-hkdf+default-devel.sha256sum] = "545926c7a832419e9759c3750a47c558fe20a5bb43dda328479dd1c42bdc667e"

URI_aarch64_rust-hkdf+kdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hkdf+kdf-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-hkdf+kdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hkdf+kdf-devel}"
SRC_URI[aarch64_rust-hkdf+kdf-devel.sha256sum] = "4d056ed3045f34a450ea595360a17f7e9f6931efead4beb3c4f2fd62a70200ca"

URI_aarch64_rust-hkdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hkdf-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hkdf-devel}"
SRC_URI[aarch64_rust-hkdf-devel.sha256sum] = "3428c189b0ad9faba2d590c8dd68b8566751cabcec6d4a7935900686dc1f2c0d"

RDEPENDS:rust-hkdf+default-devel = " \
 cargo \
 rust-hkdf-devel \
 "
RDEPENDS:rust-hkdf+kdf-devel = " \
 cargo \
 rust-hkdf-devel \
 rust-kdf+default-devel \
 "
RDEPENDS:rust-hkdf-devel = " \
 cargo \
 rust \
 rust-hmac+default-devel \
 "
