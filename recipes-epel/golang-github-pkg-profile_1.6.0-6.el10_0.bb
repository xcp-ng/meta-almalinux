# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pkg-profile"
PV = "1.6.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-pkg-profile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pkg-profile-1.6.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d7e16a690ffb58784083af19624d9d38bae1d3ea7216098569ee65d5579c690"

URI_x86_64_v2_golang-github-pkg-profile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pkg-profile-devel-1.6.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pkg-profile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pkg-profile-devel}"
SRC_URI[x86_64_v2_golang-github-pkg-profile-devel.sha256sum] = "f8e5420dc501f44534a06bc5f73eea9278c4b9fd268220e23b2ddffeb6fb9fe2"

URI_aarch64_golang-github-pkg-profile-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pkg-profile-devel-1.6.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-pkg-profile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pkg-profile-devel}"
SRC_URI[aarch64_golang-github-pkg-profile-devel.sha256sum] = "537332e81aa63ab56cd09bca4c41217429d2e0f699ac5766352357d4037958c4"

RDEPENDS:golang-github-pkg-profile-devel = " \
 go-filesystem \
 "
