# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-self_cell"
PV = "1.3.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-self_cell+default-devel \
 rust-self_cell+old_rust-devel \
 rust-self_cell+rustversion-devel \
 rust-self_cell-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-self_cell-1.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "09a751d943d4be0e729a1f21acc70fa531c3f984643a2fd0399a641d3cc88097"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell+default-devel-1.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-self_cell+default-devel.sha256sum] = "cab9c37345f99f43c79fc25610b45774ad4240229a797f7a4953a0ff6c4ec4e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell+old_rust-devel-1.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell+old_rust-devel;unpack=0"
SRC_URI[x86_64_v2_rust-self_cell+old_rust-devel.sha256sum] = "dc49651488dec5a37735bc1fcbc706994fd91464a7bc328f2cccb68bccaa4fbd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell+rustversion-devel-1.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell+rustversion-devel;unpack=0"
SRC_URI[x86_64_v2_rust-self_cell+rustversion-devel.sha256sum] = "19fff64d1de50e0c2c08c64d6a1c66bc49c0b34e31aea3ef7740a2aceea0befb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-self_cell-devel-1.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-self_cell-devel;unpack=0"
SRC_URI[x86_64_v2_rust-self_cell-devel.sha256sum] = "8039eacbe2644603e02128e3e476a988024bf287ada3a36e0bd49facf57d6467"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell+default-devel-1.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-self_cell+default-devel;unpack=0"
SRC_URI[aarch64_rust-self_cell+default-devel.sha256sum] = "00c527e4884d27cbc438830d16b7804152bdead2c8def039c328ca525f1f5c62"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell+old_rust-devel-1.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-self_cell+old_rust-devel;unpack=0"
SRC_URI[aarch64_rust-self_cell+old_rust-devel.sha256sum] = "e14031737e6c8c12278037fcc9bebd3ee8972844a4629ca47f2417fef02308a3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell+rustversion-devel-1.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-self_cell+rustversion-devel;unpack=0"
SRC_URI[aarch64_rust-self_cell+rustversion-devel.sha256sum] = "a9afc7da7cec70b2835caff25ecef674bcd26cd73933bfddf8c6418cc57b8974"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-self_cell-devel-1.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-self_cell-devel;unpack=0"
SRC_URI[aarch64_rust-self_cell-devel.sha256sum] = "8f67ff36da2e901d5a7b32adb1fe1495ef738bf2478397d3322be4ab8d8f88a7"

RDEPENDS:rust-self_cell+default-devel = " \
 cargo \
 rust-self_cell-devel \
 "
RDEPENDS:rust-self_cell+old_rust-devel = " \
 cargo \
 rust-self_cell+rustversion-devel \
 rust-self_cell-devel \
 "
RDEPENDS:rust-self_cell+rustversion-devel = " \
 cargo \
 rust-rustversion+default-devel \
 rust-self_cell-devel \
 "
RDEPENDS:rust-self_cell-devel = " \
 cargo \
 "
