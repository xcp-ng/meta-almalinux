# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rclone"
PV = "1.74.3"
PR = "1.el10_3"
PACKAGES = " \
 rclone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rclone-1.74.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0704e8c305094ff6a226cb7073cf106d83b9bdd5931e396f47b619a9445d2c5"

URI_x86_64_v2_rclone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rclone-1.74.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rclone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rclone}"
SRC_URI[x86_64_v2_rclone.sha256sum] = "77c3693f57709d0e0c807382bf09cbc2f1af60629f9b76fb809847b08be61aad"

URI_aarch64_rclone = "${EPEL_MIRROR}/aarch64/Packages/r/rclone-1.74.3-1.el10_3.aarch64.rpm;name=aarch64_rclone;unpack=0"
SRC_URI:append = " ${URI_aarch64_rclone}"
SRC_URI[aarch64_rclone.sha256sum] = "86d3dac2c70f469f20264daf79bf516f5a39be0b13ffc4f9bfbc282494f25735"

RDEPENDS:rclone = " \
 glibc \
 "
