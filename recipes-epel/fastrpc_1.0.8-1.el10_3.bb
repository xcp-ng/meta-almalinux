# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastrpc"
PV = "1.0.8"
PR = "1.el10_3"
PACKAGES = " \
 fastrpc \
 fastrpc-devel \
 fastrpc-services \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fastrpc-1.0.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bb3217fe651d7a13198f1118097373119bb0400e4a867b61430125591239a95b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fastrpc-1.0.8-1.el10_3.aarch64.rpm;name=aarch64_fastrpc;unpack=0"
SRC_URI[aarch64_fastrpc.sha256sum] = "ffda442dd14a505985a4822f552c826704a70c6f81676a4924a29cf33d21108d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fastrpc-devel-1.0.8-1.el10_3.aarch64.rpm;name=aarch64_fastrpc-devel;unpack=0"
SRC_URI[aarch64_fastrpc-devel.sha256sum] = "66df06b8b1549500a21f51c0de75787995863afa651443e9cb3bc5a198e0968b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fastrpc-services-1.0.8-1.el10_3.aarch64.rpm;name=aarch64_fastrpc-services;unpack=0"
SRC_URI[aarch64_fastrpc-services.sha256sum] = "3351e6fa5b4833c00b73c5dfc28c1ec4f9db6e28d0e63d10527ea4fe086b5e71"

RDEPENDS:fastrpc = " \
 glibc \
 libbsd \
 libyaml \
 "
RDEPENDS:fastrpc-devel = " \
 fastrpc \
 "
RDEPENDS:fastrpc-services = " \
 bash \
 fastrpc \
 glibc \
 "
