# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc-plugin-pause-click"
PV = "2.2.0"
PR = "1.el10_1"
PACKAGES = " \
 vlc-plugin-pause-click \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vlc-plugin-pause-click-2.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c74df5183dde89a468cb9d7d59d9ae56f40bca2f88fde95a2652b8e5fa3b35e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-pause-click-2.2.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-pause-click;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-pause-click.sha256sum] = "dd4bda3160ebaf02726f0dbe7f7da94c10e814df9b7c8ee594230a55d0dcdabb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-pause-click-2.2.0-1.el10_1.aarch64.rpm;name=aarch64_vlc-plugin-pause-click;unpack=0"
SRC_URI[aarch64_vlc-plugin-pause-click.sha256sum] = "c338008186bca6a437ea9d8b3411ff028ee9e96c61e591988981c8df55ddc33e"

RDEPENDS:vlc-plugin-pause-click = " \
 glibc \
 vlc-libs \
 vlc-plugins-video-out \
 "
