# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keydb"
PV = "6.3.4"
PR = "4.el10_0"
PACKAGES = " \
 keydb \
 keydb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keydb-6.3.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5db49e873306210af0fca379647860be840ada3e15a3dd7ee788ea95f3fbe23"

URI_x86_64_v2_keydb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keydb-6.3.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keydb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keydb}"
SRC_URI[x86_64_v2_keydb.sha256sum] = "f25cdb0a3764c4e1a978c31914d711a4c6415238decadec11c11c4c9e74ff9ae"

URI_x86_64_v2_keydb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keydb-devel-6.3.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keydb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keydb-devel}"
SRC_URI[x86_64_v2_keydb-devel.sha256sum] = "49ef5c4271f919e35fd9c0a0d380d49520cc6cfe25d9b8419362b31d5722d000"

URI_aarch64_keydb = "${EPEL_MIRROR}/aarch64/Packages/k/keydb-6.3.4-4.el10_0.aarch64.rpm;name=aarch64_keydb;unpack=0"
SRC_URI:append = " ${URI_aarch64_keydb}"
SRC_URI[aarch64_keydb.sha256sum] = "e1080d52aae1a435fe099ac664c3de534b1dad1dbc1aa5472f22a9944a37f80c"

URI_aarch64_keydb-devel = "${EPEL_MIRROR}/aarch64/Packages/k/keydb-devel-6.3.4-4.el10_0.aarch64.rpm;name=aarch64_keydb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_keydb-devel}"
SRC_URI[aarch64_keydb-devel.sha256sum] = "09a575ab8f4af5da3a4f1110c3953ea44478cf7863c53cb467cdd2433d9ddec6"

RDEPENDS:keydb = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 logrotate \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:keydb-devel = " \
 "
