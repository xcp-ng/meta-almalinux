# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-astropy-iers-data"
PV = "0.2026.9.21.0.56.25"
PR = "1.el10_2"
PACKAGES = " \
 python3-astropy-iers-data \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-astropy-iers-data-0.2026.9.21.0.56.25-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b17eebfdcbe60abdf2aa20f389635c61c401f4784ad55932171324a85cab6ace"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-astropy-iers-data-0.2026.9.21.0.56.25-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-astropy-iers-data;unpack=0"
SRC_URI[x86_64_v2_python3-astropy-iers-data.sha256sum] = "28dff423555442c7ccb26bbdf12a7e709615b4e42783b53a3e72cdb42538f434"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-astropy-iers-data-0.2026.9.21.0.56.25-1.el10_2.noarch.rpm;name=aarch64_python3-astropy-iers-data;unpack=0"
SRC_URI[aarch64_python3-astropy-iers-data.sha256sum] = "a514fae337f5b09905efab5193b2accb72c9712b29d2f225560a8c688f48e959"

RDEPENDS:python3-astropy-iers-data = " \
 python3 \
 "
