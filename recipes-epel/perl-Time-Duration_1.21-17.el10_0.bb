# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Time-Duration"
PV = "1.21"
PR = "17.el10_0"
PACKAGES = " \
 perl-Time-Duration \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Time-Duration-1.21-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93cc7747aee445e821c9335bcc079e8c29f891ce72434ebfff89b7ab82204fe0"

URI_x86_64_v2_perl-Time-Duration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Time-Duration-1.21-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Time-Duration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Time-Duration}"
SRC_URI[x86_64_v2_perl-Time-Duration.sha256sum] = "2be365cca1ac4bf9c81923dff01666292cb51cfede03c17314efbe1b12acf45a"

URI_aarch64_perl-Time-Duration = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Time-Duration-1.21-17.el10_0.noarch.rpm;name=aarch64_perl-Time-Duration;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Time-Duration}"
SRC_URI[aarch64_perl-Time-Duration.sha256sum] = "e75ea793e47aca318f00efba096fca6e7bc50b9e1a9ef38deca73d33da809010"

RDEPENDS:perl-Time-Duration = " \
 perl-Exporter \
 perl-constant \
 perl-libs \
 "
