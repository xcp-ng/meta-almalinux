# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-python-ulid"
PV = "3.2.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-python-ulid \
 python3-python-ulid+pydantic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-python-ulid-3.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b484ac3b2e51cb98f805704b1f1a996ad5f764b3c4dff10d281c7b3fc40926c5"

URI_x86_64_v2_python3-python-ulid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-ulid-3.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-ulid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-ulid}"
SRC_URI[x86_64_v2_python3-python-ulid.sha256sum] = "1073c3b15dd3a359d224ebd75bbe1d28b253d79c7746844b022ea8f0c2edf6c9"

URI_x86_64_v2_python3-python-ulid+pydantic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-ulid+pydantic-3.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-ulid+pydantic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-ulid+pydantic}"
SRC_URI[x86_64_v2_python3-python-ulid+pydantic.sha256sum] = "5b75a5458967a983e850667401fa76ff7fdb5295690b4410e246cfc3c4f90d78"

URI_aarch64_python3-python-ulid = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-ulid-3.2.1-1.el10_2.noarch.rpm;name=aarch64_python3-python-ulid;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-ulid}"
SRC_URI[aarch64_python3-python-ulid.sha256sum] = "b0ae6459254e53d0f33d631667e7b65cfe29c856c2d7e38c022150bbb152679d"

URI_aarch64_python3-python-ulid+pydantic = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-ulid+pydantic-3.2.1-1.el10_2.noarch.rpm;name=aarch64_python3-python-ulid+pydantic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-ulid+pydantic}"
SRC_URI[aarch64_python3-python-ulid+pydantic.sha256sum] = "65b52e2791f4781407a8d7fb07ae1fa7548c50436f036bfe0b4d143bc0209406"

RDEPENDS:python3-python-ulid = " \
 python3 \
 "
RDEPENDS:python3-python-ulid+pydantic = " \
 python3 \
 python3-pydantic \
 python3-python-ulid \
 "
