# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dymo-cups-drivers-lw5xx"
PV = "2.0.0.0"
PR = "1.el10_2"
PACKAGES = " \
 dymo-cups-drivers-lw5xx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dymo-cups-drivers-lw5xx-2.0.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53a01a74b7646ca964a623947a49e07e917c9ed1c74f19095cc77e2282f87487"

URI_x86_64_v2_dymo-cups-drivers-lw5xx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dymo-cups-drivers-lw5xx-2.0.0.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dymo-cups-drivers-lw5xx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dymo-cups-drivers-lw5xx}"
SRC_URI[x86_64_v2_dymo-cups-drivers-lw5xx.sha256sum] = "98b05e61377016a1ed48b3f3ffb21eb39e36a9b9c94b395e663cc42a0577bf0c"

URI_aarch64_dymo-cups-drivers-lw5xx = "${EPEL_MIRROR}/aarch64/Packages/d/dymo-cups-drivers-lw5xx-2.0.0.0-1.el10_2.aarch64.rpm;name=aarch64_dymo-cups-drivers-lw5xx;unpack=0"
SRC_URI:append = " ${URI_aarch64_dymo-cups-drivers-lw5xx}"
SRC_URI[aarch64_dymo-cups-drivers-lw5xx.sha256sum] = "bd83a85ab438e48df059ceac728226c591ca73c91e37c32552d9c2d1c4e890cc"

RDEPENDS:dymo-cups-drivers-lw5xx = " \
 cups \
 cups-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
