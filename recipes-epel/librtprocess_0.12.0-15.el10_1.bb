# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librtprocess"
PV = "0.12.0"
PR = "15.el10_1"
PACKAGES = " \
 librtprocess \
 librtprocess-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/librtprocess-0.12.0-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5852157728ad1ddc1a1dd84fe0b48f3e19a711f3076d84c177292cf6c797b30"

URI_x86_64_v2_librtprocess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librtprocess-0.12.0-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librtprocess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librtprocess}"
SRC_URI[x86_64_v2_librtprocess.sha256sum] = "9538ba51f6eb7061ac8912712bf66bb922301d6a27da52be5f85ac00cafb3b80"

URI_x86_64_v2_librtprocess-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librtprocess-devel-0.12.0-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librtprocess-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librtprocess-devel}"
SRC_URI[x86_64_v2_librtprocess-devel.sha256sum] = "58816e7e8e5261c52b0814c8f4dcb350b16480a0de71ca32d94899ec76481bcb"

URI_aarch64_librtprocess = "${EPEL_MIRROR}/aarch64/Packages/l/librtprocess-0.12.0-15.el10_1.aarch64.rpm;name=aarch64_librtprocess;unpack=0"
SRC_URI:append = " ${URI_aarch64_librtprocess}"
SRC_URI[aarch64_librtprocess.sha256sum] = "ec6e0b24e66a05fe9847cd7b3f1f0e523f9c0859bb1567c25560207b2b619079"

URI_aarch64_librtprocess-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librtprocess-devel-0.12.0-15.el10_1.aarch64.rpm;name=aarch64_librtprocess-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librtprocess-devel}"
SRC_URI[aarch64_librtprocess-devel.sha256sum] = "7646a78004004f856e16e144a87d82c83e4e3394d803adde106737a1dc833e77"

RDEPENDS:librtprocess = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 "
RDEPENDS:librtprocess-devel = " \
 cmake-filesystem \
 librtprocess \
 pkgconf-pkg-config \
 "
