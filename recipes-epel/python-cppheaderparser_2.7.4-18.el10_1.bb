# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cppheaderparser"
PV = "2.7.4"
PR = "18.el10_1"
PACKAGES = " \
 python3-cppheaderparser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cppheaderparser-2.7.4-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd26ba6163e9122786c00b1dc213eecce1521496e1a496063c422fc1042b5711"

URI_x86_64_v2_python3-cppheaderparser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cppheaderparser-2.7.4-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cppheaderparser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cppheaderparser}"
SRC_URI[x86_64_v2_python3-cppheaderparser.sha256sum] = "985d055f292fa43df2ae2d6b979b4c3ec7cb6cb7cad4224c13a80502680b60f3"

URI_aarch64_python3-cppheaderparser = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cppheaderparser-2.7.4-18.el10_1.noarch.rpm;name=aarch64_python3-cppheaderparser;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cppheaderparser}"
SRC_URI[aarch64_python3-cppheaderparser.sha256sum] = "3f587326829c30fc1e47aadeb6502a4a9ba92f25982f23c182483928ee533124"

RDEPENDS:python3-cppheaderparser = " \
 python3 \
 python3-ply \
 "
