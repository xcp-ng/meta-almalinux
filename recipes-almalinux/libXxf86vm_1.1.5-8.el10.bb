# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXxf86vm"
PV = "1.1.5"
PR = "8.el10"
PACKAGES = " \
 libXxf86vm \
 libXxf86vm-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXxf86vm-1.1.5-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73505b2a7660d5be0720fe7fc9a3bbff5683bab37ee2e6475e49f758c5a2093a"

URI_x86_64_v2_libXxf86vm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXxf86vm-1.1.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXxf86vm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXxf86vm}"
SRC_URI[x86_64_v2_libXxf86vm.sha256sum] = "f1ae6b67e68c2f760c3612bbb98ea722fd8a2b5a9ac6b350523209cbc19ee3d4"

URI_x86_64_v2_libXxf86vm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libXxf86vm-devel-1.1.5-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXxf86vm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXxf86vm-devel}"
SRC_URI[x86_64_v2_libXxf86vm-devel.sha256sum] = "1601b761ddceac29c37015c55b6f19df823276097ae1ee24f48ba4c1299a9c82"

URI_aarch64_libXxf86vm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXxf86vm-1.1.5-8.el10.aarch64.rpm;name=aarch64_libXxf86vm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXxf86vm}"
SRC_URI[aarch64_libXxf86vm.sha256sum] = "caed632957ed3abe1ad9cc1f3f07e1351800c66fb79f5b586034c929df06b9fa"

URI_aarch64_libXxf86vm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libXxf86vm-devel-1.1.5-8.el10.aarch64.rpm;name=aarch64_libXxf86vm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXxf86vm-devel}"
SRC_URI[aarch64_libXxf86vm-devel.sha256sum] = "ab56722d6640e6fc874b839405b17d61541206d85e35e3d39bce64c4a7d12af4"

RDEPENDS:libXxf86vm = " \
 glibc \
 libX11 \
 libXext \
 "
RDEPENDS:libXxf86vm-devel = " \
 libX11-devel \
 libXext-devel \
 libXxf86vm \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
