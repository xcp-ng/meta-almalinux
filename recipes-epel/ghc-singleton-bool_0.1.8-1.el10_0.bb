# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-singleton-bool"
PV = "0.1.8"
PR = "1.el10_0"
PACKAGES = " \
 ghc-singleton-bool \
 ghc-singleton-bool-devel \
 ghc-singleton-bool-doc \
 ghc-singleton-bool-prof \
 ghc-some \
 ghc-some-devel \
 ghc-some-doc \
 ghc-some-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-singleton-bool-0.1.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07be27f97514b25c8901ef21fc546f1a2c6675ba17f10104cc57eac93fd38d9d"

URI_x86_64_v2_ghc-singleton-bool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-singleton-bool-0.1.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-singleton-bool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-singleton-bool}"
SRC_URI[x86_64_v2_ghc-singleton-bool.sha256sum] = "c238049111df92913437cd9ee647a796fe0b2613491e965e0be49764d29ce136"

URI_x86_64_v2_ghc-singleton-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-singleton-bool-devel-0.1.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-singleton-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-singleton-bool-devel}"
SRC_URI[x86_64_v2_ghc-singleton-bool-devel.sha256sum] = "37dd0a1b49d3d0cf728c0397f52f9fc403c38aeb48d4bb08278404b8076e1537"

URI_x86_64_v2_ghc-singleton-bool-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-singleton-bool-doc-0.1.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-singleton-bool-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-singleton-bool-doc}"
SRC_URI[x86_64_v2_ghc-singleton-bool-doc.sha256sum] = "0f560f20b5cb063a11bd444901832fee400d5542f2a68d5691d31e22d6ec1bb0"

URI_x86_64_v2_ghc-singleton-bool-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-singleton-bool-prof-0.1.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-singleton-bool-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-singleton-bool-prof}"
SRC_URI[x86_64_v2_ghc-singleton-bool-prof.sha256sum] = "c3726c7ad4d6dfbf574d9a8e9945a1ba4f6311e4ac45643b4bea94e13d27c6ea"

URI_x86_64_v2_ghc-some = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-some-1.0.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-some;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-some}"
SRC_URI[x86_64_v2_ghc-some.sha256sum] = "49ecc51e5e0451f6b958a8bf4a7213fa50838c2a5dddae3105bc455ecf7d755f"

URI_x86_64_v2_ghc-some-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-some-devel-1.0.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-some-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-some-devel}"
SRC_URI[x86_64_v2_ghc-some-devel.sha256sum] = "5db763a2c59578e190d2590b47f4597f4c5a4213d6cba3ffdf2721d57b1d89f6"

URI_x86_64_v2_ghc-some-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-some-doc-1.0.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-some-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-some-doc}"
SRC_URI[x86_64_v2_ghc-some-doc.sha256sum] = "700a9ed7f24d589dc5396003f16f72f1f270a65502b275519dcabfeda9c49148"

URI_x86_64_v2_ghc-some-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-some-prof-1.0.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-some-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-some-prof}"
SRC_URI[x86_64_v2_ghc-some-prof.sha256sum] = "87eb8fc62051dc24bc126f448f2e4635a7c36e43aeb7a195c740ffe55004d9a1"

URI_aarch64_ghc-singleton-bool = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-singleton-bool-0.1.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-singleton-bool;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-singleton-bool}"
SRC_URI[aarch64_ghc-singleton-bool.sha256sum] = "f030c48090025bffa4874bdbd33352f78ca79537285e4f6b2e9c33d5145f89ca"

URI_aarch64_ghc-singleton-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-singleton-bool-devel-0.1.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-singleton-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-singleton-bool-devel}"
SRC_URI[aarch64_ghc-singleton-bool-devel.sha256sum] = "58e60070388b845289ef0090c404c9da0548fdc394a7cd49a862d370b99da9b6"

URI_aarch64_ghc-singleton-bool-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-singleton-bool-doc-0.1.8-1.el10_0.noarch.rpm;name=aarch64_ghc-singleton-bool-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-singleton-bool-doc}"
SRC_URI[aarch64_ghc-singleton-bool-doc.sha256sum] = "0927c1cb6c76d51e119a4690d2abba58ce592433cb8b2eaf352fee110a0751aa"

URI_aarch64_ghc-singleton-bool-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-singleton-bool-prof-0.1.8-1.el10_0.aarch64.rpm;name=aarch64_ghc-singleton-bool-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-singleton-bool-prof}"
SRC_URI[aarch64_ghc-singleton-bool-prof.sha256sum] = "cd9fc355e12b323408442178af6c08ffadf70e941c9f108ff76f065a0baf380f"

URI_aarch64_ghc-some = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-some-1.0.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-some;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-some}"
SRC_URI[aarch64_ghc-some.sha256sum] = "793c45f2a8cd937a5a9cd22c5a5d2d94128987ba0e4a676a409691e5ed46cfb6"

URI_aarch64_ghc-some-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-some-devel-1.0.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-some-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-some-devel}"
SRC_URI[aarch64_ghc-some-devel.sha256sum] = "47c1bc40ecd156dfa22f31294cc9728808c2603eabe700220842b7e69ba2418d"

URI_aarch64_ghc-some-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-some-doc-1.0.6-1.el10_0.noarch.rpm;name=aarch64_ghc-some-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-some-doc}"
SRC_URI[aarch64_ghc-some-doc.sha256sum] = "50176ad314b6eaac4aade40efededff68ca8e7b7e57e5e25390d6019019c833d"

URI_aarch64_ghc-some-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-some-prof-1.0.6-1.el10_0.aarch64.rpm;name=aarch64_ghc-some-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-some-prof}"
SRC_URI[aarch64_ghc-some-prof.sha256sum] = "bb0dad457850c45ba971c16fdcdf5ff461f39663459fa467e0676227ef181369"

RDEPENDS:ghc-singleton-bool = " \
 ghc-array \
 ghc-base \
 ghc-base-orphans \
 ghc-boring \
 ghc-dec \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-some \
 ghc-tagged \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-singleton-bool-devel = " \
 ghc-base-devel \
 ghc-boring-devel \
 ghc-compiler \
 ghc-dec-devel \
 ghc-deepseq-devel \
 ghc-singleton-bool \
 ghc-some-devel \
 "
RDEPENDS:ghc-singleton-bool-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-singleton-bool-prof = " \
 ghc-base-prof \
 ghc-boring-prof \
 ghc-dec-prof \
 ghc-deepseq-prof \
 ghc-singleton-bool-devel \
 ghc-some-prof \
 "
RDEPENDS:ghc-some = " \
 ghc-array \
 ghc-base \
 ghc-base-orphans \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-some-devel = " \
 ghc-base-devel \
 ghc-base-orphans-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-some \
 "
RDEPENDS:ghc-some-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-some-prof = " \
 ghc-base-orphans-prof \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-some-devel \
 "
