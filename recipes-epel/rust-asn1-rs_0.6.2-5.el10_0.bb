# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1-rs"
PV = "0.6.2"
PR = "5.el10_0"
PACKAGES = " \
 rust-asn1-rs+bigint-devel \
 rust-asn1-rs+bits-devel \
 rust-asn1-rs+bitvec-devel \
 rust-asn1-rs+colored-devel \
 rust-asn1-rs+cookie-factory-devel \
 rust-asn1-rs+datetime-devel \
 rust-asn1-rs+debug-devel \
 rust-asn1-rs+default-devel \
 rust-asn1-rs+num-bigint-devel \
 rust-asn1-rs+serialize-devel \
 rust-asn1-rs+std-devel \
 rust-asn1-rs+time-devel \
 rust-asn1-rs+trace-devel \
 rust-asn1-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-rs-0.6.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d75e6c3c0c147b863b8a31adf3c3d8af6b3d31460b8a068a51d92a6389fea64"

URI_x86_64_v2_rust-asn1-rs+bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bigint-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+bigint-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+bigint-devel.sha256sum] = "4fcc185a59aef26d9aca2a9e4207750d124d164182343abbb4e4f685af1a7ab2"

URI_x86_64_v2_rust-asn1-rs+bits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bits-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+bits-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+bits-devel.sha256sum] = "8fabda6a45247b218700a17d65c678fd656e4f6c9492cd953e339388b1c89ecc"

URI_x86_64_v2_rust-asn1-rs+bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bitvec-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+bitvec-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+bitvec-devel.sha256sum] = "22d612b04a373fe62ec6d9c33b18e96e719077d963233445795fcf8b3f08c261"

URI_x86_64_v2_rust-asn1-rs+colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+colored-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+colored-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+colored-devel.sha256sum] = "da3567986acec6c92dc753ed5e53e77629c9f460bfdb31c6e3b6a94c611be160"

URI_x86_64_v2_rust-asn1-rs+cookie-factory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+cookie-factory-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+cookie-factory-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+cookie-factory-devel.sha256sum] = "67c26f9e7cab03f233824f607705f0f985f91c01bf25ce9cd872a4bdbcec127b"

URI_x86_64_v2_rust-asn1-rs+datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+datetime-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+datetime-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+datetime-devel.sha256sum] = "8b247130ea6ad5abf3c7ec4167da3c20c680a6f1e3a9eba20541fb70ceb1b698"

URI_x86_64_v2_rust-asn1-rs+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+debug-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+debug-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+debug-devel.sha256sum] = "3dd751a276cc5c0843b1816f9f26e41039b44565eeeeba33173eac56025f6e39"

URI_x86_64_v2_rust-asn1-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+default-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+default-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+default-devel.sha256sum] = "117195fa56ebe5679982f40a09d80fe88b0fae40ce7cd5520994746dd1f7e4af"

URI_x86_64_v2_rust-asn1-rs+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+num-bigint-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+num-bigint-devel.sha256sum] = "a67a4b4466c3967f21a017b180fd4ade9b42b924115754e71ac951317e4aaaa6"

URI_x86_64_v2_rust-asn1-rs+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+serialize-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+serialize-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+serialize-devel.sha256sum] = "bc99f7a0a50b809247d116a0d238fc46c7a03ad3f191dba2a201a6520ea7b080"

URI_x86_64_v2_rust-asn1-rs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+std-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+std-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+std-devel.sha256sum] = "1fdee9ad89105fd63679c5408da88b429ffea8f4e08df2034bc33f4025e3c36f"

URI_x86_64_v2_rust-asn1-rs+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+time-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+time-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+time-devel.sha256sum] = "a4d28ea46daafd174fb6bcbecce9dc916e5fb5ddf87c501b2912f3ba8a9ed5ac"

URI_x86_64_v2_rust-asn1-rs+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+trace-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs+trace-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs+trace-devel.sha256sum] = "cddec0b30f20048b95bef875bc5b63a3b9a8248884cb7272fe643a76a4f05f63"

URI_x86_64_v2_rust-asn1-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-devel-0.6.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-rs-devel}"
SRC_URI[x86_64_v2_rust-asn1-rs-devel.sha256sum] = "d3847fb63c6a142fe0e5407ea86b0191efe091f6077bc1f9bdab2639f23da42d"

URI_aarch64_rust-asn1-rs+bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bigint-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+bigint-devel}"
SRC_URI[aarch64_rust-asn1-rs+bigint-devel.sha256sum] = "ce96e14995dd8db221b1ea6645d3488b4db3f03dc83121b5e1376cd1ef9804eb"

URI_aarch64_rust-asn1-rs+bits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bits-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+bits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+bits-devel}"
SRC_URI[aarch64_rust-asn1-rs+bits-devel.sha256sum] = "1bc5d481f996d1848c46e6f5102392a3163d2c92d5ac6dc310195621af7016ea"

URI_aarch64_rust-asn1-rs+bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bitvec-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+bitvec-devel}"
SRC_URI[aarch64_rust-asn1-rs+bitvec-devel.sha256sum] = "b2d00c3c61e612cacee807efac66b8397e74b3872c20b354e2718cfa2e387fba"

URI_aarch64_rust-asn1-rs+colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+colored-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+colored-devel}"
SRC_URI[aarch64_rust-asn1-rs+colored-devel.sha256sum] = "2405ba2b89420d1133f54a136150b827e042781232adc9949d407a28838896c3"

URI_aarch64_rust-asn1-rs+cookie-factory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+cookie-factory-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+cookie-factory-devel}"
SRC_URI[aarch64_rust-asn1-rs+cookie-factory-devel.sha256sum] = "975e888d8e0b83d7206f3ca8061d3bfbf6655ea356685c792d76f5d94e2380bb"

URI_aarch64_rust-asn1-rs+datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+datetime-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+datetime-devel}"
SRC_URI[aarch64_rust-asn1-rs+datetime-devel.sha256sum] = "a3ce3d69b98a67591f136490f35039945cf7e010f12c528cff729f75b854aa08"

URI_aarch64_rust-asn1-rs+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+debug-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+debug-devel}"
SRC_URI[aarch64_rust-asn1-rs+debug-devel.sha256sum] = "0c81de8cee3ac7c56fb4d5ce3b397c963d073c9c537745c701ff62c288510bc9"

URI_aarch64_rust-asn1-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+default-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+default-devel}"
SRC_URI[aarch64_rust-asn1-rs+default-devel.sha256sum] = "ebd90f1a203a39cab9939c17ee1a704cbc5eff966bc363b6ece77d408313697d"

URI_aarch64_rust-asn1-rs+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+num-bigint-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+num-bigint-devel}"
SRC_URI[aarch64_rust-asn1-rs+num-bigint-devel.sha256sum] = "54f235ad4ef50e51300d379b01530ce01f7c8bca026f733912b12ce21372fc52"

URI_aarch64_rust-asn1-rs+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+serialize-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+serialize-devel}"
SRC_URI[aarch64_rust-asn1-rs+serialize-devel.sha256sum] = "03490ac774506db21f64dc1450f8ca4c69c4b73567eefd0c6174e5164917bfb6"

URI_aarch64_rust-asn1-rs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+std-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+std-devel}"
SRC_URI[aarch64_rust-asn1-rs+std-devel.sha256sum] = "3c59095b0870ae56c38c68168eb133e1cd8dd03255db16f1d7f062791a0d320a"

URI_aarch64_rust-asn1-rs+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+time-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+time-devel}"
SRC_URI[aarch64_rust-asn1-rs+time-devel.sha256sum] = "e54e48044bc91a3cf8b35248cefed4dc5499a953329ee85a7a932a7209503315"

URI_aarch64_rust-asn1-rs+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+trace-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs+trace-devel}"
SRC_URI[aarch64_rust-asn1-rs+trace-devel.sha256sum] = "9dd27225d967b3240390b9c1c8b1c478b171736883ddd4158321c2bd66b6488a"

URI_aarch64_rust-asn1-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-devel-0.6.2-5.el10_0.noarch.rpm;name=aarch64_rust-asn1-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-rs-devel}"
SRC_URI[aarch64_rust-asn1-rs-devel.sha256sum] = "a7a08d22bd2942fd349b1a2d58de0daa5062579fde0caff7cee72e0c41b539b9"

RDEPENDS:rust-asn1-rs+bigint-devel = " \
 cargo \
 rust-asn1-rs+num-bigint-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+bits-devel = " \
 cargo \
 rust-asn1-rs+bitvec-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+bitvec-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-bitvec+default-devel \
 "
RDEPENDS:rust-asn1-rs+colored-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-colored2+default-devel \
 "
RDEPENDS:rust-asn1-rs+cookie-factory-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-cookie-factory+default-devel \
 "
RDEPENDS:rust-asn1-rs+datetime-devel = " \
 cargo \
 rust-asn1-rs+time-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+debug-devel = " \
 cargo \
 rust-asn1-rs+colored-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+default-devel = " \
 cargo \
 rust-asn1-rs+std-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+num-bigint-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-num-bigint+default-devel \
 "
RDEPENDS:rust-asn1-rs+serialize-devel = " \
 cargo \
 rust-asn1-rs+cookie-factory-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+std-devel = " \
 cargo \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+time-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-asn1-rs+trace-devel = " \
 cargo \
 rust-asn1-rs+debug-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs-devel = " \
 cargo \
 rust \
 rust-asn1-rs-derive+default-devel \
 rust-asn1-rs-impl+default-devel \
 rust-displaydoc+default-devel \
 rust-nom+std-devel \
 rust-nom-devel \
 rust-num-traits+default-devel \
 rust-rusticata-macros+default-devel \
 rust-thiserror1+default-devel \
 "
