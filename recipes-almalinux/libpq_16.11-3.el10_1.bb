# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpq"
PV = "16.11"
PR = "3.el10_1"
PACKAGES = " \
 libpq \
 libpq-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpq-16.11-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "463736e477fd51e3b21b8820aaa988589ff4849db60b3cbed4575b565b04d6d8"

URI_x86_64_v2_libpq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpq-16.11-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_libpq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpq}"
SRC_URI[x86_64_v2_libpq.sha256sum] = "6ea073b6fe640fd83fa79fc9e2b25820a3425be27195f5aa5070615cf0834011"

URI_x86_64_v2_libpq-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpq-devel-16.11-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_libpq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpq-devel}"
SRC_URI[x86_64_v2_libpq-devel.sha256sum] = "7f7f2f007df7b824adf0cd929e94721a400fcca83df19cab8d514c43b83a3726"

URI_aarch64_libpq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpq-16.11-3.el10_1.aarch64.rpm;name=aarch64_libpq;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpq}"
SRC_URI[aarch64_libpq.sha256sum] = "0460f65b0bb9206ed154e4147e391c9b9857c269092e519468c19fe58daa87ca"

URI_aarch64_libpq-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpq-devel-16.11-3.el10_1.aarch64.rpm;name=aarch64_libpq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpq-devel}"
SRC_URI[aarch64_libpq-devel.sha256sum] = "6aa3ae8b9e0a0a3af44becea00d0abcf76dd585222dee398a1fea644ac321ed9"

RDEPENDS:libpq = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:libpq-devel = " \
 glibc \
 libpq \
 openssl-devel \
 pkgconf-pkg-config \
 "
