# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freetype"
PV = "2.13.2"
PR = "8.el10"
PACKAGES = " \
 freetype \
 freetype-demos \
 freetype-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/freetype-2.13.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f46ec2dfa3d3a54142825d294e24a4d4dab79b7ae5447dfb248ce912e625699b"

URI_x86_64_v2_freetype = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/freetype-2.13.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_freetype;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetype}"
SRC_URI[x86_64_v2_freetype.sha256sum] = "7f6f20fce68c15df7068b895663ac4f7b4605bb9d20c555a4712810b8b37dd38"

URI_x86_64_v2_freetype-demos = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/freetype-demos-2.13.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_freetype-demos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetype-demos}"
SRC_URI[x86_64_v2_freetype-demos.sha256sum] = "160db2ca48f4808a77b693b1673d6c2933d924b57d3841f8b41fb8e453658f8b"

URI_x86_64_v2_freetype-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/freetype-devel-2.13.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_freetype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freetype-devel}"
SRC_URI[x86_64_v2_freetype-devel.sha256sum] = "379c936541d99640de3703a3c9de404796afc71feaeb501ff2a741dc100b4cb8"

URI_aarch64_freetype = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/freetype-2.13.2-8.el10.aarch64.rpm;name=aarch64_freetype;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetype}"
SRC_URI[aarch64_freetype.sha256sum] = "1e717bc6502d00cfe9e7655236860d93bb2aa02ccdfceb1de294c86c3dfbe1c8"

URI_aarch64_freetype-demos = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/freetype-demos-2.13.2-8.el10.aarch64.rpm;name=aarch64_freetype-demos;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetype-demos}"
SRC_URI[aarch64_freetype-demos.sha256sum] = "6743c6096731e0cad961a6a311f2d0890a5f0c10a6a9e9adaf7488300d9d1187"

URI_aarch64_freetype-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/freetype-devel-2.13.2-8.el10.aarch64.rpm;name=aarch64_freetype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freetype-devel}"
SRC_URI[aarch64_freetype-devel.sha256sum] = "213f25d0ef224f3f877ba9b7c3e120f38d1f837151775d79550547af21d4d3d7"

RDEPENDS:freetype = " \
 bash \
 bzip2-libs \
 glibc \
 harfbuzz \
 libbrotli \
 libpng \
 zlib-ng-compat \
 "
RDEPENDS:freetype-demos = " \
 freetype \
 glibc \
 libX11 \
 libpng \
 "
RDEPENDS:freetype-devel = " \
 bash \
 brotli-devel \
 bzip2-devel \
 freetype \
 harfbuzz-devel \
 libpng-devel \
 pkgconf \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
