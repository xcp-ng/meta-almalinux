# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hex-literal0.2"
PV = "0.2.2"
PR = "7.el10_0"
PACKAGES = " \
 rust-hex-literal0.2+default-devel \
 rust-hex-literal0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hex-literal0.2-0.2.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43e28b55114b920c2a5f84185932b1590dbf27a5025f5378bcdb130c31a639f0"

URI_x86_64_v2_rust-hex-literal0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal0.2+default-devel-0.2.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex-literal0.2+default-devel}"
SRC_URI[x86_64_v2_rust-hex-literal0.2+default-devel.sha256sum] = "e77ce59d2d8b0f530c73f43579a145380e8ef20aca558eae60e2ea6646cc3464"

URI_x86_64_v2_rust-hex-literal0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal0.2-devel-0.2.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex-literal0.2-devel}"
SRC_URI[x86_64_v2_rust-hex-literal0.2-devel.sha256sum] = "b450bc734ba147837ccb3d2c7587b6e5e235c3c883b4cdc8460bead33240ba52"

URI_aarch64_rust-hex-literal0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal0.2+default-devel-0.2.2-7.el10_0.noarch.rpm;name=aarch64_rust-hex-literal0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex-literal0.2+default-devel}"
SRC_URI[aarch64_rust-hex-literal0.2+default-devel.sha256sum] = "9eefb0108c06352951cfb298918637968c48270e628e0fb160e77d9f50a84d03"

URI_aarch64_rust-hex-literal0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal0.2-devel-0.2.2-7.el10_0.noarch.rpm;name=aarch64_rust-hex-literal0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex-literal0.2-devel}"
SRC_URI[aarch64_rust-hex-literal0.2-devel.sha256sum] = "eb0d0370b6e73c1f53b631215ad421dacfea9c83fbbc2fe63a35dceb29c03e08"

RDEPENDS:rust-hex-literal0.2+default-devel = " \
 cargo \
 rust-hex-literal0.2-devel \
 "
RDEPENDS:rust-hex-literal0.2-devel = " \
 cargo \
 rust-hex-literal-impl+default-devel \
 rust-proc-macro-hack+default-devel \
 "
