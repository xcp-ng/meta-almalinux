# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapd-glib"
PV = "1.66"
PR = "1.el10_0"
PACKAGES = " \
 snapd-glib \
 snapd-glib-devel \
 snapd-glib-tests \
 snapd-qt \
 snapd-qt-devel \
 snapd-qt-qml \
 snapd-qt-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapd-glib-1.66-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "576f1258da5ec22df8bc4425f0adc7c0d1bad061e068277aa713909db507a3a2"

URI_x86_64_v2_snapd-glib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-glib-1.66-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-glib}"
SRC_URI[x86_64_v2_snapd-glib.sha256sum] = "5ce5b5d0b1cd17a46a0a4162ea86306cadb2197b061b1e8e27a209ae9029af7b"

URI_x86_64_v2_snapd-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-glib-devel-1.66-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-glib-devel}"
SRC_URI[x86_64_v2_snapd-glib-devel.sha256sum] = "676ed0245c1e2344b4479d207ba0780eed88131aa4ed4feae001764a0c9a9732"

URI_x86_64_v2_snapd-glib-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-glib-tests-1.66-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-glib-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-glib-tests}"
SRC_URI[x86_64_v2_snapd-glib-tests.sha256sum] = "00887102b7f247ecf0c8c2a4fde26c6dcc0aee901953e76853afa1ee33b312d2"

URI_x86_64_v2_snapd-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-qt-1.66-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-qt}"
SRC_URI[x86_64_v2_snapd-qt.sha256sum] = "03cb3db306ca2d7a63e6b2b58d1cf3e317bf5eb3c9f23baee3955f139c96ae54"

URI_x86_64_v2_snapd-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-qt-devel-1.66-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-qt-devel}"
SRC_URI[x86_64_v2_snapd-qt-devel.sha256sum] = "4e14fb45661a3f9a5426c6f70a686dc3fa73a19e79543a44b5c7a202d06db8ef"

URI_x86_64_v2_snapd-qt-qml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-qt-qml-1.66-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-qt-qml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-qt-qml}"
SRC_URI[x86_64_v2_snapd-qt-qml.sha256sum] = "f7eb8994514d43538805391ae5be6752cb34e1f5a0680ba028cf2e7e4c2613a3"

URI_x86_64_v2_snapd-qt-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-qt-tests-1.66-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd-qt-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-qt-tests}"
SRC_URI[x86_64_v2_snapd-qt-tests.sha256sum] = "0b69813e2705565ac3bfd5f537a2fdd2012367036b2c33631e5569e9ee604474"

URI_aarch64_snapd-glib = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-glib-1.66-1.el10_0.aarch64.rpm;name=aarch64_snapd-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-glib}"
SRC_URI[aarch64_snapd-glib.sha256sum] = "17d8df75174dd26183c7ae473d4af12b1bffd5ec0eeb824ab530821d308db93d"

URI_aarch64_snapd-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-glib-devel-1.66-1.el10_0.aarch64.rpm;name=aarch64_snapd-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-glib-devel}"
SRC_URI[aarch64_snapd-glib-devel.sha256sum] = "711bb79198bf141d49750a75f135b352bcb9785529871c868af88ac0a6e9cdbc"

URI_aarch64_snapd-glib-tests = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-glib-tests-1.66-1.el10_0.aarch64.rpm;name=aarch64_snapd-glib-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-glib-tests}"
SRC_URI[aarch64_snapd-glib-tests.sha256sum] = "ef4a52d01037a9d46ac884bf7e9279c91433cb23a47c568b9eb5dba0e0c08b7d"

URI_aarch64_snapd-qt = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-qt-1.66-1.el10_0.aarch64.rpm;name=aarch64_snapd-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-qt}"
SRC_URI[aarch64_snapd-qt.sha256sum] = "24b6bb273e4b737e67b6f49bdedccc918517530e108b90b3b9e4ce76b1ee59f2"

URI_aarch64_snapd-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-qt-devel-1.66-1.el10_0.aarch64.rpm;name=aarch64_snapd-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-qt-devel}"
SRC_URI[aarch64_snapd-qt-devel.sha256sum] = "6473707dc9b863a44b8955fa736297d27d23ab9b059dc5b7e4a34150e4a4a525"

URI_aarch64_snapd-qt-qml = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-qt-qml-1.66-1.el10_0.aarch64.rpm;name=aarch64_snapd-qt-qml;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-qt-qml}"
SRC_URI[aarch64_snapd-qt-qml.sha256sum] = "4d9c8d2a10cfc6b54e0a99d8973db7fee9e62f59a2a485bf46ea8ba111f58256"

URI_aarch64_snapd-qt-tests = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-qt-tests-1.66-1.el10_0.aarch64.rpm;name=aarch64_snapd-qt-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-qt-tests}"
SRC_URI[aarch64_snapd-qt-tests.sha256sum] = "c16b39136dc3bdedb026b5ee9edc7aae7f1f354459c2e13c856b676282775c2b"

RDEPENDS:snapd-glib = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 "
RDEPENDS:snapd-glib-devel = " \
 glib2-devel \
 json-glib-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 snapd-glib \
 "
RDEPENDS:snapd-glib-tests = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 snapd-glib \
 "
RDEPENDS:snapd-qt = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 snapd-glib \
 "
RDEPENDS:snapd-qt-devel = " \
 cmake-filesystem \
 glib2-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 snapd-glib-devel \
 snapd-qt \
 "
RDEPENDS:snapd-qt-qml = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 snapd-qt \
 "
RDEPENDS:snapd-qt-tests = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libsoup3 \
 libstdc++ \
 qt6-qtbase \
 snapd-glib-tests \
 snapd-qt \
 "
