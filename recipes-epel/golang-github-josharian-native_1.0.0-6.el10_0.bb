# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-josharian-native"
PV = "1.0.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-josharian-native-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-josharian-native-1.0.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d2c47966e414893f0f873545b2b36b5d1b58c31d9eff2ac6dd8b15dc3f1b91d"

URI_x86_64_v2_golang-github-josharian-native-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-josharian-native-devel-1.0.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-josharian-native-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-josharian-native-devel}"
SRC_URI[x86_64_v2_golang-github-josharian-native-devel.sha256sum] = "bbc7de4b0ba4f828cd21c46d66b64a1ff80ff7e7812d61b5de4605a8314e6bb5"

URI_aarch64_golang-github-josharian-native-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-josharian-native-devel-1.0.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-josharian-native-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-josharian-native-devel}"
SRC_URI[aarch64_golang-github-josharian-native-devel.sha256sum] = "1fd1934c915f459b95d8ec5e881a8bc65b92b873474756ef6d60603665f3938f"

RDEPENDS:golang-github-josharian-native-devel = " \
 go-filesystem \
 "
