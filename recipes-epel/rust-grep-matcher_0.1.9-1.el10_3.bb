# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-matcher"
PV = "0.1.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-grep-matcher+default-devel \
 rust-grep-matcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-matcher-0.1.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "643a16830630190baf8b1325caf314e1377a5d45df8b2558f97f683722757f60"

URI_x86_64_v2_rust-grep-matcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-matcher+default-devel-0.1.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-matcher+default-devel}"
SRC_URI[x86_64_v2_rust-grep-matcher+default-devel.sha256sum] = "31e9d7542ef7b63d5325db9a1398b1899a12eda9c22113edb70f770387db210d"

URI_x86_64_v2_rust-grep-matcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-matcher-devel-0.1.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-matcher-devel}"
SRC_URI[x86_64_v2_rust-grep-matcher-devel.sha256sum] = "68c0a7b26095fd4f6553896bd6eb7ee941dcfa0eae9af82b839b01f8c0414697"

URI_aarch64_rust-grep-matcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-matcher+default-devel-0.1.9-1.el10_3.noarch.rpm;name=aarch64_rust-grep-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-matcher+default-devel}"
SRC_URI[aarch64_rust-grep-matcher+default-devel.sha256sum] = "4c980344c5eba049694ec2e8fe18acbe100dabf29d66dfb31d61ccf1f4123b81"

URI_aarch64_rust-grep-matcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-matcher-devel-0.1.9-1.el10_3.noarch.rpm;name=aarch64_rust-grep-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-matcher-devel}"
SRC_URI[aarch64_rust-grep-matcher-devel.sha256sum] = "44c4eddacd1df0ecfb446221fd56e8cf0affe366c7398163d0574556b53e720e"

RDEPENDS:rust-grep-matcher+default-devel = " \
 cargo \
 rust-grep-matcher-devel \
 "
RDEPENDS:rust-grep-matcher-devel = " \
 cargo \
 rust-memchr+default-devel \
 "
