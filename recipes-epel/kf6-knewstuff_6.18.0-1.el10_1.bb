# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-knewstuff"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-knewstuff \
 kf6-knewstuff-devel \
 kf6-knewstuff-doc \
 kf6-knewstuff-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-knewstuff-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97a89105d552dc362d111ff4ec0d22a3a42149fd862986cc217619bb5168df02"

URI_x86_64_v2_kf6-knewstuff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff}"
SRC_URI[x86_64_v2_kf6-knewstuff.sha256sum] = "282ced1efda059845bfa63924d6e7a9d2ad3ad1f1276b8a896871108a94ed8ff"

URI_x86_64_v2_kf6-knewstuff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-knewstuff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-devel}"
SRC_URI[x86_64_v2_kf6-knewstuff-devel.sha256sum] = "df2b48d4ad2e4c8c38fd312ed19260ae1ff64b26e2d6f6abf866d4785470e4b0"

URI_x86_64_v2_kf6-knewstuff-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knewstuff-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-doc}"
SRC_URI[x86_64_v2_kf6-knewstuff-doc.sha256sum] = "572b64d641451f2c2b04fc8ef5795f865a4770c1de7c5e69f2065bb6699ed9e6"

URI_x86_64_v2_kf6-knewstuff-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-knewstuff-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-knewstuff-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-knewstuff-html}"
SRC_URI[x86_64_v2_kf6-knewstuff-html.sha256sum] = "6bc795f92d6034da2842938a1c70cdc55fdd16a068d8808fdaedf88b5262566e"

URI_aarch64_kf6-knewstuff = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-knewstuff;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff}"
SRC_URI[aarch64_kf6-knewstuff.sha256sum] = "bfd0bac80693cd7e5828918dccf3eeaa66dc51d9aa0cde19df6cc2b7097ed41b"

URI_aarch64_kf6-knewstuff-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-knewstuff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-devel}"
SRC_URI[aarch64_kf6-knewstuff-devel.sha256sum] = "a74e2e3a4fcbc378d494b6ced1f6c15820d9469fd0e1347e6e00ade9174277b3"

URI_aarch64_kf6-knewstuff-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-knewstuff-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-doc}"
SRC_URI[aarch64_kf6-knewstuff-doc.sha256sum] = "3805c7dbf1e0167f9bdd4946cc5fee50bb9669f04cbb18db31669c1ec748f9b5"

URI_aarch64_kf6-knewstuff-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-knewstuff-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-knewstuff-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-knewstuff-html}"
SRC_URI[aarch64_kf6-knewstuff-html.sha256sum] = "078400c2db0f09f639017ffcd444a56bf18f9e9741261b94c1a0bfcc1dda6466"

RDEPENDS:kf6-knewstuff = " \
 glibc \
 kf6-attica \
 kf6-filesystem \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kwidgetsaddons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-knewstuff-devel = " \
 cmake-filesystem \
 glibc \
 kf6-attica-devel \
 kf6-knewstuff \
 kf6-kservice-devel \
 kf6-kxmlgui-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-knewstuff-doc = " \
 "
RDEPENDS:kf6-knewstuff-html = " \
 "
