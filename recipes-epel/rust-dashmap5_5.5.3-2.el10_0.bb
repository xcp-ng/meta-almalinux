# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dashmap5"
PV = "5.5.3"
PR = "2.el10_0"
PACKAGES = " \
 rust-dashmap5+arbitrary-devel \
 rust-dashmap5+default-devel \
 rust-dashmap5+inline-devel \
 rust-dashmap5+raw-api-devel \
 rust-dashmap5+rayon-devel \
 rust-dashmap5+serde-devel \
 rust-dashmap5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dashmap5-5.5.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c539eed8eabe154ffb959f53cc6408d70aebcb987f8dfab09686e89de13631e"

URI_x86_64_v2_rust-dashmap5+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap5+arbitrary-devel-5.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap5+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap5+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-dashmap5+arbitrary-devel.sha256sum] = "ae86a4fb5636aa75940dd66dbfb899fcae52f27733a257227db56378bb360baa"

URI_x86_64_v2_rust-dashmap5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap5+default-devel-5.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap5+default-devel}"
SRC_URI[x86_64_v2_rust-dashmap5+default-devel.sha256sum] = "f6251a46c56ce688ef4311d5941f1cbb2f2e163fd6b80eec035ac2d84ff31b7a"

URI_x86_64_v2_rust-dashmap5+inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap5+inline-devel-5.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap5+inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap5+inline-devel}"
SRC_URI[x86_64_v2_rust-dashmap5+inline-devel.sha256sum] = "865f5096beb6e1af628c5e55fe926fc5c9fbb088830031e29dff6af22fd1d7d0"

URI_x86_64_v2_rust-dashmap5+raw-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap5+raw-api-devel-5.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap5+raw-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap5+raw-api-devel}"
SRC_URI[x86_64_v2_rust-dashmap5+raw-api-devel.sha256sum] = "3355c5c105332f84f84176c8d701279207a5152ad388e219b7f333e126457c11"

URI_x86_64_v2_rust-dashmap5+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap5+rayon-devel-5.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap5+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap5+rayon-devel}"
SRC_URI[x86_64_v2_rust-dashmap5+rayon-devel.sha256sum] = "379e9bec68a2a1159c6cba2b035c6693ae37532fbbc8878a8d1de84e15e4e17a"

URI_x86_64_v2_rust-dashmap5+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap5+serde-devel-5.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap5+serde-devel}"
SRC_URI[x86_64_v2_rust-dashmap5+serde-devel.sha256sum] = "0cf3b4898dd38aee803beeba3605406ed9956f2059c198c9ddb138d67c173da8"

URI_x86_64_v2_rust-dashmap5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dashmap5-devel-5.5.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dashmap5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dashmap5-devel}"
SRC_URI[x86_64_v2_rust-dashmap5-devel.sha256sum] = "85cf50de8cd61b82b8b1578f78cd0ebe61d1392d556f5c08ec2c96c7c6b059f5"

URI_aarch64_rust-dashmap5+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap5+arbitrary-devel-5.5.3-2.el10_0.noarch.rpm;name=aarch64_rust-dashmap5+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap5+arbitrary-devel}"
SRC_URI[aarch64_rust-dashmap5+arbitrary-devel.sha256sum] = "643bec1beafa281001e49d98203bdf27d03eae6ce9fb36522d8b53874b1fd5f7"

URI_aarch64_rust-dashmap5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap5+default-devel-5.5.3-2.el10_0.noarch.rpm;name=aarch64_rust-dashmap5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap5+default-devel}"
SRC_URI[aarch64_rust-dashmap5+default-devel.sha256sum] = "614c80f151a295850935c97f33b60bc1706e9efa6678c088fc1d2d2a091db85d"

URI_aarch64_rust-dashmap5+inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap5+inline-devel-5.5.3-2.el10_0.noarch.rpm;name=aarch64_rust-dashmap5+inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap5+inline-devel}"
SRC_URI[aarch64_rust-dashmap5+inline-devel.sha256sum] = "5478239f3c0fcc6ac5b5f00e440250b65655f376547ec4a39334ac77ce65d861"

URI_aarch64_rust-dashmap5+raw-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap5+raw-api-devel-5.5.3-2.el10_0.noarch.rpm;name=aarch64_rust-dashmap5+raw-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap5+raw-api-devel}"
SRC_URI[aarch64_rust-dashmap5+raw-api-devel.sha256sum] = "806b1e76c060b027d07f3f730b66a93f8ac137c4536ff38322ef95376a99f29f"

URI_aarch64_rust-dashmap5+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap5+rayon-devel-5.5.3-2.el10_0.noarch.rpm;name=aarch64_rust-dashmap5+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap5+rayon-devel}"
SRC_URI[aarch64_rust-dashmap5+rayon-devel.sha256sum] = "0d97d8f90c548fb9b4ce3b33aada7e426ca641f0b898911a3be3a404b4c9781a"

URI_aarch64_rust-dashmap5+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap5+serde-devel-5.5.3-2.el10_0.noarch.rpm;name=aarch64_rust-dashmap5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap5+serde-devel}"
SRC_URI[aarch64_rust-dashmap5+serde-devel.sha256sum] = "e143b1f5fbd47acbfdb5f2a168ffc639f8e995b4e8e96b53e8dbd2b92d677f1a"

URI_aarch64_rust-dashmap5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dashmap5-devel-5.5.3-2.el10_0.noarch.rpm;name=aarch64_rust-dashmap5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dashmap5-devel}"
SRC_URI[aarch64_rust-dashmap5-devel.sha256sum] = "44a426b07e870638a12e69afa75a3076cd422cd74e0ee940b00af5e0718f4aef"

RDEPENDS:rust-dashmap5+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-dashmap5-devel \
 "
RDEPENDS:rust-dashmap5+default-devel = " \
 cargo \
 rust-dashmap5-devel \
 "
RDEPENDS:rust-dashmap5+inline-devel = " \
 cargo \
 rust-dashmap5-devel \
 rust-hashbrown0.14+inline-more-devel \
 "
RDEPENDS:rust-dashmap5+raw-api-devel = " \
 cargo \
 rust-dashmap5-devel \
 "
RDEPENDS:rust-dashmap5+rayon-devel = " \
 cargo \
 rust-dashmap5-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-dashmap5+serde-devel = " \
 cargo \
 rust-dashmap5-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-dashmap5-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-hashbrown0.14-devel \
 rust-lock_api+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot_core+default-devel \
 "
