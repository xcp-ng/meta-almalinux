# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-tn"
PV = "0.20150904"
PR = "18.el10"
PACKAGES = " \
 hunspell-tn \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-tn-0.20150904-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3bbc24ee3e961011103c563c1e1e3bef3d147b107063d6623acd2ab779f11dd"

URI_x86_64_v2_hunspell-tn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-tn-0.20150904-18.el10.noarch.rpm;name=x86_64_v2_hunspell-tn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-tn}"
SRC_URI[x86_64_v2_hunspell-tn.sha256sum] = "3c91c07f764cab8d4e8b83b5294d1da4a310dd07e9040ac09492c4d133d7c23b"

URI_aarch64_hunspell-tn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-tn-0.20150904-18.el10.noarch.rpm;name=aarch64_hunspell-tn;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-tn}"
SRC_URI[aarch64_hunspell-tn.sha256sum] = "3c91c07f764cab8d4e8b83b5294d1da4a310dd07e9040ac09492c4d133d7c23b"

RDEPENDS:hunspell-tn = " \
 hunspell-filesystem \
 "
