# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libdeflate-sys"
PV = "1.25.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflate-sys+freestanding-devel \
 rust-libdeflate-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libdeflate-sys-1.25.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ca641f936ad5cf82b5eec4381a3af60f541391bd433e2a870c9b45eeb2a48a1"

URI_x86_64_v2_rust-libdeflate-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+default-devel-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys+default-devel.sha256sum] = "b335128d99d895803429c7c30fb5fd5a27e710f02f28fcf9c3a5103da0e323e9"

URI_x86_64_v2_rust-libdeflate-sys+dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+dynamic-devel-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys+dynamic-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys+dynamic-devel.sha256sum] = "9a3524e88e3bf32b646f0b169f93ba6e2d6b99c6d1238c730d2363d7f263ec29"

URI_x86_64_v2_rust-libdeflate-sys+freestanding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+freestanding-devel-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys+freestanding-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys+freestanding-devel.sha256sum] = "695cab90c36e6785134138f176299435ce0cc1a6a9940c809f5d10d7c223ed96"

URI_x86_64_v2_rust-libdeflate-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys-devel-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys-devel.sha256sum] = "bc2fd7e4e2fa02e404fcaf080a36498cb8d57b8a09e4182b80937838448cb0c0"

URI_aarch64_rust-libdeflate-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+default-devel-1.25.0-1.el10_0.noarch.rpm;name=aarch64_rust-libdeflate-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys+default-devel}"
SRC_URI[aarch64_rust-libdeflate-sys+default-devel.sha256sum] = "f46eed7cd9e14f089dbbefe85860590dd9fc87f8c70dbe1ea262d31b91acd88d"

URI_aarch64_rust-libdeflate-sys+dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+dynamic-devel-1.25.0-1.el10_0.noarch.rpm;name=aarch64_rust-libdeflate-sys+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys+dynamic-devel}"
SRC_URI[aarch64_rust-libdeflate-sys+dynamic-devel.sha256sum] = "d63cb8aaa8744f54b95634d205d949c2f60e3d2911fedcfdfdb0ad1bdc0c88e7"

URI_aarch64_rust-libdeflate-sys+freestanding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+freestanding-devel-1.25.0-1.el10_0.noarch.rpm;name=aarch64_rust-libdeflate-sys+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys+freestanding-devel}"
SRC_URI[aarch64_rust-libdeflate-sys+freestanding-devel.sha256sum] = "76e747658ad8fed41fa05db7bdb100c59e28e1fbefab8922e39ba1c8607c77b4"

URI_aarch64_rust-libdeflate-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys-devel-1.25.0-1.el10_0.noarch.rpm;name=aarch64_rust-libdeflate-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys-devel}"
SRC_URI[aarch64_rust-libdeflate-sys-devel.sha256sum] = "e326d039825ba859689be09e0b4dcc1406779125766771d7ec264753ebe46a96"

RDEPENDS:rust-libdeflate-sys+default-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys+dynamic-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys+freestanding-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys-devel = " \
 cargo \
 libdeflate-devel \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 "
