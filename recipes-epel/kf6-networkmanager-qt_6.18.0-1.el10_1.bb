# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-networkmanager-qt"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-networkmanager-qt \
 kf6-networkmanager-qt-devel \
 kf6-networkmanager-qt-doc \
 kf6-networkmanager-qt-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-networkmanager-qt-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "914df39d4e5b4ca372cdeb8795ca1338c93dd4b21877fb3ee86958b060e72275"

URI_x86_64_v2_kf6-networkmanager-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt.sha256sum] = "148cb44c4a64f60353c8db3a906af071001b73bba03fcc2024114a1ed62c89f2"

URI_x86_64_v2_kf6-networkmanager-qt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-devel}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-devel.sha256sum] = "274192cfc53feddecd4b59e196c9541862462c4175fa00f9d8d57e420973f89a"

URI_x86_64_v2_kf6-networkmanager-qt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-doc}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-doc.sha256sum] = "4a05a53551fdab270a5fb933391762d4d02066e76f7b4711f1b87348c3e4226c"

URI_x86_64_v2_kf6-networkmanager-qt-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-networkmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-networkmanager-qt-html}"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-html.sha256sum] = "c8057955a0afd0795901b30dd9c14d61d35a9d090c55512dc10ffb424583b964"

URI_aarch64_kf6-networkmanager-qt = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-networkmanager-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt}"
SRC_URI[aarch64_kf6-networkmanager-qt.sha256sum] = "0937ea2a3ca60838bc8d3617e0b466ad36818829fcccc5bb55449e21321a6a24"

URI_aarch64_kf6-networkmanager-qt-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-devel}"
SRC_URI[aarch64_kf6-networkmanager-qt-devel.sha256sum] = "5fdad2fb10b1da7669c4c4334d629f5cd45b3b22ddaf92712dc95ba3a20e6dca"

URI_aarch64_kf6-networkmanager-qt-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-doc}"
SRC_URI[aarch64_kf6-networkmanager-qt-doc.sha256sum] = "c617b30dba93ab287eafe4cea55d0d73cc9c7bb6f54c897a2acd01f8fa72a8af"

URI_aarch64_kf6-networkmanager-qt-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-networkmanager-qt-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-networkmanager-qt-html}"
SRC_URI[aarch64_kf6-networkmanager-qt-html.sha256sum] = "dfbc33daa88cdab49962da958292a35d5e5af29a68ca963b8a845eb557d66fde"

RDEPENDS:kf6-networkmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-networkmanager-qt-devel = " \
 NetworkManager-libnm-devel \
 cmake-filesystem \
 kf6-networkmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-networkmanager-qt-doc = " \
 "
RDEPENDS:kf6-networkmanager-qt-html = " \
 "
