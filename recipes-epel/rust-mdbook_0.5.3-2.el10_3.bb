# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mdbook"
PV = "0.5.3"
PR = "2.el10_3"
PACKAGES = " \
 mdbook \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mdbook-0.5.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b4eb619ac613535da0c4c0f89422e18c7210524bc8e896042d7e039b69dd340"

URI_x86_64_v2_mdbook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mdbook-0.5.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mdbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mdbook}"
SRC_URI[x86_64_v2_mdbook.sha256sum] = "5d59fd4e71c67742b02c06ba4cd9674541a3ed42de4f6897ab4bb10520eb339f"

URI_aarch64_mdbook = "${EPEL_MIRROR}/aarch64/Packages/m/mdbook-0.5.3-2.el10_3.aarch64.rpm;name=aarch64_mdbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_mdbook}"
SRC_URI[aarch64_mdbook.sha256sum] = "e3369f2c4542a318fdacb0362be3e94c26b67e4f7fcbd7f7c8b3c914d43c6aa2"

RDEPENDS:mdbook = " \
 adobe-source-code-pro-fonts \
 glibc \
 libgcc \
 open-sans-fonts \
 "
