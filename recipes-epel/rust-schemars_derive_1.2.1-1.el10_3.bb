# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars_derive"
PV = "1.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-schemars_derive+default-devel \
 rust-schemars_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars_derive-1.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54557513304f859a82c13bc3669d8c69328c92a620e3376068998a3b55f00eac"

URI_x86_64_v2_rust-schemars_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive+default-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive+default-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive+default-devel.sha256sum] = "989f0a4f8f4965b41704e4b4a8a37d6ebece7a7e90487f9ac7ae520c0affc61e"

URI_x86_64_v2_rust-schemars_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive-devel-1.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive-devel.sha256sum] = "46508d1afb8e16095ec3c13e4cf5677ddafb5c86160e430f2bfcd09241fb75ea"

URI_aarch64_rust-schemars_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive+default-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-schemars_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive+default-devel}"
SRC_URI[aarch64_rust-schemars_derive+default-devel.sha256sum] = "cbd5cf4ab3359266dd74f812a82eef5365cee803ae15763d1f1b3ac0caa6f4a1"

URI_aarch64_rust-schemars_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive-devel-1.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive-devel}"
SRC_URI[aarch64_rust-schemars_derive-devel.sha256sum] = "0fe3d5111a4c8d98eb264896866a41c0443364f9d113fc81ee43ee122dceb5b7"

RDEPENDS:rust-schemars_derive+default-devel = " \
 cargo \
 rust-schemars_derive-devel \
 "
RDEPENDS:rust-schemars_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde_derive_internals+default-devel \
 rust-syn2+default-devel \
 "
