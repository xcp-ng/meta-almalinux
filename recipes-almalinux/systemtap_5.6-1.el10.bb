# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemtap"
PV = "5.6"
PR = "1.el10"
PACKAGES = " \
 systemtap \
 systemtap-client \
 systemtap-devel \
 systemtap-exporter \
 systemtap-initscript \
 systemtap-runtime \
 systemtap-runtime-java \
 systemtap-runtime-python3 \
 systemtap-runtime-virtguest \
 systemtap-runtime-virthost \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 systemtap-server \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/systemtap-5.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "643e797d5727be48259067086d53d2b6a0b14647fc45f4b92b9d4bf5d3159d31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap;unpack=0"
SRC_URI[x86_64_v2_systemtap.sha256sum] = "f58c1d0e40b657247f9b9b193775cf44773c033215f0c93d6ff1337a0ac007c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-client-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-client;unpack=0"
SRC_URI[x86_64_v2_systemtap-client.sha256sum] = "4370337a3ae5b91a1fcb3efc020f6af6d1e23d245a25f5fa9963baa0b9857e0f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-devel-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-devel;unpack=0"
SRC_URI[x86_64_v2_systemtap-devel.sha256sum] = "ca2244a162976a9f054a1df62d4f97f4295f775eab0f21a0d6fdf676e81aa4fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-exporter-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-exporter;unpack=0"
SRC_URI[x86_64_v2_systemtap-exporter.sha256sum] = "0ecb658e3f3750d7ea11c714fd96bbefd7883df10581d707ec27e30487da791f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-initscript-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-initscript;unpack=0"
SRC_URI[x86_64_v2_systemtap-initscript.sha256sum] = "a27008dbc95390677bbae3ed94285024b37d0d9339fd68687e4f96aa52121d4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime;unpack=0"
SRC_URI[x86_64_v2_systemtap-runtime.sha256sum] = "99a399052a14d8bbf4003e93e604c0263fcdb83717d49ecdd6f4c16a2cd32cb8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-java-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-java;unpack=0"
SRC_URI[x86_64_v2_systemtap-runtime-java.sha256sum] = "b2112db6d33db3353c14180d957359ebc092a57b6c1e025a3cd7fb60030fde00"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-python3-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-python3;unpack=0"
SRC_URI[x86_64_v2_systemtap-runtime-python3.sha256sum] = "6cbc01f67590648cdccf3b2ced7a2d65f5f341afbbbe446e6afcda0beac73174"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virtguest-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virtguest;unpack=0"
SRC_URI[x86_64_v2_systemtap-runtime-virtguest.sha256sum] = "d438e19aaac52dda81cccb868b0ac4d59d4fd15d2ebff8352f7fe46780fa0791"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virthost-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virthost;unpack=0"
SRC_URI[x86_64_v2_systemtap-runtime-virthost.sha256sum] = "0dedc1a00a3faaf7944c32434ddc18b60c166166ec28f2a1e82c7d7fe863819c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-devel-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-devel;unpack=0"
SRC_URI[x86_64_v2_systemtap-sdt-devel.sha256sum] = "57712180b463135151fd82f9a77296b76b9b39947b857476db78ca05c45a11ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-dtrace-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-dtrace;unpack=0"
SRC_URI[x86_64_v2_systemtap-sdt-dtrace.sha256sum] = "7433b72af9dd11d2b2682cfc9e3f58f12beaeb0fc4629841763413c21928a379"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-server-5.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-server;unpack=0"
SRC_URI[x86_64_v2_systemtap-server.sha256sum] = "8d134ce19cc9e97a9b3ccc70fb238330cfe20fa67f7eb308cf6f0e34857619dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap;unpack=0"
SRC_URI[aarch64_systemtap.sha256sum] = "71984b306d932a112358afe1b733fb76899d9115e00c4e6b42fceeb230eaf7db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-client-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-client;unpack=0"
SRC_URI[aarch64_systemtap-client.sha256sum] = "8bf6259ea7a2ff9fab1fd6c2d0ca5aba1a5adae50af3d17ae0b0557c034d285a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-devel-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-devel;unpack=0"
SRC_URI[aarch64_systemtap-devel.sha256sum] = "e24f7f260e10f83c9b43c716f60c795e988967f3f605ece859b939d33bd049ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-exporter-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-exporter;unpack=0"
SRC_URI[aarch64_systemtap-exporter.sha256sum] = "776ddc8e57efd50a427c0f3bf1847b552d683a0f7d3426d4ecb9cff6a44c8c4c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-initscript-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-initscript;unpack=0"
SRC_URI[aarch64_systemtap-initscript.sha256sum] = "ba7011bffceb14c5559efc359f36cd44f5d0a1211751cfafd7e84ca0c51b14c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-runtime;unpack=0"
SRC_URI[aarch64_systemtap-runtime.sha256sum] = "c770bcf1184d76099772c559327d5fc6e10dc7e13d9737edf75b5d55e374f1fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-java-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-runtime-java;unpack=0"
SRC_URI[aarch64_systemtap-runtime-java.sha256sum] = "86ec66a8a3cd0ba960a2614bc171692d4d6d28587e20ec2c7863abc950964894"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-python3-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-runtime-python3;unpack=0"
SRC_URI[aarch64_systemtap-runtime-python3.sha256sum] = "71fcc3bacccfea0a8f3b66e5f95bf28bce43c5ad4d945c90f47559f5bdd5b189"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virtguest-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virtguest;unpack=0"
SRC_URI[aarch64_systemtap-runtime-virtguest.sha256sum] = "7b8f422da566bd3867411e1561705c570f57aaccfe8c11cd1c803a9101e18910"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virthost-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virthost;unpack=0"
SRC_URI[aarch64_systemtap-runtime-virthost.sha256sum] = "b41d9546c2111ba12333d778fe2cf811c2dde1440d0818db7dce5388edab6574"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-devel-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-sdt-devel;unpack=0"
SRC_URI[aarch64_systemtap-sdt-devel.sha256sum] = "ce91c352bc4310204c76bca99da5e4eabc3dcf075909a9cffad7ce50f31591ff"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-dtrace-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-sdt-dtrace;unpack=0"
SRC_URI[aarch64_systemtap-sdt-dtrace.sha256sum] = "bf079c1b46e575b4be5c195d0fa82f0df02c8d6a4d092df77e727d31311e55c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-server-5.6-1.el10.aarch64.rpm;name=aarch64_systemtap-server;unpack=0"
SRC_URI[aarch64_systemtap-server.sha256sum] = "95f86811a0fd76ed1175cc1e237743ada76181bbb4fd33114f12bfd81d7d4415"

RDEPENDS:systemtap = " \
 bash \
 systemtap-client \
 systemtap-devel \
 "
RDEPENDS:systemtap-client:x86_64_v2 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 mokutil \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
 zlib-ng-compat \
"
RDEPENDS:systemtap-client:aarch64 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
 zlib-ng-compat \
"
RDEPENDS:systemtap-devel = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-devel \
 elfutils-libelf \
 elfutils-libs \
 gcc \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 make \
 nspr \
 nss \
 python3 \
 readline \
 rpm-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:systemtap-exporter = " \
 bash \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-initscript = " \
 bash \
 systemd \
 systemtap \
 "
RDEPENDS:systemtap-runtime = " \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 json-c \
 libbpf \
 libgcc \
 libselinux \
 libstdc++ \
 ncurses-libs \
 nspr \
 nss \
 shadow-utils \
 "
RDEPENDS:systemtap-runtime-java = " \
 bash \
 byteman \
 glibc \
 iproute \
 java-21-openjdk-devel \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-python3 = " \
 glibc \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-virtguest = " \
 bash \
 findutils \
 grep \
 systemtap-runtime \
 virtual/coreutils \
 "
RDEPENDS:systemtap-runtime-virthost = " \
 glibc \
 libvirt-libs \
 libxml2 \
 "
RDEPENDS:systemtap-sdt-devel = " \
 systemtap-sdt-dtrace \
 "
RDEPENDS:systemtap-sdt-dtrace = " \
 python3 \
 python3-pyparsing \
 "
RDEPENDS:systemtap-server:x86_64_v2 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssl \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-server:aarch64 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
