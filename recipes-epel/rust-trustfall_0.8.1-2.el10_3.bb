# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-trustfall"
PV = "0.8.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-trustfall+default-devel \
 rust-trustfall-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-trustfall-0.8.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cae953cff7ba6cbd321c71a8d8126b85cbd293b78b988273e2905fc931b37931"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall+default-devel-0.8.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall+default-devel.sha256sum] = "c8c6bacf8bfbde04b4e63497937ca9ed627b20e3dede47554bbe870161534acc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-trustfall-devel-0.8.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-trustfall-devel;unpack=0"
SRC_URI[x86_64_v2_rust-trustfall-devel.sha256sum] = "96e65207845a585f74b392f76d70bd175ed4e79da1f19ebd18de137fea8e863b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall+default-devel-0.8.1-2.el10_3.noarch.rpm;name=aarch64_rust-trustfall+default-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall+default-devel.sha256sum] = "3794756d8954c4f1607790c887d50fcbbe3ea0a193464abd090774fc9b6fbcdb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-trustfall-devel-0.8.1-2.el10_3.noarch.rpm;name=aarch64_rust-trustfall-devel;unpack=0"
SRC_URI[aarch64_rust-trustfall-devel.sha256sum] = "312252a445e09cdd9c8b5199ead52832fb25f2a57728387fae1a228da6a124bf"

RDEPENDS:rust-trustfall+default-devel = " \
 cargo \
 rust-trustfall-devel \
 "
RDEPENDS:rust-trustfall-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-trustfall_core+default-devel \
 rust-trustfall_derive+default-devel \
 "
