# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Method-Modifiers"
PV = "2.15"
PR = "7.el10"
PACKAGES = " \
 perl-Class-Method-Modifiers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Class-Method-Modifiers-2.15-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35f2f24c388341f4845f4f9710e929af4ea6ca5c6177736ebfa7a619f743c0d0"

URI_x86_64_v2_perl-Class-Method-Modifiers = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Class-Method-Modifiers-2.15-7.el10.noarch.rpm;name=x86_64_v2_perl-Class-Method-Modifiers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Method-Modifiers}"
SRC_URI[x86_64_v2_perl-Class-Method-Modifiers.sha256sum] = "b810dec1f4f2be6584ecd7ed39208c96cbadd9412eade9d15b3bc10190faad4c"

URI_aarch64_perl-Class-Method-Modifiers = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Class-Method-Modifiers-2.15-7.el10.noarch.rpm;name=aarch64_perl-Class-Method-Modifiers;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Method-Modifiers}"
SRC_URI[aarch64_perl-Class-Method-Modifiers.sha256sum] = "b810dec1f4f2be6584ecd7ed39208c96cbadd9412eade9d15b3bc10190faad4c"

RDEPENDS:perl-Class-Method-Modifiers = " \
 perl-B \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-libs \
 "
