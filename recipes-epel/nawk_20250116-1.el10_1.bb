# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nawk"
PV = "20250116"
PR = "1.el10_1"
PACKAGES = " \
 nawk \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nawk-20250116-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "886396cd7a6f40f54b1ab48b15142dbc61172dba49c8d1df363fe848a8217349"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nawk-20250116-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nawk;unpack=0"
SRC_URI[x86_64_v2_nawk.sha256sum] = "5c7218f4dfd87b0d6be1693d2e2098c1c4034cbd9e41e60a2bb575432374e89c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nawk-20250116-1.el10_1.aarch64.rpm;name=aarch64_nawk;unpack=0"
SRC_URI[aarch64_nawk.sha256sum] = "820018ea0beeffb834daa9c42cc09b230f433445f12a801c44ba14afab75c47d"

RDEPENDS:nawk = " \
 glibc \
 "
