# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa-compat"
PV = "25.0.7"
PR = "3.el10.alma.2"
PACKAGES = " \
 mesa-compat-libOSMesa \
 mesa-compat-libOSMesa-devel \
 mesa-compat-libxatracker \
 mesa-compat-libxatracker-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-compat-25.0.7-3.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f75e57eccb139f4a71adb725690060ac4c06a9f4e1242a8aedc39cb4afc1175"

URI_x86_64_v2_mesa-compat-libOSMesa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libOSMesa-25.0.7-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libOSMesa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-compat-libOSMesa}"
SRC_URI[x86_64_v2_mesa-compat-libOSMesa.sha256sum] = "8e200d284a7c9731d71f597e0f94c3893d7582fe56e6787074d3fd667b9d9604"

URI_x86_64_v2_mesa-compat-libOSMesa-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libOSMesa-devel-25.0.7-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libOSMesa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-compat-libOSMesa-devel}"
SRC_URI[x86_64_v2_mesa-compat-libOSMesa-devel.sha256sum] = "c2897ec283f0057b6d199ba448759365e6d030ab95dee76f728164d20783f29d"

URI_x86_64_v2_mesa-compat-libxatracker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libxatracker-25.0.7-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libxatracker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-compat-libxatracker}"
SRC_URI[x86_64_v2_mesa-compat-libxatracker.sha256sum] = "88705bb9eaf657c0f7312358275f52f048d971e225da54dc2d01d68011169874"

URI_x86_64_v2_mesa-compat-libxatracker-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-compat-libxatracker-devel-25.0.7-3.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_mesa-compat-libxatracker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-compat-libxatracker-devel}"
SRC_URI[x86_64_v2_mesa-compat-libxatracker-devel.sha256sum] = "6c051ed994323e7131cf064e99b8338a3fe48851677080f69ca87621a647d346"

URI_aarch64_mesa-compat-libOSMesa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libOSMesa-25.0.7-3.el10.alma.2.aarch64.rpm;name=aarch64_mesa-compat-libOSMesa;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-compat-libOSMesa}"
SRC_URI[aarch64_mesa-compat-libOSMesa.sha256sum] = "bfde2f40a267f1ec6e5362da74a6a8a7ba31edaf0feb84752a924fa74a36eeac"

URI_aarch64_mesa-compat-libOSMesa-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libOSMesa-devel-25.0.7-3.el10.alma.2.aarch64.rpm;name=aarch64_mesa-compat-libOSMesa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-compat-libOSMesa-devel}"
SRC_URI[aarch64_mesa-compat-libOSMesa-devel.sha256sum] = "b47f2f6482accc130d70dc07de1325d968ec47eb794116879c366517c9fab9fc"

URI_aarch64_mesa-compat-libxatracker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libxatracker-25.0.7-3.el10.alma.2.aarch64.rpm;name=aarch64_mesa-compat-libxatracker;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-compat-libxatracker}"
SRC_URI[aarch64_mesa-compat-libxatracker.sha256sum] = "902fa00ea1c024e8dfb793e37c8d0733663bb2f86b84cf08f27dc0c37ec8628e"

URI_aarch64_mesa-compat-libxatracker-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-compat-libxatracker-devel-25.0.7-3.el10.alma.2.aarch64.rpm;name=aarch64_mesa-compat-libxatracker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-compat-libxatracker-devel}"
SRC_URI[aarch64_mesa-compat-libxatracker-devel.sha256sum] = "7592e387db482f245dc65db17642d61f1e8ead790639fcc60f8ce10f5cc8c24f"

RDEPENDS:mesa-compat-libOSMesa = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-compat-libOSMesa-devel = " \
 mesa-compat-libOSMesa \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-compat-libxatracker = " \
 expat \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-compat-libxatracker-devel = " \
 mesa-compat-libxatracker \
 pkgconf-pkg-config \
 "
