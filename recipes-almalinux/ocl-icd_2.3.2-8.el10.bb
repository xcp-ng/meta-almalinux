# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ocl-icd"
PV = "2.3.2"
PR = "8.el10"
PACKAGES = " \
 ocl-icd \
 ocl-icd-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ocl-icd-2.3.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "948081d838fd9b77cb50035a508caeebe17c51b683c11c65b3451a911de31c3e"

URI_x86_64_v2_ocl-icd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ocl-icd-2.3.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_ocl-icd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocl-icd}"
SRC_URI[x86_64_v2_ocl-icd.sha256sum] = "03892a33768d07db2f8e564650a0cc84aaa10ef1ffeb895fd5939cf579c86865"

URI_x86_64_v2_ocl-icd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocl-icd-devel-2.3.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_ocl-icd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocl-icd-devel}"
SRC_URI[x86_64_v2_ocl-icd-devel.sha256sum] = "c25f6fe7162cfd22c494cbc8fd136bf27faf3dda2061b3345da757e256833a1a"

URI_aarch64_ocl-icd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ocl-icd-2.3.2-8.el10.aarch64.rpm;name=aarch64_ocl-icd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocl-icd}"
SRC_URI[aarch64_ocl-icd.sha256sum] = "ad5d3a23c53ac459d1cfc52a01b0cdf896a0c82a2ac733e99bb14b2d6c4b41bb"

URI_aarch64_ocl-icd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocl-icd-devel-2.3.2-8.el10.aarch64.rpm;name=aarch64_ocl-icd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocl-icd-devel}"
SRC_URI[aarch64_ocl-icd-devel.sha256sum] = "9f7f8bbbd19509deb2164c304f1ae94da9e84d9ed345a5fb49ea54c7b71d5b71"

RDEPENDS:ocl-icd = " \
 glibc \
 "
RDEPENDS:ocl-icd-devel = " \
 glibc \
 ocl-icd \
 opencl-headers \
 pkgconf-pkg-config \
 "
