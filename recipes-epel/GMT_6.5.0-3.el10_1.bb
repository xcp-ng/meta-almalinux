# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "GMT"
PV = "6.5.0"
PR = "3.el10_1"
PACKAGES = " \
 GMT \
 GMT-common \
 GMT-devel \
 GMT-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/GMT-6.5.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0274af40a5f3a1719fa5ab69d97ddc3d4b774016c7f08883c2c32cb6dbbccc53"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - GMT: libgeos_c.so.1()(64bit)

URI_x86_64_v2_GMT = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GMT-6.5.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GMT;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GMT}"
SRC_URI[x86_64_v2_GMT.sha256sum] = "17b87137f995f5b489c3baee8e378c527866e3dbc8c03cd601a86b2785bf45de"

URI_x86_64_v2_GMT-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GMT-common-6.5.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_GMT-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GMT-common}"
SRC_URI[x86_64_v2_GMT-common.sha256sum] = "52ad855fd69dc6af374402f7c328837d5621db06805a479b0965b0c29687e49a"

URI_x86_64_v2_GMT-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GMT-devel-6.5.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_GMT-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GMT-devel}"
SRC_URI[x86_64_v2_GMT-devel.sha256sum] = "a89a64f67f868c45da58b6d666c598546faf4d3936d3cd05862415290236af02"

URI_x86_64_v2_GMT-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/GMT-doc-6.5.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_GMT-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_GMT-doc}"
SRC_URI[x86_64_v2_GMT-doc.sha256sum] = "97cc053e591b3412643afe625823ec87cd6010cfd1122a6399e663e72450d577"

URI_aarch64_GMT = "${EPEL_MIRROR}/aarch64/Packages/g/GMT-6.5.0-3.el10_1.aarch64.rpm;name=aarch64_GMT;unpack=0"
SRC_URI:append = " ${URI_aarch64_GMT}"
SRC_URI[aarch64_GMT.sha256sum] = "9086ffb3a446ccb142d3942c7cd628d0a6881231361f0cb6dae6308235d83488"

URI_aarch64_GMT-common = "${EPEL_MIRROR}/aarch64/Packages/g/GMT-common-6.5.0-3.el10_1.noarch.rpm;name=aarch64_GMT-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_GMT-common}"
SRC_URI[aarch64_GMT-common.sha256sum] = "51d431547b50c4786bae7ff59c2f29ddd4d9676f9118d6be0a5cf294eb054b42"

URI_aarch64_GMT-devel = "${EPEL_MIRROR}/aarch64/Packages/g/GMT-devel-6.5.0-3.el10_1.aarch64.rpm;name=aarch64_GMT-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_GMT-devel}"
SRC_URI[aarch64_GMT-devel.sha256sum] = "86f10128136eb151278e600367931c3c673bb1e7b477cda1a5b9928d4e500c59"

URI_aarch64_GMT-doc = "${EPEL_MIRROR}/aarch64/Packages/g/GMT-doc-6.5.0-3.el10_1.noarch.rpm;name=aarch64_GMT-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_GMT-doc}"
SRC_URI[aarch64_GMT-doc.sha256sum] = "5ea0ab5b1a14feee21c0758bd2a34b0a113137ba308462ecb9d56fa615470160"

RDEPENDS:GMT:x86_64_v2 = " \
 GMT-common \
 GraphicsMagick \
 bash \
 dcw-gmt \
 fftw-libs-single \
 gdal \
 gdal-libs \
 glib2 \
 glibc \
 gshhg-gmt-nc4 \
 less \
 libgcc \
 libgomp \
 netcdf \
 openblas-serial \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 xdg-utils \
 zlib-ng-compat \
"
RDEPENDS:GMT:aarch64 = " \
 GMT-common \
 GraphicsMagick \
 bash \
 dcw-gmt \
 fftw-libs-single \
 gdal \
 gdal-libs \
 geos \
 glib2 \
 glibc \
 gshhg-gmt-nc4 \
 less \
 libgcc \
 libgomp \
 netcdf \
 openblas-serial \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 xdg-utils \
 zlib-ng-compat \
"
RDEPENDS:GMT-common = " \
 bash \
 perl-interpreter \
 "
RDEPENDS:GMT-devel = " \
 GMT \
 "
RDEPENDS:GMT-doc = " \
 GMT \
 "
