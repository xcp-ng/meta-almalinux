# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-TimeDate"
PE = "1"
PV = "2.33"
PR = "16.el10"
PACKAGES = " \
 perl-TimeDate \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-TimeDate-2.33-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b8ad441efd649c55768da75393a32e4d9c1d9c94b6416decb4a27f69cadcd3e"

URI_x86_64_v2_perl-TimeDate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-TimeDate-2.33-16.el10.noarch.rpm;name=x86_64_v2_perl-TimeDate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-TimeDate}"
SRC_URI[x86_64_v2_perl-TimeDate.sha256sum] = "663717344a27119689607b8c67283fc4ecaf3a28be65f363ef3dd11d678a3597"

URI_aarch64_perl-TimeDate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-TimeDate-2.33-16.el10.noarch.rpm;name=aarch64_perl-TimeDate;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-TimeDate}"
SRC_URI[aarch64_perl-TimeDate.sha256sum] = "663717344a27119689607b8c67283fc4ecaf3a28be65f363ef3dd11d678a3597"

RDEPENDS:perl-TimeDate = " \
 perl-Carp \
 perl-Exporter \
 perl-Time-Local \
 perl-TimeDate \
 perl-base \
 perl-libs \
 perl-vars \
 "
