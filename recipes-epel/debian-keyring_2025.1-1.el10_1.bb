# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debian-keyring"
PV = "2025.1"
PR = "1.el10_1"
PACKAGES = " \
 debian-keyring \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debian-keyring-2025.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd02fb3279081204822c3e3c010aafb37dc0da0fe36dd247f7b05a77020c78ea"

URI_x86_64_v2_debian-keyring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debian-keyring-2025.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_debian-keyring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debian-keyring}"
SRC_URI[x86_64_v2_debian-keyring.sha256sum] = "8b3d07face1f091a31e39b271f23c1fd291ac999c2a098667cf587276721007e"

URI_aarch64_debian-keyring = "${EPEL_MIRROR}/aarch64/Packages/d/debian-keyring-2025.1-1.el10_1.noarch.rpm;name=aarch64_debian-keyring;unpack=0"
SRC_URI:append = " ${URI_aarch64_debian-keyring}"
SRC_URI[aarch64_debian-keyring.sha256sum] = "90f7ef0b4b87af5cd67bc8da78c99db90a0eab2e531105b1b138464a00a2ecf0"

RDEPENDS:debian-keyring = " \
 keyrings-filesystem \
 "
