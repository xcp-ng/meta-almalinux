# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-base"
PV = "1.26.7"
PR = "2.el10_2.2"
PACKAGES = " \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 gstreamer1-plugins-base-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-base-1.26.7-2.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b7ee0371dbb34f4aa4bdf8cecb79a626ba8a6a35e6918f2d978ecb33d80035ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-1.26.7-2.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-base.sha256sum] = "88fc935f260a68d9cba3f880577bd9bd3563d1cfeeaa575d443d86fc2ccbdc04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-devel-1.26.7-2.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-devel.sha256sum] = "451f67a634f12d44087d2cd6abc5b84591c0bcef4102f306872b1b1f4b7cec74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-tools-1.26.7-2.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-tools.sha256sum] = "3c742e044c0d9f8454ea6ddc272efc38cfa0e0e0ce7f5d3896f1399405eeb001"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-1.26.7-2.el10_2.2.aarch64.rpm;name=aarch64_gstreamer1-plugins-base;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-base.sha256sum] = "f53a71c63a4db6dc8273df6d9c0202f0092f8da4ba68a7375d9a5f45c3f63303"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-devel-1.26.7-2.el10_2.2.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-base-devel.sha256sum] = "75d6ad9ff82ecdb700d6a201dcb957e91d292477d05fd477d8bc8c26b3e9e754"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-tools-1.26.7-2.el10_2.2.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-base-tools.sha256sum] = "d371eed7cb74c6dc185a8b6d7bd2d93348a12912d52163a80018670ac86c071b"

RDEPENDS:gstreamer1-plugins-base = " \
 alsa-lib \
 cairo \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 iso-codes \
 libX11 \
 libX11-xcb \
 libXext \
 libXi \
 libXv \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libgudev \
 libjpeg-turbo \
 libogg \
 libpng \
 libtheora \
 libvorbis \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxcb \
 mesa-libgbm \
 opus \
 orc \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-base-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 libX11-devel \
 libdrm-devel \
 libglvnd-devel \
 libgudev-devel \
 mesa-libgbm-devel \
 orc-devel \
 pkgconf-pkg-config \
 wayland-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:gstreamer1-plugins-base-tools = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 "
