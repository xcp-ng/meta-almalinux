# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tpm2-tools"
PV = "5.7"
PR = "4.el10"
PACKAGES = " \
 tpm2-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tpm2-tools-5.7-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08e50969f1d93ad16e9477af21bd9ac7e609bd439a068e8f34303c8aa540eb45"

URI_x86_64_v2_tpm2-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tpm2-tools-5.7-4.el10.x86_64_v2.rpm;name=x86_64_v2_tpm2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tpm2-tools}"
SRC_URI[x86_64_v2_tpm2-tools.sha256sum] = "93dd9001db32ac081d037ad869aa80a287ff0045dd7c05a959e571e8245a9b7a"

URI_aarch64_tpm2-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tpm2-tools-5.7-4.el10.aarch64.rpm;name=aarch64_tpm2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_tpm2-tools}"
SRC_URI[aarch64_tpm2-tools.sha256sum] = "ae50d1fa4e5e49939083b11bc3ecddb5665ffb87dc827c6def0ef1b66da99c99"

RDEPENDS:tpm2-tools = " \
 glibc \
 openssl-libs \
 tpm2-tss \
 tpm2-tss-fapi \
 virtual/libcurl.so.4___64bit_ \
 "
