# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbruch"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kbruch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbruch-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81abd574cf305d11f760662de49ec515cb898018a06b1c3bb4a9f5b8338117f4"

URI_x86_64_v2_kbruch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbruch-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbruch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbruch}"
SRC_URI[x86_64_v2_kbruch.sha256sum] = "88063283a696ab967582dd83d2a5c4e3f9dacdfb5633a9e2cf3a6132fb50113c"

URI_aarch64_kbruch = "${EPEL_MIRROR}/aarch64/Packages/k/kbruch-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kbruch;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbruch}"
SRC_URI[aarch64_kbruch.sha256sum] = "bfcb6381acfaefcdb4b4c6df565e5082c8b89d07461f838e14a1341a7c4ab79e"

RDEPENDS:kbruch = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
