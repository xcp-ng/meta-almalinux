# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-idna0.4"
PV = "0.4.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-idna0.4+alloc-devel \
 rust-idna0.4+default-devel \
 rust-idna0.4+std-devel \
 rust-idna0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-idna0.4-0.4.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4549e122d9faa4e7fac9ed29c8920ccfcbe81703562cefd1eefce44fd65da709"

URI_x86_64_v2_rust-idna0.4+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna0.4+alloc-devel-0.4.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna0.4+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna0.4+alloc-devel}"
SRC_URI[x86_64_v2_rust-idna0.4+alloc-devel.sha256sum] = "e35f97b8a101d23a4cf68a904bcd4b25cf85baf0b24953e1eb5e576ee5189f71"

URI_x86_64_v2_rust-idna0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna0.4+default-devel-0.4.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna0.4+default-devel}"
SRC_URI[x86_64_v2_rust-idna0.4+default-devel.sha256sum] = "9f59c39fbb185464fd71f3d5c5b4500cdc2ded24d4fed8d6178434c6a2557b84"

URI_x86_64_v2_rust-idna0.4+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna0.4+std-devel-0.4.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna0.4+std-devel}"
SRC_URI[x86_64_v2_rust-idna0.4+std-devel.sha256sum] = "3dd097caa31343aef565d9405ea945aa137f865fed5f10df9f716850151e81ef"

URI_x86_64_v2_rust-idna0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna0.4-devel-0.4.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna0.4-devel}"
SRC_URI[x86_64_v2_rust-idna0.4-devel.sha256sum] = "422777e07eeff28c82246e52c01fed97dbf77ed938a8bce7fc2b01c9a342aee1"

URI_aarch64_rust-idna0.4+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna0.4+alloc-devel-0.4.0-4.el10_0.noarch.rpm;name=aarch64_rust-idna0.4+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna0.4+alloc-devel}"
SRC_URI[aarch64_rust-idna0.4+alloc-devel.sha256sum] = "56c4241e7bfeab61a95f5c4f792737aeac6e23cddb7b7ded213386d20d50c51c"

URI_aarch64_rust-idna0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna0.4+default-devel-0.4.0-4.el10_0.noarch.rpm;name=aarch64_rust-idna0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna0.4+default-devel}"
SRC_URI[aarch64_rust-idna0.4+default-devel.sha256sum] = "bcb0a845d2c5887564b1c737448aaf1e52a18dc0975cb3aa0a38f6bf5bd62ad7"

URI_aarch64_rust-idna0.4+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna0.4+std-devel-0.4.0-4.el10_0.noarch.rpm;name=aarch64_rust-idna0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna0.4+std-devel}"
SRC_URI[aarch64_rust-idna0.4+std-devel.sha256sum] = "ea4726e0858ae97163102db6df41179856443fd7f9ab6d78ee1791f4bc3ba37e"

URI_aarch64_rust-idna0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna0.4-devel-0.4.0-4.el10_0.noarch.rpm;name=aarch64_rust-idna0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna0.4-devel}"
SRC_URI[aarch64_rust-idna0.4-devel.sha256sum] = "de0b4725b35f26e422292cef53ac36d88290314d3663f6eae6062ffde82e3adb"

RDEPENDS:rust-idna0.4+alloc-devel = " \
 cargo \
 rust-idna0.4-devel \
 "
RDEPENDS:rust-idna0.4+default-devel = " \
 cargo \
 rust-idna0.4+std-devel \
 rust-idna0.4-devel \
 "
RDEPENDS:rust-idna0.4+std-devel = " \
 cargo \
 rust-idna0.4+alloc-devel \
 rust-idna0.4-devel \
 rust-unicode-bidi+std-devel \
 rust-unicode-normalization+std-devel \
 "
RDEPENDS:rust-idna0.4-devel = " \
 cargo \
 rust \
 rust-unicode-bidi+hardcoded-data-devel \
 rust-unicode-bidi-devel \
 rust-unicode-normalization-devel \
 "
