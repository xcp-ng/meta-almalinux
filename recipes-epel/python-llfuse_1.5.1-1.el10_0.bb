# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-llfuse"
PV = "1.5.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-llfuse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-llfuse-1.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8249fb7fdc49d540d97c5baaf5e9769b11e1d7fc6b28f130e4cc422ea548b20c"

URI_x86_64_v2_python3-llfuse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-llfuse-1.5.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-llfuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-llfuse}"
SRC_URI[x86_64_v2_python3-llfuse.sha256sum] = "d25da95438d03118d97782e0eb5c4b661e5c565ee992221a84ff10a0933c9559"

URI_aarch64_python3-llfuse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-llfuse-1.5.1-1.el10_0.aarch64.rpm;name=aarch64_python3-llfuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-llfuse}"
SRC_URI[aarch64_python3-llfuse.sha256sum] = "476ed577126cf96bd0d0005cf7a4e90e0af1bccfaf8c5d6b8544fcc4193fcc18"

RDEPENDS:python3-llfuse = " \
 fuse-libs \
 glibc \
 python3 \
 "
