# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-extras"
PV = "8.3.19"
PR = "1.el10_1"
PACKAGES = " \
 php-pdo-dblib \
 php-pspell \
 php-sodium \
 php-tidy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-extras-8.3.19-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "141f403f8f01066e3efa727ed60580659956089d34eea3bdc6d0984dfccd8fec"

URI_x86_64_v2_php-pdo-dblib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pdo-dblib-8.3.19-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo-dblib}"
SRC_URI[x86_64_v2_php-pdo-dblib.sha256sum] = "3e937aa1c154a8a630c0c78af6210c6f761984ad8073b5b1e1013a3f5e6df8a4"

URI_x86_64_v2_php-pspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pspell-8.3.19-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pspell}"
SRC_URI[x86_64_v2_php-pspell.sha256sum] = "57954103311d271b10c2c8f4c90c3015cdf5059490012cca81469982e46138fd"

URI_x86_64_v2_php-sodium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-sodium-8.3.19-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-sodium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-sodium}"
SRC_URI[x86_64_v2_php-sodium.sha256sum] = "e7c988cde4d8fcf60436977435391a574bf87f26a5d718b36f2fa21d6948d8d4"

URI_x86_64_v2_php-tidy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-tidy-8.3.19-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-tidy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-tidy}"
SRC_URI[x86_64_v2_php-tidy.sha256sum] = "f5a58b1c6bf01609aa3c4a2214c5f3fdf2b2c485dbffa00d4aa04cae4267a7e6"

URI_aarch64_php-pdo-dblib = "${EPEL_MIRROR}/aarch64/Packages/p/php-pdo-dblib-8.3.19-1.el10_1.aarch64.rpm;name=aarch64_php-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo-dblib}"
SRC_URI[aarch64_php-pdo-dblib.sha256sum] = "d67cc56905547b23b40198b228050e96dbc9a675191971ac71ed1043a0bbed52"

URI_aarch64_php-pspell = "${EPEL_MIRROR}/aarch64/Packages/p/php-pspell-8.3.19-1.el10_1.aarch64.rpm;name=aarch64_php-pspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pspell}"
SRC_URI[aarch64_php-pspell.sha256sum] = "5f081004b101cc311820e0e6c31fe3eb5d7b188373ea8236535972e635866886"

URI_aarch64_php-sodium = "${EPEL_MIRROR}/aarch64/Packages/p/php-sodium-8.3.19-1.el10_1.aarch64.rpm;name=aarch64_php-sodium;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-sodium}"
SRC_URI[aarch64_php-sodium.sha256sum] = "9fdcb2db4f93ceb62b4c026d403fe912cb5c38792ca25a6ce14d34f359f93edc"

URI_aarch64_php-tidy = "${EPEL_MIRROR}/aarch64/Packages/p/php-tidy-8.3.19-1.el10_1.aarch64.rpm;name=aarch64_php-tidy;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-tidy}"
SRC_URI[aarch64_php-tidy.sha256sum] = "95fb674bad266ecbda091737237646389033ae12858f343ae14d2be0e6bb18ac"

RDEPENDS:php-pdo-dblib = " \
 freetds-libs \
 glibc \
 php-common \
 php-pdo \
 "
RDEPENDS:php-pspell = " \
 aspell \
 glibc \
 php-common \
 "
RDEPENDS:php-sodium = " \
 glibc \
 libsodium \
 php-common \
 "
RDEPENDS:php-tidy = " \
 glibc \
 libtidy \
 php-common \
 "
