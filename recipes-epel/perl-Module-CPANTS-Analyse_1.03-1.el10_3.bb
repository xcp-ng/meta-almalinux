# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-CPANTS-Analyse"
PV = "1.03"
PR = "1.el10_3"
PACKAGES = " \
 perl-Module-CPANTS-Analyse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-CPANTS-Analyse-1.03-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e0f89ca5d4a2eb88ae24093ee1f3a709f41fe04bd17f2724b3da3ac7bf2891c"

URI_x86_64_v2_perl-Module-CPANTS-Analyse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-CPANTS-Analyse-1.03-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-CPANTS-Analyse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-CPANTS-Analyse}"
SRC_URI[x86_64_v2_perl-Module-CPANTS-Analyse.sha256sum] = "44c9a2dd0fcd696e45d075dc6d559366049ec3354f7dec2eab69374253477d67"

URI_aarch64_perl-Module-CPANTS-Analyse = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-CPANTS-Analyse-1.03-1.el10_3.noarch.rpm;name=aarch64_perl-Module-CPANTS-Analyse;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-CPANTS-Analyse}"
SRC_URI[aarch64_perl-Module-CPANTS-Analyse.sha256sum] = "959e571360223f100c26341754001cfb9b933ac40a40deadc9ddcd64871ed36d"

RDEPENDS:perl-Module-CPANTS-Analyse = " \
 perl-Archive-Any-Lite \
 perl-Archive-Tar \
 perl-Array-Diff \
 perl-CPAN-Meta \
 perl-CPAN-Meta-YAML \
 perl-Carp \
 perl-Class-Accessor \
 perl-Data-Binary \
 perl-Encode \
 perl-Exporter \
 perl-ExtUtils-Manifest \
 perl-File-Copy \
 perl-File-Find-Object \
 perl-File-Temp \
 perl-File-stat \
 perl-JSON-PP \
 perl-Module-CPANfile \
 perl-Module-Find \
 perl-Parse-Distname \
 perl-PathTools \
 perl-Perl-PrereqScanner-NotQuiteLite \
 perl-Scalar-List-Utils \
 perl-Software-License \
 perl-Text-Balanced \
 perl-base \
 perl-libs \
 perl-version \
 "
