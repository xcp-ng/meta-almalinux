# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-data-encoding"
PV = "2.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-data-encoding+alloc-devel \
 rust-data-encoding+default-devel \
 rust-data-encoding+std-devel \
 rust-data-encoding-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-data-encoding-2.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "341868db0fd2674b360087b0d5b2d99361cadd8430329b5e1d65d1104d4ba61c"

URI_x86_64_v2_rust-data-encoding+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+alloc-devel-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding+alloc-devel}"
SRC_URI[x86_64_v2_rust-data-encoding+alloc-devel.sha256sum] = "286ce51eca217d789079ae7921af6b880adbbd86eb31153c5e42e0c495709718"

URI_x86_64_v2_rust-data-encoding+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+default-devel-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding+default-devel}"
SRC_URI[x86_64_v2_rust-data-encoding+default-devel.sha256sum] = "8d6240d8bf5b03bbda5936e11af9178d26b7ad2bc6fb09d045de65c51ed2f7f1"

URI_x86_64_v2_rust-data-encoding+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+std-devel-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding+std-devel}"
SRC_URI[x86_64_v2_rust-data-encoding+std-devel.sha256sum] = "08f3388beb05ac7551ef9c2e2f3e1ecd0ae8b0ab642b36a537438d402af52b73"

URI_x86_64_v2_rust-data-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-devel-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding-devel}"
SRC_URI[x86_64_v2_rust-data-encoding-devel.sha256sum] = "4442c0555364708118169f11482436acabf915ad44d1c57f8a6c2bdfc23b8f5a"

URI_aarch64_rust-data-encoding+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+alloc-devel-2.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-data-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding+alloc-devel}"
SRC_URI[aarch64_rust-data-encoding+alloc-devel.sha256sum] = "3c46f1ef89b6c55de2d0fdf1c7064a2e8ad51acef698e027e516dc3aba76c6e1"

URI_aarch64_rust-data-encoding+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+default-devel-2.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-data-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding+default-devel}"
SRC_URI[aarch64_rust-data-encoding+default-devel.sha256sum] = "c3e7d51636dccf7bc6d58a3c11516e1222b497e9bf4764ff8edcf63a5ed86ccf"

URI_aarch64_rust-data-encoding+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+std-devel-2.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-data-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding+std-devel}"
SRC_URI[aarch64_rust-data-encoding+std-devel.sha256sum] = "0d98fc51c376f788a77740db12acbdd9967133f05565a24aad499fdffec6b0fe"

URI_aarch64_rust-data-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-devel-2.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding-devel}"
SRC_URI[aarch64_rust-data-encoding-devel.sha256sum] = "f5f74ffadfdcfe74aa07dbce0ae06d9a577c68ebd5b2f5702239d7631c6f5068"

RDEPENDS:rust-data-encoding+alloc-devel = " \
 cargo \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding+default-devel = " \
 cargo \
 rust-data-encoding+std-devel \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding+std-devel = " \
 cargo \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding-devel = " \
 cargo \
 rust \
 "
