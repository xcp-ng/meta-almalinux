# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "juk"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 juk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/juk-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5834d7740d427e247938dd11737485aa67a865c988187013721b825dbc0c39e"

URI_x86_64_v2_juk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/juk-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_juk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_juk}"
SRC_URI[x86_64_v2_juk.sha256sum] = "d6dbe75a17b39c026f4d3f0d428f78dfead1b3e14d7edbdd9eb0665fc7d6055a"

URI_aarch64_juk = "${EPEL_MIRROR}/aarch64/Packages/j/juk-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_juk;unpack=0"
SRC_URI:append = " ${URI_aarch64_juk}"
SRC_URI[aarch64_juk.sha256sum] = "76f0a16568fb0e17352f6848dbc22c6ab20dd5c17071c9ef62ca9957905ff465"

RDEPENDS:juk = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 taglib \
 "
