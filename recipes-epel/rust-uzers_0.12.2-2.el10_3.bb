# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uzers"
PV = "0.12.2"
PR = "2.el10_3"
PACKAGES = " \
 rust-uzers+cache-devel \
 rust-uzers+default-devel \
 rust-uzers+log-devel \
 rust-uzers+logging-devel \
 rust-uzers+mock-devel \
 rust-uzers+test-integration-devel \
 rust-uzers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uzers-0.12.2-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1256815cc2cbaeb322249dfcebf6f2641e13186552c350e8241f19045d83af2c"

URI_x86_64_v2_rust-uzers+cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+cache-devel-0.12.2-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+cache-devel}"
SRC_URI[x86_64_v2_rust-uzers+cache-devel.sha256sum] = "d2aa32dde7a8dca3f9d981da19932740f9f769a68cd490d8e825628d488e52e9"

URI_x86_64_v2_rust-uzers+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+default-devel-0.12.2-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+default-devel}"
SRC_URI[x86_64_v2_rust-uzers+default-devel.sha256sum] = "6752276a356168e472b712bc0cb3ee3cb3c21ccfad8e881ecccb5fa502b16b9f"

URI_x86_64_v2_rust-uzers+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+log-devel-0.12.2-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+log-devel}"
SRC_URI[x86_64_v2_rust-uzers+log-devel.sha256sum] = "79acc4b57b4781263cced03910212cc8ea37bccdd643f8966c297f3fd7a9d406"

URI_x86_64_v2_rust-uzers+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+logging-devel-0.12.2-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+logging-devel}"
SRC_URI[x86_64_v2_rust-uzers+logging-devel.sha256sum] = "87333947ed0ab29268451864f3602d33fc584444fbb7579045cc01522573b822"

URI_x86_64_v2_rust-uzers+mock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+mock-devel-0.12.2-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+mock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+mock-devel}"
SRC_URI[x86_64_v2_rust-uzers+mock-devel.sha256sum] = "7b1fe0ae2877de11c1070ee980a1651a59182bf5d62ec1af0c251cf251c75370"

URI_x86_64_v2_rust-uzers+test-integration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers+test-integration-devel-0.12.2-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers+test-integration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers+test-integration-devel}"
SRC_URI[x86_64_v2_rust-uzers+test-integration-devel.sha256sum] = "5942cd825319d3072bfa46026ca08105dcda66267289acdca788636b5a79d018"

URI_x86_64_v2_rust-uzers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uzers-devel-0.12.2-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uzers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uzers-devel}"
SRC_URI[x86_64_v2_rust-uzers-devel.sha256sum] = "ba7a3b3d3c89ae3e0c31b853bda5b021ae75397baede969bc5f8d20184f7ad4e"

URI_aarch64_rust-uzers+cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+cache-devel-0.12.2-2.el10_3.noarch.rpm;name=aarch64_rust-uzers+cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+cache-devel}"
SRC_URI[aarch64_rust-uzers+cache-devel.sha256sum] = "2c654e4da24e21b034e70b50058314dfbf549603981b994189f4555dc4635709"

URI_aarch64_rust-uzers+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+default-devel-0.12.2-2.el10_3.noarch.rpm;name=aarch64_rust-uzers+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+default-devel}"
SRC_URI[aarch64_rust-uzers+default-devel.sha256sum] = "b26c2de746a1565fd8ca85a6f880376b2537a0d773d2aaaa9deeadd72a90f0fc"

URI_aarch64_rust-uzers+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+log-devel-0.12.2-2.el10_3.noarch.rpm;name=aarch64_rust-uzers+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+log-devel}"
SRC_URI[aarch64_rust-uzers+log-devel.sha256sum] = "324401a189f53cd7b816c2a8910d21d0254dc34abed983b9741b9f475e1e7a45"

URI_aarch64_rust-uzers+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+logging-devel-0.12.2-2.el10_3.noarch.rpm;name=aarch64_rust-uzers+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+logging-devel}"
SRC_URI[aarch64_rust-uzers+logging-devel.sha256sum] = "1f63f982ccb8e2b216bf180de97149e835e64c5101423f83424d3320027a4dfa"

URI_aarch64_rust-uzers+mock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+mock-devel-0.12.2-2.el10_3.noarch.rpm;name=aarch64_rust-uzers+mock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+mock-devel}"
SRC_URI[aarch64_rust-uzers+mock-devel.sha256sum] = "60b8f97746c868c1216f4ac0419ca5f5ee41dd0584b3578dafa29cb21f8ababc"

URI_aarch64_rust-uzers+test-integration-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers+test-integration-devel-0.12.2-2.el10_3.noarch.rpm;name=aarch64_rust-uzers+test-integration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers+test-integration-devel}"
SRC_URI[aarch64_rust-uzers+test-integration-devel.sha256sum] = "0c80a254d5377dbb37f410a6148aa4315879349bc3796dddfb0ca70d3f5f53b3"

URI_aarch64_rust-uzers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uzers-devel-0.12.2-2.el10_3.noarch.rpm;name=aarch64_rust-uzers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uzers-devel}"
SRC_URI[aarch64_rust-uzers-devel.sha256sum] = "f32673f316565ffa81e7730a8911a8388c2632bf7e9b6a87efa142275a4072f5"

RDEPENDS:rust-uzers+cache-devel = " \
 cargo \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+default-devel = " \
 cargo \
 rust-uzers+cache-devel \
 rust-uzers+logging-devel \
 rust-uzers+mock-devel \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+log-devel = " \
 cargo \
 rust-log-devel \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+logging-devel = " \
 cargo \
 rust-uzers+log-devel \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+mock-devel = " \
 cargo \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers+test-integration-devel = " \
 cargo \
 rust-uzers-devel \
 "
RDEPENDS:rust-uzers-devel = " \
 cargo \
 rust-libc+default-devel \
 "
