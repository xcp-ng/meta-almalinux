# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-data-clist"
PV = "0.2"
PR = "9.el10_0"
PACKAGES = " \
 ghc-data-clist \
 ghc-data-clist-devel \
 ghc-data-clist-doc \
 ghc-data-clist-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-data-clist-0.2-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "529bbb51b1aa5c020d6ebfdceb7082a8e0902eec13bedea32ff03a039fde76bd"

URI_x86_64_v2_ghc-data-clist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-clist-0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-clist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-clist}"
SRC_URI[x86_64_v2_ghc-data-clist.sha256sum] = "54d3dbdcc2f112155387957877777832fb9eff0d2878788c915dd7a9f9ec4459"

URI_x86_64_v2_ghc-data-clist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-clist-devel-0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-clist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-clist-devel}"
SRC_URI[x86_64_v2_ghc-data-clist-devel.sha256sum] = "987a0837822f8c4672ef7a5165f232c6e702a236aff37280f2bde0276ecba074"

URI_x86_64_v2_ghc-data-clist-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-clist-doc-0.2-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-data-clist-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-clist-doc}"
SRC_URI[x86_64_v2_ghc-data-clist-doc.sha256sum] = "174a28a0506e96ee3626535dcc93ff1acf9374a9af3c7d4332728df007092f0a"

URI_x86_64_v2_ghc-data-clist-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-data-clist-prof-0.2-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-data-clist-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-data-clist-prof}"
SRC_URI[x86_64_v2_ghc-data-clist-prof.sha256sum] = "fa53c0bb5cbc365b7b4bea2f313e12382037f1594d021eb00e09cde99ee22f71"

URI_aarch64_ghc-data-clist = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-clist-0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-data-clist;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-clist}"
SRC_URI[aarch64_ghc-data-clist.sha256sum] = "93be12674887385360782895319a77e2e19106297a92eed93664393c260f1490"

URI_aarch64_ghc-data-clist-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-clist-devel-0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-data-clist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-clist-devel}"
SRC_URI[aarch64_ghc-data-clist-devel.sha256sum] = "9222f97eae48e34215f8520116894e836be7f3b6a6887c4f0062dca79351447b"

URI_aarch64_ghc-data-clist-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-clist-doc-0.2-9.el10_0.noarch.rpm;name=aarch64_ghc-data-clist-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-clist-doc}"
SRC_URI[aarch64_ghc-data-clist-doc.sha256sum] = "4fc270b2f7c68de45bb5b3505037ee1d7bd4548e3053e527447ada7bf1bf250f"

URI_aarch64_ghc-data-clist-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-data-clist-prof-0.2-9.el10_0.aarch64.rpm;name=aarch64_ghc-data-clist-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-data-clist-prof}"
SRC_URI[aarch64_ghc-data-clist-prof.sha256sum] = "c54295fd05ab77417e8c64f5ba7eccb62849f9257f75b6667881b4bf2b231a4a"

RDEPENDS:ghc-data-clist = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-data-clist-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-data-clist \
 ghc-deepseq-devel \
 "
RDEPENDS:ghc-data-clist-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-data-clist-prof = " \
 ghc-base-prof \
 ghc-data-clist-devel \
 ghc-deepseq-prof \
 "
