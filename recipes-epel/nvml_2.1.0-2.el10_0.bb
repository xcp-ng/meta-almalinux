# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nvml"
PV = "2.1.0"
PR = "2.el10_0"
PACKAGES:x86_64_v2 = " \
 daxio \
 libpmem \
 libpmem-debug \
 libpmem-devel \
 libpmem2 \
 libpmem2-debug \
 libpmem2-devel \
 libpmemobj \
 libpmemobj-debug \
 libpmemobj-devel \
 libpmempool \
 libpmempool-debug \
 libpmempool-devel \
 pmempool \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/n/nvml-2.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c9c9a001a30cff700811835272e2e25c10d1da63ba1db3e06fddda9675ea583"

URI_x86_64_v2_daxio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/daxio-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_daxio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_daxio}"
SRC_URI[x86_64_v2_daxio.sha256sum] = "3eec58717cf27cf6d8e69202097eba88ddb9a301443fd83165b8558a1be1dd4f"

URI_x86_64_v2_libpmem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmem-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmem}"
SRC_URI[x86_64_v2_libpmem.sha256sum] = "3e25e30bfe26ae82209440a2e32c7334e476bd7e340102de01c77b1045492fc3"

URI_x86_64_v2_libpmem-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmem-debug-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmem-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmem-debug}"
SRC_URI[x86_64_v2_libpmem-debug.sha256sum] = "6d3e16b85ee2a1a607b8824cd0e42b2a2acb41ad1fa3f76cba6eab405a99cc2b"

URI_x86_64_v2_libpmem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmem-devel-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmem-devel}"
SRC_URI[x86_64_v2_libpmem-devel.sha256sum] = "57771e8380f1edf3e702150659bc7569958e98a3f248cbf4d334e0f1f1834de9"

URI_x86_64_v2_libpmem2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmem2-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmem2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmem2}"
SRC_URI[x86_64_v2_libpmem2.sha256sum] = "2703b77a07eacd44b930f72f902becd6ac2bae73b45eb49c6a4a1e920c80e7bc"

URI_x86_64_v2_libpmem2-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmem2-debug-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmem2-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmem2-debug}"
SRC_URI[x86_64_v2_libpmem2-debug.sha256sum] = "b720da75d025b8d3c843e439c0f87620602bc4e94fc2c30dc9bae573e60713b1"

URI_x86_64_v2_libpmem2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmem2-devel-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmem2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmem2-devel}"
SRC_URI[x86_64_v2_libpmem2-devel.sha256sum] = "3959478670c674ecc4308303b5712e09af0e3035f423611bd9b95a6684d9a172"

URI_x86_64_v2_libpmemobj = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmemobj-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmemobj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmemobj}"
SRC_URI[x86_64_v2_libpmemobj.sha256sum] = "9812c3c7820415fdccafbc7e2e4c5d9b44c9486ab8264e43ac8664ebc2ba4506"

URI_x86_64_v2_libpmemobj-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmemobj-debug-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmemobj-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmemobj-debug}"
SRC_URI[x86_64_v2_libpmemobj-debug.sha256sum] = "5aecf1f19fed519f0713c57b24dab1f1046f7e41ccbb3ab2611cc0d26ba60960"

URI_x86_64_v2_libpmemobj-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmemobj-devel-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmemobj-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmemobj-devel}"
SRC_URI[x86_64_v2_libpmemobj-devel.sha256sum] = "f4496d67288825de06199f4c2aeedc05d4186735a760ca8ae0f9a148c85ee803"

URI_x86_64_v2_libpmempool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmempool-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmempool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmempool}"
SRC_URI[x86_64_v2_libpmempool.sha256sum] = "5b8aea8b6ef04fc300b642c6819b92a7963165517595f64119b61568b5c5769e"

URI_x86_64_v2_libpmempool-debug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmempool-debug-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmempool-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmempool-debug}"
SRC_URI[x86_64_v2_libpmempool-debug.sha256sum] = "4256760d29a14d1f3a2787ec5b4ae4369da8d8c956cf4b861b6c90b229f54560"

URI_x86_64_v2_libpmempool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpmempool-devel-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpmempool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpmempool-devel}"
SRC_URI[x86_64_v2_libpmempool-devel.sha256sum] = "1c595e8e4f03ded7b77048261dffedfdf01e3cf77199a185924300f1fb4f4f3b"

URI_x86_64_v2_pmempool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pmempool-2.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pmempool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pmempool}"
SRC_URI[x86_64_v2_pmempool.sha256sum] = "5415491059cce713994dea684f37eb378cb9e7b809427983b950ab74e08ed8ac"

RDEPENDS:daxio = " \
 daxctl-libs \
 glibc \
 libpmem \
 ndctl-libs \
 "
RDEPENDS:libpmem = " \
 daxctl-libs \
 glibc \
 ndctl-libs \
 "
RDEPENDS:libpmem-debug = " \
 daxctl-libs \
 glibc \
 libpmem \
 ndctl-libs \
 "
RDEPENDS:libpmem-devel = " \
 libpmem \
 pkgconf-pkg-config \
 "
RDEPENDS:libpmem2 = " \
 daxctl-libs \
 glibc \
 ndctl-libs \
 "
RDEPENDS:libpmem2-debug = " \
 daxctl-libs \
 glibc \
 libpmem \
 libpmem2 \
 ndctl-libs \
 "
RDEPENDS:libpmem2-devel = " \
 libpmem \
 libpmem2 \
 pkgconf-pkg-config \
 "
RDEPENDS:libpmemobj = " \
 daxctl-libs \
 glibc \
 libpmem \
 ndctl-libs \
 "
RDEPENDS:libpmemobj-debug = " \
 daxctl-libs \
 glibc \
 libpmem \
 libpmemobj \
 ndctl-libs \
 "
RDEPENDS:libpmemobj-devel = " \
 daxctl-devel \
 libpmem-devel \
 libpmemobj \
 ndctl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libpmempool = " \
 daxctl-libs \
 glibc \
 libpmem \
 ndctl-libs \
 "
RDEPENDS:libpmempool-debug = " \
 daxctl-libs \
 glibc \
 libpmem \
 libpmempool \
 ndctl-libs \
 "
RDEPENDS:libpmempool-devel = " \
 daxctl-devel \
 libpmem-devel \
 libpmempool \
 ndctl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:pmempool = " \
 daxctl-libs \
 glibc \
 libpmem \
 libpmemobj \
 libpmempool \
 ndctl-libs \
 "
