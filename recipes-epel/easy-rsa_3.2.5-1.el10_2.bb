# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "easy-rsa"
PV = "3.2.5"
PR = "1.el10_2"
PACKAGES = " \
 easy-rsa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/easy-rsa-3.2.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "328ad511f3df7ce0ced62af1135be772ee23c42384fd2e17abbfaa9ef68cc6e9"

URI_x86_64_v2_easy-rsa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/easy-rsa-3.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_easy-rsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_easy-rsa}"
SRC_URI[x86_64_v2_easy-rsa.sha256sum] = "99cc4a00975ad904a62b99d98adee1716d1db95111c2474a4356f9497b8a4328"

URI_aarch64_easy-rsa = "${EPEL_MIRROR}/aarch64/Packages/e/easy-rsa-3.2.5-1.el10_2.noarch.rpm;name=aarch64_easy-rsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_easy-rsa}"
SRC_URI[aarch64_easy-rsa.sha256sum] = "c7dda05171c9b38b177e17f614f78a3e4bb8312029b7dd25a6fc096430965557"

RDEPENDS:easy-rsa = " \
 bash \
 openssl \
 "
