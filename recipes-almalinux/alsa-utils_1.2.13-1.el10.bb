# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-utils"
PV = "1.2.13"
PR = "1.el10"
PACKAGES = " \
 alsa-ucm-utils \
 alsa-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-utils-1.2.13-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bf5e2bfcb84a9eb5c60077a641db20be46bd275038c507b7fa96cdefb9160ba"

URI_x86_64_v2_alsa-ucm-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-ucm-utils-1.2.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-ucm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-ucm-utils}"
SRC_URI[x86_64_v2_alsa-ucm-utils.sha256sum] = "6d9ef83ccc73db76ef0c4e9596d5b04f95de19b99280331c0d42a77bbdef16be"

URI_x86_64_v2_alsa-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-utils-1.2.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-utils}"
SRC_URI[x86_64_v2_alsa-utils.sha256sum] = "756c7054a7d5d91487e98149de82ee946b47dc40e612ace76f3ae7a9320f4562"

URI_aarch64_alsa-ucm-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-ucm-utils-1.2.13-1.el10.aarch64.rpm;name=aarch64_alsa-ucm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-ucm-utils}"
SRC_URI[aarch64_alsa-ucm-utils.sha256sum] = "f7852a19524487722f65820e4118aff98db20913218224c8d0dab897253d9f79"

URI_aarch64_alsa-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-utils-1.2.13-1.el10.aarch64.rpm;name=aarch64_alsa-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-utils}"
SRC_URI[aarch64_alsa-utils.sha256sum] = "c38da49ad19f5145942468e1000ea10fdff6330c372d883bcade00eaf01785a5"

RDEPENDS:alsa-ucm-utils = " \
 alsa-lib \
 glibc \
 "
RDEPENDS:alsa-utils = " \
 alsa-lib \
 alsa-ucm \
 bash \
 glibc \
 libsamplerate \
 ncurses-libs \
 systemd \
 "
