# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prodash"
PV = "30.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-prodash+async-io-devel \
 rust-prodash+bytesize-devel \
 rust-prodash+crosstermion-devel \
 rust-prodash+ctrlc-devel \
 rust-prodash+dashmap-devel \
 rust-prodash+default-devel \
 rust-prodash+futures-core-devel \
 rust-prodash+futures-lite-devel \
 rust-prodash+human_format-devel \
 rust-prodash+is-terminal-devel \
 rust-prodash+jiff-devel \
 rust-prodash+local-time-devel \
 rust-prodash+log-devel \
 rust-prodash+parking_lot-devel \
 rust-prodash+progress-log-devel \
 rust-prodash+progress-tree-devel \
 rust-prodash+progress-tree-hp-hashmap-devel \
 rust-prodash+progress-tree-log-devel \
 rust-prodash+render-line-autoconfigure-devel \
 rust-prodash+render-line-crossterm-devel \
 rust-prodash+render-line-devel \
 rust-prodash+render-tui-crossterm-devel \
 rust-prodash+render-tui-devel \
 rust-prodash+signal-hook-devel \
 rust-prodash+tui-devel \
 rust-prodash+tui-react-devel \
 rust-prodash+unicode-segmentation-devel \
 rust-prodash+unicode-width-devel \
 rust-prodash+unit-bytes-devel \
 rust-prodash+unit-duration-devel \
 rust-prodash+unit-human-devel \
 rust-prodash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prodash-30.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef0dbb8e7e0a5329d212e55397e301f54794d1ebc5b9bc75fd4f49148d1714f9"

URI_x86_64_v2_rust-prodash+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+async-io-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+async-io-devel}"
SRC_URI[x86_64_v2_rust-prodash+async-io-devel.sha256sum] = "ac73165a55539cfe615d835aabde78eb8457debe18532767e03725f9c51a139e"

URI_x86_64_v2_rust-prodash+bytesize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+bytesize-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+bytesize-devel}"
SRC_URI[x86_64_v2_rust-prodash+bytesize-devel.sha256sum] = "867f098c7e5744727bb9ef53153a6a5abe481834f0976317b76006717aedbfd9"

URI_x86_64_v2_rust-prodash+crosstermion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+crosstermion-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+crosstermion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+crosstermion-devel}"
SRC_URI[x86_64_v2_rust-prodash+crosstermion-devel.sha256sum] = "02ebc79c7f9fbf3fd6e4747350334c93cd36e76ce85019a090c277bb4c3b25af"

URI_x86_64_v2_rust-prodash+ctrlc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+ctrlc-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+ctrlc-devel}"
SRC_URI[x86_64_v2_rust-prodash+ctrlc-devel.sha256sum] = "13c6e80052adc39f785c0924e5d184de6f43b321d14c7dc760eb45b85e3c445a"

URI_x86_64_v2_rust-prodash+dashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+dashmap-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+dashmap-devel}"
SRC_URI[x86_64_v2_rust-prodash+dashmap-devel.sha256sum] = "e8032039d98d67d19040085591fe4dab664cae96dc5d179765723bf000fdb52f"

URI_x86_64_v2_rust-prodash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+default-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+default-devel}"
SRC_URI[x86_64_v2_rust-prodash+default-devel.sha256sum] = "8fb10673590a4a2eac48984a332299d57e7681ec72946b98f75acc0b0281d78c"

URI_x86_64_v2_rust-prodash+futures-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+futures-core-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+futures-core-devel}"
SRC_URI[x86_64_v2_rust-prodash+futures-core-devel.sha256sum] = "9c993b212574898a8a65b76586d563b8cb8dbe7ce82dfed42a29ad88f4f42edc"

URI_x86_64_v2_rust-prodash+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+futures-lite-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-prodash+futures-lite-devel.sha256sum] = "f3afe1ca8fe67e78d0adad9c0d10487dc4cc1339bf66b5f0d567cfb05bcf9de1"

URI_x86_64_v2_rust-prodash+human_format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+human_format-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+human_format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+human_format-devel}"
SRC_URI[x86_64_v2_rust-prodash+human_format-devel.sha256sum] = "e7eea795b54f28a9d847615eba6183574b7bbc08ff0cdc08bc097a428cbe4f5f"

URI_x86_64_v2_rust-prodash+is-terminal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+is-terminal-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+is-terminal-devel}"
SRC_URI[x86_64_v2_rust-prodash+is-terminal-devel.sha256sum] = "1b46f0a7b713a34f9f04e604af6d8fe233e27a55493a22500f13b481a938d8bb"

URI_x86_64_v2_rust-prodash+jiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+jiff-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+jiff-devel}"
SRC_URI[x86_64_v2_rust-prodash+jiff-devel.sha256sum] = "e1d3807d132219b76223dc580fc5ddbbaa021d11cb0b362e9664708e0bf85993"

URI_x86_64_v2_rust-prodash+local-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+local-time-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+local-time-devel}"
SRC_URI[x86_64_v2_rust-prodash+local-time-devel.sha256sum] = "422d04451c7290ef092b72da6c9672e5b19fa30427c2143f9340e1f1ed8bccbd"

URI_x86_64_v2_rust-prodash+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+log-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+log-devel}"
SRC_URI[x86_64_v2_rust-prodash+log-devel.sha256sum] = "24f5228725c73287d28d8919595c6d920b26abfac3c724fc019740a6e0acde33"

URI_x86_64_v2_rust-prodash+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+parking_lot-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-prodash+parking_lot-devel.sha256sum] = "b345344e52b68feaf9a212d6ecb7b2206d9b2884446cf06c49a099d8044321ef"

URI_x86_64_v2_rust-prodash+progress-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-log-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-log-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-log-devel.sha256sum] = "31ecef0f5732c3069f43e6fbd6c0b23129c572ce89743273404b7a353cf725b2"

URI_x86_64_v2_rust-prodash+progress-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-tree-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-tree-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-tree-devel.sha256sum] = "f170eb2d910cf7ed0c69bcc0459c8d191be701aac6d49ebeb786ce060aeb1fbd"

URI_x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-tree-hp-hashmap-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-tree-hp-hashmap-devel.sha256sum] = "e3b4c284b7ba04623fa01c6619ddfcd3845891b83ce4247773ed4826889668da"

URI_x86_64_v2_rust-prodash+progress-tree-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+progress-tree-log-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+progress-tree-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+progress-tree-log-devel}"
SRC_URI[x86_64_v2_rust-prodash+progress-tree-log-devel.sha256sum] = "9dc4c53bfd8e8c10533615fe349443cbc7245e182f28043776468085d89a8c23"

URI_x86_64_v2_rust-prodash+render-line-autoconfigure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-line-autoconfigure-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-line-autoconfigure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-line-autoconfigure-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-line-autoconfigure-devel.sha256sum] = "bd4e2647da241f1292073618c6d587e8c5f7c2c42e7298621b1c119faca9f30d"

URI_x86_64_v2_rust-prodash+render-line-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-line-crossterm-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-line-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-line-crossterm-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-line-crossterm-devel.sha256sum] = "3ae511dc44e41bd48995f3f4107080821c7e2bd22b4127051ecbdf325142054a"

URI_x86_64_v2_rust-prodash+render-line-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-line-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-line-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-line-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-line-devel.sha256sum] = "cdc1d611bfce29f52a1943119641940fb47be8e2017b454e92b996ec4159916c"

URI_x86_64_v2_rust-prodash+render-tui-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-tui-crossterm-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-tui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-tui-crossterm-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-tui-crossterm-devel.sha256sum] = "f56d84b5ed857cc05265721ce983c96fe193b1422c2c24e1b27ffe619158399b"

URI_x86_64_v2_rust-prodash+render-tui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+render-tui-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+render-tui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+render-tui-devel}"
SRC_URI[x86_64_v2_rust-prodash+render-tui-devel.sha256sum] = "16705653d8b6a69b73c613292b71baf607b661a1f470a866af62fa945f1b50a0"

URI_x86_64_v2_rust-prodash+signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+signal-hook-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+signal-hook-devel}"
SRC_URI[x86_64_v2_rust-prodash+signal-hook-devel.sha256sum] = "6b25d35648e0dc6d02e39110b8ecb24cb48ca6c1560712fd664cd830d2bdbc74"

URI_x86_64_v2_rust-prodash+tui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+tui-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+tui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+tui-devel}"
SRC_URI[x86_64_v2_rust-prodash+tui-devel.sha256sum] = "c6412fce4a8e05ade76d29db208bc1ff984a5ca5e6f079dd5a96eb0498e48116"

URI_x86_64_v2_rust-prodash+tui-react-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+tui-react-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+tui-react-devel}"
SRC_URI[x86_64_v2_rust-prodash+tui-react-devel.sha256sum] = "132a139fd049a5a192f60bd4471c2e16d92a28dbc965321b92410c55791db222"

URI_x86_64_v2_rust-prodash+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unicode-segmentation-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-prodash+unicode-segmentation-devel.sha256sum] = "b395d9322019caa0b382c1669efbef19a6337b54e14a66dbcee0ae5cc923f47e"

URI_x86_64_v2_rust-prodash+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unicode-width-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-prodash+unicode-width-devel.sha256sum] = "df21849d771d1df6818808142fa21bafc8aa52067286a93bc2b4d04ed6e0a17f"

URI_x86_64_v2_rust-prodash+unit-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unit-bytes-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unit-bytes-devel}"
SRC_URI[x86_64_v2_rust-prodash+unit-bytes-devel.sha256sum] = "3b558d3090f2af2a831acd2757431de8d406adef7dd6b410581c4ada396cb548"

URI_x86_64_v2_rust-prodash+unit-duration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unit-duration-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unit-duration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unit-duration-devel}"
SRC_URI[x86_64_v2_rust-prodash+unit-duration-devel.sha256sum] = "e924f95070112c763f9a5052ed2dd2c63fbc05630632b15a7f8f58ba5557bbaa"

URI_x86_64_v2_rust-prodash+unit-human-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash+unit-human-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash+unit-human-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash+unit-human-devel}"
SRC_URI[x86_64_v2_rust-prodash+unit-human-devel.sha256sum] = "facdf3d58c74af80036dd5c6d802d3064ff48fac0ae11cf61e8292116d801fd3"

URI_x86_64_v2_rust-prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prodash-devel-30.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prodash-devel}"
SRC_URI[x86_64_v2_rust-prodash-devel.sha256sum] = "7cc23bdeea040295d156bd4310131f105f2bd48b96e4aff34da1ed3196c74483"

URI_aarch64_rust-prodash+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+async-io-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+async-io-devel}"
SRC_URI[aarch64_rust-prodash+async-io-devel.sha256sum] = "71777200e6f08e770e4e09bba25741cbc44dda9ab37846b6b7d8148d773a1c86"

URI_aarch64_rust-prodash+bytesize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+bytesize-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+bytesize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+bytesize-devel}"
SRC_URI[aarch64_rust-prodash+bytesize-devel.sha256sum] = "e3abb3d313e44ea31d85e5667e9a98fdb137410003c9f9ae3569a12559f5e22f"

URI_aarch64_rust-prodash+crosstermion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+crosstermion-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+crosstermion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+crosstermion-devel}"
SRC_URI[aarch64_rust-prodash+crosstermion-devel.sha256sum] = "f32b775799c3fdeb09929e28c7e6bf962dc8b047bfd6ea665c6fb23923214020"

URI_aarch64_rust-prodash+ctrlc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+ctrlc-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+ctrlc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+ctrlc-devel}"
SRC_URI[aarch64_rust-prodash+ctrlc-devel.sha256sum] = "4d9285d533b45152f111ed117c3d6982314177dfadef442d6c0a90204df1da50"

URI_aarch64_rust-prodash+dashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+dashmap-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+dashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+dashmap-devel}"
SRC_URI[aarch64_rust-prodash+dashmap-devel.sha256sum] = "74222c24fa735449c04f458ceb8b539554572f945b74be8ee9fc3acce741aaac"

URI_aarch64_rust-prodash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+default-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+default-devel}"
SRC_URI[aarch64_rust-prodash+default-devel.sha256sum] = "9a8443e7b3a6a9d50ef48afcfe3c21a38d6cee2efdbd6a61a0790055b2e6e1a3"

URI_aarch64_rust-prodash+futures-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+futures-core-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+futures-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+futures-core-devel}"
SRC_URI[aarch64_rust-prodash+futures-core-devel.sha256sum] = "e4abf920cc023936c40949574193f125024e19811a72c4bd3aac3edc1eb5c02f"

URI_aarch64_rust-prodash+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+futures-lite-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+futures-lite-devel}"
SRC_URI[aarch64_rust-prodash+futures-lite-devel.sha256sum] = "7f9baa8f74a174497735c7073277fd88897fc1d91de55aeb6b9251f452b05ff4"

URI_aarch64_rust-prodash+human_format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+human_format-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+human_format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+human_format-devel}"
SRC_URI[aarch64_rust-prodash+human_format-devel.sha256sum] = "938ef29518ecb92cb495e8e4734839132e28e143ae95d9275e90020ab478c3f0"

URI_aarch64_rust-prodash+is-terminal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+is-terminal-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+is-terminal-devel}"
SRC_URI[aarch64_rust-prodash+is-terminal-devel.sha256sum] = "5acd5cb88e90b1cf7f2515c47d45887f7cde54f28f65b3ecec9f7dfcfa213f2d"

URI_aarch64_rust-prodash+jiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+jiff-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+jiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+jiff-devel}"
SRC_URI[aarch64_rust-prodash+jiff-devel.sha256sum] = "3d296b68bf9116e58aa0c234c0a44dd4d082d0d6f64f662735391ebe0ad7c98e"

URI_aarch64_rust-prodash+local-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+local-time-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+local-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+local-time-devel}"
SRC_URI[aarch64_rust-prodash+local-time-devel.sha256sum] = "a511f4d5255500e91c595d39ebb30b34204f8b5169759e51c9da1d5951025620"

URI_aarch64_rust-prodash+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+log-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+log-devel}"
SRC_URI[aarch64_rust-prodash+log-devel.sha256sum] = "9b5d791b3886462a8a7b0a88d02a2ebfdacf3bee3386dc20e0c8f15290d43308"

URI_aarch64_rust-prodash+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+parking_lot-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+parking_lot-devel}"
SRC_URI[aarch64_rust-prodash+parking_lot-devel.sha256sum] = "f32444e23c1b06b22fbc3902b5e045a0e5e8c211e5967efd6335b1ac5e5b31e1"

URI_aarch64_rust-prodash+progress-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-log-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+progress-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-log-devel}"
SRC_URI[aarch64_rust-prodash+progress-log-devel.sha256sum] = "1402a9c32f8b9676afe5d91d58c3321cf6abc1de61fe75d4cc1f6f63520913f7"

URI_aarch64_rust-prodash+progress-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-tree-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-tree-devel}"
SRC_URI[aarch64_rust-prodash+progress-tree-devel.sha256sum] = "94227d7795347bfd6120bd38d1b5a6c013cdb93642fe3209484a16ebe8ecf195"

URI_aarch64_rust-prodash+progress-tree-hp-hashmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-tree-hp-hashmap-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+progress-tree-hp-hashmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-tree-hp-hashmap-devel}"
SRC_URI[aarch64_rust-prodash+progress-tree-hp-hashmap-devel.sha256sum] = "1d5a691efd21d21d3b873b519ff07d44198a79dc4a3475beb54ad012be078d11"

URI_aarch64_rust-prodash+progress-tree-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+progress-tree-log-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+progress-tree-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+progress-tree-log-devel}"
SRC_URI[aarch64_rust-prodash+progress-tree-log-devel.sha256sum] = "1201bc4fcd3a23ed631f626f55735cfd3126b31bbaccc7e1f48ad809f569d8d4"

URI_aarch64_rust-prodash+render-line-autoconfigure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-line-autoconfigure-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+render-line-autoconfigure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-line-autoconfigure-devel}"
SRC_URI[aarch64_rust-prodash+render-line-autoconfigure-devel.sha256sum] = "1a600d1fa5cae3d7fd87385dd2077c6513e8b329fe951d9bf7696f7a2592ee39"

URI_aarch64_rust-prodash+render-line-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-line-crossterm-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+render-line-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-line-crossterm-devel}"
SRC_URI[aarch64_rust-prodash+render-line-crossterm-devel.sha256sum] = "df74f3c57684c544ca4e52ac500fde03e6695bdf1ae66b9f908e2d615c75771b"

URI_aarch64_rust-prodash+render-line-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-line-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+render-line-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-line-devel}"
SRC_URI[aarch64_rust-prodash+render-line-devel.sha256sum] = "7d58c1d880d16a2010020fc27249900bb8e0c4f1364304f12bb05fb142669463"

URI_aarch64_rust-prodash+render-tui-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-tui-crossterm-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+render-tui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-tui-crossterm-devel}"
SRC_URI[aarch64_rust-prodash+render-tui-crossterm-devel.sha256sum] = "e4a3eb2b4e7cee7aba142d21bca400188578ca83e95a1b3b0c14be53416b9fc4"

URI_aarch64_rust-prodash+render-tui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+render-tui-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+render-tui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+render-tui-devel}"
SRC_URI[aarch64_rust-prodash+render-tui-devel.sha256sum] = "3600b0823121fc190ae2cc87412faa99aa971b1c5217ae1364ade1f854713f20"

URI_aarch64_rust-prodash+signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+signal-hook-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+signal-hook-devel}"
SRC_URI[aarch64_rust-prodash+signal-hook-devel.sha256sum] = "2fa678b91c622ae38aa65162a5e60e115c53304c179a71b83ca7ada9681ab379"

URI_aarch64_rust-prodash+tui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+tui-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+tui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+tui-devel}"
SRC_URI[aarch64_rust-prodash+tui-devel.sha256sum] = "a75eeb8efc0376d7f766e59f52c63dfc52876616a67851aa0cfa207385a03fdb"

URI_aarch64_rust-prodash+tui-react-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+tui-react-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+tui-react-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+tui-react-devel}"
SRC_URI[aarch64_rust-prodash+tui-react-devel.sha256sum] = "feca45dd18f9301028fad8f316c1533695bdca60955ee42b606ca9ac096fa95a"

URI_aarch64_rust-prodash+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unicode-segmentation-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-prodash+unicode-segmentation-devel.sha256sum] = "b2e0d02b7aba3811f748d4e62821eb5c907611492b0a6d4fcfe7eef3b9c2a857"

URI_aarch64_rust-prodash+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unicode-width-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unicode-width-devel}"
SRC_URI[aarch64_rust-prodash+unicode-width-devel.sha256sum] = "5d26a9ef9615da1d7c8c8ce74dcdcfedeffe82bcc981889f28be9de8f60a1a07"

URI_aarch64_rust-prodash+unit-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unit-bytes-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unit-bytes-devel}"
SRC_URI[aarch64_rust-prodash+unit-bytes-devel.sha256sum] = "16a9b9a82167b11eecf894dbfd5e0a825f61e56e2de4bb32d61c64417a88072d"

URI_aarch64_rust-prodash+unit-duration-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unit-duration-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+unit-duration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unit-duration-devel}"
SRC_URI[aarch64_rust-prodash+unit-duration-devel.sha256sum] = "769488f8b149cdd9c168dbbdae801840c9e77864d8ac11475bf419a68a6d975a"

URI_aarch64_rust-prodash+unit-human-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash+unit-human-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash+unit-human-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash+unit-human-devel}"
SRC_URI[aarch64_rust-prodash+unit-human-devel.sha256sum] = "95c055e1149bd5fd795a21a16b386548e77815dc2699ff451e7a3f82e12c3f6a"

URI_aarch64_rust-prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prodash-devel-30.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prodash-devel}"
SRC_URI[aarch64_rust-prodash-devel.sha256sum] = "126ca25da83f89aaab16eeae312a734601458f4cae89fda2a5375eb245cd10de"

RDEPENDS:rust-prodash+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+bytesize-devel = " \
 cargo \
 rust-bytesize+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+crosstermion-devel = " \
 cargo \
 rust-crosstermion-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+ctrlc-devel = " \
 cargo \
 rust-ctrlc+termination-devel \
 rust-ctrlc-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+dashmap-devel = " \
 cargo \
 rust-dashmap-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+default-devel = " \
 cargo \
 rust-prodash+progress-tree-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+futures-core-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+human_format-devel = " \
 cargo \
 rust-human_format+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+is-terminal-devel = " \
 cargo \
 rust-is-terminal+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+jiff-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+local-time-devel = " \
 cargo \
 rust-prodash+jiff-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+parking_lot-devel = " \
 cargo \
 rust-parking_lot-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-log-devel = " \
 cargo \
 rust-prodash+log-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-tree-devel = " \
 cargo \
 rust-prodash+parking_lot-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-tree-hp-hashmap-devel = " \
 cargo \
 rust-prodash+dashmap-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+progress-tree-log-devel = " \
 cargo \
 rust-prodash+log-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-line-autoconfigure-devel = " \
 cargo \
 rust-prodash+is-terminal-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-line-crossterm-devel = " \
 cargo \
 rust-crosstermion+crossterm-devel \
 rust-crosstermion-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-line-devel = " \
 cargo \
 rust-crosstermion+color-devel \
 rust-crosstermion-devel \
 rust-prodash+jiff-devel \
 rust-prodash+unicode-width-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-tui-crossterm-devel = " \
 cargo \
 rust-crosstermion+input-async-crossterm-devel \
 rust-crosstermion+tui-react-crossterm-devel \
 rust-crosstermion-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+render-tui-devel = " \
 cargo \
 rust-crosstermion+input-async-devel \
 rust-crosstermion-devel \
 rust-prodash+async-io-devel \
 rust-prodash+futures-core-devel \
 rust-prodash+futures-lite-devel \
 rust-prodash+jiff-devel \
 rust-prodash+tui-devel \
 rust-prodash+tui-react-devel \
 rust-prodash+unicode-segmentation-devel \
 rust-prodash+unicode-width-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+signal-hook-devel = " \
 cargo \
 rust-prodash-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-prodash+tui-devel = " \
 cargo \
 rust-prodash-devel \
 rust-ratatui0.26-devel \
 "
RDEPENDS:rust-prodash+tui-react-devel = " \
 cargo \
 rust-prodash-devel \
 rust-tui-react+default-devel \
 "
RDEPENDS:rust-prodash+unicode-segmentation-devel = " \
 cargo \
 rust-prodash-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-prodash+unicode-width-devel = " \
 cargo \
 rust-prodash-devel \
 rust-unicode-width0.1+default-devel \
 "
RDEPENDS:rust-prodash+unit-bytes-devel = " \
 cargo \
 rust-prodash+bytesize-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+unit-duration-devel = " \
 cargo \
 rust-prodash+jiff-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash+unit-human-devel = " \
 cargo \
 rust-prodash+human_format-devel \
 rust-prodash-devel \
 "
RDEPENDS:rust-prodash-devel = " \
 cargo \
 rust \
 "
