# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mattn-isatty"
PV = "0.0.20"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-mattn-isatty-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mattn-isatty-0.0.20-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9adb239b15d251052308f5fd58e23b13603ecfb576c0edda0906736c06c7fd64"

URI_x86_64_v2_golang-github-mattn-isatty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mattn-isatty-devel-0.0.20-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mattn-isatty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mattn-isatty-devel}"
SRC_URI[x86_64_v2_golang-github-mattn-isatty-devel.sha256sum] = "b9e29d098d6a17b3b25e0c41b55a29153d5d1e9cfb8dd3b732e2515271908455"

URI_aarch64_golang-github-mattn-isatty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mattn-isatty-devel-0.0.20-2.el10_0.noarch.rpm;name=aarch64_golang-github-mattn-isatty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mattn-isatty-devel}"
SRC_URI[aarch64_golang-github-mattn-isatty-devel.sha256sum] = "34770cb9169e492e05ca61615f3d6066f06eb76b99f171d1a9179dd60c1ca7a7"

RDEPENDS:golang-github-mattn-isatty-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
