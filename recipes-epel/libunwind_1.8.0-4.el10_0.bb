# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libunwind"
PV = "1.8.0"
PR = "4.el10_0"
PACKAGES = " \
 libunwind \
 libunwind-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libunwind-1.8.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bbc7a41cc926ad7cf912a1274e2d7d28ec4ce67515cbf2b7de3f35181fe5b6ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libunwind-1.8.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libunwind;unpack=0"
SRC_URI[x86_64_v2_libunwind.sha256sum] = "59dd3d9229640a1389ff751c12fc84b9951ba0a3b1c2927793cbdb9cb2da364c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libunwind-devel-1.8.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libunwind-devel;unpack=0"
SRC_URI[x86_64_v2_libunwind-devel.sha256sum] = "014e0f573b9ba7a9999b3da046e81e7dd9fa218e60178ab1a74ff6738e4443b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libunwind-1.8.0-4.el10_0.aarch64.rpm;name=aarch64_libunwind;unpack=0"
SRC_URI[aarch64_libunwind.sha256sum] = "3ba564dfd3c3993778b7e71a756a5e702f919a607104b9505feb260ad42fa9fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libunwind-devel-1.8.0-4.el10_0.aarch64.rpm;name=aarch64_libunwind-devel;unpack=0"
SRC_URI[aarch64_libunwind-devel.sha256sum] = "23a9f0198b024ee02d876c20cf3d3522a3fe9880f2e558e5e2ad896d45658248"

RDEPENDS:libunwind:x86_64_v2 = " \
 glibc \
"
RDEPENDS:libunwind:aarch64 = " \
 glibc \
 libgcc \
"
RDEPENDS:libunwind-devel = " \
 libunwind \
 libunwind-devel \
 pkgconf-pkg-config \
 "
