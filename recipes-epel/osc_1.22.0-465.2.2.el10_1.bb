# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osc"
PV = "1.22.0"
PR = "465.2.2.el10_1"
PACKAGES = " \
 osc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/osc-1.22.0-465.2.2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d6f734927bb03c2389809ae828242f1097913924830c7997796abc1f5a5f665"

URI_x86_64_v2_osc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/osc-1.22.0-465.2.2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_osc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osc}"
SRC_URI[x86_64_v2_osc.sha256sum] = "ac6032d19d04d6e5303d54597efae8359e06f741920a140627f741f366fee484"

URI_aarch64_osc = "${EPEL_MIRROR}/aarch64/Packages/o/osc-1.22.0-465.2.2.el10_1.noarch.rpm;name=aarch64_osc;unpack=0"
SRC_URI:append = " ${URI_aarch64_osc}"
SRC_URI[aarch64_osc.sha256sum] = "6ff85144719ff0af8d28c694a6d8edab6f80b1280b7b7cda464a409c57e17d57"

RDEPENDS:osc = " \
 bash \
 python3 \
 python3-cryptography \
 python3-distro \
 python3-lxml \
 python3-progressbar2 \
 python3-rpm \
 python3-ruamel-yaml \
 python3-urllib3 \
 "
