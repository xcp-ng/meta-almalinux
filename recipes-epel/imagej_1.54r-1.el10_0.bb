# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "imagej"
PV = "1.54r"
PR = "1.el10_0"
PACKAGES = " \
 imagej \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/imagej-1.54r-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3180cdf7b9d214a4bd393822d34a6690a042fcd1ddc03cd45e41b58b5d12215f"

URI_x86_64_v2_imagej = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imagej-1.54r-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_imagej;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_imagej}"
SRC_URI[x86_64_v2_imagej.sha256sum] = "15c6dc65e379e0b5e9831f6440cf4c6cab2c4b3846d749b19e13d911b977f06a"

URI_aarch64_imagej = "${EPEL_MIRROR}/aarch64/Packages/i/imagej-1.54r-1.el10_0.noarch.rpm;name=aarch64_imagej;unpack=0"
SRC_URI:append = " ${URI_aarch64_imagej}"
SRC_URI[aarch64_imagej.sha256sum] = "7f4dfc50a8f8e5efd09342ec928751a9c26672dec670bb9bb2e6337d8a922a21"

RDEPENDS:imagej = " \
 bash \
 java-21-openjdk-devel \
 javapackages-tools \
 "
