# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-process-tests"
PV = "3.0.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-process-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-process-tests-3.0.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a210d5d243248ce3f915f3d100e15c02d01ca5477fb3a475c85b2457243820e"

URI_x86_64_v2_python3-process-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-process-tests-3.0.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-process-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-process-tests}"
SRC_URI[x86_64_v2_python3-process-tests.sha256sum] = "a201cbef6a97641f3ed329c2c8bb7f7e55c038e3c97b8fcae20afc626a6c666b"

URI_aarch64_python3-process-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-process-tests-3.0.0-3.el10_0.noarch.rpm;name=aarch64_python3-process-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-process-tests}"
SRC_URI[aarch64_python3-process-tests.sha256sum] = "cab0303716367b5d2f97af41d758c39b6e14dfc5bdf1ba745585e340c9b54e6b"

RDEPENDS:python3-process-tests = " \
 python3 \
 "
