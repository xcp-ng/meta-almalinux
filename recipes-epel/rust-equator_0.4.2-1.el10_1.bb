# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-equator"
PV = "0.4.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-equator+default-devel \
 rust-equator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-equator-0.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e64da5f688964f023f23adb3250339616bfeeb28fb1aaccf7db3691e9f9c97b4"

URI_x86_64_v2_rust-equator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator+default-devel-0.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator+default-devel}"
SRC_URI[x86_64_v2_rust-equator+default-devel.sha256sum] = "90bad430765b052a4b8cd7d55c90c38b7e6fe5cde1eec5462c550fe541f64856"

URI_x86_64_v2_rust-equator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator-devel-0.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator-devel}"
SRC_URI[x86_64_v2_rust-equator-devel.sha256sum] = "34a6c0516c0ec194f99b84d9c9e4ee9e1e454f68d477d683f8bee218f60fe358"

URI_aarch64_rust-equator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator+default-devel-0.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-equator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator+default-devel}"
SRC_URI[aarch64_rust-equator+default-devel.sha256sum] = "98f9eeaec4ee29629ade2d280d339b5a0ba44078b93e5d67cdd54787babe73d0"

URI_aarch64_rust-equator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator-devel-0.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-equator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator-devel}"
SRC_URI[aarch64_rust-equator-devel.sha256sum] = "0fce047334b8f1ca1a9d022f8615218fec6f4aa73a512c43393950d440cdc676"

RDEPENDS:rust-equator+default-devel = " \
 cargo \
 rust-equator-devel \
 "
RDEPENDS:rust-equator-devel = " \
 cargo \
 rust-equator-macro+default-devel \
 "
