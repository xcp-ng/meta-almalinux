# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxslt"
PV = "1.1.39"
PR = "10.el10"
PACKAGES = " \
 libxslt \
 libxslt-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libxslt-1.1.39-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f73d89dd2c1026e32837079f0446ffb7b0f814609ce899f44e343d7d10203a15"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxslt-1.1.39-10.el10.x86_64_v2.rpm;name=x86_64_v2_libxslt;unpack=0"
SRC_URI[x86_64_v2_libxslt.sha256sum] = "5b949078b3e03d0631ac8251060267464068a0772a982906a3c6c2980282004f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxslt-devel-1.1.39-10.el10.x86_64_v2.rpm;name=x86_64_v2_libxslt-devel;unpack=0"
SRC_URI[x86_64_v2_libxslt-devel.sha256sum] = "62608c4daaf2a5241958baec0f7a3004cd59deff99b8eaef65dbd8ecceb57fd1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxslt-1.1.39-10.el10.aarch64.rpm;name=aarch64_libxslt;unpack=0"
SRC_URI[aarch64_libxslt.sha256sum] = "78aa786d34868aa0f26b2d7d35688a7bebfd91ee691978c2247f886534576f89"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxslt-devel-1.1.39-10.el10.aarch64.rpm;name=aarch64_libxslt-devel;unpack=0"
SRC_URI[aarch64_libxslt-devel.sha256sum] = "92231e7cf3f6ca0ba33c7b20fe9a2c1608b808e36f0a4cf6230c4dad155f98f6"

RDEPENDS:libxslt = " \
 glibc \
 libxml2 \
 "
RDEPENDS:libxslt-devel = " \
 bash \
 libgpg-error-devel \
 libxml2-devel \
 libxslt \
 libxslt-devel \
 pkgconf-pkg-config \
 "
