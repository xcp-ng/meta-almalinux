# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-log-macros"
PV = "0.2.19"
PR = "1.el10_2"
PACKAGES = " \
 rust-test-log-macros+default-devel \
 rust-test-log-macros+log-devel \
 rust-test-log-macros+trace-devel \
 rust-test-log-macros+unstable-devel \
 rust-test-log-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-log-macros-0.2.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5856f8a10d6a7c2ebdfe67322bf579654ed54c49aa5dedf2f4710cfc616aaaf5"

URI_x86_64_v2_rust-test-log-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+default-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+default-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+default-devel.sha256sum] = "5980b7e08e673ff5554fe7518e58c3ab931c87abdb8c53342e1cc39c14a94971"

URI_x86_64_v2_rust-test-log-macros+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+log-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+log-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+log-devel.sha256sum] = "5d0def6539cc32c2ff5871c074f24bac0692b111b4793c8e3ee4bf2b448e55cd"

URI_x86_64_v2_rust-test-log-macros+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+trace-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+trace-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+trace-devel.sha256sum] = "bd5668544dd9ff548bca45ba96d0cf56b256cce30ccf50156acb1621ee70c96a"

URI_x86_64_v2_rust-test-log-macros+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros+unstable-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros+unstable-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros+unstable-devel.sha256sum] = "30105dc214f0c6ecbba5fa8eca4dea54b4536d8372beee6ff8c0daa85beba994"

URI_x86_64_v2_rust-test-log-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-macros-devel-0.2.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-macros-devel}"
SRC_URI[x86_64_v2_rust-test-log-macros-devel.sha256sum] = "a8089f0793fed6f693f8d79c4ef34a4a76010b7e1a3d15a92b14a4454d192863"

URI_aarch64_rust-test-log-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+default-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+default-devel}"
SRC_URI[aarch64_rust-test-log-macros+default-devel.sha256sum] = "49d9bceb643970d7314e60628bd82ddefabc80a58a98036301b5f06f1e7eac28"

URI_aarch64_rust-test-log-macros+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+log-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log-macros+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+log-devel}"
SRC_URI[aarch64_rust-test-log-macros+log-devel.sha256sum] = "209374d89767d61cc4d450c3eea831de55fa1b09673da3e969f78d7e1f28648b"

URI_aarch64_rust-test-log-macros+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+trace-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log-macros+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+trace-devel}"
SRC_URI[aarch64_rust-test-log-macros+trace-devel.sha256sum] = "2ce47ca208660d7a8fca842cd3a30aaadaec017772962e600ed1dc12b218239d"

URI_aarch64_rust-test-log-macros+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros+unstable-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log-macros+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros+unstable-devel}"
SRC_URI[aarch64_rust-test-log-macros+unstable-devel.sha256sum] = "18bbe354ac7b5849982e411c83937bea8a2c68560f917f4d9a2c938fb0ba67a5"

URI_aarch64_rust-test-log-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-macros-devel-0.2.19-1.el10_2.noarch.rpm;name=aarch64_rust-test-log-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-macros-devel}"
SRC_URI[aarch64_rust-test-log-macros-devel.sha256sum] = "cf056f1a311311b600e912b729ef5bc341dca5e042b6919225cca7a66940dbe6"

RDEPENDS:rust-test-log-macros+default-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros+log-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros+trace-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros+unstable-devel = " \
 cargo \
 rust-test-log-macros-devel \
 "
RDEPENDS:rust-test-log-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
