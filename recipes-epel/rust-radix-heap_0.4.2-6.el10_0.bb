# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-radix-heap"
PV = "0.4.2"
PR = "6.el10_0"
PACKAGES = " \
 rust-radix-heap+default-devel \
 rust-radix-heap+ordered-float-devel \
 rust-radix-heap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-radix-heap-0.4.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "383abd0d1176a7e7904e2c6f1ce45fa0975070c291fecfe5bce0d20a98a6fa6d"

URI_x86_64_v2_rust-radix-heap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radix-heap+default-devel-0.4.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radix-heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-radix-heap+default-devel}"
SRC_URI[x86_64_v2_rust-radix-heap+default-devel.sha256sum] = "49132e3dfadf1550306b4b7b8a638458a680aa99456f28efac91cf72a678e807"

URI_x86_64_v2_rust-radix-heap+ordered-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radix-heap+ordered-float-devel-0.4.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radix-heap+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-radix-heap+ordered-float-devel}"
SRC_URI[x86_64_v2_rust-radix-heap+ordered-float-devel.sha256sum] = "b0297a9dc6f7ee90f6a6a62ec2547afc7517c6ab56c4808f5c3020c4cd0572b7"

URI_x86_64_v2_rust-radix-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radix-heap-devel-0.4.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radix-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-radix-heap-devel}"
SRC_URI[x86_64_v2_rust-radix-heap-devel.sha256sum] = "0cb1692ab93eeea7d8d14e5e88dc16c085a9c821def22b221f37dd08e9595454"

URI_aarch64_rust-radix-heap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-radix-heap+default-devel-0.4.2-6.el10_0.noarch.rpm;name=aarch64_rust-radix-heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-radix-heap+default-devel}"
SRC_URI[aarch64_rust-radix-heap+default-devel.sha256sum] = "9390a65ced20b9310a868b3cbdd8e2a29223bf52f62652132969fea95361bffa"

URI_aarch64_rust-radix-heap+ordered-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-radix-heap+ordered-float-devel-0.4.2-6.el10_0.noarch.rpm;name=aarch64_rust-radix-heap+ordered-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-radix-heap+ordered-float-devel}"
SRC_URI[aarch64_rust-radix-heap+ordered-float-devel.sha256sum] = "6c06de85c14ae86be8900e637b02fd2898b320f538b4ed483f8289b79db9ea09"

URI_aarch64_rust-radix-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-radix-heap-devel-0.4.2-6.el10_0.noarch.rpm;name=aarch64_rust-radix-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-radix-heap-devel}"
SRC_URI[aarch64_rust-radix-heap-devel.sha256sum] = "0697db2a1411893b5d7331f7e64c1046feec7eb27463ee34dcbc70d04e26fc35"

RDEPENDS:rust-radix-heap+default-devel = " \
 cargo \
 rust-radix-heap-devel \
 "
RDEPENDS:rust-radix-heap+ordered-float-devel = " \
 cargo \
 rust-ordered-float2+default-devel \
 rust-radix-heap-devel \
 "
RDEPENDS:rust-radix-heap-devel = " \
 cargo \
 "
