# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-notes"
PV = "24.08.3"
PR = "1.el10_0"
PACKAGES = " \
 akonadi-notes \
 akonadi-notes-devel \
 akonadi-notes-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akonadi-notes-24.08.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cba5e628921049323658b64a260b8e8f5a42d268148b041c28da9b48f2ab51e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-notes-24.08.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-notes;unpack=0"
SRC_URI[x86_64_v2_akonadi-notes.sha256sum] = "95932d82c80aea280b6d813762ff62d46b0cd77474eb5ee91bcf4b9ed118bd1d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-notes-devel-24.08.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-notes-devel;unpack=0"
SRC_URI[x86_64_v2_akonadi-notes-devel.sha256sum] = "2c7e26abb9970ce690ec7209cd52ebc4189a5ac68c3664445dc505726f9b3634"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-notes-doc-24.08.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-notes-doc;unpack=0"
SRC_URI[x86_64_v2_akonadi-notes-doc.sha256sum] = "e0f6787f89b0987301b3d097eb922625c76fc31d7788970e8bf510e3e0fe9fdf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-notes-24.08.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-notes;unpack=0"
SRC_URI[aarch64_akonadi-notes.sha256sum] = "f3fe3bde9816d4ea54c9e77745efeaad3e4386033fe8879e9fac9375a54316a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-notes-devel-24.08.3-1.el10_0.aarch64.rpm;name=aarch64_akonadi-notes-devel;unpack=0"
SRC_URI[aarch64_akonadi-notes-devel.sha256sum] = "2b5fedc3dcaaf4d051fa7c9726d2329f7b009b6f509bb4df0e0025c3317feb5b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-notes-doc-24.08.3-1.el10_0.noarch.rpm;name=aarch64_akonadi-notes-doc;unpack=0"
SRC_URI[aarch64_akonadi-notes-doc.sha256sum] = "82ff269e4c3b53893ca59040631a872daecb340aac6588351c908102895602d9"

RDEPENDS:akonadi-notes = " \
 glibc \
 kf6-ki18n \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:akonadi-notes-devel = " \
 akonadi-notes \
 cmake-filesystem \
 kmime-devel \
 "
RDEPENDS:akonadi-notes-doc = " \
 "
