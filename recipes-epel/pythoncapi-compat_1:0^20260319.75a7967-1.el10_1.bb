# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pythoncapi-compat"
PE = "1"
PV = "0^20260319.75a7967"
PR = "1.el10_1"
PACKAGES = " \
 pythoncapi-compat-devel \
 pythoncapi-compat-doc \
 pythoncapi-compat-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pythoncapi-compat-0^20260319.75a7967-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25693525622f1aacbd9adb2621caf96baf0bcaf2c9a47dcf054584b52fb4b185"

URI_x86_64_v2_pythoncapi-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-devel-0^20260319.75a7967-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-devel}"
SRC_URI[x86_64_v2_pythoncapi-compat-devel.sha256sum] = "99fbeda399a83b4baf5da3e70397067b0f8de8419a88eca8fbe8387e54cbac33"

URI_x86_64_v2_pythoncapi-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-doc-0^20260319.75a7967-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-doc}"
SRC_URI[x86_64_v2_pythoncapi-compat-doc.sha256sum] = "bf32d6d84dfa3c28efe95f9bade40b029fc8ca060746d82ec2d2b05c0213e0e9"

URI_x86_64_v2_pythoncapi-compat-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-tools-0^20260319.75a7967-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-tools}"
SRC_URI[x86_64_v2_pythoncapi-compat-tools.sha256sum] = "e1a257953c5910031237b19243ecb6443c513c729869d52e14b3962c114b9098"

URI_aarch64_pythoncapi-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-devel-0^20260319.75a7967-1.el10_1.noarch.rpm;name=aarch64_pythoncapi-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-devel}"
SRC_URI[aarch64_pythoncapi-compat-devel.sha256sum] = "407ef0c00ce3d494f08af32019e6b2d0f05322afae561eae6924068bd22d45d0"

URI_aarch64_pythoncapi-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-doc-0^20260319.75a7967-1.el10_1.noarch.rpm;name=aarch64_pythoncapi-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-doc}"
SRC_URI[aarch64_pythoncapi-compat-doc.sha256sum] = "5abb8b56ddcbcdb4840a97d46576efbb7edda393945654b4bd423fa3029f8d7f"

URI_aarch64_pythoncapi-compat-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-tools-0^20260319.75a7967-1.el10_1.noarch.rpm;name=aarch64_pythoncapi-compat-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-tools}"
SRC_URI[aarch64_pythoncapi-compat-tools.sha256sum] = "d34047856f4b3ee0673f8cb2621ba53231d7248a5cb15756d462b8de598afa76"

RDEPENDS:pythoncapi-compat-devel = " \
 "
RDEPENDS:pythoncapi-compat-doc = " \
 "
RDEPENDS:pythoncapi-compat-tools = " \
 python3 \
 "
