# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-salsa20"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-salsa20+default-devel \
 rust-salsa20+zeroize-devel \
 rust-salsa20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-salsa20-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2029c59c15b133ea66fdaa434bb9dfa0c0730b976f2853a9b33b18a19814df00"

URI_x86_64_v2_rust-salsa20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20+default-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20+default-devel}"
SRC_URI[x86_64_v2_rust-salsa20+default-devel.sha256sum] = "cd099c8ab258ffd3b4a0d51ccfe6fd80d4943580713ed3cf1175c7dfafe5c7ce"

URI_x86_64_v2_rust-salsa20+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20+zeroize-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20+zeroize-devel}"
SRC_URI[x86_64_v2_rust-salsa20+zeroize-devel.sha256sum] = "9890c36069873a04c3dabc3e6f6c28f88b469ba235b75a4ee0f433cf6bf2fcdd"

URI_x86_64_v2_rust-salsa20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-salsa20-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-salsa20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-salsa20-devel}"
SRC_URI[x86_64_v2_rust-salsa20-devel.sha256sum] = "20e08a16ad92a9e232d4db3b535808e4ca3c3a157b81e74fee7b533f9e861d4b"

URI_aarch64_rust-salsa20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20+default-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-salsa20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20+default-devel}"
SRC_URI[aarch64_rust-salsa20+default-devel.sha256sum] = "7001699804039a3a38246b74c5ada673ed71dfb69c9518fe2c563b8f4d32b5a7"

URI_aarch64_rust-salsa20+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20+zeroize-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-salsa20+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20+zeroize-devel}"
SRC_URI[aarch64_rust-salsa20+zeroize-devel.sha256sum] = "a791b771c3330263d512a06129906be48e678d0c7903449d7915a3e2474e6ed0"

URI_aarch64_rust-salsa20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-salsa20-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-salsa20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-salsa20-devel}"
SRC_URI[aarch64_rust-salsa20-devel.sha256sum] = "5bde1c67e2eb2ce0cd0abc5defb9fd26c1ecad9e3b0adbe1b39c8e23d1eee781"

RDEPENDS:rust-salsa20+default-devel = " \
 cargo \
 rust-salsa20-devel \
 "
RDEPENDS:rust-salsa20+zeroize-devel = " \
 cargo \
 rust-cipher+zeroize-devel \
 rust-salsa20-devel \
 "
RDEPENDS:rust-salsa20-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cipher+default-devel \
 rust-cipher+stream-wrapper-devel \
 "
