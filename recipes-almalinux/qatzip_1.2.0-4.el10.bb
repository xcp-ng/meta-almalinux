# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatzip"
PV = "1.2.0"
PR = "4.el10"
PACKAGES:x86_64_v2 = " \
 qatzip \
 qatzip-devel \
 qatzip-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatzip-1.2.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca80dad6b4499f6b472233214e7ea549fb3947dbbb75baf311d364d775cfe91f"

URI_x86_64_v2_qatzip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatzip-1.2.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatzip}"
SRC_URI[x86_64_v2_qatzip.sha256sum] = "f2ea1fe51053781fcea667c510f679410f75e1db43990bbb26e7be536e2cb3d8"

URI_x86_64_v2_qatzip-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatzip-devel-1.2.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatzip-devel}"
SRC_URI[x86_64_v2_qatzip-devel.sha256sum] = "ee522b84e1f8bba324e9c2226ed3aeba44beccf604b3fa11aed6a0f932fb58e9"

URI_x86_64_v2_qatzip-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatzip-libs-1.2.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatzip-libs}"
SRC_URI[x86_64_v2_qatzip-libs.sha256sum] = "9a143cf3b758235e1f24a9a9bd99bbadef9a2f7c0207f35493cc0d9540a12881"

RDEPENDS:qatzip = " \
 glibc \
 lz4-libs \
 qatlib \
 zlib-ng-compat \
 "
RDEPENDS:qatzip-devel = " \
 lz4-devel \
 pkgconf-pkg-config \
 qatzip-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:qatzip-libs = " \
 glibc \
 lz4-libs \
 qatlib \
 zlib-ng-compat \
 "
