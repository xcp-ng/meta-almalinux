# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kubrick"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kubrick \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kubrick-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d6ca54f97f0f2bc073d3cffd7888c100b640be1c2403a513d3226f4f923782ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kubrick-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kubrick;unpack=0"
SRC_URI[x86_64_v2_kubrick.sha256sum] = "e2e39f37bc69c9a153f1ea429b127665d70d57b42ec9f1c07342373e1c582516"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kubrick-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kubrick;unpack=0"
SRC_URI[aarch64_kubrick.sha256sum] = "f1ccf0278ab597be2768932f448b43ed95e30665072424ec35a4aadc325b0e65"

RDEPENDS:kubrick = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libglvnd-opengl \
 libkdegames \
 libstdc++ \
 mesa-libGLU \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
