# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpsl"
PV = "0.21.5"
PR = "6.el10"
PACKAGES = " \
 libpsl \
 libpsl-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libpsl-0.21.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bd5e5d4ef48803aee49fe47dee5b991f14cbc3eb11fce80e150b706f62a5fec"

URI_x86_64_v2_libpsl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpsl-0.21.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_libpsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpsl}"
SRC_URI[x86_64_v2_libpsl.sha256sum] = "1d1f4ba5ec8632991cd89ff539b7d32b16d5acd2c5162e9c6f9e1e125a59f579"

URI_x86_64_v2_libpsl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpsl-devel-0.21.5-6.el10.x86_64_v2.rpm;name=x86_64_v2_libpsl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpsl-devel}"
SRC_URI[x86_64_v2_libpsl-devel.sha256sum] = "2780d66e3446e153db427be5d7201248658b4681bc48c162592382e51a59395c"

URI_aarch64_libpsl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpsl-0.21.5-6.el10.aarch64.rpm;name=aarch64_libpsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpsl}"
SRC_URI[aarch64_libpsl.sha256sum] = "d181e730e2b094cd024f117dc1eb70f197c190314911319e0b5f69168005dcbc"

URI_aarch64_libpsl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpsl-devel-0.21.5-6.el10.aarch64.rpm;name=aarch64_libpsl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpsl-devel}"
SRC_URI[aarch64_libpsl-devel.sha256sum] = "4b8d93d5955f4fb2862426710091014f13ad9d1e5b9c26eaec317280769d39a6"

RDEPENDS:libpsl = " \
 glibc \
 libidn2 \
 libunistring \
 publicsuffix-list-dafsa \
 "
RDEPENDS:libpsl-devel = " \
 libpsl \
 pkgconf-pkg-config \
 publicsuffix-list \
 "
