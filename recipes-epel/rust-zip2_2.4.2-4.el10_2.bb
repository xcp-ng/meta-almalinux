# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zip2"
PV = "2.4.2"
PR = "4.el10_2"
PACKAGES = " \
 rust-zip2+_all-features-devel \
 rust-zip2+_deflate-any-devel \
 rust-zip2+aes-crypto-devel \
 rust-zip2+aes-devel \
 rust-zip2+bzip2-devel \
 rust-zip2+chrono-devel \
 rust-zip2+constant_time_eq-devel \
 rust-zip2+default-devel \
 rust-zip2+deflate-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2+deflate-miniz-devel \
 rust-zip2+deflate-zlib-devel \
 rust-zip2+deflate-zlib-ng-devel \
 rust-zip2+deflate-zopfli-devel \
 rust-zip2+deflate64-devel \
 rust-zip2+flate2-devel \
 rust-zip2+getrandom-devel \
 rust-zip2+hmac-devel \
 rust-zip2+lzma-devel \
 rust-zip2+lzma-rs-devel \
 rust-zip2+pbkdf2-devel \
 rust-zip2+sha1-devel \
 rust-zip2+time-devel \
 rust-zip2+unreserved-devel \
 rust-zip2+xz-devel \
 rust-zip2+zeroize-devel \
 rust-zip2+zopfli-devel \
 rust-zip2+zstd-devel \
 rust-zip2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zip2-2.4.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76d6056a53d321d8c1bce50ab5f8b95ba51dd85b4f062792714b6c4bd8fc55c9"

URI_x86_64_v2_rust-zip2+_all-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+_all-features-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+_all-features-devel}"
SRC_URI[x86_64_v2_rust-zip2+_all-features-devel.sha256sum] = "61518209f4ac9ac0d1b85d3fd85cfc2f49880358a7406aa4c021f2cc69947a8e"

URI_x86_64_v2_rust-zip2+_deflate-any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+_deflate-any-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+_deflate-any-devel}"
SRC_URI[x86_64_v2_rust-zip2+_deflate-any-devel.sha256sum] = "f494559a1c774832c39dcc856801baf699be5e4aeb3395aade5c5d90208c4c80"

URI_x86_64_v2_rust-zip2+aes-crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+aes-crypto-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+aes-crypto-devel}"
SRC_URI[x86_64_v2_rust-zip2+aes-crypto-devel.sha256sum] = "485cea2bab49e1faa5ce0e511ffeac5e60b38ec3f7ca94dd75c78baa504e2034"

URI_x86_64_v2_rust-zip2+aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+aes-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+aes-devel}"
SRC_URI[x86_64_v2_rust-zip2+aes-devel.sha256sum] = "e901150de5995c90f4a997328306a964b354278e310933497e3d2550e9938b1d"

URI_x86_64_v2_rust-zip2+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+bzip2-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+bzip2-devel}"
SRC_URI[x86_64_v2_rust-zip2+bzip2-devel.sha256sum] = "65fba17811124ec189dffc0468444bab1b50e28f9eb1eeddab1b7be72fe9e3bb"
RPROVIDES:rust-zip2+bzip2-devel:x86_64_v2 = "virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_8.0.0~"

URI_x86_64_v2_rust-zip2+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+chrono-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+chrono-devel}"
SRC_URI[x86_64_v2_rust-zip2+chrono-devel.sha256sum] = "265c452dbc198970e7c7290258b4383f3e418c2ca6a4b9239a8d550d09e60082"

URI_x86_64_v2_rust-zip2+constant_time_eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+constant_time_eq-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+constant_time_eq-devel}"
SRC_URI[x86_64_v2_rust-zip2+constant_time_eq-devel.sha256sum] = "0dbccf610bd312d746637025402047f5692c3b55e64f26f82ba9f315a700aaad"

URI_x86_64_v2_rust-zip2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+default-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+default-devel}"
SRC_URI[x86_64_v2_rust-zip2+default-devel.sha256sum] = "1dd26d3b871e8d4ee3cd8ad63ccd72641a0992ed170ab0f34030cd0773dbe6aa"

URI_x86_64_v2_rust-zip2+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-devel.sha256sum] = "588ba961042b5331cdf7ac50bb3b780afb8a8a920bdb1650af3dec153f8633a1"
RPROVIDES:rust-zip2+deflate-devel:x86_64_v2 = "virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_8.0.0~"

URI_x86_64_v2_rust-zip2+deflate-flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-flate2-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-flate2-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-flate2-devel.sha256sum] = "a6c0164e0dde5c4e6440b850cec3fb4719a97ce7157f1e3fab8cf4870e26fd2f"

URI_x86_64_v2_rust-zip2+deflate-miniz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-miniz-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-miniz-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-miniz-devel.sha256sum] = "de38fa1cef0089d90abde1fdd6150340db6f5aee8c77bd4851c2409efb623490"

URI_x86_64_v2_rust-zip2+deflate-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-zlib-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-zlib-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-zlib-devel.sha256sum] = "7e8bc21c58880177c48a14aa593d7a958e3b155e7aeea23f4baa9a801e3957ec"

URI_x86_64_v2_rust-zip2+deflate-zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-zlib-ng-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-zlib-ng-devel.sha256sum] = "ca2f66f5f75019bd75105df07477aaa5e4b9235639199f335f6f44c93b51db8b"

URI_x86_64_v2_rust-zip2+deflate-zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate-zopfli-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate-zopfli-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate-zopfli-devel.sha256sum] = "78dba80b3e49f0c7b87bb6d6a6d261d93f64661e46b405b39b8b5d9eb7969db2"

URI_x86_64_v2_rust-zip2+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+deflate64-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+deflate64-devel}"
SRC_URI[x86_64_v2_rust-zip2+deflate64-devel.sha256sum] = "73db577bca8178b00499e8c1680b4681f429010306f51a469470a3630e6da339"

URI_x86_64_v2_rust-zip2+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+flate2-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+flate2-devel}"
SRC_URI[x86_64_v2_rust-zip2+flate2-devel.sha256sum] = "c89ae03e3203ffde2bac509137f47b06bc0946fda0086a75dc35e274eb4004a1"

URI_x86_64_v2_rust-zip2+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+getrandom-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+getrandom-devel}"
SRC_URI[x86_64_v2_rust-zip2+getrandom-devel.sha256sum] = "391f2985571a2c4cd5f6726bbdcd95b9bfeac755e558c581c594f2474c511e73"

URI_x86_64_v2_rust-zip2+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+hmac-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+hmac-devel}"
SRC_URI[x86_64_v2_rust-zip2+hmac-devel.sha256sum] = "37f067048a8d4d9e18acb4bede5e113d563a387c6ac26d3d83f9fa481d749167"

URI_x86_64_v2_rust-zip2+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+lzma-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+lzma-devel}"
SRC_URI[x86_64_v2_rust-zip2+lzma-devel.sha256sum] = "abdc088bcffd5112f37c3f7b9af4f00a3b4d7930b2369552f344a896ac146734"

URI_x86_64_v2_rust-zip2+lzma-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+lzma-rs-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+lzma-rs-devel}"
SRC_URI[x86_64_v2_rust-zip2+lzma-rs-devel.sha256sum] = "4e2c62a8db00df0b7737b43650ef157a5ef6ee3e542d394feacfb429142ec558"

URI_x86_64_v2_rust-zip2+pbkdf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+pbkdf2-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+pbkdf2-devel}"
SRC_URI[x86_64_v2_rust-zip2+pbkdf2-devel.sha256sum] = "4720ad538acb884a689a2f08d919b9023519b2c04ddf0d46e189bea9278ef0c4"

URI_x86_64_v2_rust-zip2+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+sha1-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+sha1-devel}"
SRC_URI[x86_64_v2_rust-zip2+sha1-devel.sha256sum] = "a8e3819c8899a202bc8db3d4b8efadb859283de7a866a5a0b5a696834a86e0de"

URI_x86_64_v2_rust-zip2+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+time-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+time-devel}"
SRC_URI[x86_64_v2_rust-zip2+time-devel.sha256sum] = "43d0ea774b581fbb54e25057c0710f90a742012ee481550c753bb0a52d493662"

URI_x86_64_v2_rust-zip2+unreserved-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+unreserved-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+unreserved-devel}"
SRC_URI[x86_64_v2_rust-zip2+unreserved-devel.sha256sum] = "e06fa7e781baa285415d2ea696e0c21a729de86d6252d0e4a49c91e3c1f6eb7f"

URI_x86_64_v2_rust-zip2+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+xz-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+xz-devel}"
SRC_URI[x86_64_v2_rust-zip2+xz-devel.sha256sum] = "3a8eeb2fcd507ad133ec583800777612a1d0e751b556a25c7005b266dadda01c"

URI_x86_64_v2_rust-zip2+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+zeroize-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+zeroize-devel}"
SRC_URI[x86_64_v2_rust-zip2+zeroize-devel.sha256sum] = "70504af5d0c587af38255968eb813bdabedf8804416ba878423da6ac89784186"

URI_x86_64_v2_rust-zip2+zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+zopfli-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+zopfli-devel}"
SRC_URI[x86_64_v2_rust-zip2+zopfli-devel.sha256sum] = "3355944258cdb6cdf9d39a52be83d1c7063994a7735615d10035f0ea75a5b3c4"

URI_x86_64_v2_rust-zip2+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2+zstd-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2+zstd-devel}"
SRC_URI[x86_64_v2_rust-zip2+zstd-devel.sha256sum] = "c9eae844b5a44e927486c99d5f9dda9d9dc404fa0d2dd8606c2000ee46f14c04"

URI_x86_64_v2_rust-zip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip2-devel-2.4.2-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip2-devel}"
SRC_URI[x86_64_v2_rust-zip2-devel.sha256sum] = "e8993e0d2a130d920067da9945d8163add87f3df7c2b449ed465e67e0dd03aed"
RPROVIDES:rust-zip2-devel:x86_64_v2 = "virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_8.0.0~"

URI_aarch64_rust-zip2+_all-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+_all-features-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+_all-features-devel}"
SRC_URI[aarch64_rust-zip2+_all-features-devel.sha256sum] = "3679fc90449312c92867d206ae649f62ebbb61c7e56affd52f097c484caf04dc"

URI_aarch64_rust-zip2+_deflate-any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+_deflate-any-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+_deflate-any-devel}"
SRC_URI[aarch64_rust-zip2+_deflate-any-devel.sha256sum] = "9bc3d0f3ebb09f1a7190918fcd83860969263490e4c82f6d90398c3ed66f8c8b"

URI_aarch64_rust-zip2+aes-crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+aes-crypto-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+aes-crypto-devel}"
SRC_URI[aarch64_rust-zip2+aes-crypto-devel.sha256sum] = "568161fbeb5073b6067fc7ce5094db783b29498661e6f4ad5e437faab58d4035"

URI_aarch64_rust-zip2+aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+aes-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+aes-devel}"
SRC_URI[aarch64_rust-zip2+aes-devel.sha256sum] = "47a1d8700371a701aea3e272069d04d6f25becfc213ea4c338438064abff8f92"

URI_aarch64_rust-zip2+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+bzip2-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+bzip2-devel}"
SRC_URI[aarch64_rust-zip2+bzip2-devel.sha256sum] = "399ae50193ed55fc9fbf14f83ce26d6742b603ebad1d14b3bfcb0f228d09b4a1"
RPROVIDES:rust-zip2+bzip2-devel:aarch64 = "virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_8.0.0~"

URI_aarch64_rust-zip2+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+chrono-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+chrono-devel}"
SRC_URI[aarch64_rust-zip2+chrono-devel.sha256sum] = "ba7756af3441289de3983f14f8f028134390f29cb1e2284c85b1c3a6fdbbbfb3"

URI_aarch64_rust-zip2+constant_time_eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+constant_time_eq-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+constant_time_eq-devel}"
SRC_URI[aarch64_rust-zip2+constant_time_eq-devel.sha256sum] = "cfd80d53d937cda60c8e1f5d434e4bd3995c92b3b94daef617643210aa6a8430"

URI_aarch64_rust-zip2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+default-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+default-devel}"
SRC_URI[aarch64_rust-zip2+default-devel.sha256sum] = "6ede66b29bc70497997da89e3f2161fae2919b871a8b060b7583a76d9b713c78"

URI_aarch64_rust-zip2+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-devel}"
SRC_URI[aarch64_rust-zip2+deflate-devel.sha256sum] = "4dabbf47a04bc72473104229c7af43f5944f9d2fd28b3e256dfa26098e08e74f"
RPROVIDES:rust-zip2+deflate-devel:aarch64 = "virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_8.0.0~"

URI_aarch64_rust-zip2+deflate-flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-flate2-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-flate2-devel}"
SRC_URI[aarch64_rust-zip2+deflate-flate2-devel.sha256sum] = "4ec13f0c8f579e4c3db0203a66887ee261ecd62370be914813beb7277478d4a0"

URI_aarch64_rust-zip2+deflate-miniz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-miniz-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+deflate-miniz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-miniz-devel}"
SRC_URI[aarch64_rust-zip2+deflate-miniz-devel.sha256sum] = "3457fdae8418f0f194a5c656fa40c0006c3aac6bad3b6b22174fd77871c3baa1"

URI_aarch64_rust-zip2+deflate-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-zlib-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+deflate-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-zlib-devel}"
SRC_URI[aarch64_rust-zip2+deflate-zlib-devel.sha256sum] = "70a23701ca03a72938828429167aee914f9820d6c626cf924fd99ca8dc86abb1"

URI_aarch64_rust-zip2+deflate-zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-zlib-ng-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+deflate-zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-zlib-ng-devel}"
SRC_URI[aarch64_rust-zip2+deflate-zlib-ng-devel.sha256sum] = "f5be7629bbe5dcc7ab5028c341ca103b36b69ac0141943c15ff909f1e706d4b6"

URI_aarch64_rust-zip2+deflate-zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate-zopfli-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate-zopfli-devel}"
SRC_URI[aarch64_rust-zip2+deflate-zopfli-devel.sha256sum] = "5abb6f67121a6151ed46a646cd94291184d038c59a35ca49fa7385328e2bc7bf"

URI_aarch64_rust-zip2+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+deflate64-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+deflate64-devel}"
SRC_URI[aarch64_rust-zip2+deflate64-devel.sha256sum] = "1a508ddf711a5513d6fc4ba9661f621f5467c284657bf7610a5adcc149622ff3"

URI_aarch64_rust-zip2+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+flate2-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+flate2-devel}"
SRC_URI[aarch64_rust-zip2+flate2-devel.sha256sum] = "52b4cd267b265081472e9a718a24bd8238c61cc8a342d1ff94bcbaa394740b42"

URI_aarch64_rust-zip2+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+getrandom-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+getrandom-devel}"
SRC_URI[aarch64_rust-zip2+getrandom-devel.sha256sum] = "7900ae81403ad7807eda5e24d7e09d40535f7e87a7b653afbee8156e29c4d188"

URI_aarch64_rust-zip2+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+hmac-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+hmac-devel}"
SRC_URI[aarch64_rust-zip2+hmac-devel.sha256sum] = "1e34b1c5baf5ac5a1052bab04fe7a9b5052be2579f0bd48c2e9b142959d7aa86"

URI_aarch64_rust-zip2+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+lzma-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+lzma-devel}"
SRC_URI[aarch64_rust-zip2+lzma-devel.sha256sum] = "7d664d1acd2ec2788fb3449aa713edebedaf5f5b2a60c5791b3a4aa0ca13b243"

URI_aarch64_rust-zip2+lzma-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+lzma-rs-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+lzma-rs-devel}"
SRC_URI[aarch64_rust-zip2+lzma-rs-devel.sha256sum] = "404088a19b87138a368f2bb3ac21aa4d50a90d9a2c333e82657c5f86df113d02"

URI_aarch64_rust-zip2+pbkdf2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+pbkdf2-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+pbkdf2-devel}"
SRC_URI[aarch64_rust-zip2+pbkdf2-devel.sha256sum] = "60ef5eead1b27047fa06db183e520201507cc9b069c809b172364337c229b388"

URI_aarch64_rust-zip2+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+sha1-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+sha1-devel}"
SRC_URI[aarch64_rust-zip2+sha1-devel.sha256sum] = "87783a16e988ee0811bfaf99129ed2b4a8cc0d0f869fe57a58c4908d064a1719"

URI_aarch64_rust-zip2+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+time-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+time-devel}"
SRC_URI[aarch64_rust-zip2+time-devel.sha256sum] = "24fa4912bccfd1128677685273a5487b3cf69905918f031121dbc2a7c09a188f"

URI_aarch64_rust-zip2+unreserved-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+unreserved-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+unreserved-devel}"
SRC_URI[aarch64_rust-zip2+unreserved-devel.sha256sum] = "c6d9d533311174c8b20a97f3786c16508b3fa2de549139d49f5187cc52582089"

URI_aarch64_rust-zip2+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+xz-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+xz-devel}"
SRC_URI[aarch64_rust-zip2+xz-devel.sha256sum] = "55083aa1be8171c01f060a11a0b05a4cb0a490e86df0e5742aa5f334bc83fb00"

URI_aarch64_rust-zip2+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+zeroize-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+zeroize-devel}"
SRC_URI[aarch64_rust-zip2+zeroize-devel.sha256sum] = "571028c869464091d80c6e492a1809b02d8f00f631669150b97de033388b91f2"

URI_aarch64_rust-zip2+zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+zopfli-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+zopfli-devel}"
SRC_URI[aarch64_rust-zip2+zopfli-devel.sha256sum] = "7c71d8c1579ef9e51676c7b36a4971b027df069848e8340c3626f060fb37bba2"

URI_aarch64_rust-zip2+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2+zstd-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2+zstd-devel}"
SRC_URI[aarch64_rust-zip2+zstd-devel.sha256sum] = "558a1765045a36e4f21834217810ee3fa795ecac26886d064c39c171fcef986d"

URI_aarch64_rust-zip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip2-devel-2.4.2-4.el10_2.noarch.rpm;name=aarch64_rust-zip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip2-devel}"
SRC_URI[aarch64_rust-zip2-devel.sha256sum] = "44c8c09b340e80c47f51a20de3b2236c51fa1afcdf308ee1c3d50ee2fb644b6c"
RPROVIDES:rust-zip2-devel:aarch64 = "virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_8.0.0~"

RDEPENDS:rust-zip2+_all-features-devel = " \
 cargo \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+_deflate-any-devel = " \
 cargo \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+aes-crypto-devel = " \
 cargo \
 rust-zip2+aes-devel \
 rust-zip2+constant_time_eq-devel \
 rust-zip2+getrandom-devel \
 rust-zip2+hmac-devel \
 rust-zip2+pbkdf2-devel \
 rust-zip2+sha1-devel \
 rust-zip2+zeroize-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+aes-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+chrono-devel = " \
 cargo \
 rust-chrono+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+constant_time_eq-devel = " \
 cargo \
 rust-constant_time_eq+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+default-devel = " \
 cargo \
 rust-zip2+aes-crypto-devel \
 rust-zip2+bzip2-devel \
 rust-zip2+deflate-devel \
 rust-zip2+deflate64-devel \
 rust-zip2+lzma-devel \
 rust-zip2+time-devel \
 rust-zip2+xz-devel \
 rust-zip2+zstd-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-devel = " \
 cargo \
 rust-flate2+rust_backend-devel \
 rust-flate2-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2+deflate-zopfli-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-flate2-devel = " \
 cargo \
 rust-zip2+_deflate-any-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-miniz-devel = " \
 cargo \
 rust-zip2+deflate-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-zlib-devel = " \
 cargo \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-zlib-ng-devel = " \
 cargo \
 rust-flate2+zlib-ng-devel \
 rust-flate2-devel \
 rust-zip2+deflate-flate2-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate-zopfli-devel = " \
 cargo \
 rust-zip2+_deflate-any-devel \
 rust-zip2+zopfli-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+deflate64-devel = " \
 cargo \
 rust-deflate64+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+flate2-devel = " \
 cargo \
 rust-flate2-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+getrandom-devel = " \
 cargo \
 rust-getrandom0.3+default-devel \
 rust-getrandom0.3+std-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+hmac-devel = " \
 cargo \
 rust-hmac+default-devel \
 rust-hmac+reset-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+lzma-devel = " \
 cargo \
 rust-lzma-rs+stream-devel \
 rust-lzma-rs-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+lzma-rs-devel = " \
 cargo \
 rust-lzma-rs-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+pbkdf2-devel = " \
 cargo \
 rust-pbkdf2+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+sha1-devel = " \
 cargo \
 rust-sha1+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+time-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+unreserved-devel = " \
 cargo \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+xz-devel = " \
 cargo \
 rust-xz2+default-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+zeroize-devel = " \
 cargo \
 rust-zeroize+default-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zip2-devel \
 "
RDEPENDS:rust-zip2+zopfli-devel = " \
 cargo \
 rust-zip2-devel \
 rust-zopfli+default-devel \
 "
RDEPENDS:rust-zip2+zstd-devel = " \
 cargo \
 rust-zip2-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-zip2-devel = " \
 cargo \
 rust \
 rust-crc32fast+default-devel \
 rust-displaydoc-devel \
 rust-indexmap+default-devel \
 rust-memchr+default-devel \
 rust-thiserror+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_8.0.0~ rpm/virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_8.0.0~ rpm/virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_8.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_8.0.0~ rpm/virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_8.0.0~ rpm/virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_8.0.0~"
