# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openldap"
PV = "2.6.10"
PR = "1.el10"
PACKAGES = " \
 openldap \
 openldap-clients \
 openldap-compat \
 openldap-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openldap-2.6.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "975ae537d44e1aa22a52707b9070d26f2ed0092d1f5d4ef9a9d2d14d179f2d2c"

URI_x86_64_v2_openldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-2.6.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap}"
SRC_URI[x86_64_v2_openldap.sha256sum] = "4edfe1a1b929a71e2a79affd1fd5db0b403e4d18b111ce757f1b46f0497d5e6c"

URI_x86_64_v2_openldap-clients = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-clients-2.6.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-clients}"
SRC_URI[x86_64_v2_openldap-clients.sha256sum] = "bd0196fcb0e2db7be125d3e8538ff2c916d1d6c342ed8617deb9410ddde92d8b"

URI_x86_64_v2_openldap-compat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-compat-2.6.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-compat}"
SRC_URI[x86_64_v2_openldap-compat.sha256sum] = "6d3077ec0c678e60f7e1166c1ecc778143856383da25e028c6c70dba37c25ba3"

URI_x86_64_v2_openldap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openldap-devel-2.6.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-devel}"
SRC_URI[x86_64_v2_openldap-devel.sha256sum] = "02102119ecb4c52303cbbee26c42cb31617d6c370950ab625ca0fffd9389333a"

URI_aarch64_openldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-2.6.10-1.el10.aarch64.rpm;name=aarch64_openldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap}"
SRC_URI[aarch64_openldap.sha256sum] = "c052643c2f0cc79e215085fa39ca157fdc92ab0e0663718278670315c7518da9"

URI_aarch64_openldap-clients = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-clients-2.6.10-1.el10.aarch64.rpm;name=aarch64_openldap-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-clients}"
SRC_URI[aarch64_openldap-clients.sha256sum] = "34402f6a83d805b561b1cbc2bfdede584f87a09de54a8d7260e33922c43d0f35"

URI_aarch64_openldap-compat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-compat-2.6.10-1.el10.aarch64.rpm;name=aarch64_openldap-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-compat}"
SRC_URI[aarch64_openldap-compat.sha256sum] = "b3632d69e1ae3b3b4e68c5b4e2ab000038695fc86467bf3555b7b92cee989edd"

URI_aarch64_openldap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openldap-devel-2.6.10-1.el10.aarch64.rpm;name=aarch64_openldap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-devel}"
SRC_URI[aarch64_openldap-devel.sha256sum] = "cb734591b3748e856a53296b25f998e7daee14fd82268f48b1711f271b7435e0"

RDEPENDS:openldap = " \
 cyrus-sasl-lib \
 glibc \
 libevent \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:openldap-clients = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 "
RDEPENDS:openldap-compat = " \
 glibc \
 openldap \
 "
RDEPENDS:openldap-devel = " \
 cyrus-sasl-devel \
 openldap \
 openldap-devel \
 pkgconf-pkg-config \
 "
