# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "redhat-fonts"
PV = "4.1.0"
PR = "1.el10"
PACKAGES = " \
 redhat-display-fonts \
 redhat-display-vf-fonts \
 redhat-mono-fonts \
 redhat-mono-vf-fonts \
 redhat-text-fonts \
 redhat-text-vf-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/redhat-fonts-4.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14105523ca287ecc5b8e6fb417beb0c683d6f8a96445d1f9b376b21fa993ebc8"

URI_x86_64_v2_redhat-display-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-display-fonts-4.1.0-1.el10.noarch.rpm;name=x86_64_v2_redhat-display-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-display-fonts}"
SRC_URI[x86_64_v2_redhat-display-fonts.sha256sum] = "53a0dd0ddde918ca7f9f9392aa16bbcfff5481c1e1bfd8bf949da267765e100d"
RPROVIDES:redhat-display-fonts:append:x86_64_v2 = " virtual/font_redhatdisplay_"

URI_x86_64_v2_redhat-display-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-display-vf-fonts-4.1.0-1.el10.noarch.rpm;name=x86_64_v2_redhat-display-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-display-vf-fonts}"
SRC_URI[x86_64_v2_redhat-display-vf-fonts.sha256sum] = "17765fc6a6a0c3d126ae7369184298c9f9425d83aab2a7e0dcbcbe4852b29679"
RPROVIDES:redhat-display-vf-fonts:append:x86_64_v2 = " virtual/font_redhatdisplay_"

URI_x86_64_v2_redhat-mono-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-mono-fonts-4.1.0-1.el10.noarch.rpm;name=x86_64_v2_redhat-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-mono-fonts}"
SRC_URI[x86_64_v2_redhat-mono-fonts.sha256sum] = "3674bc1ef134cd1c43e53915c984d1444b9f8a3772a0d6dbd7a481664a255688"

URI_x86_64_v2_redhat-mono-vf-fonts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/redhat-mono-vf-fonts-4.1.0-1.el10.noarch.rpm;name=x86_64_v2_redhat-mono-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-mono-vf-fonts}"
SRC_URI[x86_64_v2_redhat-mono-vf-fonts.sha256sum] = "969ab2fa29f673a3155030928cd4ac36602c3d3c7462f49e75b6c2947950b0b6"

URI_x86_64_v2_redhat-text-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-text-fonts-4.1.0-1.el10.noarch.rpm;name=x86_64_v2_redhat-text-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-text-fonts}"
SRC_URI[x86_64_v2_redhat-text-fonts.sha256sum] = "a849c57fb18bd245cc1b7ac58f523c8a0f63bb601dac90814f8b1a2c571fdd49"
RPROVIDES:redhat-text-fonts:append:x86_64_v2 = " virtual/font_redhattext_"

URI_x86_64_v2_redhat-text-vf-fonts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/redhat-text-vf-fonts-4.1.0-1.el10.noarch.rpm;name=x86_64_v2_redhat-text-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-text-vf-fonts}"
SRC_URI[x86_64_v2_redhat-text-vf-fonts.sha256sum] = "b30117cd215b8de56ce8fb9090fca9857c7dc6f4fb48494adf2dec5f92fcdb7a"
RPROVIDES:redhat-text-vf-fonts:append:x86_64_v2 = " virtual/font_redhattext_"

URI_aarch64_redhat-display-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-display-fonts-4.1.0-1.el10.noarch.rpm;name=aarch64_redhat-display-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-display-fonts}"
SRC_URI[aarch64_redhat-display-fonts.sha256sum] = "53a0dd0ddde918ca7f9f9392aa16bbcfff5481c1e1bfd8bf949da267765e100d"
RPROVIDES:redhat-display-fonts:append:aarch64 = " virtual/font_redhatdisplay_"

URI_aarch64_redhat-display-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-display-vf-fonts-4.1.0-1.el10.noarch.rpm;name=aarch64_redhat-display-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-display-vf-fonts}"
SRC_URI[aarch64_redhat-display-vf-fonts.sha256sum] = "17765fc6a6a0c3d126ae7369184298c9f9425d83aab2a7e0dcbcbe4852b29679"
RPROVIDES:redhat-display-vf-fonts:append:aarch64 = " virtual/font_redhatdisplay_"

URI_aarch64_redhat-mono-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-mono-fonts-4.1.0-1.el10.noarch.rpm;name=aarch64_redhat-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-mono-fonts}"
SRC_URI[aarch64_redhat-mono-fonts.sha256sum] = "3674bc1ef134cd1c43e53915c984d1444b9f8a3772a0d6dbd7a481664a255688"

URI_aarch64_redhat-mono-vf-fonts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/redhat-mono-vf-fonts-4.1.0-1.el10.noarch.rpm;name=aarch64_redhat-mono-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-mono-vf-fonts}"
SRC_URI[aarch64_redhat-mono-vf-fonts.sha256sum] = "969ab2fa29f673a3155030928cd4ac36602c3d3c7462f49e75b6c2947950b0b6"

URI_aarch64_redhat-text-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-text-fonts-4.1.0-1.el10.noarch.rpm;name=aarch64_redhat-text-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-text-fonts}"
SRC_URI[aarch64_redhat-text-fonts.sha256sum] = "a849c57fb18bd245cc1b7ac58f523c8a0f63bb601dac90814f8b1a2c571fdd49"
RPROVIDES:redhat-text-fonts:append:aarch64 = " virtual/font_redhattext_"

URI_aarch64_redhat-text-vf-fonts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/redhat-text-vf-fonts-4.1.0-1.el10.noarch.rpm;name=aarch64_redhat-text-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-text-vf-fonts}"
SRC_URI[aarch64_redhat-text-vf-fonts.sha256sum] = "b30117cd215b8de56ce8fb9090fca9857c7dc6f4fb48494adf2dec5f92fcdb7a"
RPROVIDES:redhat-text-vf-fonts:append:aarch64 = " virtual/font_redhattext_"

RDEPENDS:redhat-display-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-display-vf-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-mono-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-mono-vf-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-text-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-text-vf-fonts = " \
 fonts-filesystem \
 "
