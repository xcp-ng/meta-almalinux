# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-MemInfo"
PV = "0.99"
PR = "32.el10_0"
PACKAGES = " \
 perl-Sys-MemInfo \
 perl-Sys-MemInfo-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-MemInfo-0.99-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1abdff6309f848453ec5fb30c2345fd211c79a3f978433ff43e8ef77d96ec92a"

URI_x86_64_v2_perl-Sys-MemInfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-MemInfo-0.99-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-MemInfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-MemInfo}"
SRC_URI[x86_64_v2_perl-Sys-MemInfo.sha256sum] = "7ced5126c3a712525aeb1d4ee69173743c481adce6c46ff67e6a5838ee416cdd"

URI_x86_64_v2_perl-Sys-MemInfo-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-MemInfo-tests-0.99-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sys-MemInfo-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-MemInfo-tests}"
SRC_URI[x86_64_v2_perl-Sys-MemInfo-tests.sha256sum] = "0646871a86cebd2f026643f4339a57d2ffada071e295d5553f458ccf386ee34e"

URI_aarch64_perl-Sys-MemInfo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-MemInfo-0.99-32.el10_0.aarch64.rpm;name=aarch64_perl-Sys-MemInfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-MemInfo}"
SRC_URI[aarch64_perl-Sys-MemInfo.sha256sum] = "ea41a2f9c6d941901e0fb4a55c2a3328ce79250ee27779a86d1dd1c404c87a7b"

URI_aarch64_perl-Sys-MemInfo-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-MemInfo-tests-0.99-32.el10_0.noarch.rpm;name=aarch64_perl-Sys-MemInfo-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-MemInfo-tests}"
SRC_URI[aarch64_perl-Sys-MemInfo-tests.sha256sum] = "06ecb76bf79f015becec653e1da55e3a69c4902151af1b5a9a0a88cd09edfd8f"

RDEPENDS:perl-Sys-MemInfo = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Sys-MemInfo-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Sys-MemInfo \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
