# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "converseen"
PV = "0.15.2.7"
PR = "2.el10_2"
PACKAGES = " \
 converseen \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/converseen-0.15.2.7-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c0c20353aecfc91f97ecd0e9ebf2270220410882ac4a9565f782c2484a37e9eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/converseen-0.15.2.7-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_converseen;unpack=0"
SRC_URI[x86_64_v2_converseen.sha256sum] = "356c4640d974a4d220ca6016d115b9fccc158f143a063d7f6ab2cf5ccd1a59ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/converseen-0.15.2.7-2.el10_2.aarch64.rpm;name=aarch64_converseen;unpack=0"
SRC_URI[aarch64_converseen.sha256sum] = "59bdf622137e3a0dcee5a1795f35863882c8b9b30a857da2c91eb8db477a6da8"

RDEPENDS:converseen = " \
 ImageMagick-c++ \
 ImageMagick-libs \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
