# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kxmlgui"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kxmlgui \
 kf6-kxmlgui-devel \
 kf6-kxmlgui-doc \
 kf6-kxmlgui-html \
 python3-kf6-kxmlgui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kxmlgui-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21efc159a70901d9608053c849692b2cac2c19a41b4deaddad6c4fba9e8c4326"

URI_x86_64_v2_kf6-kxmlgui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui}"
SRC_URI[x86_64_v2_kf6-kxmlgui.sha256sum] = "8950e2eacabe6d883bd095a5ff184558eb202c65503f1c20330209d9d62d8051"

URI_x86_64_v2_kf6-kxmlgui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-devel}"
SRC_URI[x86_64_v2_kf6-kxmlgui-devel.sha256sum] = "24635b3d0679d00f920334a3bdc306940fd64d516ae220bf6fac44bf8c1c6f4b"

URI_x86_64_v2_kf6-kxmlgui-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kxmlgui-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-doc}"
SRC_URI[x86_64_v2_kf6-kxmlgui-doc.sha256sum] = "3e81c078d6b40e272790877c202d53393757566ec2cfeb8128f23cb3a59d8f25"

URI_x86_64_v2_kf6-kxmlgui-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kxmlgui-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-html}"
SRC_URI[x86_64_v2_kf6-kxmlgui-html.sha256sum] = "cb3c1159e82504bc9665c94801ce434b8d70a7500db4aac165938e849f275de1"

URI_x86_64_v2_python3-kf6-kxmlgui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kxmlgui-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kxmlgui}"
SRC_URI[x86_64_v2_python3-kf6-kxmlgui.sha256sum] = "6e503db5b5e0fb4230ed3912712151c870e10b7f6c04d4e2dbc26552b076835f"

URI_aarch64_kf6-kxmlgui = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui}"
SRC_URI[aarch64_kf6-kxmlgui.sha256sum] = "d2ebca2ea76d5f4abb86a8bf6aa92f0f2a0a1e2a1907e8242cbcd7344574a033"

URI_aarch64_kf6-kxmlgui-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kxmlgui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-devel}"
SRC_URI[aarch64_kf6-kxmlgui-devel.sha256sum] = "6d3a3bdec42a0b2cfc677985f575132734b70b2d397e0058e853f34bf0a35b46"

URI_aarch64_kf6-kxmlgui-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kxmlgui-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-doc}"
SRC_URI[aarch64_kf6-kxmlgui-doc.sha256sum] = "f1c2fa3f1f761b65bf5e85f82ef529c4e039fc29c7074dd734ea4b08517fc6de"

URI_aarch64_kf6-kxmlgui-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kxmlgui-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-html}"
SRC_URI[aarch64_kf6-kxmlgui-html.sha256sum] = "52adb74ef3a6849ca344b1c46264e4d0902e1a7b93726689c0d1ab94005bdbde"

URI_aarch64_python3-kf6-kxmlgui = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kxmlgui-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_python3-kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kxmlgui}"
SRC_URI[aarch64_python3-kf6-kxmlgui.sha256sum] = "9ae9287f4a1486464eb939d68826c4a1e0e2aeceda15c82aadb5803963604c27"

RDEPENDS:kf6-kxmlgui = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kguiaddons-devel \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-doc = " \
 "
RDEPENDS:kf6-kxmlgui-html = " \
 "
RDEPENDS:python3-kf6-kxmlgui = " \
 glibc \
 kf6-kxmlgui \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
