# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iana-time-zone"
PV = "0.1.65"
PR = "1.el10_2"
PACKAGES = " \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 rust-iana-time-zone-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iana-time-zone-0.1.65-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88a8a3d6a34cf4de5143c9c854ff9f891b9c995c1586743cc641578143dd5df5"

URI_x86_64_v2_rust-iana-time-zone+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iana-time-zone+default-devel-0.1.65-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iana-time-zone+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iana-time-zone+default-devel}"
SRC_URI[x86_64_v2_rust-iana-time-zone+default-devel.sha256sum] = "572bddef69da898cbf1fb9ccb54a056f41be91064bc9a6ed319e02b24be06f6a"

URI_x86_64_v2_rust-iana-time-zone+fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iana-time-zone+fallback-devel-0.1.65-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iana-time-zone+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iana-time-zone+fallback-devel}"
SRC_URI[x86_64_v2_rust-iana-time-zone+fallback-devel.sha256sum] = "96ca9903a1624654c271e5b2dc124015b60e043fe4481ec9416c38f47ee45660"

URI_x86_64_v2_rust-iana-time-zone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iana-time-zone-devel-0.1.65-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iana-time-zone-devel}"
SRC_URI[x86_64_v2_rust-iana-time-zone-devel.sha256sum] = "ecc85ce703d8dfc61516827c1626dc3c64ad93f00332ef26d47035c67b69babe"

URI_aarch64_rust-iana-time-zone+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iana-time-zone+default-devel-0.1.65-1.el10_2.noarch.rpm;name=aarch64_rust-iana-time-zone+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iana-time-zone+default-devel}"
SRC_URI[aarch64_rust-iana-time-zone+default-devel.sha256sum] = "12499ba2ef49e0d625adcc8bc4627e05d60d45da8c61cfd53d8b9f6cd6397690"

URI_aarch64_rust-iana-time-zone+fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iana-time-zone+fallback-devel-0.1.65-1.el10_2.noarch.rpm;name=aarch64_rust-iana-time-zone+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iana-time-zone+fallback-devel}"
SRC_URI[aarch64_rust-iana-time-zone+fallback-devel.sha256sum] = "17cbf811108779d0a1ea04d2ee1ae22f80ede8a9eba71fba53f93f6bdc078d1a"

URI_aarch64_rust-iana-time-zone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iana-time-zone-devel-0.1.65-1.el10_2.noarch.rpm;name=aarch64_rust-iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iana-time-zone-devel}"
SRC_URI[aarch64_rust-iana-time-zone-devel.sha256sum] = "73914659e29ee7bf46485e01ff74d23e16675265bda27056b39a7760c53875d3"

RDEPENDS:rust-iana-time-zone+default-devel = " \
 cargo \
 rust-iana-time-zone-devel \
 "
RDEPENDS:rust-iana-time-zone+fallback-devel = " \
 cargo \
 rust-iana-time-zone-devel \
 "
RDEPENDS:rust-iana-time-zone-devel = " \
 cargo \
 rust \
 "
