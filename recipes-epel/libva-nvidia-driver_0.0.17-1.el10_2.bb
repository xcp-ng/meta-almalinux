# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libva-nvidia-driver"
PV = "0.0.17"
PR = "1.el10_2"
PACKAGES = " \
 libva-nvidia-driver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libva-nvidia-driver-0.0.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d954c1812b056fdf41cbd24bcfa0cd3e1cb242cc537f313323127349bb4fb26b"

URI_x86_64_v2_libva-nvidia-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libva-nvidia-driver-0.0.17-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libva-nvidia-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libva-nvidia-driver}"
SRC_URI[x86_64_v2_libva-nvidia-driver.sha256sum] = "6981f6d0c7eff04ea67f4444903964b4d9b037e0e28a1b1fe9a087c3f6306bcc"

URI_aarch64_libva-nvidia-driver = "${EPEL_MIRROR}/aarch64/Packages/l/libva-nvidia-driver-0.0.17-1.el10_2.aarch64.rpm;name=aarch64_libva-nvidia-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_libva-nvidia-driver}"
SRC_URI[aarch64_libva-nvidia-driver.sha256sum] = "d1df4186866d2d9e750c5d40467be8e9c622bd6579d0745d03845eb8fdd99b04"

RDEPENDS:libva-nvidia-driver = " \
 glibc \
 gstreamer1-plugins-bad-free-libs \
 libglvnd-egl \
 "
