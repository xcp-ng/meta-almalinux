# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-milou"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-milou \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-milou-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0564283c1fd42554c964531ee6f57a906f45a768eabb986ef71256dce80b804c"

URI_x86_64_v2_plasma-milou = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-milou-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-milou;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-milou}"
SRC_URI[x86_64_v2_plasma-milou.sha256sum] = "0a15d9dbdec1007d35c3c884b2ebd06f485ca611728d75ae58a1b1bf2fea06d5"

URI_aarch64_plasma-milou = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-milou-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-milou;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-milou}"
SRC_URI[aarch64_plasma-milou.sha256sum] = "972fa892464b165b6663a44c402f70cdda1909849142acdfd268e3d0401ce897"

RDEPENDS:plasma-milou = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-krunner \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
