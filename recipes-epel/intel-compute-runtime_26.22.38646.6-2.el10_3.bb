# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-compute-runtime"
PV = "26.22.38646.6"
PR = "2.el10_3"
PACKAGES:x86_64_v2 = " \
 intel-compute-runtime \
 intel-level-zero \
 intel-level-zero-devel \
 intel-ocloc \
 intel-ocloc-devel \
 intel-opencl \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-compute-runtime-26.22.38646.6-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b1e7f43a35a9e1314ae1c7c6ef9734194166f2a24c441519d7e3ce2e32eaec6"

URI_x86_64_v2_intel-compute-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-compute-runtime-26.22.38646.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-compute-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-compute-runtime}"
SRC_URI[x86_64_v2_intel-compute-runtime.sha256sum] = "8d5e20a790141ac2a22724005bcf9db5c9b985fa95312533c504b9d59df44a20"

URI_x86_64_v2_intel-level-zero = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-level-zero-26.22.38646.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-level-zero;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-level-zero}"
SRC_URI[x86_64_v2_intel-level-zero.sha256sum] = "6bb7543e1a331cd527a594cfd8e7efce865e4650625229ee1418334305a1b1bb"

URI_x86_64_v2_intel-level-zero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-level-zero-devel-26.22.38646.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-level-zero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-level-zero-devel}"
SRC_URI[x86_64_v2_intel-level-zero-devel.sha256sum] = "185f72d31587db0e39ec63b49844c4d8f389692bd6ac304fc3cc6be7fd17ebae"

URI_x86_64_v2_intel-ocloc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-ocloc-26.22.38646.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-ocloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-ocloc}"
SRC_URI[x86_64_v2_intel-ocloc.sha256sum] = "b55f69a1bf6c7029bea4ed4f0d196f3ea92141a835300e747ee70503a4cca3d7"

URI_x86_64_v2_intel-ocloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-ocloc-devel-26.22.38646.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-ocloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-ocloc-devel}"
SRC_URI[x86_64_v2_intel-ocloc-devel.sha256sum] = "18419577fc9cc44364e20e46d2797d6a1e7c461313e6a93ecbc9361becdda0fc"

URI_x86_64_v2_intel-opencl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-opencl-26.22.38646.6-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-opencl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-opencl}"
SRC_URI[x86_64_v2_intel-opencl.sha256sum] = "f573b5081e58565938db743422d3ac52081e0fa3beefd776e4e221ebfd2a4491"

RDEPENDS:intel-compute-runtime = " \
 intel-igc \
 intel-level-zero \
 intel-ocloc \
 intel-opencl \
 "
RDEPENDS:intel-level-zero = " \
 glibc \
 intel-gmmlib \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-level-zero-devel = " \
 intel-level-zero \
 "
RDEPENDS:intel-ocloc = " \
 bash \
 glibc \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-ocloc-devel = " \
 intel-ocloc \
 "
RDEPENDS:intel-opencl = " \
 glibc \
 intel-gmmlib \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
