# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvpn"
PV = "2.7_beta3"
PR = "2.el10_0"
PACKAGES = " \
 openvpn \
 openvpn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openvpn-2.7_beta3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6667bcaf9a8369eea61df593e1d66e8d364621663cf7422fdafdb714efa06e5f"

URI_x86_64_v2_openvpn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-2.7_beta3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvpn}"
SRC_URI[x86_64_v2_openvpn.sha256sum] = "870cef5f6485d521ca122767f836213057a3619d90f12c12bcb9833d7cc0f7e3"

URI_x86_64_v2_openvpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-devel-2.7_beta3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvpn-devel}"
SRC_URI[x86_64_v2_openvpn-devel.sha256sum] = "a1fbe27e3f93d005a450a7e88dcb723934936fb3332d77fb8782a55dd730f3f4"

URI_aarch64_openvpn = "${EPEL_MIRROR}/aarch64/Packages/o/openvpn-2.7_beta3-2.el10_0.aarch64.rpm;name=aarch64_openvpn;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvpn}"
SRC_URI[aarch64_openvpn.sha256sum] = "d4452bf43dab2059f28aa5dc0cbe86d186b7620c561b2ed018a7c8aedde491d2"

URI_aarch64_openvpn-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openvpn-devel-2.7_beta3-2.el10_0.aarch64.rpm;name=aarch64_openvpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvpn-devel}"
SRC_URI[aarch64_openvpn-devel.sha256sum] = "3199782d1c443008b8fba62de8f1c12568566a0aa2da61efc86d7f190bd4a5a0"

RDEPENDS:openvpn = " \
 bash \
 gawk \
 glibc \
 libcap-ng \
 libnl3 \
 libselinux \
 lz4-libs \
 lzo \
 openssl-libs \
 pam-libs \
 pkcs11-helper \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:openvpn-devel = " \
 "
