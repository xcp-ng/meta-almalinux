# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwidgetsaddons"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kwidgetsaddons \
 kf6-kwidgetsaddons-devel \
 kf6-kwidgetsaddons-doc \
 kf6-kwidgetsaddons-html \
 python3-kf6-kwidgetsaddons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwidgetsaddons-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2568c357d922c1eeaadffb6e0e0e2b7f67ad9d9945560cb94bb62b66665eda1"

URI_x86_64_v2_kf6-kwidgetsaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons.sha256sum] = "5c119fbefd8fe1e211588e4c4ce143958dd4a672acaf169f4a88deda6601e513"

URI_x86_64_v2_kf6-kwidgetsaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-devel}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-devel.sha256sum] = "f6c99c1b5544c67c44f873c25813c68d8e89155d9e1fa70a46d8cf9a065e26bd"

URI_x86_64_v2_kf6-kwidgetsaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-doc}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-doc.sha256sum] = "6a192e0a1bb7f84f0710a992c7cc25a925de24285504b808a3dfd2822671285c"

URI_x86_64_v2_kf6-kwidgetsaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwidgetsaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-html}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-html.sha256sum] = "86fa7b6e85541f31f04e3ce4bf9146368cdcc8fb24035600aedaf2648b5f62cc"

URI_x86_64_v2_python3-kf6-kwidgetsaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kwidgetsaddons-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kwidgetsaddons}"
SRC_URI[x86_64_v2_python3-kf6-kwidgetsaddons.sha256sum] = "9ebd02dddfe2096207b483fdb2203eac3bbc565b98a94e26203439f73292a7b1"

URI_aarch64_kf6-kwidgetsaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons}"
SRC_URI[aarch64_kf6-kwidgetsaddons.sha256sum] = "2a42ed2db269f248194b6108340ea59095d61657592884decae081088e0912a5"

URI_aarch64_kf6-kwidgetsaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-devel}"
SRC_URI[aarch64_kf6-kwidgetsaddons-devel.sha256sum] = "b0cf52ea627653e5281f5031a684c01e70d5e242548135800841182604b0ae24"

URI_aarch64_kf6-kwidgetsaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-doc}"
SRC_URI[aarch64_kf6-kwidgetsaddons-doc.sha256sum] = "eba6fb636cd0aff4e2e60b1ee52bd3465170e6020e194a8f1ea1dc8f7886872a"

URI_aarch64_kf6-kwidgetsaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwidgetsaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-html}"
SRC_URI[aarch64_kf6-kwidgetsaddons-html.sha256sum] = "aa06d6099196b7a5d26a281f24d251e862602e31de4ff8382ead9e5d0e9b9e9e"

URI_aarch64_python3-kf6-kwidgetsaddons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kwidgetsaddons-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kwidgetsaddons}"
SRC_URI[aarch64_python3-kf6-kwidgetsaddons.sha256sum] = "d772639a6ec02425650bd6139608749887a331e923f4584c6bfed829e43e7eea"

RDEPENDS:kf6-kwidgetsaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-doc = " \
 "
RDEPENDS:kf6-kwidgetsaddons-html = " \
 "
RDEPENDS:python3-kf6-kwidgetsaddons = " \
 glibc \
 kf6-kwidgetsaddons \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
