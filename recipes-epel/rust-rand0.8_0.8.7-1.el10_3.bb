# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand0.8"
PV = "0.8.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+default-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8+log-devel \
 rust-rand0.8+min_const_gen-devel \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8+serde-devel \
 rust-rand0.8+serde1-devel \
 rust-rand0.8+small_rng-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand0.8-0.8.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b587c4f2be05176933aa3a0b11ec195901426b1525152513bf16801ff7d7189"

URI_x86_64_v2_rust-rand0.8+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+alloc-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+alloc-devel.sha256sum] = "e33bbd48107bb0a94dd7381ddd92b2ebb6471ffc825931e507449c8a8d008a80"

URI_x86_64_v2_rust-rand0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+default-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+default-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+default-devel.sha256sum] = "f92be88d7f5a612651d6c839cb87584558b447fba5ab07f5e3f86a8709c2642b"
RPROVIDES:rust-rand0.8+default-devel:x86_64_v2 = "virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

URI_x86_64_v2_rust-rand0.8+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+getrandom-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+getrandom-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+getrandom-devel.sha256sum] = "768547a8f0ca6b1800a95ef6a6c41e0cb09392bbe21601e72301317b9131e030"

URI_x86_64_v2_rust-rand0.8+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+libc-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+libc-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+libc-devel.sha256sum] = "cd23cd48551725361dd8275b9804c0da4d2fe1c448489b402c44c274917d7924"

URI_x86_64_v2_rust-rand0.8+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+log-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+log-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+log-devel.sha256sum] = "abf71335fd7f34f1a641fdab951b18e7cafce1f112d52f7d509ba852ebeb53c4"

URI_x86_64_v2_rust-rand0.8+min_const_gen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+min_const_gen-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+min_const_gen-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+min_const_gen-devel.sha256sum] = "ce8bd82461c53e4c45165ad65ca76207e5dc0b87e9f1476b897322d99e2e7a11"

URI_x86_64_v2_rust-rand0.8+rand_chacha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+rand_chacha-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+rand_chacha-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+rand_chacha-devel.sha256sum] = "5429a614cc5f2086f209f4972864e45a68c426684e4d36b7719ae02d16283a07"

URI_x86_64_v2_rust-rand0.8+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+serde-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+serde-devel.sha256sum] = "8ac7e34fc7707b2cc14cb25ffd9b6dca9a65bbffcf769f56c951abeddadacdaf"

URI_x86_64_v2_rust-rand0.8+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+serde1-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+serde1-devel.sha256sum] = "0622aefc91a6d1b89b1145ac7def2043453951214b23b66f13ba9d51560dc676"

URI_x86_64_v2_rust-rand0.8+small_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+small_rng-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+small_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+small_rng-devel.sha256sum] = "c33c58427b93b768a861394f3fa3233364ef3629b24931863e3cae84ead9a84c"

URI_x86_64_v2_rust-rand0.8+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+std-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+std-devel.sha256sum] = "abe7f8d76578f4b6b56cee11b1b3d7ff19f0507565f93fe16e247f0899e4c039"

URI_x86_64_v2_rust-rand0.8+std_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8+std_rng-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8+std_rng-devel}"
SRC_URI[x86_64_v2_rust-rand0.8+std_rng-devel.sha256sum] = "32aeffed9407ef577cbf2f894e49a5457e880dba42e86d3a2db287f3bdc2078c"

URI_x86_64_v2_rust-rand0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand0.8-devel-0.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand0.8-devel}"
SRC_URI[x86_64_v2_rust-rand0.8-devel.sha256sum] = "c1807969200bb4913c6d3653282553421dc6f007eff3b4b3ddbb3221e35cf55f"

URI_aarch64_rust-rand0.8+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+alloc-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+alloc-devel}"
SRC_URI[aarch64_rust-rand0.8+alloc-devel.sha256sum] = "c6f7d531b7a0aa7065a27fe0b722f65408bb92bb6c42f386da356fe260380cbc"

URI_aarch64_rust-rand0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+default-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+default-devel}"
SRC_URI[aarch64_rust-rand0.8+default-devel.sha256sum] = "55cf5092a0684ba99e31480f42d81046f2760932dd8b6c69a209f8513045c64e"
RPROVIDES:rust-rand0.8+default-devel:aarch64 = "virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

URI_aarch64_rust-rand0.8+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+getrandom-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+getrandom-devel}"
SRC_URI[aarch64_rust-rand0.8+getrandom-devel.sha256sum] = "0ce040dfc6fbeef145ec58f07d308cf28b844c88af253594bf75f686cceb0635"

URI_aarch64_rust-rand0.8+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+libc-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+libc-devel}"
SRC_URI[aarch64_rust-rand0.8+libc-devel.sha256sum] = "7808075ac4dd54038d1484a842489f21ee96f92f4a66101c7109baca7d62ee6b"

URI_aarch64_rust-rand0.8+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+log-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+log-devel}"
SRC_URI[aarch64_rust-rand0.8+log-devel.sha256sum] = "0028069a988647f3334adcd25e90beb5f383a54b671f6a7de4c9dd90f8102481"

URI_aarch64_rust-rand0.8+min_const_gen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+min_const_gen-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+min_const_gen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+min_const_gen-devel}"
SRC_URI[aarch64_rust-rand0.8+min_const_gen-devel.sha256sum] = "8eb24f72a1676576acb223334abbe3d22bf4e62338206ece0cd592cc492c1da0"

URI_aarch64_rust-rand0.8+rand_chacha-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+rand_chacha-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+rand_chacha-devel}"
SRC_URI[aarch64_rust-rand0.8+rand_chacha-devel.sha256sum] = "16974a8e3093a3e505954a9f72f5192b83e343c950c92a36b4732f6c781813eb"

URI_aarch64_rust-rand0.8+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+serde-devel}"
SRC_URI[aarch64_rust-rand0.8+serde-devel.sha256sum] = "68872766f83cc8cea7e0e89dba0c72cc70021a250df9d657ce7bb9f9709eadac"

URI_aarch64_rust-rand0.8+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+serde1-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+serde1-devel}"
SRC_URI[aarch64_rust-rand0.8+serde1-devel.sha256sum] = "6e8e871850695aefc943595e5f39373e0be38a7509d42deb3136d1bbbc9fed2b"

URI_aarch64_rust-rand0.8+small_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+small_rng-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+small_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+small_rng-devel}"
SRC_URI[aarch64_rust-rand0.8+small_rng-devel.sha256sum] = "0837b72748b24188dbcd34976a1a2d46609920759427b150a5b8aea4fa252907"

URI_aarch64_rust-rand0.8+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+std-devel}"
SRC_URI[aarch64_rust-rand0.8+std-devel.sha256sum] = "c0b20f1b21a2b3275c43161e26d1b8fa6afe28c03989fd5ebb373c734695f985"

URI_aarch64_rust-rand0.8+std_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8+std_rng-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8+std_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8+std_rng-devel}"
SRC_URI[aarch64_rust-rand0.8+std_rng-devel.sha256sum] = "876f03516fa14a7f721b01f177768ae6687622218aef268dc1baa31967d06018"

URI_aarch64_rust-rand0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand0.8-devel-0.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-rand0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand0.8-devel}"
SRC_URI[aarch64_rust-rand0.8-devel.sha256sum] = "498730691781f032843358f485c1745ee67119db70a00e91ab3b2dd6cb74dced"

RDEPENDS:rust-rand0.8+alloc-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+alloc-devel \
 "
RDEPENDS:rust-rand0.8+default-devel = " \
 cargo \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+getrandom-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_core0.6+getrandom-devel \
 "
RDEPENDS:rust-rand0.8+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+log-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+min_const_gen-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+rand_chacha-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rand_chacha0.3-devel \
 "
RDEPENDS:rust-rand0.8+serde-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand0.8+serde1-devel = " \
 cargo \
 rust-rand0.8+serde-devel \
 rust-rand0.8-devel \
 rust-rand_core0.6+serde1-devel \
 "
RDEPENDS:rust-rand0.8+small_rng-devel = " \
 cargo \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8+std-devel = " \
 cargo \
 rust-rand0.8+alloc-devel \
 rust-rand0.8+getrandom-devel \
 rust-rand0.8+libc-devel \
 rust-rand0.8-devel \
 rust-rand_chacha0.3+std-devel \
 rust-rand_chacha0.3-devel \
 rust-rand_core0.6+std-devel \
 "
RDEPENDS:rust-rand0.8+std_rng-devel = " \
 cargo \
 rust-rand0.8+rand_chacha-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-rand0.8-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~"
