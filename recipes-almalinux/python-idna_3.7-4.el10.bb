# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-idna"
PV = "3.7"
PR = "4.el10"
PACKAGES = " \
 python3-idna \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-idna-3.7-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "296fcbbe144304dd4a8017a44f7393d38a5454244e0f85a2f35bc5c86939b20b"

URI_x86_64_v2_python3-idna = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-idna-3.7-4.el10.noarch.rpm;name=x86_64_v2_python3-idna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-idna}"
SRC_URI[x86_64_v2_python3-idna.sha256sum] = "0ad9dbbd02ad24afd3e528d95fce616703ec5ded6b82c9385748ee012a8972f1"

URI_aarch64_python3-idna = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-idna-3.7-4.el10.noarch.rpm;name=aarch64_python3-idna;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-idna}"
SRC_URI[aarch64_python3-idna.sha256sum] = "0ad9dbbd02ad24afd3e528d95fce616703ec5ded6b82c9385748ee012a8972f1"

RDEPENDS:python3-idna = " \
 python3 \
 "
