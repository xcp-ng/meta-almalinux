# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "webp-pixbuf-loader"
PV = "0.2.7"
PR = "2.el10_0"
PACKAGES = " \
 webp-pixbuf-loader \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/webp-pixbuf-loader-0.2.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7a64f2a3e8414938e39dacdc8bf7bacc5278ef0337be3ec73529a19ed1a1921"

URI_x86_64_v2_webp-pixbuf-loader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webp-pixbuf-loader-0.2.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webp-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webp-pixbuf-loader}"
SRC_URI[x86_64_v2_webp-pixbuf-loader.sha256sum] = "06be8d5e5d62a3156bbe60606e8cad66fa705d329b03dd3e3160c08b92436aac"

URI_aarch64_webp-pixbuf-loader = "${EPEL_MIRROR}/aarch64/Packages/w/webp-pixbuf-loader-0.2.7-2.el10_0.aarch64.rpm;name=aarch64_webp-pixbuf-loader;unpack=0"
SRC_URI:append = " ${URI_aarch64_webp-pixbuf-loader}"
SRC_URI[aarch64_webp-pixbuf-loader.sha256sum] = "69ed888ec9db992a1b9679d8b2bc4a2442975a96fce067c134d40fa80e82f298"

RDEPENDS:webp-pixbuf-loader = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libwebp \
 "
