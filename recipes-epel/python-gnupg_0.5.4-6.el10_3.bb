# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gnupg"
PV = "0.5.4"
PR = "6.el10_3"
PACKAGES = " \
 python3-gnupg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gnupg-0.5.4-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a755c3435f77c730b790858e3f998ee41e45fe9893075dac423bc533be361be5"

URI_x86_64_v2_python3-gnupg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gnupg-0.5.4-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gnupg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gnupg}"
SRC_URI[x86_64_v2_python3-gnupg.sha256sum] = "299975cccd875f753f56743437451276f9e63b02ac786de718c5218f07f311a4"

URI_aarch64_python3-gnupg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gnupg-0.5.4-6.el10_3.noarch.rpm;name=aarch64_python3-gnupg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gnupg}"
SRC_URI[aarch64_python3-gnupg.sha256sum] = "f3583717363343449fafe6b783063004af1a64481ace040d4a3edb45b74ced10"

RDEPENDS:python3-gnupg = " \
 gnupg2 \
 python3 \
 "
