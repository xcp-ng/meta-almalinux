# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apr"
PV = "1.7.5"
PR = "2.el10"
PACKAGES = " \
 apr \
 apr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apr-1.7.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cd7fe715a6c4548d3eb0a2a21771af1cc779258e9003ad49d057d09db549d95"

URI_x86_64_v2_apr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-1.7.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_apr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr}"
SRC_URI[x86_64_v2_apr.sha256sum] = "53a09aeb274797e42bab4bfb46785ade4eda627ece9a5df5bf9469eca7a5dab5"

URI_x86_64_v2_apr-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-devel-1.7.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_apr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-devel}"
SRC_URI[x86_64_v2_apr-devel.sha256sum] = "4620a072a43d0f304249eaf101b67832c1f3aebf5d360a75c2645ff60e11d403"

URI_aarch64_apr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-1.7.5-2.el10.aarch64.rpm;name=aarch64_apr;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr}"
SRC_URI[aarch64_apr.sha256sum] = "fff681e667ffb22d32c6f063ae72af4d0b0c3f5a1cacec53519b7b1effaedf3b"

URI_aarch64_apr-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-devel-1.7.5-2.el10.aarch64.rpm;name=aarch64_apr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-devel}"
SRC_URI[aarch64_apr-devel.sha256sum] = "fce33961d9fd8afb64485d9c1d5ea870bb2e5c854e6966917989cf5990b0cf41"

RDEPENDS:apr = " \
 glibc \
 libuuid \
 libxcrypt \
 "
RDEPENDS:apr-devel = " \
 apr \
 bash \
 pkgconf-pkg-config \
 python3 \
 "
