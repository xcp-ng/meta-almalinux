# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk-portable"
PE = "1"
PV = "24.0.1.0.9"
PR = "1.rolling.el8"
PACKAGES = " \
 java-latest-openjdk-portable \
 java-latest-openjdk-portable-devel \
 java-latest-openjdk-portable-devel-fastdebug \
 java-latest-openjdk-portable-devel-slowdebug \
 java-latest-openjdk-portable-docs \
 java-latest-openjdk-portable-fastdebug \
 java-latest-openjdk-portable-misc \
 java-latest-openjdk-portable-slowdebug \
 java-latest-openjdk-portable-sources \
 java-latest-openjdk-portable-static-libs \
 java-latest-openjdk-portable-static-libs-fastdebug \
 java-latest-openjdk-portable-static-libs-slowdebug \
 java-latest-openjdk-portable-unstripped \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-portable-24.0.1.0.9-1.rolling.el8.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dfa71f4ead5442beb1f64ed6d01bfe9de01d4b70073bb44be0bee004ac9a469"

URI_aarch64_java-latest-openjdk-portable = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable}"
SRC_URI[aarch64_java-latest-openjdk-portable.sha256sum] = "57f829591639d7816a8c8f9cf51eede1ef09393e53be27efd8b17f3ef0dc62f4"

URI_aarch64_java-latest-openjdk-portable-devel = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel.sha256sum] = "d2c4d940b4b93ad119270cba71171a7e0eaca4cb135ea96cd20f8d29a511e688"

URI_aarch64_java-latest-openjdk-portable-devel-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-fastdebug-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-fastdebug.sha256sum] = "30b9797eb6e50ffdd2d34807433153f080332067b4fbd7b38eb0a93ec657c08e"

URI_aarch64_java-latest-openjdk-portable-devel-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-devel-slowdebug-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-devel-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-devel-slowdebug.sha256sum] = "618e9c6a4cfac83636131eb6cb973d2592aca0b96984e26db7cfe119747cd3fe"

URI_aarch64_java-latest-openjdk-portable-docs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-docs-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-docs}"
SRC_URI[aarch64_java-latest-openjdk-portable-docs.sha256sum] = "882c3aa7326cafd67d2494201b158f7fef7827b7aed9075769568659bfbd00b3"

URI_aarch64_java-latest-openjdk-portable-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-fastdebug-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-fastdebug.sha256sum] = "7c6fe4b19fb403025474f8ce39dbd3538a9ac2334d35ca2464843a0df9448f22"

URI_aarch64_java-latest-openjdk-portable-misc = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-misc-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-misc}"
SRC_URI[aarch64_java-latest-openjdk-portable-misc.sha256sum] = "70bfd54c467bbb4565d36899fd964721ff27d9a4da947cd863f1be47e65bd575"

URI_aarch64_java-latest-openjdk-portable-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-slowdebug-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-slowdebug.sha256sum] = "7426f8bd2f035fd584d9377c33fb9074085fba44118eb5cb523d5d5dc757ba21"

URI_aarch64_java-latest-openjdk-portable-sources = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-sources-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-sources;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-sources}"
SRC_URI[aarch64_java-latest-openjdk-portable-sources.sha256sum] = "4525522503cfdd8267cf428583b1b35c1b8ab69bc279c1d2655be00c147be76f"

URI_aarch64_java-latest-openjdk-portable-static-libs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs.sha256sum] = "93743fa2be4fda3265bbbe35a55e5b58a5392dbe6e6c50b4a876d7d13a5c4bf7"

URI_aarch64_java-latest-openjdk-portable-static-libs-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-fastdebug-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-fastdebug.sha256sum] = "bb3d705115c48e1eff9e553afdfe5d32b15596a4463ed431bb74d08b27a58af6"

URI_aarch64_java-latest-openjdk-portable-static-libs-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-static-libs-slowdebug-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-static-libs-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-portable-static-libs-slowdebug.sha256sum] = "588f56cbed22774afd43bd12729956e805751abe5cdc31676671b2188c1e579a"

URI_aarch64_java-latest-openjdk-portable-unstripped = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-portable-unstripped-24.0.1.0.9-1.rolling.el8.aarch64.rpm;name=aarch64_java-latest-openjdk-portable-unstripped;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-portable-unstripped}"
SRC_URI[aarch64_java-latest-openjdk-portable-unstripped.sha256sum] = "010310401d60d4975d515babc8604edba71ade637c9edf64cb2f1df540338fbe"

RDEPENDS:java-latest-openjdk-portable = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-devel-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-docs = " \
 "
RDEPENDS:java-latest-openjdk-portable-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-misc = " \
 "
RDEPENDS:java-latest-openjdk-portable-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-sources = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-fastdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-static-libs-slowdebug = " \
 "
RDEPENDS:java-latest-openjdk-portable-unstripped = " \
 "
