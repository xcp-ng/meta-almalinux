# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-urllib3"
PV = "2.6.3"
PR = "2.el10"
PACKAGES = " \
 python3.14-urllib3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-urllib3-2.6.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "646528ea3b77cbefce45219534ef3e47a335151ce9b519c577ea5ce01972f111"

URI_x86_64_v2_python3.14-urllib3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-urllib3-2.6.3-2.el10.noarch.rpm;name=x86_64_v2_python3.14-urllib3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-urllib3}"
SRC_URI[x86_64_v2_python3.14-urllib3.sha256sum] = "913666c9b2b32015fa76318d901a4d79841276ef0ff9629daa6f7dde11356895"

URI_aarch64_python3.14-urllib3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-urllib3-2.6.3-2.el10.noarch.rpm;name=aarch64_python3.14-urllib3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-urllib3}"
SRC_URI[aarch64_python3.14-urllib3.sha256sum] = "913666c9b2b32015fa76318d901a4d79841276ef0ff9629daa6f7dde11356895"

RDEPENDS:python3.14-urllib3 = " \
 ca-certificates \
 python3.14 \
 python3.14-idna \
 "
