# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-fixed"
PV = "0.3"
PR = "15.el10_0"
PACKAGES = " \
 ghc-fixed \
 ghc-fixed-devel \
 ghc-fixed-doc \
 ghc-fixed-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-fixed-0.3-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3b6abfefe8c52e56d45119e1a1177468dc4d4e43d9f3c7635b96a231bf10d8c"

URI_x86_64_v2_ghc-fixed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fixed-0.3-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fixed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fixed}"
SRC_URI[x86_64_v2_ghc-fixed.sha256sum] = "93a642c21f38697e0952ed6649f70f52393e25ce742a258388ee69d95e09cea2"

URI_x86_64_v2_ghc-fixed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fixed-devel-0.3-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fixed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fixed-devel}"
SRC_URI[x86_64_v2_ghc-fixed-devel.sha256sum] = "2019f79dfd98aed843d0aa37f7eb65a1008eb9c309e2909d47685ad275a9b3cf"

URI_x86_64_v2_ghc-fixed-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fixed-doc-0.3-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-fixed-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fixed-doc}"
SRC_URI[x86_64_v2_ghc-fixed-doc.sha256sum] = "6c93eb4769c4e579b2a5660f6ad22676e0ee31a9971b867af2458e7c562840ea"

URI_x86_64_v2_ghc-fixed-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-fixed-prof-0.3-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-fixed-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-fixed-prof}"
SRC_URI[x86_64_v2_ghc-fixed-prof.sha256sum] = "0bfb5a21f66a5b44ffab3a3f1a6fb70eace35262f8f61bb2ef40bc3dc856e08d"

URI_aarch64_ghc-fixed = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fixed-0.3-15.el10_0.aarch64.rpm;name=aarch64_ghc-fixed;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fixed}"
SRC_URI[aarch64_ghc-fixed.sha256sum] = "cbaf742b4b205393e3475dcd8b987434cbfb00ab176084d0a1046ce959316317"

URI_aarch64_ghc-fixed-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fixed-devel-0.3-15.el10_0.aarch64.rpm;name=aarch64_ghc-fixed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fixed-devel}"
SRC_URI[aarch64_ghc-fixed-devel.sha256sum] = "2e77852cc160caf48e7b3fe9090b433bd3ad6e506e9c9d5b26871e1d25919601"

URI_aarch64_ghc-fixed-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fixed-doc-0.3-15.el10_0.noarch.rpm;name=aarch64_ghc-fixed-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fixed-doc}"
SRC_URI[aarch64_ghc-fixed-doc.sha256sum] = "9dab502870df3b77d964ed4f2155164d625071729a047ce2fd5e480c5e48d4be"

URI_aarch64_ghc-fixed-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-fixed-prof-0.3-15.el10_0.aarch64.rpm;name=aarch64_ghc-fixed-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-fixed-prof}"
SRC_URI[aarch64_ghc-fixed-prof.sha256sum] = "3cd8c397eb97d222f941234dde40fc5d8c637980c1854be128f538e90a0dc5f6"

RDEPENDS:ghc-fixed = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-fixed-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-fixed \
 "
RDEPENDS:ghc-fixed-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-fixed-prof = " \
 ghc-base-prof \
 ghc-fixed-devel \
 "
