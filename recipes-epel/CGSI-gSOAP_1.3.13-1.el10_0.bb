# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "CGSI-gSOAP"
PV = "1.3.13"
PR = "1.el10_0"
PACKAGES = " \
 CGSI-gSOAP \
 CGSI-gSOAP-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/CGSI-gSOAP-1.3.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8aeb9eb23294cdec54325a119f91a9ab5bc289300ef9281f3a2c5e6c010a7c94"

URI_x86_64_v2_CGSI-gSOAP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGSI-gSOAP-1.3.13-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGSI-gSOAP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGSI-gSOAP}"
SRC_URI[x86_64_v2_CGSI-gSOAP.sha256sum] = "92f9c2eaa84fd515b472e2e372eb6db5d436d3b50b482284337f6865a7691586"

URI_x86_64_v2_CGSI-gSOAP-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CGSI-gSOAP-devel-1.3.13-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CGSI-gSOAP-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_CGSI-gSOAP-devel}"
SRC_URI[x86_64_v2_CGSI-gSOAP-devel.sha256sum] = "64925925836768b0d16e960fd4e215aa36a86fa8f98d17c6921245d860bfc905"

URI_aarch64_CGSI-gSOAP = "${EPEL_MIRROR}/aarch64/Packages/c/CGSI-gSOAP-1.3.13-1.el10_0.aarch64.rpm;name=aarch64_CGSI-gSOAP;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGSI-gSOAP}"
SRC_URI[aarch64_CGSI-gSOAP.sha256sum] = "e76473a675d436d692c17af8359b81d2a2742f5e010d74d3b72229f6400c68a6"

URI_aarch64_CGSI-gSOAP-devel = "${EPEL_MIRROR}/aarch64/Packages/c/CGSI-gSOAP-devel-1.3.13-1.el10_0.aarch64.rpm;name=aarch64_CGSI-gSOAP-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_CGSI-gSOAP-devel}"
SRC_URI[aarch64_CGSI-gSOAP-devel.sha256sum] = "bd3f2abd12599b565c818d351c8f1b707ece5a5b6203dd763be40ee26482f485"

RDEPENDS:CGSI-gSOAP = " \
 glibc \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-openssl-module \
 libstdc++ \
 openssl-libs \
 voms \
 "
RDEPENDS:CGSI-gSOAP-devel = " \
 CGSI-gSOAP \
 gsoap-devel \
 "
