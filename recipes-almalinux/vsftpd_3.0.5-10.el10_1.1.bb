# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vsftpd"
PV = "3.0.5"
PR = "10.el10_1.1"
PACKAGES = " \
 vsftpd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vsftpd-3.0.5-10.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8966aba1998d5001ee0adcfacb7ddbab82ba3549fe8b87b7c30ac71c58eeea30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vsftpd-3.0.5-10.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_vsftpd;unpack=0"
SRC_URI[x86_64_v2_vsftpd.sha256sum] = "2077a6c31affedd99513cda8809bdfaa6e8eee8d4bee775677c47eb8e83c3c1d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vsftpd-3.0.5-10.el10_1.1.aarch64.rpm;name=aarch64_vsftpd;unpack=0"
SRC_URI[aarch64_vsftpd.sha256sum] = "7812fb889c320feadd3990a27ad75a6a002ffab23dc9d2fc1f7be8c06e1e3f01"

RDEPENDS:vsftpd = " \
 bash \
 glibc \
 libcap \
 logrotate \
 openssl-libs \
 pam-libs \
 "
