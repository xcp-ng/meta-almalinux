# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "packit"
PV = "1.16.0"
PR = "1.el10_1"
PACKAGES = " \
 packit \
 python3-packit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/packit-1.16.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3f724f6b635df52024c0a73474289a01bbf4066c8aebf099ce0cdca0f54193d"

URI_x86_64_v2_packit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/packit-1.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_packit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_packit}"
SRC_URI[x86_64_v2_packit.sha256sum] = "a04b8132c10f64a8e356c54a231c30542c0f64bf9f81cf04c54ba93ea8b6aeb3"

URI_x86_64_v2_python3-packit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-packit-1.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-packit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-packit}"
SRC_URI[x86_64_v2_python3-packit.sha256sum] = "2b8dec1e321060d551788e467ba8cecfb5d684b06be8b656d59a89288c5d55ab"

URI_aarch64_packit = "${EPEL_MIRROR}/aarch64/Packages/p/packit-1.16.0-1.el10_1.noarch.rpm;name=aarch64_packit;unpack=0"
SRC_URI:append = " ${URI_aarch64_packit}"
SRC_URI[aarch64_packit.sha256sum] = "07800defba086f2b34fc52aba227d4cfd6d7653fc2a8600f924e2f4286e3b94f"

URI_aarch64_python3-packit = "${EPEL_MIRROR}/aarch64/Packages/p/python3-packit-1.16.0-1.el10_1.noarch.rpm;name=aarch64_python3-packit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-packit}"
SRC_URI[aarch64_python3-packit.sha256sum] = "5bd8438fecec56789bf6ba22ba2b918f17103c304ed1b5862e5e08b42bfec50e"

RDEPENDS:packit = " \
 python3 \
 python3-packit \
 "
RDEPENDS:python3-packit = " \
 bash \
 bodhi-client \
 fedpkg \
 git-core \
 krb5-workstation \
 osc \
 python3 \
 python3-GitPython \
 python3-backoff \
 python3-bugzilla \
 python3-cachetools \
 python3-cccolutils \
 python3-click \
 python3-copr \
 python3-fedora-distro-aliases \
 python3-gnupg \
 python3-koji \
 python3-lazy-object-proxy \
 python3-marshmallow \
 python3-munch \
 python3-ogr \
 python3-opensuse-distro-aliases \
 python3-packaging \
 python3-pyyaml \
 python3-requests \
 python3-requests-kerberos \
 python3-rpkg \
 python3-specfile \
 python3-tabulate \
 rpm-build \
 rpmdevtools \
 rsync \
 "
