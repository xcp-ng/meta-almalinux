# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flake8"
PV = "6.1.0"
PR = "9.el10_2"
PACKAGES = " \
 python3-flake8 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flake8-6.1.0-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f15982ce4faef1e0fe1bf874678e4e56ac0ab8fa3808c578f1e2d66a42eca3c1"

URI_x86_64_v2_python3-flake8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flake8-6.1.0-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flake8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flake8}"
SRC_URI[x86_64_v2_python3-flake8.sha256sum] = "79776b06aefaac7613e8acd75e31db751936d98d1d281fc8a3e9db8ca6d0fbf0"

URI_aarch64_python3-flake8 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flake8-6.1.0-9.el10_2.noarch.rpm;name=aarch64_python3-flake8;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flake8}"
SRC_URI[aarch64_python3-flake8.sha256sum] = "3ca027b28cdefe63461fdd28540969fbd35d6b3c267f627b84a1ef9b81ab6f7e"

RDEPENDS:python3-flake8 = " \
 python3 \
 python3-mccabe \
 python3-pycodestyle \
 python3-pyflakes \
 "
