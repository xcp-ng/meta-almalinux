# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "c4core"
PV = "0.2.2"
PR = "5.el10_1"
PACKAGES = " \
 c4core \
 c4core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/c4core-0.2.2-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51f5272e193a9f373e20c0a71b0549c006b67c1e1d597ba6536b191e2ca06b5f"

URI_x86_64_v2_c4core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4core-0.2.2-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4core}"
SRC_URI[x86_64_v2_c4core.sha256sum] = "452fb0a5df9452c65ea70748a6a8d3f617b110b25c6d3b83332907fcc42fc164"

URI_x86_64_v2_c4core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/c4core-devel-0.2.2-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_c4core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_c4core-devel}"
SRC_URI[x86_64_v2_c4core-devel.sha256sum] = "f88960782a17445e1e8c199b51348645dd121c674f6014aa848e69a863a7a20f"

URI_aarch64_c4core = "${EPEL_MIRROR}/aarch64/Packages/c/c4core-0.2.2-5.el10_1.aarch64.rpm;name=aarch64_c4core;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4core}"
SRC_URI[aarch64_c4core.sha256sum] = "5aa2bbd6c8bfa5c1e1213b13b879045491e5f99e92bcadc7f2da0815e716a637"

URI_aarch64_c4core-devel = "${EPEL_MIRROR}/aarch64/Packages/c/c4core-devel-0.2.2-5.el10_1.aarch64.rpm;name=aarch64_c4core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_c4core-devel}"
SRC_URI[aarch64_c4core-devel.sha256sum] = "a9512eb3ff945e6c1087769056e72400ae246a16e03da82d847b8634b200835d"

RDEPENDS:c4core = " \
 glibc \
 libstdc++ \
 "
RDEPENDS:c4core-devel = " \
 c4core \
 cmake-filesystem \
 debugbreak-devel \
 fast_float-devel \
 "
