# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wild"
PV = "2.2.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-wild+default-devel \
 rust-wild+glob-quoted-on-windows-devel \
 rust-wild-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wild-2.2.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7150e9bbf00f380e0d5c13e80c6df11d6ee8d94450e7f47ef3cfca86048b185c"

URI_x86_64_v2_rust-wild+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wild+default-devel-2.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wild+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wild+default-devel}"
SRC_URI[x86_64_v2_rust-wild+default-devel.sha256sum] = "f765ccfbbf07858aa20929eefe8639306be0165208373d5fac75f31bc1c3168e"

URI_x86_64_v2_rust-wild+glob-quoted-on-windows-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wild+glob-quoted-on-windows-devel-2.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wild+glob-quoted-on-windows-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wild+glob-quoted-on-windows-devel}"
SRC_URI[x86_64_v2_rust-wild+glob-quoted-on-windows-devel.sha256sum] = "6f2a9860c87dbd6439037fd835412f98b55be5fb97b7b8067542b8c07dd5feb7"

URI_x86_64_v2_rust-wild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wild-devel-2.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wild-devel}"
SRC_URI[x86_64_v2_rust-wild-devel.sha256sum] = "35b7617ab569ebc19de0e90f277110a7adbf672cdc58128b47f5f5421e4c2a18"

URI_aarch64_rust-wild+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wild+default-devel-2.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-wild+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wild+default-devel}"
SRC_URI[aarch64_rust-wild+default-devel.sha256sum] = "e3159597e99d43e6c8738dcab75d16560496d3f916e0a9e43643e29a54b24030"

URI_aarch64_rust-wild+glob-quoted-on-windows-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wild+glob-quoted-on-windows-devel-2.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-wild+glob-quoted-on-windows-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wild+glob-quoted-on-windows-devel}"
SRC_URI[aarch64_rust-wild+glob-quoted-on-windows-devel.sha256sum] = "84621f46bd27ce069078d8e39f20a5f1544eb904b3c1e03df03d132ce55ffb02"

URI_aarch64_rust-wild-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wild-devel-2.2.1-2.el10_0.noarch.rpm;name=aarch64_rust-wild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wild-devel}"
SRC_URI[aarch64_rust-wild-devel.sha256sum] = "5933b4d6b058c6fbca1f6a013952a6a4852df2bccfe82b39ab7e7cca79334d14"

RDEPENDS:rust-wild+default-devel = " \
 cargo \
 rust-wild-devel \
 "
RDEPENDS:rust-wild+glob-quoted-on-windows-devel = " \
 cargo \
 rust-wild-devel \
 "
RDEPENDS:rust-wild-devel = " \
 cargo \
 "
