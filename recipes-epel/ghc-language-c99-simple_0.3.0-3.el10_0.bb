# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-language-c99-simple"
PV = "0.3.0"
PR = "3.el10_0"
PACKAGES = " \
 ghc-language-c99-simple \
 ghc-language-c99-simple-devel \
 ghc-language-c99-simple-doc \
 ghc-language-c99-simple-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-language-c99-simple-0.3.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f915a7dfd92cc079ce4428373abc8397a95247ced92f5af72cc3380ea94402c"

URI_x86_64_v2_ghc-language-c99-simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-c99-simple-0.3.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-language-c99-simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-c99-simple}"
SRC_URI[x86_64_v2_ghc-language-c99-simple.sha256sum] = "e2d1f16a7d36313488749c87c1cef1e714b822f829bd61736e7ffbf0600d7eee"

URI_x86_64_v2_ghc-language-c99-simple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-c99-simple-devel-0.3.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-language-c99-simple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-c99-simple-devel}"
SRC_URI[x86_64_v2_ghc-language-c99-simple-devel.sha256sum] = "95aeb35d5c7d6826b2006c4cb6002dc301e9f9746a30dd6e3b97690e8e53e54b"

URI_x86_64_v2_ghc-language-c99-simple-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-c99-simple-doc-0.3.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-language-c99-simple-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-c99-simple-doc}"
SRC_URI[x86_64_v2_ghc-language-c99-simple-doc.sha256sum] = "86592a90ac0a3046fc174ff5103847132251fa898e556eae3bd8612fc40f2066"

URI_x86_64_v2_ghc-language-c99-simple-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-language-c99-simple-prof-0.3.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-language-c99-simple-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-language-c99-simple-prof}"
SRC_URI[x86_64_v2_ghc-language-c99-simple-prof.sha256sum] = "956a1afb11edb5920aa1579e87deb82040c0fe85b549035d9cb26da65261a1cc"

URI_aarch64_ghc-language-c99-simple = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-c99-simple-0.3.0-3.el10_0.aarch64.rpm;name=aarch64_ghc-language-c99-simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-c99-simple}"
SRC_URI[aarch64_ghc-language-c99-simple.sha256sum] = "2cbbfd9bab98f7398cc8981db47520572d251b9efda77f5663f102c4e34007eb"

URI_aarch64_ghc-language-c99-simple-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-c99-simple-devel-0.3.0-3.el10_0.aarch64.rpm;name=aarch64_ghc-language-c99-simple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-c99-simple-devel}"
SRC_URI[aarch64_ghc-language-c99-simple-devel.sha256sum] = "bc15ad85e524c78f1f3c80a9a08082c4ec5efd0d69579bca3b92fa57b89edb56"

URI_aarch64_ghc-language-c99-simple-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-c99-simple-doc-0.3.0-3.el10_0.noarch.rpm;name=aarch64_ghc-language-c99-simple-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-c99-simple-doc}"
SRC_URI[aarch64_ghc-language-c99-simple-doc.sha256sum] = "3819ad6f2773c20ae7f984cadb45670e6e117b7d290f61e5af2583982b617e72"

URI_aarch64_ghc-language-c99-simple-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-language-c99-simple-prof-0.3.0-3.el10_0.aarch64.rpm;name=aarch64_ghc-language-c99-simple-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-language-c99-simple-prof}"
SRC_URI[aarch64_ghc-language-c99-simple-prof.sha256sum] = "c8913169e945f03e16b0389fd6b7e8a0b777c3af38bcde872b1665a75bbfbb47"

RDEPENDS:ghc-language-c99-simple = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ieee754 \
 ghc-language-c99 \
 ghc-language-c99-util \
 ghc-mtl \
 ghc-pretty \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-language-c99-simple-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-language-c99-devel \
 ghc-language-c99-simple \
 ghc-language-c99-util-devel \
 ghc-mtl-devel \
 "
RDEPENDS:ghc-language-c99-simple-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-language-c99-simple-prof = " \
 ghc-base-prof \
 ghc-language-c99-prof \
 ghc-language-c99-simple-devel \
 ghc-language-c99-util-prof \
 ghc-mtl-prof \
 "
