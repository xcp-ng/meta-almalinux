# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-joho-godotenv"
PV = "1.5.1"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-joho-godotenv \
 golang-github-joho-godotenv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-joho-godotenv-1.5.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85fdaa27b6328f699a8ba9344e3566cdd9f644ab18fbcf7e0a93cca4e1689254"

URI_x86_64_v2_golang-github-joho-godotenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-joho-godotenv-1.5.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-joho-godotenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-joho-godotenv}"
SRC_URI[x86_64_v2_golang-github-joho-godotenv.sha256sum] = "c7dd94af657e94158d876f426db8c33b28cc1f2253e84fe01ba980e0736d32de"

URI_x86_64_v2_golang-github-joho-godotenv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-joho-godotenv-devel-1.5.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-joho-godotenv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-joho-godotenv-devel}"
SRC_URI[x86_64_v2_golang-github-joho-godotenv-devel.sha256sum] = "b34f083edf27383b1da9b0c6ef53a5360d96293db69417cbc7648bef24ceab59"

URI_aarch64_golang-github-joho-godotenv = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-joho-godotenv-1.5.1-7.el10_0.aarch64.rpm;name=aarch64_golang-github-joho-godotenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-joho-godotenv}"
SRC_URI[aarch64_golang-github-joho-godotenv.sha256sum] = "59d932a5c3133a13a73a9e77519646d3734465b7f48cc0accb926ed11443f638"

URI_aarch64_golang-github-joho-godotenv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-joho-godotenv-devel-1.5.1-7.el10_0.noarch.rpm;name=aarch64_golang-github-joho-godotenv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-joho-godotenv-devel}"
SRC_URI[aarch64_golang-github-joho-godotenv-devel.sha256sum] = "b92756ea2a271f82ace65716398d3015c6ed0920197d9f2f135b274933911dfd"

RDEPENDS:golang-github-joho-godotenv = " \
 glibc \
 "
RDEPENDS:golang-github-joho-godotenv-devel = " \
 go-filesystem \
 "
