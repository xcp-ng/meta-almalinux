# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluedevil"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 bluedevil \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bluedevil-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1800fd116edb128392d36dedfbe738174b801445273c7a37b4f453043fa58059"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluedevil-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluedevil;unpack=0"
SRC_URI[x86_64_v2_bluedevil.sha256sum] = "d9ed21031feb2e72bbda3b4bfde15cd686e232f933c55e37fbabb2d30e5e64b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bluedevil-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_bluedevil;unpack=0"
SRC_URI[aarch64_bluedevil.sha256sum] = "cee652f3af70d61a809ba6a8f7232e5280871dd501629105806a951f56065496"

RDEPENDS:bluedevil = " \
 bluez \
 bluez-obexd \
 glibc \
 kf6-bluez-qt \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libplasma \
 libstdc++ \
 pipewire-pulseaudio \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
