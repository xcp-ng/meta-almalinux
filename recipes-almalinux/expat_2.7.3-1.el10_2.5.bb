# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "expat"
PV = "2.7.3"
PR = "1.el10_2.5"
PACKAGES = " \
 expat \
 expat-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/expat-2.7.3-1.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "34a1f30bbe0a610d6152ce0505a088e4b115ae8a097565aa95c1b5f6f5279c93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/expat-2.7.3-1.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_expat;unpack=0"
SRC_URI[x86_64_v2_expat.sha256sum] = "dfbc954c9f30c5daab73fd6b44a6db8b8bfe693f261d0e1607b17bac351b9741"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/expat-devel-2.7.3-1.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_expat-devel;unpack=0"
SRC_URI[x86_64_v2_expat-devel.sha256sum] = "5d1310b36374412e9615fa9c50c57542359092b003be2d22921c4bc4bafac85c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/expat-2.7.3-1.el10_2.5.aarch64.rpm;name=aarch64_expat;unpack=0"
SRC_URI[aarch64_expat.sha256sum] = "c2419008163b0cf73a990a166d8e3d0e4a9e1821b748fdb34fc94d8cd31cfd6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/expat-devel-2.7.3-1.el10_2.5.aarch64.rpm;name=aarch64_expat-devel;unpack=0"
SRC_URI[aarch64_expat-devel.sha256sum] = "5447040fb05a0dc0bf3bb1ad3c660c6336bd4e2e23541651d7c2af4b00c28fae"

RDEPENDS:expat = " \
 glibc \
 "
RDEPENDS:expat-devel = " \
 expat \
 pkgconf-pkg-config \
 "
