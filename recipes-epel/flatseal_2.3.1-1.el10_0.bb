# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatseal"
PV = "2.3.1"
PR = "1.el10_0"
PACKAGES = " \
 flatseal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flatseal-2.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fda1bfa932d2ec49bfa62e6e21fff9d4551fe8139986b20515eae6f5e129bf9f"

URI_x86_64_v2_flatseal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flatseal-2.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_flatseal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatseal}"
SRC_URI[x86_64_v2_flatseal.sha256sum] = "15a5b35d67670d9b39822cb36866d6b291f3c34eb034217c54fa136e548b6374"

URI_aarch64_flatseal = "${EPEL_MIRROR}/aarch64/Packages/f/flatseal-2.3.1-1.el10_0.noarch.rpm;name=aarch64_flatseal;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatseal}"
SRC_URI[aarch64_flatseal.sha256sum] = "45d9f1876535b131cf15e657b9af5bb44b9927455e825557f8e264b0a1ed6a0e"

RDEPENDS:flatseal = " \
 appstream \
 gjs \
 gtk4 \
 libadwaita \
 webkitgtk6.0 \
 "
