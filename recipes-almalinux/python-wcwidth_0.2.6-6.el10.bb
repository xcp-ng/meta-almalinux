# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wcwidth"
PV = "0.2.6"
PR = "6.el10"
PACKAGES = " \
 python3-wcwidth \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-wcwidth-0.2.6-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eafacb2eb4f4b063c91c5ee9cd96d31aa7ac66fcc636bcd08a505479799d76b2"

URI_x86_64_v2_python3-wcwidth = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-wcwidth-0.2.6-6.el10.noarch.rpm;name=x86_64_v2_python3-wcwidth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wcwidth}"
SRC_URI[x86_64_v2_python3-wcwidth.sha256sum] = "9ce2e99b4e9c2df1ec81e1235345b4941e57bdfdd66785ec65ebfb342a99e02f"

URI_aarch64_python3-wcwidth = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-wcwidth-0.2.6-6.el10.noarch.rpm;name=aarch64_python3-wcwidth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wcwidth}"
SRC_URI[aarch64_python3-wcwidth.sha256sum] = "9ce2e99b4e9c2df1ec81e1235345b4941e57bdfdd66785ec65ebfb342a99e02f"

RDEPENDS:python3-wcwidth = " \
 python3 \
 "
