# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-terminal-exec"
PV = "0.13.2"
PR = "1.el10_0"
PACKAGES = " \
 xdg-terminal-exec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xdg-terminal-exec-0.13.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8439a21d9dbb106f958d261a2c06e0e126ef4d09830ffc5237d94611524ccbd5"

URI_x86_64_v2_xdg-terminal-exec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xdg-terminal-exec-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_xdg-terminal-exec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-terminal-exec}"
SRC_URI[x86_64_v2_xdg-terminal-exec.sha256sum] = "e1c283549735007ce6c16bba797d1729864905e71282e848b919745bdb5bf374"

URI_aarch64_xdg-terminal-exec = "${EPEL_MIRROR}/aarch64/Packages/x/xdg-terminal-exec-0.13.2-1.el10_0.noarch.rpm;name=aarch64_xdg-terminal-exec;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-terminal-exec}"
SRC_URI[aarch64_xdg-terminal-exec.sha256sum] = "04438d6ab15a144aec7085ca50e1a2cc25d861468361066479489296751da616"

RDEPENDS:xdg-terminal-exec = " \
 bash \
 "
