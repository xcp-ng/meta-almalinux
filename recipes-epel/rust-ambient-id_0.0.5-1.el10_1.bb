# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ambient-id"
PV = "0.0.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-ambient-id+default-devel \
 rust-ambient-id-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ambient-id-0.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66f7be1f1603663a50f06516297149fc357c9fbcc8792d25e7bd649e97dea304"

URI_x86_64_v2_rust-ambient-id+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id+default-devel-0.0.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id+default-devel}"
SRC_URI[x86_64_v2_rust-ambient-id+default-devel.sha256sum] = "9b0c5f1a2e0ef459560fb2c5c1b60a2021d47f47e4ed49c57c6d58477ff88d6b"

URI_x86_64_v2_rust-ambient-id-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ambient-id-devel-0.0.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ambient-id-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ambient-id-devel}"
SRC_URI[x86_64_v2_rust-ambient-id-devel.sha256sum] = "99a0696624a99be9d381f0e2ba7da96b749a4a29f719a2d790a26d1f499d5a74"

URI_aarch64_rust-ambient-id+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id+default-devel-0.0.5-1.el10_1.noarch.rpm;name=aarch64_rust-ambient-id+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id+default-devel}"
SRC_URI[aarch64_rust-ambient-id+default-devel.sha256sum] = "357c5329673034e090c44652445df7ab1a1858f0ff8eca79bdfb35a00d029a49"

URI_aarch64_rust-ambient-id-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ambient-id-devel-0.0.5-1.el10_1.noarch.rpm;name=aarch64_rust-ambient-id-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ambient-id-devel}"
SRC_URI[aarch64_rust-ambient-id-devel.sha256sum] = "7d238531cb9645355af01019c525d97c4c1dc426702b36cb66ff8aee875a822f"

RDEPENDS:rust-ambient-id+default-devel = " \
 cargo \
 rust-ambient-id-devel \
 "
RDEPENDS:rust-ambient-id-devel = " \
 cargo \
 rust-reqwest+deflate-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+json-devel \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest+rustls-tls-native-roots-devel \
 rust-reqwest-devel \
 rust-reqwest-middleware+default-devel \
 rust-secrecy+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 "
