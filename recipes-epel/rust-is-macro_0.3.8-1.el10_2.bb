# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is-macro"
PV = "0.3.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-is-macro+default-devel \
 rust-is-macro+small-panic-devel \
 rust-is-macro-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-is-macro-0.3.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f12e983da2b89c07548c08d8c22d2d3907b841b5187b5f0663b7c41f80954f6d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-macro+default-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-macro+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-is-macro+default-devel.sha256sum] = "58252e03a5cb5d1a5a5b66308c7faa73f897629adf0496dc911682a27ed4d9cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-macro+small-panic-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-macro+small-panic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-is-macro+small-panic-devel.sha256sum] = "a01c4f1367946af7b1c957fc2899b0ded80a9c2d67fcae925fffbb1116c4df27"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-macro-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-is-macro-devel.sha256sum] = "a3de88205a7853aadfd66bd566de12ab4b3ade86e85f14d1cdc8a6f3876d0bfe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-is-macro+default-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-is-macro+default-devel;unpack=0"
SRC_URI[aarch64_rust-is-macro+default-devel.sha256sum] = "f7a62b7bbf70aa60571982b5ddf947fc43e1bcb3e26846e92af0ce94d0c53d61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-is-macro+small-panic-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-is-macro+small-panic-devel;unpack=0"
SRC_URI[aarch64_rust-is-macro+small-panic-devel.sha256sum] = "149b13770e6dc25e3d044485f4a445f542e1d852147e7781809ba97be6ab76d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-is-macro-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-is-macro-devel;unpack=0"
SRC_URI[aarch64_rust-is-macro-devel.sha256sum] = "538526db2df0ff95b7414238cafc0c5a43b249cdfe2da5a215f2f55856f881d0"

RDEPENDS:rust-is-macro+default-devel = " \
 cargo \
 rust-is-macro-devel \
 "
RDEPENDS:rust-is-macro+small-panic-devel = " \
 cargo \
 rust-is-macro-devel \
 "
RDEPENDS:rust-is-macro-devel = " \
 cargo \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 "
