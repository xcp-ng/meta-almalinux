# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tungstenite0.23"
PV = "0.23.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tungstenite0.23+__rustls-tls-devel \
 rust-tungstenite0.23+data-encoding-devel \
 rust-tungstenite0.23+default-devel \
 rust-tungstenite0.23+handshake-devel \
 rust-tungstenite0.23+http-devel \
 rust-tungstenite0.23+httparse-devel \
 rust-tungstenite0.23+native-tls-crate-devel \
 rust-tungstenite0.23+native-tls-devel \
 rust-tungstenite0.23+rustls-devel \
 rust-tungstenite0.23+rustls-native-certs-devel \
 rust-tungstenite0.23+rustls-pki-types-devel \
 rust-tungstenite0.23+rustls-tls-native-roots-devel \
 rust-tungstenite0.23+rustls-tls-webpki-roots-devel \
 rust-tungstenite0.23+sha1-devel \
 rust-tungstenite0.23+url-devel \
 rust-tungstenite0.23+webpki-roots-devel \
 rust-tungstenite0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tungstenite0.23-0.23.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1d20fc150902b1803e36554d18ef4d6c84cfc92aea66430488513e7f3198b19"

URI_x86_64_v2_rust-tungstenite0.23+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+__rustls-tls-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+__rustls-tls-devel.sha256sum] = "99f4ccd6e1f20a04a04e0c93317e85d1b93d58a61193c4b8394b45aaaad98bb5"

URI_x86_64_v2_rust-tungstenite0.23+data-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+data-encoding-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+data-encoding-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+data-encoding-devel.sha256sum] = "e0340d06f8f0e97057207d7f2d5b50722e7e89bdf1d6601f0533590f2a0d4f36"

URI_x86_64_v2_rust-tungstenite0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+default-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+default-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+default-devel.sha256sum] = "663a65bc2592c838dc8c058e02d7633479db48a01ddaa1b49582dd2c36ace27d"

URI_x86_64_v2_rust-tungstenite0.23+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+handshake-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+handshake-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+handshake-devel.sha256sum] = "2c9a56b095a8da0128ac628e7dc242a54e27a0d6f9cc3e0708b428d953347cbd"

URI_x86_64_v2_rust-tungstenite0.23+http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+http-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+http-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+http-devel.sha256sum] = "7222498be1f08a4aa49f0f4c4ce379d43dfad8ab3f06f034083a3afa30c6e220"

URI_x86_64_v2_rust-tungstenite0.23+httparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+httparse-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+httparse-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+httparse-devel.sha256sum] = "6aa93533b9824a095842ec7beac6b2b48c13414f34e6c0112bd2207b7ef35680"

URI_x86_64_v2_rust-tungstenite0.23+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+native-tls-crate-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+native-tls-crate-devel.sha256sum] = "971cfe8354bc49fecb671706748d2310b3192b3aae04a8d54a4c211d696611f8"

URI_x86_64_v2_rust-tungstenite0.23+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+native-tls-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+native-tls-devel.sha256sum] = "f80e743d3f91b15bce9a099d6796449aa1f1e981712cb6e04452c29f06b7c645"

URI_x86_64_v2_rust-tungstenite0.23+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+rustls-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+rustls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+rustls-devel.sha256sum] = "f84ba49d13351af43464c76647c0e087a6d1d9aab6f8bc144fda09663c2225ae"

URI_x86_64_v2_rust-tungstenite0.23+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+rustls-native-certs-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+rustls-native-certs-devel.sha256sum] = "f79881771eae60a7ba39b253ab81de15dd19e00ac81efc8a394a94f0a24ffac6"

URI_x86_64_v2_rust-tungstenite0.23+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+rustls-pki-types-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+rustls-pki-types-devel.sha256sum] = "77d804e6ab86c2c33843d5ac5003ab471836f1a5526e338b051b7f4326a70d7e"

URI_x86_64_v2_rust-tungstenite0.23+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+rustls-tls-native-roots-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+rustls-tls-native-roots-devel.sha256sum] = "2715a6fa1c6bad3b9b7315d5fe39285e6535b43657d447a90688a2455b88d37a"

URI_x86_64_v2_rust-tungstenite0.23+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+rustls-tls-webpki-roots-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+rustls-tls-webpki-roots-devel.sha256sum] = "5cbb9e12d424eabecf78fd6b9699a3a068ee1ea77ada084ebaa984cc88c00a04"

URI_x86_64_v2_rust-tungstenite0.23+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+sha1-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+sha1-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+sha1-devel.sha256sum] = "55005a5d557ab3e6849a87b0ada738b69f964276a34361a32a97f71e2bc5aaee"

URI_x86_64_v2_rust-tungstenite0.23+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+url-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+url-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+url-devel.sha256sum] = "f022c3f5ab49f02cce7e64c20e9f5cbc58d7e33798c9f682c3cf3aa67c15b809"

URI_x86_64_v2_rust-tungstenite0.23+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23+webpki-roots-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23+webpki-roots-devel.sha256sum] = "2cef0e9fdf180b9c89d457080072502fcef2c5194043b46c7432d4c69a33a981"

URI_x86_64_v2_rust-tungstenite0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite0.23-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite0.23-devel}"
SRC_URI[x86_64_v2_rust-tungstenite0.23-devel.sha256sum] = "2178d1f27798d3d8cc0acfaac1c838cdcc072522262571a6270c15f755137039"

URI_aarch64_rust-tungstenite0.23+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+__rustls-tls-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+__rustls-tls-devel.sha256sum] = "15bafc26109f751fe23c482540c621ff3877749ac87afd3248d45db831841d5d"

URI_aarch64_rust-tungstenite0.23+data-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+data-encoding-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+data-encoding-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+data-encoding-devel.sha256sum] = "2886c968c7f330003998aace8a9876b814a611f25223b942121ebb65911f995b"

URI_aarch64_rust-tungstenite0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+default-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+default-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+default-devel.sha256sum] = "3553c94a790dd91dbead608c97307340f49443bb0dcbed44246a7e2725b47578"

URI_aarch64_rust-tungstenite0.23+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+handshake-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+handshake-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+handshake-devel.sha256sum] = "d63021c1dac87563e06d382495ffaaa5f5f5cc855d5c86c1e3e634df88eeea79"

URI_aarch64_rust-tungstenite0.23+http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+http-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+http-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+http-devel.sha256sum] = "ed5cf04645805c642dc3eb7343765e61a87ee9c200b46fb5df526916410be7d2"

URI_aarch64_rust-tungstenite0.23+httparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+httparse-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+httparse-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+httparse-devel.sha256sum] = "f089ee04cfc1fd74d3136a6b095b911b61168bd96587045807850c50ab869129"

URI_aarch64_rust-tungstenite0.23+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+native-tls-crate-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+native-tls-crate-devel.sha256sum] = "d5b2585e50c1b5d08267ee5b63e4e81b1888efa5921b23a77f125f935b525926"

URI_aarch64_rust-tungstenite0.23+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+native-tls-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+native-tls-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+native-tls-devel.sha256sum] = "235213ffadfc24390e4ccdbb24fccf7528882065cba2dd74fff5ceca776cd0f6"

URI_aarch64_rust-tungstenite0.23+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+rustls-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+rustls-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+rustls-devel.sha256sum] = "91e58d46df28a739b3dad8d1f7b3ef4384021640c4961cbabb159ecd75323d53"

URI_aarch64_rust-tungstenite0.23+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+rustls-native-certs-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+rustls-native-certs-devel.sha256sum] = "7c95897d50a8b9f361ad2c587f68444d1ae33a1c22db97cd362cff449d2a1792"

URI_aarch64_rust-tungstenite0.23+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+rustls-pki-types-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+rustls-pki-types-devel.sha256sum] = "6e1124b307047c72d44a336fe3bc533e67475afeccd2004b0c6a3395df646368"

URI_aarch64_rust-tungstenite0.23+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+rustls-tls-native-roots-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+rustls-tls-native-roots-devel.sha256sum] = "aee3194157581e56c78724b12ca13129bb90542750038bccaccf7cc6d3951d9f"

URI_aarch64_rust-tungstenite0.23+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+rustls-tls-webpki-roots-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+rustls-tls-webpki-roots-devel.sha256sum] = "b71e48455189732d9b67b14431bf2d857fa616a55352d48a76e4538a80799122"

URI_aarch64_rust-tungstenite0.23+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+sha1-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+sha1-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+sha1-devel.sha256sum] = "9b3d7980af9f66eb6634e1c9749fd3523d4381912fc312f9695218f68959d43c"

URI_aarch64_rust-tungstenite0.23+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+url-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+url-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+url-devel.sha256sum] = "6d8dc01aa8342821aae98907eaf0a22da3cfbf2c3aa45e5a704117e5007cbc04"

URI_aarch64_rust-tungstenite0.23+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23+webpki-roots-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23+webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite0.23+webpki-roots-devel.sha256sum] = "74eb292bbd52ceadd23c1bd4a37e314706397890c600b5ac2abcf2bf4802dab1"

URI_aarch64_rust-tungstenite0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite0.23-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite0.23-devel}"
SRC_URI[aarch64_rust-tungstenite0.23-devel.sha256sum] = "ad4fa45acf1337915c81541c2d6a8ffa8aec595a6dde8516beb09ee3f5776a79"

RDEPENDS:rust-tungstenite0.23+__rustls-tls-devel = " \
 cargo \
 rust-tungstenite0.23+rustls-devel \
 rust-tungstenite0.23+rustls-pki-types-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+data-encoding-devel = " \
 cargo \
 rust-data-encoding+default-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+default-devel = " \
 cargo \
 rust-tungstenite0.23+handshake-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+handshake-devel = " \
 cargo \
 rust-tungstenite0.23+data-encoding-devel \
 rust-tungstenite0.23+http-devel \
 rust-tungstenite0.23+httparse-devel \
 rust-tungstenite0.23+sha1-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+http-devel = " \
 cargo \
 rust-http+default-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+httparse-devel = " \
 cargo \
 rust-httparse+default-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+native-tls-devel = " \
 cargo \
 rust-tungstenite0.23+native-tls-crate-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+rustls-devel = " \
 cargo \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs0.7+default-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tungstenite0.23+__rustls-tls-devel \
 rust-tungstenite0.23+rustls-native-certs-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tungstenite0.23+__rustls-tls-devel \
 rust-tungstenite0.23+webpki-roots-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+sha1-devel = " \
 cargo \
 rust-sha1_0.10+default-devel \
 rust-tungstenite0.23-devel \
 "
RDEPENDS:rust-tungstenite0.23+url-devel = " \
 cargo \
 rust-tungstenite0.23-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-tungstenite0.23+webpki-roots-devel = " \
 cargo \
 rust-tungstenite0.23-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-tungstenite0.23-devel = " \
 cargo \
 rust \
 rust-byteorder+default-devel \
 rust-bytes+default-devel \
 rust-log+default-devel \
 rust-rand0.8+default-devel \
 rust-thiserror1+default-devel \
 rust-utf-8+default-devel \
 "
