# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nftables"
PE = "1"
PV = "1.1.5"
PR = "5.el10_2"
PACKAGES = " \
 nftables \
 nftables-devel \
 python3-nftables \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nftables-1.1.5-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3126dbfb4aa795c92e9350fe2327e2edbdc84844f15b2d9cd574c27247749c49"

URI_x86_64_v2_nftables = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nftables-1.1.5-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_nftables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nftables}"
SRC_URI[x86_64_v2_nftables.sha256sum] = "0eec0f6d4cfe653a122be5981cd7d2424ef5c87e819ec7ed578f0ba7c6b4b0bc"

URI_x86_64_v2_nftables-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nftables-devel-1.1.5-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_nftables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nftables-devel}"
SRC_URI[x86_64_v2_nftables-devel.sha256sum] = "87a93618928c9c8dccae4db0eebeee9ef3c7c4f01a11a1aeaf7642574e259fd2"

URI_x86_64_v2_python3-nftables = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-nftables-1.1.5-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-nftables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nftables}"
SRC_URI[x86_64_v2_python3-nftables.sha256sum] = "029fe0dfa021109a3cfcece7e601d90cdce3ef46184d65e3eef467bbd52eb903"

URI_aarch64_nftables = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nftables-1.1.5-5.el10_2.aarch64.rpm;name=aarch64_nftables;unpack=0"
SRC_URI:append = " ${URI_aarch64_nftables}"
SRC_URI[aarch64_nftables.sha256sum] = "8fa9af3a99a4945bf8719950c3720495f198a4d7215f8d7630e516ac1f70b5e9"

URI_aarch64_nftables-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nftables-devel-1.1.5-5.el10_2.aarch64.rpm;name=aarch64_nftables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nftables-devel}"
SRC_URI[aarch64_nftables-devel.sha256sum] = "595f9e4e4a305c3bc72e33e2536b9aadb3fdd3230ddce1abcfcee8fffcb639f8"

URI_aarch64_python3-nftables = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-nftables-1.1.5-5.el10_2.aarch64.rpm;name=aarch64_python3-nftables;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nftables}"
SRC_URI[aarch64_python3-nftables.sha256sum] = "fc0d3d7a660c7cbdcd8702895705b5211e13a918e72c38104032c651d207dd0a"

RDEPENDS:nftables = " \
 bash \
 glibc \
 gmp \
 iptables-libs \
 jansson \
 libmnl \
 libnftnl \
 readline \
 "
RDEPENDS:nftables-devel = " \
 nftables \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-nftables = " \
 nftables \
 python3 \
 "
