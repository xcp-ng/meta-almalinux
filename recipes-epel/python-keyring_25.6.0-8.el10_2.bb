# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-keyring"
PV = "25.6.0"
PR = "8.el10_2"
PACKAGES = " \
 python3-keyring \
 python3-keyring+completion \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-keyring-25.6.0-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bb3faa8cfaadac56ed16290a073ca8abecad585a55e344df5c6b5c0b1f63c2b"

URI_x86_64_v2_python3-keyring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keyring-25.6.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keyring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keyring}"
SRC_URI[x86_64_v2_python3-keyring.sha256sum] = "903b46639f43dd439f331775f573f19bc0ffcda8235a7f577014ee3fd064799c"

URI_x86_64_v2_python3-keyring+completion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-keyring+completion-25.6.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-keyring+completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keyring+completion}"
SRC_URI[x86_64_v2_python3-keyring+completion.sha256sum] = "0e31b7eca43d1a1b07bca72f0467190aa6af97aaeec8be0c9ba33dd039fe7640"

URI_aarch64_python3-keyring = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keyring-25.6.0-8.el10_2.noarch.rpm;name=aarch64_python3-keyring;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keyring}"
SRC_URI[aarch64_python3-keyring.sha256sum] = "bd6f41e023afd455d77b31fbf901db343221dfdb5c2b4b1bba055bbeaaee9225"

URI_aarch64_python3-keyring+completion = "${EPEL_MIRROR}/aarch64/Packages/p/python3-keyring+completion-25.6.0-8.el10_2.noarch.rpm;name=aarch64_python3-keyring+completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keyring+completion}"
SRC_URI[aarch64_python3-keyring+completion.sha256sum] = "88a16686ef899b2cb103488de89ecf93d0927f1e6a404e37aba78df9994d51f6"

RDEPENDS:python3-keyring = " \
 python3 \
 python3-jaraco-classes \
 python3-jaraco-context \
 python3-jaraco-functools \
 python3-jeepney \
 python3-secretstorage \
 "
RDEPENDS:python3-keyring+completion = " \
 python3 \
 python3-keyring \
 python3-shtab \
 "
