# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "JUnitParams"
PV = "1.1.1"
PR = "15.el10_3"
PACKAGES = " \
 JUnitParams \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/JUnitParams-1.1.1-15.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6396bbec380106040620cd648a72ab61f61973ea8f5f270ff1815839836c8987"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/JUnitParams-1.1.1-15.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_JUnitParams;unpack=0"
SRC_URI[x86_64_v2_JUnitParams.sha256sum] = "4b61c754b29df8e9c030848ebc9912152cfae29efa1d3be46fb2851511cdebcf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/JUnitParams-1.1.1-15.el10_3.noarch.rpm;name=aarch64_JUnitParams;unpack=0"
SRC_URI[aarch64_JUnitParams.sha256sum] = "3aeddaa6a9d7d0d13da18f675314439c4bf82be0cecdb782ec064e130a4b4783"

RDEPENDS:JUnitParams = " \
 javapackages-filesystem \
 junit \
 "
