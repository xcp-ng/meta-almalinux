# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-admin"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kio-admin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-admin-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a04eac45936342e03c56a7efb97c90bebb4fc2979c6ef7a90e8048c5428111b"

URI_x86_64_v2_kio-admin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-admin-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-admin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-admin}"
SRC_URI[x86_64_v2_kio-admin.sha256sum] = "4f1aa30ba487e27c22e4e6d84fbd17c31f6d6aa6d61c3d0b2cd5534f7d01481d"

URI_aarch64_kio-admin = "${EPEL_MIRROR}/aarch64/Packages/k/kio-admin-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kio-admin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-admin}"
SRC_URI[aarch64_kio-admin.sha256sum] = "bb95a0e4255b32ca8de400e19b6c58c86cc93a927d8689109d234a914f6da0f9"

RDEPENDS:kio-admin = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 libatomic \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
