# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clang-sys"
PV = "1.9.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-clang-sys+clang_10_0-devel \
 rust-clang-sys+clang_11_0-devel \
 rust-clang-sys+clang_12_0-devel \
 rust-clang-sys+clang_13_0-devel \
 rust-clang-sys+clang_14_0-devel \
 rust-clang-sys+clang_15_0-devel \
 rust-clang-sys+clang_16_0-devel \
 rust-clang-sys+clang_17_0-devel \
 rust-clang-sys+clang_18_0-devel \
 rust-clang-sys+clang_19_0-devel \
 rust-clang-sys+clang_20_0-devel \
 rust-clang-sys+clang_3_5-devel \
 rust-clang-sys+clang_3_6-devel \
 rust-clang-sys+clang_3_7-devel \
 rust-clang-sys+clang_3_8-devel \
 rust-clang-sys+clang_3_9-devel \
 rust-clang-sys+clang_4_0-devel \
 rust-clang-sys+clang_5_0-devel \
 rust-clang-sys+clang_6_0-devel \
 rust-clang-sys+clang_7_0-devel \
 rust-clang-sys+clang_8_0-devel \
 rust-clang-sys+clang_9_0-devel \
 rust-clang-sys+default-devel \
 rust-clang-sys+libcpp-devel \
 rust-clang-sys+libloading-devel \
 rust-clang-sys+runtime-devel \
 rust-clang-sys+static-devel \
 rust-clang-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-clang-sys-1.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b9983fc94a1c7772fc80bafd6d7e9bcd3fce21646e6849384159daf7c3850c72"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_10_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_10_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_10_0-devel.sha256sum] = "899d53f10f2a963f8cd1ca20cee2e925cfc43f6591392f16bf1eb9ef71a0647a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_11_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_11_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_11_0-devel.sha256sum] = "55c2ba4a8e87eb56de5bd5e9eec5e38715e5d4d106c88dcad06678fb037e7ea3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_12_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_12_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_12_0-devel.sha256sum] = "cccea3666e03a9328aa34b3e746dcfa92f2a8aa5ae994b27a45bd92d61c2c2ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_13_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_13_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_13_0-devel.sha256sum] = "1bb16b13a82295e46c2e5e673869a8d514c8101e97e540deffc2b91718572660"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_14_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_14_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_14_0-devel.sha256sum] = "2ea524540791e18845a4f1bc92d0a480853f9e1eb2de9306504b05a3b454f0e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_15_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_15_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_15_0-devel.sha256sum] = "ad4249986eecd76130ace0a10a971d1bc982ac953422441a96c08dc7f0147692"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_16_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_16_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_16_0-devel.sha256sum] = "f559b8596a227fc6a30712aee1699a0852cd5d0a4acd88f529dcc8db1949d471"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_17_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_17_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_17_0-devel.sha256sum] = "77f9fdde028d853e380381050523dd7560033208a6c7acdb3c742277c9f3974f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_18_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_18_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_18_0-devel.sha256sum] = "c98223f48c659f8bcdbdada0102744da552981aefcbe84d97f3061897b02a5f6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_19_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_19_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_19_0-devel.sha256sum] = "617184f484db44b590d2aa219dca8fcf70d755ccd1d6cca5fd5871624855b0df"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_20_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_20_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_20_0-devel.sha256sum] = "d40ca0ed63049339b10f2424703580a8061056b512ad461365f831dc485e0d4c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_5-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_5-devel.sha256sum] = "b82d9e01aac14e9224d17b136d4d62814e80eae25385dbf04f5f47787ac21849"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_6-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_6-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_6-devel.sha256sum] = "8ad1d7b495c20fce4b6a6b5429012fd284bd897e70fed31079123c370856cf54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_7-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_7-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_7-devel.sha256sum] = "b4b1f80f4da0f4cb0a561b86d5a04633a6ca40024d3428d1104a828b9385a44d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_8-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_8-devel.sha256sum] = "ac61bfc7caef3cda41f4e76a7b85b1446906f345f6493c5ec1a3ff352cf2b929"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_3_9-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_3_9-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_3_9-devel.sha256sum] = "b04de0bf56a06ffd85fa2305d02d430d9a1ba4b1be14dcebdd6e13445fb382da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_4_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_4_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_4_0-devel.sha256sum] = "9c184120987a955533d34867a80723502b33298c0faccc19d957b25348ee3c64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_5_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_5_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_5_0-devel.sha256sum] = "0e0a4523e874f8eaf73222992caf6d04dcbb8a6ae561a9b4579baff46ce8a7ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_6_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_6_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_6_0-devel.sha256sum] = "391e3c542d43a06f0666bced2e3e925cc5412b58c740bc7cb77696242daa966b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_7_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_7_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_7_0-devel.sha256sum] = "6eff355eaee3be66ac966fdb2b0c45b74cc0eea2c159ee02c39dc27e17edb0a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_8_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_8_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_8_0-devel.sha256sum] = "75755aa0b6e7388ac287bd15611d6664afed3fd4e255a8d4598dddc81037dc48"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+clang_9_0-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+clang_9_0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+clang_9_0-devel.sha256sum] = "5a62668855382f8d30515566df562e76414e2637b3b7e910f079be301994a7eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+default-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+default-devel.sha256sum] = "bc75152b3a47291f5e908db09a21027847367796d3f1cb82a4c2e8a748432f6c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+libcpp-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+libcpp-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+libcpp-devel.sha256sum] = "805de9e777b338e4cca1f437ace09cecb61dac0b2285cabb0f08f348705ac536"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+libloading-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+libloading-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+libloading-devel.sha256sum] = "43b71179c96aedfcab02bb498b05b5e5c3ea3561d7d3a945ac71dd8fb839dce7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+runtime-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+runtime-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+runtime-devel.sha256sum] = "2d63738a9d9367f02efd4ebdf3015639a77494cb7d77821d2c723e37f18146da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys+static-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys+static-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys+static-devel.sha256sum] = "87bb32546f017de6773780eee57ce3b027e9112df81f09219ae5fd88946c95f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clang-sys-devel-1.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clang-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clang-sys-devel.sha256sum] = "602076fe233e77f113ce688dc558467d437bfa1c143fb06cf0ae08f721bafcbd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_10_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_10_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_10_0-devel.sha256sum] = "489c38e24617d91cd7b60ac99becdd6b6ac55a2868b1ace48dcdd478e829fb6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_11_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_11_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_11_0-devel.sha256sum] = "9c627e9a15fff02e50ab70532e575f68849e93b75456e361fc32d75b5a2f9e49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_12_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_12_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_12_0-devel.sha256sum] = "fd232c88126e7b36e0e7eca1d8bcb2c6108cc67723137069ead59fdfb34bc7ff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_13_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_13_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_13_0-devel.sha256sum] = "618223f49a87bf74ce5b215e32c17b6c24931b24f5c0ab12e27a9bedbc45b6c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_14_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_14_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_14_0-devel.sha256sum] = "880e297432ea15ce7b3209432c485da840fc2bd22f914f65a0e91ec3a5ee84a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_15_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_15_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_15_0-devel.sha256sum] = "1eb1399e1cf390d91ff1ce2f8bbef6c459e558484c339d0e38a8c0a294cc8291"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_16_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_16_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_16_0-devel.sha256sum] = "b53679e165722757a1e299cdb3f379f93bfd3bc0a955a32a47c2ab02c86a3d1a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_17_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_17_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_17_0-devel.sha256sum] = "a7a67f6bc00b99b6dd95f335c086fb5e1e997bda399e2cd81fc7b584461f3296"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_18_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_18_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_18_0-devel.sha256sum] = "f68334eebb80f15dbdd39f9a55a1837f8932d5a385fe630644a0da00758a07e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_19_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_19_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_19_0-devel.sha256sum] = "6478d959259ddae1d62aea078ff46d85cd9500d72b0337cce1c25327ea19df5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_20_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_20_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_20_0-devel.sha256sum] = "1858f21f84741a2a961b47037a12690a3e9281cbb9295c9b088699e125829eeb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_5-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_5-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_5-devel.sha256sum] = "3b039b4a4b8d26b0cc1c1714b55fe32a9a207deffe4d86c7040d291b74d6e319"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_6-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_6-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_6-devel.sha256sum] = "01aadf2292e554eaec911aaaa9d2f246845debaf68a26e3a3ef8247be9975a7e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_7-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_7-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_7-devel.sha256sum] = "f3dcfd95ed5f7f09d333a7553c11033d3a0186330c3219cd6590b8257da73567"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_8-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_8-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_8-devel.sha256sum] = "484a52c0ceb1d2b3a92452317bfe1bbee3d0bd64ecdea0de124dbe0791db958f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_3_9-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_3_9-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_3_9-devel.sha256sum] = "d83175b5474467fe44b7c267de2b3eab5d15455da676250172c2683d556ef384"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_4_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_4_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_4_0-devel.sha256sum] = "15342c981bb148253d3b756fdab65cba68a2d022c409c641e0c021eaf9340464"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_5_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_5_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_5_0-devel.sha256sum] = "5ba3e6a489d24b3ec5d438227dbb7d89d9c4cfe83c534b350a2d0d22144e751d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_6_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_6_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_6_0-devel.sha256sum] = "f8f941b70bc792e19e73c7e32f3b91a38c6d37d3002747bcf57f9fc0321b3993"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_7_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_7_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_7_0-devel.sha256sum] = "40ba5f2a889dbf6c9226ef92285eefc13bf1d87e4c2bcbac000c2d98e5d902de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_8_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_8_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_8_0-devel.sha256sum] = "0d9b65413fc1b1d842ee3dab84e248811ffb488371304bc4b461f121f9edf422"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+clang_9_0-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+clang_9_0-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+clang_9_0-devel.sha256sum] = "4ac60e21dc41272e729bb2c31ada68ee805121fcccc5a8a1ce0f4f5ecd610062"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+default-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+default-devel.sha256sum] = "e81e50467de50b69adecf660c4b8d584e432b492b52d34f6d0e4409961aa3b42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+libcpp-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+libcpp-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+libcpp-devel.sha256sum] = "46154d07a50b6373e32fcfa69ea773b319797f60921f9f3b2b724b854fe7b75c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+libloading-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+libloading-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+libloading-devel.sha256sum] = "02197980c32c850af9edb8a5a50d3816d700b792658d47cde4bd38d6285ac614"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+runtime-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+runtime-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+runtime-devel.sha256sum] = "d451f88dfa1d1a79c23dbcc1b2b61be7e52811bb7d1eff13f0cd9b776e2e1edd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys+static-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys+static-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys+static-devel.sha256sum] = "9352dd3fd50f0264ab07aae37bb0a9e9bcea5b1a3578e53b4764e3408fec660d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clang-sys-devel-1.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-clang-sys-devel;unpack=0"
SRC_URI[aarch64_rust-clang-sys-devel.sha256sum] = "11bb995039684964dba4df1275c7c2dde20304110f98f31b23191956d8972843"

RDEPENDS:rust-clang-sys+clang_10_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_9_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_11_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_10_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_12_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_11_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_13_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_12_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_14_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_13_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_15_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_14_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_16_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_15_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_17_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_16_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_18_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_17_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_19_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_18_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_20_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_19_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_5-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_6-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_5-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_7-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_6-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_8-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_7-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_3_9-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_8-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_4_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_3_9-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_5_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_4_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_6_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_5_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_7_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_6_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_8_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_7_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+clang_9_0-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys+clang_8_0-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+default-devel = " \
 cargo \
 clang-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+libcpp-devel = " \
 cargo \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+libloading-devel = " \
 cargo \
 rust-clang-sys-devel \
 rust-libloading+default-devel \
 "
RDEPENDS:rust-clang-sys+runtime-devel = " \
 cargo \
 clang-libs \
 rust-clang-sys+libloading-devel \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys+static-devel = " \
 cargo \
 rust-clang-sys-devel \
 "
RDEPENDS:rust-clang-sys-devel = " \
 cargo \
 rust-glob+default-devel \
 rust-libc-devel \
 "
