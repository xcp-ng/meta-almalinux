# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-UseAllModules"
PV = "0.17"
PR = "25.el10_0"
PACKAGES = " \
 perl-Test-UseAllModules \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Test-UseAllModules-0.17-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d6d1c1c53362a8aa7a265858e57c80326d513eb1e3bc7d82dc9e7480e345e6da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-UseAllModules-0.17-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-UseAllModules;unpack=0"
SRC_URI[x86_64_v2_perl-Test-UseAllModules.sha256sum] = "f3a9a702f45b5525bbbb3916c19186ce88700e4f1936c0b54432e77a3c81af9d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-UseAllModules-0.17-25.el10_0.noarch.rpm;name=aarch64_perl-Test-UseAllModules;unpack=0"
SRC_URI[aarch64_perl-Test-UseAllModules.sha256sum] = "eb7d43aebd5c59f89aeedc8f9cf56ac4fe096676a836fdb9f796d85f4615d9fa"

RDEPENDS:perl-Test-UseAllModules = " \
 perl-Exporter \
 perl-ExtUtils-Manifest \
 perl-Test-Simple \
 perl-libs \
 "
