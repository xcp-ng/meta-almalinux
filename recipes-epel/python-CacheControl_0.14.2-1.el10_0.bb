# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-CacheControl"
PV = "0.14.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-CacheControl \
 python3-CacheControl+filecache \
 python3-CacheControl+redis \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-CacheControl-0.14.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7ce55cbc9e643a46be0003d9dfda34a924492dea73c1de6e4964087999d0449"

URI_x86_64_v2_python3-CacheControl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-CacheControl-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-CacheControl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-CacheControl}"
SRC_URI[x86_64_v2_python3-CacheControl.sha256sum] = "50be5567a1f4ef1a426dbfcab24297782e21361a918f6974ee5b5777ba13a3dd"

URI_x86_64_v2_python3-CacheControl+filecache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-CacheControl+filecache-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-CacheControl+filecache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-CacheControl+filecache}"
SRC_URI[x86_64_v2_python3-CacheControl+filecache.sha256sum] = "dd6f55a60306a4c91ef0f13068a698e04b071f349acc7a50ddfe7fdac184ab13"

URI_x86_64_v2_python3-CacheControl+redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-CacheControl+redis-0.14.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-CacheControl+redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-CacheControl+redis}"
SRC_URI[x86_64_v2_python3-CacheControl+redis.sha256sum] = "8fe730b2edf72b533b4d22e528f459349888417657369c104ba7c4751eb7df71"

URI_aarch64_python3-CacheControl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-CacheControl-0.14.2-1.el10_0.noarch.rpm;name=aarch64_python3-CacheControl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-CacheControl}"
SRC_URI[aarch64_python3-CacheControl.sha256sum] = "fdccb24e820a6a30d7092636ae0ec5f38ea4e839b783a0d8bc5d3e580dd0f8e5"

URI_aarch64_python3-CacheControl+filecache = "${EPEL_MIRROR}/aarch64/Packages/p/python3-CacheControl+filecache-0.14.2-1.el10_0.noarch.rpm;name=aarch64_python3-CacheControl+filecache;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-CacheControl+filecache}"
SRC_URI[aarch64_python3-CacheControl+filecache.sha256sum] = "09de49707ccc07540ffe52c5b9ea853a43d016719fc50ed32ed4de56b80a5db1"

URI_aarch64_python3-CacheControl+redis = "${EPEL_MIRROR}/aarch64/Packages/p/python3-CacheControl+redis-0.14.2-1.el10_0.noarch.rpm;name=aarch64_python3-CacheControl+redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-CacheControl+redis}"
SRC_URI[aarch64_python3-CacheControl+redis.sha256sum] = "730ad5fcc2dab03aa3c2e629c613054c9ddf14e1b25f16829f0b7f3865c58ba3"

RDEPENDS:python3-CacheControl = " \
 python3 \
 python3-msgpack \
 python3-requests \
 "
RDEPENDS:python3-CacheControl+filecache = " \
 python3 \
 python3-CacheControl \
 python3-filelock \
 "
RDEPENDS:python3-CacheControl+redis = " \
 python3 \
 python3-CacheControl \
 python3-redis \
 "
