# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum"
PV = "0.8.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-axum+__private-devel \
 rust-axum+default-devel \
 rust-axum+form-devel \
 rust-axum+http1-devel \
 rust-axum+http2-devel \
 rust-axum+json-devel \
 rust-axum+macros-devel \
 rust-axum+matched-path-devel \
 rust-axum+multipart-devel \
 rust-axum+original-uri-devel \
 rust-axum+query-devel \
 rust-axum+serde-devel \
 rust-axum+tokio-devel \
 rust-axum+tower-http-devel \
 rust-axum+tower-log-devel \
 rust-axum+tracing-devel \
 rust-axum+ws-devel \
 rust-axum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-0.8.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "433897cfb2ec13a1429c139d8790b96ce34dd3292ced44aa33b25a85338a6839"

URI_x86_64_v2_rust-axum+__private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+__private-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+__private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+__private-devel}"
SRC_URI[x86_64_v2_rust-axum+__private-devel.sha256sum] = "5bdb1fd18f79d172225e18f85d1bc31c759100553356edc8864b253b778579b0"

URI_x86_64_v2_rust-axum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+default-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+default-devel}"
SRC_URI[x86_64_v2_rust-axum+default-devel.sha256sum] = "0c93e4bc22d1cc7b90f4e4669e6180c42b886580fb4ac2618fcfb8d3aa76fe5f"

URI_x86_64_v2_rust-axum+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+form-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+form-devel}"
SRC_URI[x86_64_v2_rust-axum+form-devel.sha256sum] = "9a7aa2bee4729b481950cf6d2103ce487bc58b9a87c6e5737d59fed7d34ac847"

URI_x86_64_v2_rust-axum+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+http1-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+http1-devel}"
SRC_URI[x86_64_v2_rust-axum+http1-devel.sha256sum] = "03f88cb91d3a47f4db65c22c0a5251584f618d5fdce8edf18f4134d6a29ac69d"

URI_x86_64_v2_rust-axum+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+http2-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+http2-devel}"
SRC_URI[x86_64_v2_rust-axum+http2-devel.sha256sum] = "8ebe7d277b67670562f276037be18c1bdc4e4b26ebc7dd07e34d80eb767b8640"

URI_x86_64_v2_rust-axum+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+json-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+json-devel}"
SRC_URI[x86_64_v2_rust-axum+json-devel.sha256sum] = "f773621aaa776ed1913faf665c57215a09fe4c154fe9e2397831e9d6bf8da0c0"

URI_x86_64_v2_rust-axum+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+macros-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+macros-devel}"
SRC_URI[x86_64_v2_rust-axum+macros-devel.sha256sum] = "bca0538470f8df4a8ea40d04260214211010e8de06c0f868d96a938dbf8c41ce"

URI_x86_64_v2_rust-axum+matched-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+matched-path-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+matched-path-devel}"
SRC_URI[x86_64_v2_rust-axum+matched-path-devel.sha256sum] = "04ca6f60d7f1d1b532fc4fa852070c4ef07ae1106d83079613d9902fc5fd0bd1"

URI_x86_64_v2_rust-axum+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+multipart-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+multipart-devel}"
SRC_URI[x86_64_v2_rust-axum+multipart-devel.sha256sum] = "c7c7274b9e282f41cc0cb92d81479ad814898795f98748e35f8b11a75e2c788a"

URI_x86_64_v2_rust-axum+original-uri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+original-uri-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+original-uri-devel}"
SRC_URI[x86_64_v2_rust-axum+original-uri-devel.sha256sum] = "6039b674d113e71bd9da2245155bda63d8e5b6d518527bda74542aa4f54cfd01"

URI_x86_64_v2_rust-axum+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+query-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+query-devel}"
SRC_URI[x86_64_v2_rust-axum+query-devel.sha256sum] = "88314d790ab6687097d8a148f4f34d665036b32bb98b879714337885f862ba0a"

URI_x86_64_v2_rust-axum+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+serde-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+serde-devel}"
SRC_URI[x86_64_v2_rust-axum+serde-devel.sha256sum] = "349cc2a6b92c9f23c1505645eee2ccc4f2d54de6d3899ca7040a7ae177e799eb"

URI_x86_64_v2_rust-axum+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tokio-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tokio-devel}"
SRC_URI[x86_64_v2_rust-axum+tokio-devel.sha256sum] = "e36d3bd967e982ce95be54bc9fff06bea5ff47e6f042692075c1c0c9d8ac8d9d"

URI_x86_64_v2_rust-axum+tower-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tower-http-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tower-http-devel}"
SRC_URI[x86_64_v2_rust-axum+tower-http-devel.sha256sum] = "7e0086005f540cb1a15b7d88486da2778bd624a87eafe4e9d239da07c77595c3"

URI_x86_64_v2_rust-axum+tower-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tower-log-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tower-log-devel}"
SRC_URI[x86_64_v2_rust-axum+tower-log-devel.sha256sum] = "4b97ff6b91b72533270bf0d9d9b9f9983c3e652718bcf6fc774893da5f4c675a"

URI_x86_64_v2_rust-axum+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+tracing-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+tracing-devel}"
SRC_URI[x86_64_v2_rust-axum+tracing-devel.sha256sum] = "1e03a171fe0596581feb84f887b9301435ae9b6b1a677503214fbb3e94377d81"

URI_x86_64_v2_rust-axum+ws-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum+ws-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum+ws-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum+ws-devel}"
SRC_URI[x86_64_v2_rust-axum+ws-devel.sha256sum] = "6ff6d29722aa9522759b8b06075fa30216a1626639b1bb049d7763c2ce488955"

URI_x86_64_v2_rust-axum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-devel}"
SRC_URI[x86_64_v2_rust-axum-devel.sha256sum] = "da4fe5fd3adabc9c9493dfb4b98b96e28eb0d7ed75fd7a616c11a830f22de2f8"

URI_aarch64_rust-axum+__private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+__private-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+__private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+__private-devel}"
SRC_URI[aarch64_rust-axum+__private-devel.sha256sum] = "4d1403daeb6c32971cabdae6e2e4880790f25a4ed4c456d8346b16f8d55ba341"

URI_aarch64_rust-axum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+default-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+default-devel}"
SRC_URI[aarch64_rust-axum+default-devel.sha256sum] = "24317ec145a7b6b8ff0b5b0d3e64805a41c317f26a8123b3ec7abe9b1f009e39"

URI_aarch64_rust-axum+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+form-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+form-devel}"
SRC_URI[aarch64_rust-axum+form-devel.sha256sum] = "ec5a02d6354c3e1a0db8a27d13b2b6967a0ee0a8eb24384a1f52803a7e643c64"

URI_aarch64_rust-axum+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+http1-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+http1-devel}"
SRC_URI[aarch64_rust-axum+http1-devel.sha256sum] = "5367fcb182cf8fc60cf6f157e3e559bdf8fa4ffed5a77d2ec764f39cdb4c8d37"

URI_aarch64_rust-axum+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+http2-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+http2-devel}"
SRC_URI[aarch64_rust-axum+http2-devel.sha256sum] = "40b907f2c871e0a4b384b15b0ca1cc83e1bc6956db7a4d8ae794b2be56c01780"

URI_aarch64_rust-axum+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+json-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+json-devel}"
SRC_URI[aarch64_rust-axum+json-devel.sha256sum] = "c7f1c3d2629abf5aeefc74e7646c78211306ae1ee9d43230a29e2268ea7c0482"

URI_aarch64_rust-axum+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+macros-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+macros-devel}"
SRC_URI[aarch64_rust-axum+macros-devel.sha256sum] = "afe11e43aae924c81d4b2b233d4aaf6564c93fa375b41cf3518ebfcb5e3086b7"

URI_aarch64_rust-axum+matched-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+matched-path-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+matched-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+matched-path-devel}"
SRC_URI[aarch64_rust-axum+matched-path-devel.sha256sum] = "a899dd02f824b107229a8cb887ae01fbdef5d0908053684b3bf333f8525cf4f0"

URI_aarch64_rust-axum+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+multipart-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+multipart-devel}"
SRC_URI[aarch64_rust-axum+multipart-devel.sha256sum] = "cc88ec41dced670fbbfd0571f2c930c29054a9a7271e22992c92eca0e7afabec"

URI_aarch64_rust-axum+original-uri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+original-uri-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+original-uri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+original-uri-devel}"
SRC_URI[aarch64_rust-axum+original-uri-devel.sha256sum] = "641f3db9af2c50cff9c15533602a0d14f2fb7d86997a12c100adbf0d86a45d2c"

URI_aarch64_rust-axum+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+query-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+query-devel}"
SRC_URI[aarch64_rust-axum+query-devel.sha256sum] = "e52201e3742c0de550241c31e150920e09cc4faf977170b1705cea15b0b98388"

URI_aarch64_rust-axum+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+serde-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+serde-devel}"
SRC_URI[aarch64_rust-axum+serde-devel.sha256sum] = "b6142acb376481d20d73059dc2d8a90338490302e2b7fab8e087b05a3db12b34"

URI_aarch64_rust-axum+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tokio-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tokio-devel}"
SRC_URI[aarch64_rust-axum+tokio-devel.sha256sum] = "20eea22106acacbfd81a7839ecdd85a0c58b08bd3ab3ba31d60ca62beb6dce04"

URI_aarch64_rust-axum+tower-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tower-http-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+tower-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tower-http-devel}"
SRC_URI[aarch64_rust-axum+tower-http-devel.sha256sum] = "f7ebe92c96281a1c51c124174731f5f87247d90672b1940882d04691ee235e82"

URI_aarch64_rust-axum+tower-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tower-log-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+tower-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tower-log-devel}"
SRC_URI[aarch64_rust-axum+tower-log-devel.sha256sum] = "15398a97b6941c6aba0162d3d1b20dd62803962a81d688ae3a2cb2e0a7aea1f1"

URI_aarch64_rust-axum+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+tracing-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+tracing-devel}"
SRC_URI[aarch64_rust-axum+tracing-devel.sha256sum] = "bce19f0ae42f57bc49b9a335d3ccc0c298527d8ab175490b5ca1ab63da764fa4"

URI_aarch64_rust-axum+ws-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum+ws-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum+ws-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum+ws-devel}"
SRC_URI[aarch64_rust-axum+ws-devel.sha256sum] = "dcc428aec5572432d1fce832e30bca4e2437ad0e7636698d341793e19964768b"

URI_aarch64_rust-axum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-axum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-devel}"
SRC_URI[aarch64_rust-axum-devel.sha256sum] = "e84093b6b70e12423eca44df9b8f139c1007e71fe973ac88b684a413ddeee415"

RDEPENDS:rust-axum+__private-devel = " \
 cargo \
 rust-axum+http1-devel \
 rust-axum+tokio-devel \
 rust-axum-devel \
 rust-axum-macros+__private-devel \
 rust-axum-macros+default-devel \
 rust-reqwest0.12+json-devel \
 rust-reqwest0.12+multipart-devel \
 rust-reqwest0.12+stream-devel \
 rust-reqwest0.12-devel \
 "
RDEPENDS:rust-axum+default-devel = " \
 cargo \
 rust-axum+form-devel \
 rust-axum+http1-devel \
 rust-axum+json-devel \
 rust-axum+matched-path-devel \
 rust-axum+original-uri-devel \
 rust-axum+query-devel \
 rust-axum+tokio-devel \
 rust-axum+tower-log-devel \
 rust-axum+tracing-devel \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+form-devel = " \
 cargo \
 rust-axum-devel \
 rust-form_urlencoded+default-devel \
 rust-serde_path_to_error+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum+http1-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum+http2-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper+default-devel \
 rust-hyper+http2-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 "
RDEPENDS:rust-axum+json-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-serde_path_to_error+default-devel \
 "
RDEPENDS:rust-axum+macros-devel = " \
 cargo \
 rust-axum-devel \
 rust-axum-macros+default-devel \
 "
RDEPENDS:rust-axum+matched-path-devel = " \
 cargo \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+multipart-devel = " \
 cargo \
 rust-axum-devel \
 rust-multer+default-devel \
 "
RDEPENDS:rust-axum+original-uri-devel = " \
 cargo \
 rust-axum-devel \
 "
RDEPENDS:rust-axum+query-devel = " \
 cargo \
 rust-axum-devel \
 rust-form_urlencoded+default-devel \
 rust-serde_path_to_error+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-axum+serde-devel = " \
 cargo \
 rust-axum-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-axum+tokio-devel = " \
 cargo \
 rust-axum-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-tokio+default-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 rust-tower+make-devel \
 "
RDEPENDS:rust-axum+tower-http-devel = " \
 cargo \
 rust-axum-devel \
 rust-tower-http+add-extension-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+default-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+util-devel \
 rust-tower-http+validate-request-devel \
 "
RDEPENDS:rust-axum+tower-log-devel = " \
 cargo \
 rust-axum-devel \
 rust-tower+log-devel \
 "
RDEPENDS:rust-axum+tracing-devel = " \
 cargo \
 rust-axum-core+tracing-devel \
 rust-axum-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-axum+ws-devel = " \
 cargo \
 rust-axum+tokio-devel \
 rust-axum-devel \
 rust-base64_0.22+default-devel \
 rust-hyper+default-devel \
 rust-sha1_0.10+default-devel \
 rust-tokio-tungstenite+default-devel \
 "
RDEPENDS:rust-axum-devel = " \
 cargo \
 rust \
 rust-axum-core+default-devel \
 rust-bytes+default-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-itoa+default-devel \
 rust-matchit0.8+default-devel \
 rust-memchr+default-devel \
 rust-mime+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-serde_core+default-devel \
 rust-sync_wrapper+default-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
