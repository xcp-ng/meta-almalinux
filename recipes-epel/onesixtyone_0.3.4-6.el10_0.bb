# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "onesixtyone"
PV = "0.3.4"
PR = "6.el10_0"
PACKAGES = " \
 onesixtyone \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/onesixtyone-0.3.4-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96b384fb76d697be1ad1ef954016b064781f8ad48382eaf27d71af1e0277ad4f"

URI_x86_64_v2_onesixtyone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/onesixtyone-0.3.4-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_onesixtyone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_onesixtyone}"
SRC_URI[x86_64_v2_onesixtyone.sha256sum] = "d9096412d29ee1dcbc45af6ebd5a077188a55c597385d43c20679c268deb8dee"

URI_aarch64_onesixtyone = "${EPEL_MIRROR}/aarch64/Packages/o/onesixtyone-0.3.4-6.el10_0.aarch64.rpm;name=aarch64_onesixtyone;unpack=0"
SRC_URI:append = " ${URI_aarch64_onesixtyone}"
SRC_URI[aarch64_onesixtyone.sha256sum] = "cec5ebaa888920295fc687428bf901b3a67902fef8808f90da508df2d615cea5"

RDEPENDS:onesixtyone = " \
 glibc \
 "
