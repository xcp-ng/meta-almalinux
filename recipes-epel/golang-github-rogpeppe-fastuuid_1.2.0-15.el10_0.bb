# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-rogpeppe-fastuuid"
PV = "1.2.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-rogpeppe-fastuuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-rogpeppe-fastuuid-1.2.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14576e991e8c76d343d5c9d2a14adbd6f119ed82a7afcfde29834c6fb400aff1"

URI_x86_64_v2_golang-github-rogpeppe-fastuuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-rogpeppe-fastuuid-devel-1.2.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-rogpeppe-fastuuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-rogpeppe-fastuuid-devel}"
SRC_URI[x86_64_v2_golang-github-rogpeppe-fastuuid-devel.sha256sum] = "32d9fa049d2a2adf0428b87d4f1683dacee783f9f5380c9c29f2df91ca12cedd"

URI_aarch64_golang-github-rogpeppe-fastuuid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-rogpeppe-fastuuid-devel-1.2.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-rogpeppe-fastuuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-rogpeppe-fastuuid-devel}"
SRC_URI[aarch64_golang-github-rogpeppe-fastuuid-devel.sha256sum] = "0a2114f4e612938f3a04c8c97d782546e73b13ae0b4840e5d404c7e352ec8cfd"

RDEPENDS:golang-github-rogpeppe-fastuuid-devel = " \
 go-filesystem \
 "
