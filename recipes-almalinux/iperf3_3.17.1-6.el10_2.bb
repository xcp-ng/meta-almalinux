# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iperf3"
PV = "3.17.1"
PR = "6.el10_2"
PACKAGES = " \
 iperf3 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/iperf3-3.17.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99197b99b360bbb606ff30931c069764a18aed5e85aa5c7b4d2431395a164dd4"

URI_x86_64_v2_iperf3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iperf3-3.17.1-6.el10_2.x86_64_v2.rpm;name=x86_64_v2_iperf3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iperf3}"
SRC_URI[x86_64_v2_iperf3.sha256sum] = "7fc0bb27250b3ddd6caba4d821f2c8ee95f462066c8066ccb8139194bddbf96c"

URI_aarch64_iperf3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iperf3-3.17.1-6.el10_2.aarch64.rpm;name=aarch64_iperf3;unpack=0"
SRC_URI:append = " ${URI_aarch64_iperf3}"
SRC_URI[aarch64_iperf3.sha256sum] = "9a63599bb5d8e5df5c4d5139482dea2cfea78f5692a069e37e8db09a84860bfb"

RDEPENDS:iperf3 = " \
 glibc \
 lksctp-tools \
 openssl-libs \
 "
