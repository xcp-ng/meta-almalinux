# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kspaceduel"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kspaceduel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kspaceduel-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3e021ec77403191565647aea39c116483f1871019b2f1e8479f6e58f82ec770"

URI_x86_64_v2_kspaceduel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kspaceduel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kspaceduel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kspaceduel}"
SRC_URI[x86_64_v2_kspaceduel.sha256sum] = "897a845858eff520b1135c32f4ca36d3b9109850be6f61750f6fb126a0edfbf2"

URI_aarch64_kspaceduel = "${EPEL_MIRROR}/aarch64/Packages/k/kspaceduel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kspaceduel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kspaceduel}"
SRC_URI[aarch64_kspaceduel.sha256sum] = "af6aabb15dcd094581919d2512417fae71789a92a04bb51f26cd603316038193"

RDEPENDS:kspaceduel = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
