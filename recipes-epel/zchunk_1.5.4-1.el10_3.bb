# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zchunk"
PV = "1.5.4"
PR = "1.el10_3"
PACKAGES = " \
 zchunk \
 zchunk-devel \
 zchunk-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zchunk-1.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91043ac6e42a68a0a6a7f48df943dedf4bb59ceb0d9c237b3ae1ef2fe8506ce7"

URI_x86_64_v2_zchunk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zchunk-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zchunk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zchunk}"
SRC_URI[x86_64_v2_zchunk.sha256sum] = "0a8d108c1ca64380c029ff6145cc2440ec4fcfb9c0dc1a2e421ed71a3bcb0432"

URI_x86_64_v2_zchunk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zchunk-devel-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zchunk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zchunk-devel}"
SRC_URI[x86_64_v2_zchunk-devel.sha256sum] = "9c51f0e1fd7f18fa6b2ff5b896ea7d2767364d451b7e0ec0426a74025f27efdc"

URI_x86_64_v2_zchunk-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zchunk-libs-1.5.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zchunk-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zchunk-libs}"
SRC_URI[x86_64_v2_zchunk-libs.sha256sum] = "fd055439e919180e8d395ecaf9d488adf0e3975ee1dcbe6db3dff7ca2994ee42"

URI_aarch64_zchunk = "${EPEL_MIRROR}/aarch64/Packages/z/zchunk-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_zchunk;unpack=0"
SRC_URI:append = " ${URI_aarch64_zchunk}"
SRC_URI[aarch64_zchunk.sha256sum] = "27a75a095c8d2a150c0176292ce8bb83f7880cef319897807c10f04db638dd8c"

URI_aarch64_zchunk-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zchunk-devel-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_zchunk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zchunk-devel}"
SRC_URI[aarch64_zchunk-devel.sha256sum] = "f5649128d974640f8b499e4c2dc4c4f176f879f073759c834b205b45dc214db2"

URI_aarch64_zchunk-libs = "${EPEL_MIRROR}/aarch64/Packages/z/zchunk-libs-1.5.4-1.el10_3.aarch64.rpm;name=aarch64_zchunk-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_zchunk-libs}"
SRC_URI[aarch64_zchunk-libs.sha256sum] = "6758d0a359f73ed7fa6ab10c5fe9281aaf714580d6b18557dbca9c18c9638995"

RDEPENDS:zchunk = " \
 glibc \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 zchunk-libs \
 "
RDEPENDS:zchunk-devel = " \
 libzstd-devel \
 openssl-devel \
 pkgconf-pkg-config \
 zchunk-libs \
 "
RDEPENDS:zchunk-libs = " \
 glibc \
 libzstd \
 openssl-libs \
 "
