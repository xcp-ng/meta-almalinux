# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-typing-booster"
PV = "2.25.13"
PR = "2.el10"
PACKAGES = " \
 ibus-typing-booster \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-typing-booster-2.25.13-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56371ab0a8aef4fcf0331a4abcfe345e4551c1ea5b738a054a0cb6ba8b6b65d1"

URI_x86_64_v2_ibus-typing-booster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-typing-booster-2.25.13-2.el10.noarch.rpm;name=x86_64_v2_ibus-typing-booster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-typing-booster}"
SRC_URI[x86_64_v2_ibus-typing-booster.sha256sum] = "deea0e9b6c211f742d228df801416de3ca75c55f6affd44e86905db44c804c7b"

URI_aarch64_ibus-typing-booster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-typing-booster-2.25.13-2.el10.noarch.rpm;name=aarch64_ibus-typing-booster;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-typing-booster}"
SRC_URI[aarch64_ibus-typing-booster.sha256sum] = "deea0e9b6c211f742d228df801416de3ca75c55f6affd44e86905db44c804c7b"

RDEPENDS:ibus-typing-booster = " \
 bash \
 cldr-emoji-annotation \
 ibus \
 m17n-lib \
 python3 \
 python3-dbus \
 python3-distro \
 python3-enchant \
 python3-packaging \
 python3-pyxdg \
 unicode-ucd \
 "
