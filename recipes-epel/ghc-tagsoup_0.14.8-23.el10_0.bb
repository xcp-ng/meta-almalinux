# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tagsoup"
PV = "0.14.8"
PR = "23.el10_0"
PACKAGES = " \
 ghc-tagsoup \
 ghc-tagsoup-devel \
 ghc-tagsoup-doc \
 ghc-tagsoup-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tagsoup-0.14.8-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87bf1a673f64d0d4d4165a5d22d0fd0af816b7d6a69e8babaa1d628dabd56844"

URI_x86_64_v2_ghc-tagsoup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tagsoup-0.14.8-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tagsoup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tagsoup}"
SRC_URI[x86_64_v2_ghc-tagsoup.sha256sum] = "3adf0546428285d7006fa563704c0d1e7998ea51af4f47475a51a1475096d741"

URI_x86_64_v2_ghc-tagsoup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tagsoup-devel-0.14.8-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tagsoup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tagsoup-devel}"
SRC_URI[x86_64_v2_ghc-tagsoup-devel.sha256sum] = "e444bc3239ae574b9f3d2f77f39f199300e026944f749c09c2251d149b3e452a"

URI_x86_64_v2_ghc-tagsoup-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tagsoup-doc-0.14.8-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tagsoup-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tagsoup-doc}"
SRC_URI[x86_64_v2_ghc-tagsoup-doc.sha256sum] = "20ddb418ee8b8ea1ec9395eebb34c95e9facd134480774d84f3c59527b4205d1"

URI_x86_64_v2_ghc-tagsoup-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tagsoup-prof-0.14.8-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tagsoup-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tagsoup-prof}"
SRC_URI[x86_64_v2_ghc-tagsoup-prof.sha256sum] = "361255c402b3fa7eeffc409b0ee11fdd6721bdacda1c26e397169e07abd45666"

URI_aarch64_ghc-tagsoup = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tagsoup-0.14.8-23.el10_0.aarch64.rpm;name=aarch64_ghc-tagsoup;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tagsoup}"
SRC_URI[aarch64_ghc-tagsoup.sha256sum] = "7de0859712da53f804374afbd31e9f0c1f6f7d281c4dbcb5189aa0b3561f8e2a"

URI_aarch64_ghc-tagsoup-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tagsoup-devel-0.14.8-23.el10_0.aarch64.rpm;name=aarch64_ghc-tagsoup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tagsoup-devel}"
SRC_URI[aarch64_ghc-tagsoup-devel.sha256sum] = "0913747eb83ab5008ac97730525141071876a82b2bec61df48b3c52a89e1ad8d"

URI_aarch64_ghc-tagsoup-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tagsoup-doc-0.14.8-23.el10_0.noarch.rpm;name=aarch64_ghc-tagsoup-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tagsoup-doc}"
SRC_URI[aarch64_ghc-tagsoup-doc.sha256sum] = "1509797abde4ce3fd58179432deaaf0718ddeb88323b76c0b5c23e4f13cc044c"

URI_aarch64_ghc-tagsoup-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tagsoup-prof-0.14.8-23.el10_0.aarch64.rpm;name=aarch64_ghc-tagsoup-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tagsoup-prof}"
SRC_URI[aarch64_ghc-tagsoup-prof.sha256sum] = "54ee365e6fc89af0ff13384c21cf3da118f176a068592d69c78e57cea88bdb4e"

RDEPENDS:ghc-tagsoup = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tagsoup-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-tagsoup \
 ghc-text-devel \
 "
RDEPENDS:ghc-tagsoup-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tagsoup-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-tagsoup-devel \
 ghc-text-prof \
 "
