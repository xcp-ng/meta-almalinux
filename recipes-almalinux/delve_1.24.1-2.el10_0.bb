# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "delve"
PV = "1.24.1"
PR = "2.el10_0"
PACKAGES = " \
 delve \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/delve-1.24.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1479fe808ef116d07a6c96d721765aa744d163d7e2e6cbab8d54040fd7a91900"

URI_x86_64_v2_delve = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/delve-1.24.1-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_delve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_delve}"
SRC_URI[x86_64_v2_delve.sha256sum] = "6e29b2cfbb2e17e86d5663e6983d4c8538bdcdea97fa78ee0358ddfb16b23c13"

URI_aarch64_delve = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/delve-1.24.1-2.el10_0.aarch64.rpm;name=aarch64_delve;unpack=0"
SRC_URI:append = " ${URI_aarch64_delve}"
SRC_URI[aarch64_delve.sha256sum] = "fce680a35722e6bb7b6d8fe77865fbf03d7ef47848585bb929035926c9f9a4c5"

RDEPENDS:delve = " \
 glibc \
 "
