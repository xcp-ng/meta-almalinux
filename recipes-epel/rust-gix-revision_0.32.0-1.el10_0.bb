# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-revision"
PV = "0.32.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-revision+default-devel \
 rust-gix-revision+describe-devel \
 rust-gix-revision+document-features-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision+serde-devel \
 rust-gix-revision-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-revision-0.32.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96ad485c907744d89edc2cab76c57e23dfb105c78a7e371dbf4fe467ad918dcd"

URI_x86_64_v2_rust-gix-revision+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+default-devel-0.32.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+default-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+default-devel.sha256sum] = "c6dbf06351920bd9e14b5a465109de9d3cec1d5aec7d9133999b005be3830060"

URI_x86_64_v2_rust-gix-revision+describe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+describe-devel-0.32.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+describe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+describe-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+describe-devel.sha256sum] = "6d4a51f827c4af87def1973838c4363ed4aa3fecb14ef0840bfebb6ede63a820"

URI_x86_64_v2_rust-gix-revision+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+document-features-devel-0.32.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+document-features-devel.sha256sum] = "1b8944f008ebd640e37907c08c1b6f200a2e0a7f947485adb4e43a68725f81a9"

URI_x86_64_v2_rust-gix-revision+merge_base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+merge_base-devel-0.32.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+merge_base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+merge_base-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+merge_base-devel.sha256sum] = "d17a9fbe11917e2bf41b99a46746ccc2dfccd02bd7e428b955295d3c650e7527"

URI_x86_64_v2_rust-gix-revision+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+serde-devel-0.32.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+serde-devel.sha256sum] = "a7104c80bc781dc56d6b9d27e4aca5c1b095bf7bfca71b88ad0fc4e42b3a40d3"

URI_x86_64_v2_rust-gix-revision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision-devel-0.32.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision-devel}"
SRC_URI[x86_64_v2_rust-gix-revision-devel.sha256sum] = "2ea466283942935359c880e7c4f5c193d444eba432f42087c9d7c68e2d79dcb0"

URI_aarch64_rust-gix-revision+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+default-devel-0.32.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-revision+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+default-devel}"
SRC_URI[aarch64_rust-gix-revision+default-devel.sha256sum] = "ab06557428bb675eb4f98e3082d2b707c4cc1ba3bdfbeb502c847305e82e80af"

URI_aarch64_rust-gix-revision+describe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+describe-devel-0.32.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-revision+describe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+describe-devel}"
SRC_URI[aarch64_rust-gix-revision+describe-devel.sha256sum] = "3fbe086d5500c73386853d641993a24647040ce403c7058a763e085643d67af4"

URI_aarch64_rust-gix-revision+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+document-features-devel-0.32.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-revision+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+document-features-devel}"
SRC_URI[aarch64_rust-gix-revision+document-features-devel.sha256sum] = "052e1491e4eb51daf48f2c79e2f3cd4fc4fbf029aa6b6d63a1f5ffb0da1235c9"

URI_aarch64_rust-gix-revision+merge_base-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+merge_base-devel-0.32.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-revision+merge_base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+merge_base-devel}"
SRC_URI[aarch64_rust-gix-revision+merge_base-devel.sha256sum] = "e08b3483e8fe707aa1ca44336687e7239b2eab12577e80290ecca3101da71757"

URI_aarch64_rust-gix-revision+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+serde-devel-0.32.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-revision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+serde-devel}"
SRC_URI[aarch64_rust-gix-revision+serde-devel.sha256sum] = "5f851b6e8aac9b8d3bb2785560fa2d5b4b52428718cc409c224bc86cac55bf84"

URI_aarch64_rust-gix-revision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision-devel-0.32.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-revision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision-devel}"
SRC_URI[aarch64_rust-gix-revision-devel.sha256sum] = "5e31f7045bb753487c2dbe14fd3c6400a7884c5a0219e2068313e8c1eafd309f"

RDEPENDS:rust-gix-revision+default-devel = " \
 cargo \
 rust-gix-revision+describe-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision+describe-devel = " \
 cargo \
 rust-gix-hashtable+default-devel \
 rust-gix-revision-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-revision+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision+merge_base-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-gix-revision-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-revision+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-revision-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-revision-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-thiserror+default-devel \
 "
