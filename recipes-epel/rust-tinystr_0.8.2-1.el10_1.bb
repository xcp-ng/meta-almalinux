# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinystr"
PV = "0.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-tinystr+alloc-devel \
 rust-tinystr+databake-devel \
 rust-tinystr+default-devel \
 rust-tinystr+serde-devel \
 rust-tinystr+std-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tinystr-0.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b4b213f024b636de6ec9acd34e2c09050d4987e977cef3e1d914567dda62b94"

URI_x86_64_v2_rust-tinystr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+alloc-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+alloc-devel}"
SRC_URI[x86_64_v2_rust-tinystr+alloc-devel.sha256sum] = "ebbc4723810379d61c3320852dcc4759635572979a7d90aac0509ee6b1d70458"

URI_x86_64_v2_rust-tinystr+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+databake-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+databake-devel}"
SRC_URI[x86_64_v2_rust-tinystr+databake-devel.sha256sum] = "c1ac91f24eab3ae25391005518b937fa5267435b3d5cb270c2585e14d0f67978"

URI_x86_64_v2_rust-tinystr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+default-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+default-devel}"
SRC_URI[x86_64_v2_rust-tinystr+default-devel.sha256sum] = "d89e9a5cab63499c5f25ae9e6bf2264957032094abdece3d0a1481892c277a31"

URI_x86_64_v2_rust-tinystr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+serde-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+serde-devel}"
SRC_URI[x86_64_v2_rust-tinystr+serde-devel.sha256sum] = "7695c6cac0186de835debbf18e26e41da88e5c1d542780e30c0aef62b893f137"

URI_x86_64_v2_rust-tinystr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+std-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+std-devel}"
SRC_URI[x86_64_v2_rust-tinystr+std-devel.sha256sum] = "b515250d19a871a7c1e7fb53324ef43f30c17bafcc69fa00885b0b1dbfd51bb6"

URI_x86_64_v2_rust-tinystr+zerovec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+zerovec-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr+zerovec-devel}"
SRC_URI[x86_64_v2_rust-tinystr+zerovec-devel.sha256sum] = "ff2fa70a8cdfcb6047f543db7c04b13050d4cd4a79919fb12642e43f97b272ae"

URI_x86_64_v2_rust-tinystr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinystr-devel}"
SRC_URI[x86_64_v2_rust-tinystr-devel.sha256sum] = "75d54e2a7ae1f0cce7e03d1998b2d84f77127306a4ec26dddb4ec26c0af65b8b"

URI_aarch64_rust-tinystr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+alloc-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-tinystr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+alloc-devel}"
SRC_URI[aarch64_rust-tinystr+alloc-devel.sha256sum] = "04275b694b0dd0bfd984ffbecf6b387e861c023d89dc0bf835fdae8e9c33c0b2"

URI_aarch64_rust-tinystr+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+databake-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-tinystr+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+databake-devel}"
SRC_URI[aarch64_rust-tinystr+databake-devel.sha256sum] = "7d947c99e966630ee3b7ce42eae86a5433872ff0e05d24adf3eac4f48b385515"

URI_aarch64_rust-tinystr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+default-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-tinystr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+default-devel}"
SRC_URI[aarch64_rust-tinystr+default-devel.sha256sum] = "1aa4877006799d91936e2d227b9de55fa6f3d484acccd05d78bf9a0539d10801"

URI_aarch64_rust-tinystr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+serde-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-tinystr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+serde-devel}"
SRC_URI[aarch64_rust-tinystr+serde-devel.sha256sum] = "5d904cfa91058c92ada978e9c705ca03ad574d424f8caed233275c8b0f09e9f9"

URI_aarch64_rust-tinystr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+std-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-tinystr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+std-devel}"
SRC_URI[aarch64_rust-tinystr+std-devel.sha256sum] = "6480829b8f449c93200d0880fe0562d09bca021731098c1f53ac4dc7211b3e31"

URI_aarch64_rust-tinystr+zerovec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+zerovec-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr+zerovec-devel}"
SRC_URI[aarch64_rust-tinystr+zerovec-devel.sha256sum] = "fda673aac1a6d9bca0ccfac86b7648c8822e6cea6b6f65c48ea1c9716074ebb3"

URI_aarch64_rust-tinystr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-tinystr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinystr-devel}"
SRC_URI[aarch64_rust-tinystr-devel.sha256sum] = "7753a10d2d298cfcb25a455f3505c2ba2e7849650aaefb6a10cd99fd39b4439e"

RDEPENDS:rust-tinystr+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-tinystr-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-tinystr+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+default-devel = " \
 cargo \
 rust-tinystr+alloc-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+std-devel = " \
 cargo \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+zerovec-devel = " \
 cargo \
 rust-tinystr-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-tinystr-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 "
