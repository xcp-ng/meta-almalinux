# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-spki"
PV = "0.7.3"
PR = "6.el10_2"
PACKAGES = " \
 rust-spki+alloc-devel \
 rust-spki+arbitrary-devel \
 rust-spki+base64-devel \
 rust-spki+default-devel \
 rust-spki+fingerprint-devel \
 rust-spki+pem-devel \
 rust-spki+sha2-devel \
 rust-spki+std-devel \
 rust-spki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-spki-0.7.3-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a68190bd1f5a8c8daad11f25a51da2a06c70d2a41e5bc6f8cf87dc6da3436b37"

URI_x86_64_v2_rust-spki+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+alloc-devel-0.7.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+alloc-devel}"
SRC_URI[x86_64_v2_rust-spki+alloc-devel.sha256sum] = "86cb260a9e334bc915c4d5e28fab136579e4a37c5064a72cc52bf34139e223ad"

URI_x86_64_v2_rust-spki+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+arbitrary-devel-0.7.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-spki+arbitrary-devel.sha256sum] = "09e6bd87c6cb07913a3162c6a452f0b6eef4cf9613bcde651247abd26c5e8486"

URI_x86_64_v2_rust-spki+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+base64-devel-0.7.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+base64-devel}"
SRC_URI[x86_64_v2_rust-spki+base64-devel.sha256sum] = "8c7695650e5cdb1c7cd65dd0e2b15864c3db78948143b1ac06ff1730815ce75f"

URI_x86_64_v2_rust-spki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+default-devel-0.7.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+default-devel}"
SRC_URI[x86_64_v2_rust-spki+default-devel.sha256sum] = "9006554c8bcf8fd0f0d99951d19dcfdf86d04989fb7566de3c4128bbef7af2ae"

URI_x86_64_v2_rust-spki+fingerprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+fingerprint-devel-0.7.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+fingerprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+fingerprint-devel}"
SRC_URI[x86_64_v2_rust-spki+fingerprint-devel.sha256sum] = "03fc07cc49188f20cb6a03ed9998deb0e835880e3a44addf3b58ea50616875b2"

URI_x86_64_v2_rust-spki+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+pem-devel-0.7.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+pem-devel}"
SRC_URI[x86_64_v2_rust-spki+pem-devel.sha256sum] = "ac2f9850218ed2b361c413763451f81231e4ad04631d28bc207ab62bf2679fed"

URI_x86_64_v2_rust-spki+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+sha2-devel-0.7.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+sha2-devel}"
SRC_URI[x86_64_v2_rust-spki+sha2-devel.sha256sum] = "5905ccb1c3e4cb4585212245d2b76cc3bf4ccc7526a3e2f7c4f74079bc241b64"

URI_x86_64_v2_rust-spki+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki+std-devel-0.7.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki+std-devel}"
SRC_URI[x86_64_v2_rust-spki+std-devel.sha256sum] = "e6923e4babd7c2ef4a120050dfb8b1ba3285f23b39f8e532f8db751c5c966476"

URI_x86_64_v2_rust-spki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-spki-devel-0.7.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-spki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-spki-devel}"
SRC_URI[x86_64_v2_rust-spki-devel.sha256sum] = "ea1e9d4ff010cd4d2352c329e7ae5bb5730caa0e835942903a42eefc8bbffdbb"

URI_aarch64_rust-spki+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+alloc-devel-0.7.3-6.el10_2.noarch.rpm;name=aarch64_rust-spki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+alloc-devel}"
SRC_URI[aarch64_rust-spki+alloc-devel.sha256sum] = "3e0d522fce0a2c5b9e9943deaf5ddedb501339a79d6672e9367403554c94315b"

URI_aarch64_rust-spki+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+arbitrary-devel-0.7.3-6.el10_2.noarch.rpm;name=aarch64_rust-spki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+arbitrary-devel}"
SRC_URI[aarch64_rust-spki+arbitrary-devel.sha256sum] = "afd95274f703b2d520e33ec86e3b824e79336b01e2f719aabe96b25c55eb0de9"

URI_aarch64_rust-spki+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+base64-devel-0.7.3-6.el10_2.noarch.rpm;name=aarch64_rust-spki+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+base64-devel}"
SRC_URI[aarch64_rust-spki+base64-devel.sha256sum] = "b9d433647771edf4a6712dcf7de62bb795e720793d4576a8880fa5da26d2b138"

URI_aarch64_rust-spki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+default-devel-0.7.3-6.el10_2.noarch.rpm;name=aarch64_rust-spki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+default-devel}"
SRC_URI[aarch64_rust-spki+default-devel.sha256sum] = "15d695c54fe53697f59ae6aeb59b7581889ea88c56c5c6ef991779e7643c5c5a"

URI_aarch64_rust-spki+fingerprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+fingerprint-devel-0.7.3-6.el10_2.noarch.rpm;name=aarch64_rust-spki+fingerprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+fingerprint-devel}"
SRC_URI[aarch64_rust-spki+fingerprint-devel.sha256sum] = "3a3028fb82cbeff506499764833192324011ba092797c5f2542bfefd7224ea14"

URI_aarch64_rust-spki+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+pem-devel-0.7.3-6.el10_2.noarch.rpm;name=aarch64_rust-spki+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+pem-devel}"
SRC_URI[aarch64_rust-spki+pem-devel.sha256sum] = "30eb1dcb6e57cf83b7fbca8ec3e2f0b3c1f6d0e1390b23755a28991f9b1cac4a"

URI_aarch64_rust-spki+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+sha2-devel-0.7.3-6.el10_2.noarch.rpm;name=aarch64_rust-spki+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+sha2-devel}"
SRC_URI[aarch64_rust-spki+sha2-devel.sha256sum] = "594b373e17feeedeb719973e37af2011e9c6d478fde33a73e085325bd6d1a999"

URI_aarch64_rust-spki+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki+std-devel-0.7.3-6.el10_2.noarch.rpm;name=aarch64_rust-spki+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki+std-devel}"
SRC_URI[aarch64_rust-spki+std-devel.sha256sum] = "f3691dc6a32e13e72580f192e022bf8d4659e4861398194f506e3e50eed0c727"

URI_aarch64_rust-spki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-spki-devel-0.7.3-6.el10_2.noarch.rpm;name=aarch64_rust-spki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-spki-devel}"
SRC_URI[aarch64_rust-spki-devel.sha256sum] = "608967a0d648ad3157debc33800f5074ee3e00aa1858c7d14c2fd2c6a80198b7"

RDEPENDS:rust-spki+alloc-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-base64ct-devel \
 rust-der+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-der+arbitrary-devel \
 rust-spki+std-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+base64-devel = " \
 cargo \
 rust-base64ct-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+default-devel = " \
 cargo \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+fingerprint-devel = " \
 cargo \
 rust-spki+sha2-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+pem-devel = " \
 cargo \
 rust-der+pem-devel \
 rust-spki+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+sha2-devel = " \
 cargo \
 rust-sha2-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki+std-devel = " \
 cargo \
 rust-der+std-devel \
 rust-spki+alloc-devel \
 rust-spki-devel \
 "
RDEPENDS:rust-spki-devel = " \
 cargo \
 rust \
 rust-der+default-devel \
 rust-der+oid-devel \
 "
