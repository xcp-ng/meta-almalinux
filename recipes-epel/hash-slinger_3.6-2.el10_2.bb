# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hash-slinger"
PV = "3.6"
PR = "2.el10_2"
PACKAGES = " \
 hash-slinger \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/h/hash-slinger-3.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "06fdd634383d87e22b4c631252859f54d90d5a0648e830843aab3cb31ce8c5c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hash-slinger-3.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_hash-slinger;unpack=0"
SRC_URI[x86_64_v2_hash-slinger.sha256sum] = "36ff38223ff83be63381d4db3a6f453073b11dcd00b51256d4caa3aec7ac0c40"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/h/hash-slinger-3.6-2.el10_2.noarch.rpm;name=aarch64_hash-slinger;unpack=0"
SRC_URI[aarch64_hash-slinger.sha256sum] = "d30c357d538d3fd3b6e67d58e3ab6d45558826c00b9740249daf560d0beec940"

RDEPENDS:hash-slinger = " \
 openssh-clients \
 python3 \
 python3-cryptography \
 python3-dns \
 python3-gnupg \
 python3-unbound \
 "
