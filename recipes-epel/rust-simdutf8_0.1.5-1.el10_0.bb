# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simdutf8"
PV = "0.1.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-simdutf8+aarch64_neon-devel \
 rust-simdutf8+aarch64_neon_prefetch-devel \
 rust-simdutf8+default-devel \
 rust-simdutf8+hints-devel \
 rust-simdutf8+public_imp-devel \
 rust-simdutf8+std-devel \
 rust-simdutf8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simdutf8-0.1.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cf78745fb35a0b20db895535d9b16b194f3efbf4bbee64253fb1dd76364605e"

URI_x86_64_v2_rust-simdutf8+aarch64_neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simdutf8+aarch64_neon-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simdutf8+aarch64_neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simdutf8+aarch64_neon-devel}"
SRC_URI[x86_64_v2_rust-simdutf8+aarch64_neon-devel.sha256sum] = "ae89fcc7905ad5c091ef2b3b39a491ecd0353b01c96a782534abee9f13b7abdb"

URI_x86_64_v2_rust-simdutf8+aarch64_neon_prefetch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simdutf8+aarch64_neon_prefetch-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simdutf8+aarch64_neon_prefetch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simdutf8+aarch64_neon_prefetch-devel}"
SRC_URI[x86_64_v2_rust-simdutf8+aarch64_neon_prefetch-devel.sha256sum] = "01a4d4e1b1cc7930b07a723d17a789b149ae05389431e0c1d4bc74a211d8f0b1"

URI_x86_64_v2_rust-simdutf8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simdutf8+default-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simdutf8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simdutf8+default-devel}"
SRC_URI[x86_64_v2_rust-simdutf8+default-devel.sha256sum] = "3e940af663333e8dc5d14dec5033e9fffdfaa2932d4294c03e46642bfa079dc9"

URI_x86_64_v2_rust-simdutf8+hints-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simdutf8+hints-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simdutf8+hints-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simdutf8+hints-devel}"
SRC_URI[x86_64_v2_rust-simdutf8+hints-devel.sha256sum] = "238420baace37730060173207cbdf11effd84d5c79b48093cfc632b1688727d8"

URI_x86_64_v2_rust-simdutf8+public_imp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simdutf8+public_imp-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simdutf8+public_imp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simdutf8+public_imp-devel}"
SRC_URI[x86_64_v2_rust-simdutf8+public_imp-devel.sha256sum] = "280476437098a0bfc8f73bf26e07333cb91ab8358be60affb48ce9ec0f761661"

URI_x86_64_v2_rust-simdutf8+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simdutf8+std-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simdutf8+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simdutf8+std-devel}"
SRC_URI[x86_64_v2_rust-simdutf8+std-devel.sha256sum] = "1948146126ae9fd7faa29ddc6adf4f7ff7c554fceddbad6efdc80ae1533a4c31"

URI_x86_64_v2_rust-simdutf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simdutf8-devel-0.1.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simdutf8-devel}"
SRC_URI[x86_64_v2_rust-simdutf8-devel.sha256sum] = "83e371641cef8ac4312927de52f758bba78dac85a940b9f4e4b49861c273dda7"

URI_aarch64_rust-simdutf8+aarch64_neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simdutf8+aarch64_neon-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-simdutf8+aarch64_neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simdutf8+aarch64_neon-devel}"
SRC_URI[aarch64_rust-simdutf8+aarch64_neon-devel.sha256sum] = "5aee4a967fa9cc89870f142bd2f57cac7420a887f95eb2a4357f8e7263062166"

URI_aarch64_rust-simdutf8+aarch64_neon_prefetch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simdutf8+aarch64_neon_prefetch-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-simdutf8+aarch64_neon_prefetch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simdutf8+aarch64_neon_prefetch-devel}"
SRC_URI[aarch64_rust-simdutf8+aarch64_neon_prefetch-devel.sha256sum] = "ac80a64888db4eff6be5222f16bfa65761a02a226036c352101968da8be24c9d"

URI_aarch64_rust-simdutf8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simdutf8+default-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-simdutf8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simdutf8+default-devel}"
SRC_URI[aarch64_rust-simdutf8+default-devel.sha256sum] = "b78ea644366dc2f59510cad3001bae2da33e4bad14522f94721b9a8be9540f6f"

URI_aarch64_rust-simdutf8+hints-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simdutf8+hints-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-simdutf8+hints-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simdutf8+hints-devel}"
SRC_URI[aarch64_rust-simdutf8+hints-devel.sha256sum] = "d963a7ad63d760d7f1de638d5151e26ac3075a3fcdbd55bb9af77f11ef970981"

URI_aarch64_rust-simdutf8+public_imp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simdutf8+public_imp-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-simdutf8+public_imp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simdutf8+public_imp-devel}"
SRC_URI[aarch64_rust-simdutf8+public_imp-devel.sha256sum] = "37d4ec572acf3c066d9d189ed40f8650ec7547ab9db4309696411518ddadd6b4"

URI_aarch64_rust-simdutf8+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simdutf8+std-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-simdutf8+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simdutf8+std-devel}"
SRC_URI[aarch64_rust-simdutf8+std-devel.sha256sum] = "36d3b7c09d788d2f58c236cc6a88446f4f01ed01b1f73d7be16df00c65aadd35"

URI_aarch64_rust-simdutf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simdutf8-devel-0.1.5-1.el10_0.noarch.rpm;name=aarch64_rust-simdutf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simdutf8-devel}"
SRC_URI[aarch64_rust-simdutf8-devel.sha256sum] = "52fb6763f9732711ba594f23804948033122caa721ac48b2014ea235a5360b9d"

RDEPENDS:rust-simdutf8+aarch64_neon-devel = " \
 cargo \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-simdutf8+aarch64_neon_prefetch-devel = " \
 cargo \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-simdutf8+default-devel = " \
 cargo \
 rust-simdutf8+std-devel \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-simdutf8+hints-devel = " \
 cargo \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-simdutf8+public_imp-devel = " \
 cargo \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-simdutf8+std-devel = " \
 cargo \
 rust-simdutf8-devel \
 "
RDEPENDS:rust-simdutf8-devel = " \
 cargo \
 "
