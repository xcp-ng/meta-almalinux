# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base64ct"
PV = "1.8.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-base64ct+alloc-devel \
 rust-base64ct+default-devel \
 rust-base64ct+std-devel \
 rust-base64ct-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base64ct-1.8.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4021cf38f5315f8c5734602abfbde2f4e95238a7a2e5c2ee242a45654a2c5e9a"

URI_x86_64_v2_rust-base64ct+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+alloc-devel-1.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct+alloc-devel}"
SRC_URI[x86_64_v2_rust-base64ct+alloc-devel.sha256sum] = "82a1a4fcc0419c9d03c6dc6c26d8d20f3c3aec1a86e92b61ab8cbae778c7d079"

URI_x86_64_v2_rust-base64ct+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+default-devel-1.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct+default-devel}"
SRC_URI[x86_64_v2_rust-base64ct+default-devel.sha256sum] = "55826bb2c7662726b7327323084eec4c990ee610fc20f012d13f75d156122743"

URI_x86_64_v2_rust-base64ct+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct+std-devel-1.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct+std-devel}"
SRC_URI[x86_64_v2_rust-base64ct+std-devel.sha256sum] = "24c3658f099ce436a81d29619677d76363d2479765b4d999c9d364b95ba4b991"

URI_x86_64_v2_rust-base64ct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64ct-devel-1.8.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64ct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64ct-devel}"
SRC_URI[x86_64_v2_rust-base64ct-devel.sha256sum] = "bf0784c8f2afa0649db7a730025d00db27cc59832e55740d7b003c8eed734d81"

URI_aarch64_rust-base64ct+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+alloc-devel-1.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-base64ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct+alloc-devel}"
SRC_URI[aarch64_rust-base64ct+alloc-devel.sha256sum] = "6c4f31ca13d370cdcee56bc94e14b7b4870e2030ce5f7e53aa71a62bdbc1ba71"

URI_aarch64_rust-base64ct+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+default-devel-1.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-base64ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct+default-devel}"
SRC_URI[aarch64_rust-base64ct+default-devel.sha256sum] = "839e3360b6e1951b4a2a18c5d792ecdf986e5ae515ee2da35633be1757b4c4db"

URI_aarch64_rust-base64ct+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct+std-devel-1.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-base64ct+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct+std-devel}"
SRC_URI[aarch64_rust-base64ct+std-devel.sha256sum] = "3e85205dfc89090b4840ee5dba73ebffc5b2001bb96ed7937cd4ea3a06c3b75a"

URI_aarch64_rust-base64ct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64ct-devel-1.8.3-1.el10_2.noarch.rpm;name=aarch64_rust-base64ct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64ct-devel}"
SRC_URI[aarch64_rust-base64ct-devel.sha256sum] = "21bdd84f7bcf29a47b0be6333afd3917f4d94aca1cea9009ba020fcf6be1ee23"

RDEPENDS:rust-base64ct+alloc-devel = " \
 cargo \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct+default-devel = " \
 cargo \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct+std-devel = " \
 cargo \
 rust-base64ct+alloc-devel \
 rust-base64ct-devel \
 "
RDEPENDS:rust-base64ct-devel = " \
 cargo \
 rust \
 "
