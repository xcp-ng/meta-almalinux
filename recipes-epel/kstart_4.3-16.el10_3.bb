# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kstart"
PV = "4.3"
PR = "16.el10_3"
PACKAGES = " \
 kstart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kstart-4.3-16.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95ab02d0f70ec3f120c749899b0230466ce935a997f4ee150218f39bbcb9eaf9"

URI_x86_64_v2_kstart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kstart-4.3-16.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kstart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kstart}"
SRC_URI[x86_64_v2_kstart.sha256sum] = "3f8bcb772b4e430881d1c04598192c0945900b216152d4c157d835597da8b4f9"

URI_aarch64_kstart = "${EPEL_MIRROR}/aarch64/Packages/k/kstart-4.3-16.el10_3.aarch64.rpm;name=aarch64_kstart;unpack=0"
SRC_URI:append = " ${URI_aarch64_kstart}"
SRC_URI[aarch64_kstart.sha256sum] = "9c47ca7d18d1ddeb2fdff5174107ae33301094040f4a4a4415cfce7c7b38ef02"

RDEPENDS:kstart = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 "
