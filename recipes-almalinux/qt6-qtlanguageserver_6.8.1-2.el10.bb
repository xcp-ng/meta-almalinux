# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtlanguageserver"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtlanguageserver \
 qt6-qtlanguageserver-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtlanguageserver-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3a5842773c90b4c6ad2ff379266e2c50583ca51027d99b47929003b453f56d2"

URI_x86_64_v2_qt6-qtlanguageserver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlanguageserver-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlanguageserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlanguageserver}"
SRC_URI[x86_64_v2_qt6-qtlanguageserver.sha256sum] = "3c02cdd378270fc7bcaf850bf4670cd3936e7fda42ac46d6fd47c42345a79d04"

URI_x86_64_v2_qt6-qtlanguageserver-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlanguageserver-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlanguageserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlanguageserver-devel}"
SRC_URI[x86_64_v2_qt6-qtlanguageserver-devel.sha256sum] = "cdf977d0bfb03cb09b162927622759027c7fd2e1d28b6a868b95d1227663c4f5"

URI_aarch64_qt6-qtlanguageserver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlanguageserver-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtlanguageserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlanguageserver}"
SRC_URI[aarch64_qt6-qtlanguageserver.sha256sum] = "30f3d59efc171ed2a34c19810357aafd449dadc9303188504585262eb3b744d8"

URI_aarch64_qt6-qtlanguageserver-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlanguageserver-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtlanguageserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlanguageserver-devel}"
SRC_URI[aarch64_qt6-qtlanguageserver-devel.sha256sum] = "e0afa5369e34988cf1a08c8116ad2c37713256b7adb6b8cca0ba34e849409248"

RDEPENDS:qt6-qtlanguageserver = " \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtlanguageserver-devel = " \
 cmake-filesystem \
 qt6-qtbase-devel \
 qt6-qtlanguageserver \
 "
