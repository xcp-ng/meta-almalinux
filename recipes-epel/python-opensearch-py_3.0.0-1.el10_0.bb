# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-opensearch-py"
PV = "3.0.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-opensearch-py \
 python3-opensearch-py+async \
 python3-opensearch-py+kerberos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-opensearch-py-3.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43e3ba869bb31f2b2712625cbe2f3e3ab615c6d7da8ba5daed6ae59e6560d951"

URI_x86_64_v2_python3-opensearch-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py-3.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py}"
SRC_URI[x86_64_v2_python3-opensearch-py.sha256sum] = "c8e7be17391550fa9b940b769ada5712d67946c7e6a3ffa17058f60cb1733956"

URI_x86_64_v2_python3-opensearch-py+async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py+async-3.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py+async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py+async}"
SRC_URI[x86_64_v2_python3-opensearch-py+async.sha256sum] = "a78505033e1b620d317da05571de8724ea1cbe82d0a316d4d5500dba0fa347f8"

URI_x86_64_v2_python3-opensearch-py+kerberos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-opensearch-py+kerberos-3.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-opensearch-py+kerberos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-opensearch-py+kerberos}"
SRC_URI[x86_64_v2_python3-opensearch-py+kerberos.sha256sum] = "28acf6dbce1525595bb70cb16d5afd08bd9260b59e75e0e63ed6b64766392d05"

URI_aarch64_python3-opensearch-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py-3.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-opensearch-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py}"
SRC_URI[aarch64_python3-opensearch-py.sha256sum] = "dd124d7d5dd4676a79bf930fbaf3076923893dc6b7e876225c21673fd0792e4b"

URI_aarch64_python3-opensearch-py+async = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py+async-3.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-opensearch-py+async;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py+async}"
SRC_URI[aarch64_python3-opensearch-py+async.sha256sum] = "81d06430afbe65a1f6cb0d8b3751332a733d421d072f60d3541ad7c04c9e2b99"

URI_aarch64_python3-opensearch-py+kerberos = "${EPEL_MIRROR}/aarch64/Packages/p/python3-opensearch-py+kerberos-3.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-opensearch-py+kerberos;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-opensearch-py+kerberos}"
SRC_URI[aarch64_python3-opensearch-py+kerberos.sha256sum] = "2b5ffd7971c8537ffea37c663a1647eefab1a9ffa5cabe89b4ea8a6cdec84fbb"

RDEPENDS:python3-opensearch-py = " \
 python3 \
 python3-certifi \
 python3-dateutil \
 python3-events \
 python3-requests \
 python3-urllib3 \
 "
RDEPENDS:python3-opensearch-py+async = " \
 python3 \
 python3-aiohttp \
 python3-opensearch-py \
 "
RDEPENDS:python3-opensearch-py+kerberos = " \
 python3 \
 python3-opensearch-py \
 python3-requests-kerberos \
 "
