# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtkwave"
PV = "3.3.128"
PR = "1.el10_3"
PACKAGES = " \
 gtkwave \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtkwave-3.3.128-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4bc97e95c0e3952d6dbbccdc51e3816b41189c7adc3a144f394ec9d070d6087"

URI_x86_64_v2_gtkwave = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkwave-3.3.128-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtkwave;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkwave}"
SRC_URI[x86_64_v2_gtkwave.sha256sum] = "6c5524af0b848f6c3c54a6c5c4eaef4d2901bf3c1750bd722546cad7feb6bfe4"

URI_aarch64_gtkwave = "${EPEL_MIRROR}/aarch64/Packages/g/gtkwave-3.3.128-1.el10_3.aarch64.rpm;name=aarch64_gtkwave;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkwave}"
SRC_URI[aarch64_gtkwave.sha256sum] = "606e7555262c0e77f1cec2dc951782f56811b2fd89f451174363cf529ab57d14"

RDEPENDS:gtkwave = " \
 Judy \
 bzip2-libs \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 pango \
 shared-mime-info \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
