# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXxf86dga"
PV = "1.1.6"
PR = "5.el10_0"
PACKAGES = " \
 libXxf86dga \
 libXxf86dga-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libXxf86dga-1.1.6-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8eece929cd25df2401868e97f21d26e5d97e8083a6d7f5ea8bb58aa0fce8e84d"

URI_x86_64_v2_libXxf86dga = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXxf86dga-1.1.6-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXxf86dga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXxf86dga}"
SRC_URI[x86_64_v2_libXxf86dga.sha256sum] = "87d2a85b736c5ca40bc75feeb8edcc2ca5c701d318902ec6cde652196cbb6401"

URI_x86_64_v2_libXxf86dga-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXxf86dga-devel-1.1.6-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXxf86dga-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXxf86dga-devel}"
SRC_URI[x86_64_v2_libXxf86dga-devel.sha256sum] = "c0d938687f57aa3e8b0327be47c593c49a320ec6567a78be77700ebfc2bc4451"

URI_aarch64_libXxf86dga = "${EPEL_MIRROR}/aarch64/Packages/l/libXxf86dga-1.1.6-5.el10_0.aarch64.rpm;name=aarch64_libXxf86dga;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXxf86dga}"
SRC_URI[aarch64_libXxf86dga.sha256sum] = "cb4d6c9ea2361b1a1e2f7cbf0009dfe4ffd890f0cc30ad9f076883ab79fc6e06"

URI_aarch64_libXxf86dga-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libXxf86dga-devel-1.1.6-5.el10_0.aarch64.rpm;name=aarch64_libXxf86dga-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXxf86dga-devel}"
SRC_URI[aarch64_libXxf86dga-devel.sha256sum] = "7c29ef2fa6d5bd93abcf4e5db3f2bbdabb9b8ee7d2a35422ccd4ccdfc771dd81"

RDEPENDS:libXxf86dga = " \
 glibc \
 libX11 \
 libXext \
 "
RDEPENDS:libXxf86dga-devel = " \
 libX11-devel \
 libXext-devel \
 libXxf86dga \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
