# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_lex"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-clap_lex+default-devel \
 rust-clap_lex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_lex-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c473eafa1917ed31a9230e5f14a0f531e8a89f42e822e206b0f01d9844b17163"

URI_x86_64_v2_rust-clap_lex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex+default-devel}"
SRC_URI[x86_64_v2_rust-clap_lex+default-devel.sha256sum] = "707d8189867449c0d461f8192b1feb272dcf04dda3a3633f751f78967bc531cf"

URI_x86_64_v2_rust-clap_lex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_lex-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_lex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_lex-devel}"
SRC_URI[x86_64_v2_rust-clap_lex-devel.sha256sum] = "1fc50cdb550d2ef65c3e4dce475f2a46a696885260fc6762ea375ecdc18e2c5f"

URI_aarch64_rust-clap_lex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-clap_lex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex+default-devel}"
SRC_URI[aarch64_rust-clap_lex+default-devel.sha256sum] = "c3de7e5f6352affa30b3cac2956efdc1faf36a150103efec83c59ef53424ec3b"

URI_aarch64_rust-clap_lex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_lex-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-clap_lex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_lex-devel}"
SRC_URI[aarch64_rust-clap_lex-devel.sha256sum] = "463ac9f6e6bfcbeae3c75c9a54c5ff78368933e505690880a26720aef40326be"

RDEPENDS:rust-clap_lex+default-devel = " \
 cargo \
 rust-clap_lex-devel \
 "
RDEPENDS:rust-clap_lex-devel = " \
 cargo \
 rust \
 "
