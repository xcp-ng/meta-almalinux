# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde-untagged"
PV = "0.1.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde-untagged+default-devel \
 rust-serde-untagged-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde-untagged-0.1.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd16cf0262e20d54de40a0fd6e6415683a0f19d0d929b0716133435070a4bd08"

URI_x86_64_v2_rust-serde-untagged+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-untagged+default-devel-0.1.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-untagged+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-untagged+default-devel}"
SRC_URI[x86_64_v2_rust-serde-untagged+default-devel.sha256sum] = "827b2355ab89a75162fd69a78bde42dc6a4a1bb5f270141e15aee7d24316ef94"

URI_x86_64_v2_rust-serde-untagged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde-untagged-devel-0.1.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde-untagged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde-untagged-devel}"
SRC_URI[x86_64_v2_rust-serde-untagged-devel.sha256sum] = "35a76d6316e98bb79e9583f75e59ee5436f9b33ee4b027ba598b0f493718347d"

URI_aarch64_rust-serde-untagged+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-untagged+default-devel-0.1.7-1.el10_0.noarch.rpm;name=aarch64_rust-serde-untagged+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-untagged+default-devel}"
SRC_URI[aarch64_rust-serde-untagged+default-devel.sha256sum] = "676654a40a495b86cb9457d1682c9685cf41be15753937dc107d36a0b04d47e1"

URI_aarch64_rust-serde-untagged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde-untagged-devel-0.1.7-1.el10_0.noarch.rpm;name=aarch64_rust-serde-untagged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde-untagged-devel}"
SRC_URI[aarch64_rust-serde-untagged-devel.sha256sum] = "4a0a5ded9e85b4c4d1a186cef91c4ac3d0652dfacc23ee78da243e81ffe99e66"

RDEPENDS:rust-serde-untagged+default-devel = " \
 cargo \
 rust-serde-untagged-devel \
 "
RDEPENDS:rust-serde-untagged-devel = " \
 cargo \
 rust \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-typeid+default-devel \
 "
