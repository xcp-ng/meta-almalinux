# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clru"
PV = "0.6.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-clru+default-devel \
 rust-clru-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clru-0.6.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c299541fdb79a66feb33bda0da8faf0cc37c98f5e23075e5f231b832965cd43"

URI_x86_64_v2_rust-clru+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clru+default-devel-0.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clru+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clru+default-devel}"
SRC_URI[x86_64_v2_rust-clru+default-devel.sha256sum] = "58ec807d9afc3c461621b1092833ed7ab7e613699f8bf4aa3f470f2396b5c8ec"

URI_x86_64_v2_rust-clru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clru-devel-0.6.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clru-devel}"
SRC_URI[x86_64_v2_rust-clru-devel.sha256sum] = "edd2fd3a3fbbf68c2c8d3692f92c8ef3c9eeab6ddd39b315f277732fbe94932f"

URI_aarch64_rust-clru+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clru+default-devel-0.6.3-1.el10_3.noarch.rpm;name=aarch64_rust-clru+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clru+default-devel}"
SRC_URI[aarch64_rust-clru+default-devel.sha256sum] = "3924bdf3934bdcfb02f5fb6f675ac7d9d0cc0ea5c6dfbaa6cb5874294e773929"

URI_aarch64_rust-clru-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clru-devel-0.6.3-1.el10_3.noarch.rpm;name=aarch64_rust-clru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clru-devel}"
SRC_URI[aarch64_rust-clru-devel.sha256sum] = "5074bc1a70ef82ba8598abd9fb773e7800daf8c373671613a69a4fbf2010a93c"

RDEPENDS:rust-clru+default-devel = " \
 cargo \
 rust-clru-devel \
 "
RDEPENDS:rust-clru-devel = " \
 cargo \
 rust-hashbrown0.16+default-devel \
 "
