# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtdb"
PV = "1.4.13"
PR = "100.el10"
PACKAGES = " \
 libtdb \
 libtdb-devel \
 python3-tdb \
 tdb-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtdb-1.4.13-100.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "def1a0140233fc3e4e190554868bdfee70e6884dbe62853c7848703a1ebcee32"

URI_x86_64_v2_libtdb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtdb-1.4.13-100.el10.x86_64_v2.rpm;name=x86_64_v2_libtdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtdb}"
SRC_URI[x86_64_v2_libtdb.sha256sum] = "862238f33b9745f39c82c1ae6b1e3174b596da8186794f0e23102c709b1d9e01"

URI_x86_64_v2_libtdb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtdb-devel-1.4.13-100.el10.x86_64_v2.rpm;name=x86_64_v2_libtdb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtdb-devel}"
SRC_URI[x86_64_v2_libtdb-devel.sha256sum] = "8bad19fec17d1383eb7f354f24fd5a34dbe7a5432ed3024d670d61d209e189c8"

URI_x86_64_v2_python3-tdb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-tdb-1.4.13-100.el10.x86_64_v2.rpm;name=x86_64_v2_python3-tdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tdb}"
SRC_URI[x86_64_v2_python3-tdb.sha256sum] = "f71b067e200eb0736aa6ad3c41f11b9fa1982dbbfd30637f5f5f07e00df89565"

URI_x86_64_v2_tdb-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tdb-tools-1.4.13-100.el10.x86_64_v2.rpm;name=x86_64_v2_tdb-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tdb-tools}"
SRC_URI[x86_64_v2_tdb-tools.sha256sum] = "90b8b8a568ba379110951190f571ec4595df99ead8e41f4d92a521f464813cba"

URI_aarch64_libtdb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtdb-1.4.13-100.el10.aarch64.rpm;name=aarch64_libtdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtdb}"
SRC_URI[aarch64_libtdb.sha256sum] = "d674228eac40949603cd165747ed66a955e5fda3b42d973bf8dc5c4153ed430e"

URI_aarch64_libtdb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtdb-devel-1.4.13-100.el10.aarch64.rpm;name=aarch64_libtdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtdb-devel}"
SRC_URI[aarch64_libtdb-devel.sha256sum] = "d0b2b1e1c028ea26e8f1b049dff8bebb615d557a1acdf366d6a67022e0cf3507"

URI_aarch64_python3-tdb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-tdb-1.4.13-100.el10.aarch64.rpm;name=aarch64_python3-tdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tdb}"
SRC_URI[aarch64_python3-tdb.sha256sum] = "a553c18f0d4ba330672566e1630717fee7f775ad2a595fc0feb05e2d203af06e"

URI_aarch64_tdb-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tdb-tools-1.4.13-100.el10.aarch64.rpm;name=aarch64_tdb-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_tdb-tools}"
SRC_URI[aarch64_tdb-tools.sha256sum] = "e4a3ab467abff3e0bea82cbb7b59ce5ad3d871256de5b108e3a163b41c2df230"

RDEPENDS:libtdb = " \
 glibc \
 "
RDEPENDS:libtdb-devel = " \
 libtdb \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-tdb = " \
 glibc \
 libtdb \
 python3 \
 "
RDEPENDS:tdb-tools = " \
 glibc \
 libtdb \
 "
