# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pycosat"
PV = "0.6.6"
PR = "11.el10_3"
PACKAGES = " \
 python3-pycosat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pycosat-0.6.6-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bebcb7b7aeac17eaeb7c9d8fc23f88e94a76409ac5f62c9090edf97eda0fe992"

URI_x86_64_v2_python3-pycosat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pycosat-0.6.6-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pycosat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pycosat}"
SRC_URI[x86_64_v2_python3-pycosat.sha256sum] = "c2d01720903c3d59c36a559e8ac8f4e8071e869000f22d0cd5ba718f921bec2e"

URI_aarch64_python3-pycosat = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pycosat-0.6.6-11.el10_3.aarch64.rpm;name=aarch64_python3-pycosat;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pycosat}"
SRC_URI[aarch64_python3-pycosat.sha256sum] = "436686fd9b55b498714950018746f103287fd5805c5af743e9d43b78dfff1df6"

RDEPENDS:python3-pycosat = " \
 glibc \
 picosat-libs \
 python3 \
 "
