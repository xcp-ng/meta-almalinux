# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-terminal_size0.3"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-terminal_size0.3+default-devel \
 rust-terminal_size0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-terminal_size0.3-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "290fab5851e51ce1afbd0faf2859d8da221e0bb7d16b05d5f790b905a0979dd6"

URI_x86_64_v2_rust-terminal_size0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size0.3+default-devel-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size0.3+default-devel}"
SRC_URI[x86_64_v2_rust-terminal_size0.3+default-devel.sha256sum] = "288b2945b325fff9101e61e2186be8d5b723cf6396716b42c6d7322824d53c1c"

URI_x86_64_v2_rust-terminal_size0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-terminal_size0.3-devel-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-terminal_size0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-terminal_size0.3-devel}"
SRC_URI[x86_64_v2_rust-terminal_size0.3-devel.sha256sum] = "43c38ec52737df197b9d1f5ba3ae5e2bbbb094186fcc57bc959e9a56e20e3488"

URI_aarch64_rust-terminal_size0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size0.3+default-devel-0.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-terminal_size0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size0.3+default-devel}"
SRC_URI[aarch64_rust-terminal_size0.3+default-devel.sha256sum] = "04d191422e03e59c6e2f50bd8f6d18c575d09bbc0fa80a9f38adf391f4279662"

URI_aarch64_rust-terminal_size0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-terminal_size0.3-devel-0.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-terminal_size0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-terminal_size0.3-devel}"
SRC_URI[aarch64_rust-terminal_size0.3-devel.sha256sum] = "ad76d1182457476ba9ae8055a06739c5d47adda19dbb929049d5bcd7cec2c02b"

RDEPENDS:rust-terminal_size0.3+default-devel = " \
 cargo \
 rust-terminal_size0.3-devel \
 "
RDEPENDS:rust-terminal_size0.3-devel = " \
 cargo \
 rust-rustix+default-devel \
 rust-rustix+termios-devel \
 "
