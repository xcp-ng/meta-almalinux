# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdvdread"
PV = "6.1.3"
PR = "9.el10"
PACKAGES = " \
 libdvdread \
 libdvdread-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libdvdread-6.1.3-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e40d16c45f1c53ba9d241f869f12b30465f6f636341a1d46a83fb0016439324"

URI_x86_64_v2_libdvdread = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libdvdread-6.1.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_libdvdread;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdvdread}"
SRC_URI[x86_64_v2_libdvdread.sha256sum] = "64b1da9ae281dfe530d46ff5564095567ace386fe63c4b525676f1d5e6b16689"

URI_x86_64_v2_libdvdread-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdvdread-devel-6.1.3-9.el10.x86_64_v2.rpm;name=x86_64_v2_libdvdread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdvdread-devel}"
SRC_URI[x86_64_v2_libdvdread-devel.sha256sum] = "c2d0775803dd1baf090bdf24a98fc8bb5f872871462ca7142789af8060e3290b"

URI_aarch64_libdvdread = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libdvdread-6.1.3-9.el10.aarch64.rpm;name=aarch64_libdvdread;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdvdread}"
SRC_URI[aarch64_libdvdread.sha256sum] = "aaae1c36546be1a895cf069bba6a46f3c888c146b699b79dd76cc7469cc6f61e"

URI_aarch64_libdvdread-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdvdread-devel-6.1.3-9.el10.aarch64.rpm;name=aarch64_libdvdread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdvdread-devel}"
SRC_URI[aarch64_libdvdread-devel.sha256sum] = "f2387c03cab0038fb9095cc28dc96bf374b201b4994819faff06f907e1646199"

RDEPENDS:libdvdread = " \
 glibc \
 "
RDEPENDS:libdvdread-devel = " \
 libdvdread \
 pkgconf-pkg-config \
 "
