# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-Curve25519"
PV = "0.07"
PR = "9.el10_0"
PACKAGES = " \
 perl-Crypt-Curve25519 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-Curve25519-0.07-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "985fa56b2c9a14823b3bd66875a8e2572f5b803adedf59ed04315242ac0ab341"

URI_x86_64_v2_perl-Crypt-Curve25519 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-Curve25519-0.07-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-Curve25519;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-Curve25519}"
SRC_URI[x86_64_v2_perl-Crypt-Curve25519.sha256sum] = "9b6f33cec929d256eecafe02002ac253a8c78fadada6a7ccc934d73828a29cf9"

URI_aarch64_perl-Crypt-Curve25519 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-Curve25519-0.07-9.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-Curve25519;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-Curve25519}"
SRC_URI[aarch64_perl-Crypt-Curve25519.sha256sum] = "5411a59025ba2200f89e1ab963ceee4d3ae651beefb245035bc3b55520ffdfde"

RDEPENDS:perl-Crypt-Curve25519 = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 "
