# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgtop2"
PV = "2.41.2"
PR = "5.el10"
PACKAGES = " \
 libgtop2 \
 libgtop2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libgtop2-2.41.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "693c3328c2dca90c31bd9c2c37cdbbab598e7c5e5ae59a90e9d09f935dd7d4c6"

URI_x86_64_v2_libgtop2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgtop2-2.41.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libgtop2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgtop2}"
SRC_URI[x86_64_v2_libgtop2.sha256sum] = "a337f92584f2e344020ddbac6f6c4cd39ee8e0bd820639827ca1b407db39b93f"

URI_x86_64_v2_libgtop2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgtop2-devel-2.41.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libgtop2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgtop2-devel}"
SRC_URI[x86_64_v2_libgtop2-devel.sha256sum] = "174f0e62c6f06933487f503f329b7acd6d73e5933cb6a4bc19ac35c1e45ea422"

URI_aarch64_libgtop2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgtop2-2.41.2-5.el10.aarch64.rpm;name=aarch64_libgtop2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgtop2}"
SRC_URI[aarch64_libgtop2.sha256sum] = "525dcbc7455703ec2efab438f20189e4e6212429a0d859ce4d294d593dd26858"

URI_aarch64_libgtop2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgtop2-devel-2.41.2-5.el10.aarch64.rpm;name=aarch64_libgtop2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgtop2-devel}"
SRC_URI[aarch64_libgtop2-devel.sha256sum] = "687272ed4e71767b4ea684b95c4d498ff436026bab2dd2e982165e3bb40b5c96"

RDEPENDS:libgtop2 = " \
 glib2 \
 glibc \
 "
RDEPENDS:libgtop2-devel = " \
 glib2-devel \
 libgtop2 \
 pkgconf-pkg-config \
 "
