# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iri-string"
PV = "0.7.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-iri-string+alloc-devel \
 rust-iri-string+default-devel \
 rust-iri-string+memchr-devel \
 rust-iri-string+serde-devel \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iri-string-0.7.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4dcaa8bdd93578ce6961f4751499d1ee0ca5a3563acbcc3e398ff5e96ee49ed"

URI_x86_64_v2_rust-iri-string+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+alloc-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+alloc-devel}"
SRC_URI[x86_64_v2_rust-iri-string+alloc-devel.sha256sum] = "850c1b37882ff7862360b856528ad7aa153662c898beb0ea849da6d2a506ede1"

URI_x86_64_v2_rust-iri-string+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+default-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+default-devel}"
SRC_URI[x86_64_v2_rust-iri-string+default-devel.sha256sum] = "93ebd2307b4733a1b4ab73ad1f57e58de5497ba354a1cd5e27882a245d265adf"

URI_x86_64_v2_rust-iri-string+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+memchr-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+memchr-devel}"
SRC_URI[x86_64_v2_rust-iri-string+memchr-devel.sha256sum] = "090cac09abea809f0dd31c17f80521405f894bc2a0b16a683b15c1f9928926cf"

URI_x86_64_v2_rust-iri-string+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+serde-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+serde-devel}"
SRC_URI[x86_64_v2_rust-iri-string+serde-devel.sha256sum] = "5d4b0882cbb1d40a5b9f3e809406dab32795e60568a60022898481a9b34f107a"

URI_x86_64_v2_rust-iri-string+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+std-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+std-devel}"
SRC_URI[x86_64_v2_rust-iri-string+std-devel.sha256sum] = "ab8da367f237f67e96348a991e78f792e8e135ffaaaeec2e6d19f9b13b48396c"

URI_x86_64_v2_rust-iri-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string-devel-0.7.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string-devel}"
SRC_URI[x86_64_v2_rust-iri-string-devel.sha256sum] = "df118b911cb115ff81037716e02fa4186fa3d809c087a891de85d01157f41882"

URI_aarch64_rust-iri-string+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+alloc-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-iri-string+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+alloc-devel}"
SRC_URI[aarch64_rust-iri-string+alloc-devel.sha256sum] = "3b4d49037f439c554e269c72d44870878af5356d6dbab4ed380200c18c73fb19"

URI_aarch64_rust-iri-string+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+default-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-iri-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+default-devel}"
SRC_URI[aarch64_rust-iri-string+default-devel.sha256sum] = "27d5a50f64a98763c20515811f67e7e181d807177a2b6b002c2db02f0fc674ad"

URI_aarch64_rust-iri-string+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+memchr-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-iri-string+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+memchr-devel}"
SRC_URI[aarch64_rust-iri-string+memchr-devel.sha256sum] = "2257c75c693bd8d68720ca20c2923bbb8975a938774a1510e7a3b5980def2f21"

URI_aarch64_rust-iri-string+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+serde-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-iri-string+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+serde-devel}"
SRC_URI[aarch64_rust-iri-string+serde-devel.sha256sum] = "3249510cf06abaff1cd71467ed2d4edc5d6dced6695bc2a59425520d37d0483e"

URI_aarch64_rust-iri-string+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+std-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-iri-string+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+std-devel}"
SRC_URI[aarch64_rust-iri-string+std-devel.sha256sum] = "bc07bffd34144a1eb719928e921acedefc43c39948844687653e0734494b3320"

URI_aarch64_rust-iri-string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string-devel-0.7.8-1.el10_0.noarch.rpm;name=aarch64_rust-iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string-devel}"
SRC_URI[aarch64_rust-iri-string-devel.sha256sum] = "c62885e6f4b703ece1708712ece151e4a3aee8050a071637b04b27c69b478667"

RDEPENDS:rust-iri-string+alloc-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+default-devel = " \
 cargo \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "
RDEPENDS:rust-iri-string+memchr-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-iri-string+serde-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+std-devel = " \
 cargo \
 rust-iri-string+alloc-devel \
 rust-iri-string-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string-devel = " \
 cargo \
 rust \
 "
