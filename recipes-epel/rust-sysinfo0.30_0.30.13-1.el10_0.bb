# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sysinfo0.30"
PV = "0.30.13"
PR = "1.el10_0"
PACKAGES = " \
 rust-sysinfo0.30+c-interface-devel \
 rust-sysinfo0.30+debug-devel \
 rust-sysinfo0.30+default-devel \
 rust-sysinfo0.30+linux-netdevs-devel \
 rust-sysinfo0.30+linux-tmpfs-devel \
 rust-sysinfo0.30+multithread-devel \
 rust-sysinfo0.30+rayon-devel \
 rust-sysinfo0.30+serde-devel \
 rust-sysinfo0.30-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sysinfo0.30-0.30.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e48928e098d300b43b8431505b9039faf703af16a76464e4a5c006cfe2b0289"

URI_x86_64_v2_rust-sysinfo0.30+c-interface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+c-interface-devel-0.30.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+c-interface-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+c-interface-devel.sha256sum] = "ef1feec773987d94389d04df69cbfcd40f0ac73be6f2987bd6eb714fd2e00d20"

URI_x86_64_v2_rust-sysinfo0.30+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+debug-devel-0.30.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+debug-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+debug-devel.sha256sum] = "3704d75f59aa60c5591376c685c0d7f3b781b71459685841858d3857777e7900"

URI_x86_64_v2_rust-sysinfo0.30+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+default-devel-0.30.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+default-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+default-devel.sha256sum] = "1c5239ac1999588f97bd26f1446f8796662707bb494890c5c1d32b61dd29d14b"

URI_x86_64_v2_rust-sysinfo0.30+linux-netdevs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+linux-netdevs-devel-0.30.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+linux-netdevs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+linux-netdevs-devel.sha256sum] = "49026e147c1b7fd03366d1fd63c2521b8db3d3bbf0ba4cfbcdc435a9a47bab63"

URI_x86_64_v2_rust-sysinfo0.30+linux-tmpfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+linux-tmpfs-devel-0.30.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+linux-tmpfs-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+linux-tmpfs-devel.sha256sum] = "783096339d1c6eeb1a917eb7fb54a8e1352095470e145b24aceeaef980c225e4"

URI_x86_64_v2_rust-sysinfo0.30+multithread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+multithread-devel-0.30.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+multithread-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+multithread-devel.sha256sum] = "4038eebd5b69485c4280e3bf4bddd049dab53f0cdc221089970a4f38a8174ad1"

URI_x86_64_v2_rust-sysinfo0.30+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+rayon-devel-0.30.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+rayon-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+rayon-devel.sha256sum] = "e58ea80ae998a7ec3b1b473bccf87a0067072b00638cefe4bd4d132618518332"

URI_x86_64_v2_rust-sysinfo0.30+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30+serde-devel-0.30.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30+serde-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30+serde-devel.sha256sum] = "6aaccb5067c3b9678cbe4e8736b132d31c129e93a200edf9024879f42cfd56aa"

URI_x86_64_v2_rust-sysinfo0.30-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.30-devel-0.30.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.30-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.30-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.30-devel.sha256sum] = "5b70ef75ff7f69effee69dd528e1115b2640d1ce9a72b919861d623add4c1ec3"

URI_aarch64_rust-sysinfo0.30+c-interface-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+c-interface-devel-0.30.13-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo0.30+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+c-interface-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+c-interface-devel.sha256sum] = "e81220baa69a2fbc843e7f2d5f8e0c37fff8ce04f4f055de33ef287772c17302"

URI_aarch64_rust-sysinfo0.30+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+debug-devel-0.30.13-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo0.30+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+debug-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+debug-devel.sha256sum] = "dd6217d6ca85e104b0d808220a893a064b8326e0cda4e59f94ac47ff31cca544"

URI_aarch64_rust-sysinfo0.30+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+default-devel-0.30.13-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo0.30+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+default-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+default-devel.sha256sum] = "792f1e3dd221581457f1f665ed9a2c6ef0c19669161926dfb84050a85150e3dd"

URI_aarch64_rust-sysinfo0.30+linux-netdevs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+linux-netdevs-devel-0.30.13-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo0.30+linux-netdevs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+linux-netdevs-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+linux-netdevs-devel.sha256sum] = "7da3c047dac66236f941c0b3c75749f052568c4fcb10cd7a817eec3a4fa87b6e"

URI_aarch64_rust-sysinfo0.30+linux-tmpfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+linux-tmpfs-devel-0.30.13-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo0.30+linux-tmpfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+linux-tmpfs-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+linux-tmpfs-devel.sha256sum] = "3126013f91940d70da52fc9760a2078f0fb16bcc38717870d80ed4bcdbe1387b"

URI_aarch64_rust-sysinfo0.30+multithread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+multithread-devel-0.30.13-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo0.30+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+multithread-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+multithread-devel.sha256sum] = "8ac78ef8bfc49dfc6c0f940a0c11b37649314c5a919c9c158a75175ea42d063a"

URI_aarch64_rust-sysinfo0.30+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+rayon-devel-0.30.13-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo0.30+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+rayon-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+rayon-devel.sha256sum] = "5599d6a6ee05d3257900aa88341e40440d3010da7b73969bcc5c8568a340aa14"

URI_aarch64_rust-sysinfo0.30+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30+serde-devel-0.30.13-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo0.30+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30+serde-devel}"
SRC_URI[aarch64_rust-sysinfo0.30+serde-devel.sha256sum] = "40f27045998250d8f889fa888b15d582e5304e31c38f82fc8445056367aebc50"

URI_aarch64_rust-sysinfo0.30-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.30-devel-0.30.13-1.el10_0.noarch.rpm;name=aarch64_rust-sysinfo0.30-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.30-devel}"
SRC_URI[aarch64_rust-sysinfo0.30-devel.sha256sum] = "7e5b0b94e36d26451b9e6b544006ade44b3c486c65e2dba11f35b7bafcfde58c"

RDEPENDS:rust-sysinfo0.30+c-interface-devel = " \
 cargo \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+debug-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+default-devel = " \
 cargo \
 rust-sysinfo0.30+multithread-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+linux-netdevs-devel = " \
 cargo \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+linux-tmpfs-devel = " \
 cargo \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+multithread-devel = " \
 cargo \
 rust-sysinfo0.30+rayon-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+rayon-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sysinfo0.30-devel \
 "
RDEPENDS:rust-sysinfo0.30-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 "
