# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jigdo"
PV = "0.8.2"
PR = "9.el10_3"
PACKAGES = " \
 jigdo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/j/jigdo-0.8.2-9.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4497a4d143dbd15113ad03427f32c9af6ef7ed87a0db97b6e1773e9322772a3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jigdo-0.8.2-9.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jigdo;unpack=0"
SRC_URI[x86_64_v2_jigdo.sha256sum] = "dae534832ba7c145d058fdf1c593a48a5039eb82fc4981f15ac5352d3877981b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/j/jigdo-0.8.2-9.el10_3.aarch64.rpm;name=aarch64_jigdo;unpack=0"
SRC_URI[aarch64_jigdo.sha256sum] = "9d18e8cc47b80721cd82f8c620445aa6357e72ba979675b993babf18abbbc16a"

RDEPENDS:jigdo = " \
 bash \
 bzip2-libs \
 glibc \
 libdb \
 libgcc \
 libstdc++ \
 wget \
 zlib-ng-compat \
 "
