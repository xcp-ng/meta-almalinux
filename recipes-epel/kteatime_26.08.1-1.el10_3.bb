# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kteatime"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kteatime \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kteatime-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2a2b539f6684ca0ec56c67d15d89d0f5ed6e32a5c391df9fe8b0834b97d664c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kteatime-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kteatime;unpack=0"
SRC_URI[x86_64_v2_kteatime.sha256sum] = "036c249098fa0d545f029050473682d1a9a5c6c9e6242eac8eae137e8d9e9dde"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kteatime-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kteatime;unpack=0"
SRC_URI[aarch64_kteatime.sha256sum] = "29ce5c6cde7a844e3ec71a40697c23e82c574d71500f5ca4c96bca23865c7e3c"

RDEPENDS:kteatime = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
