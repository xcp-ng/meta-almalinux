# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "w3m"
PV = "0.5.3"
PR = "65.git20230121.el10_0"
PACKAGES = " \
 w3m \
 w3m-img \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/w3m-0.5.3-65.git20230121.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "379ae67969ccbd8e95afd58fa137571fa2faa07aaa5c7bd01a45f66aec1bfcd0"

URI_x86_64_v2_w3m = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/w3m-0.5.3-65.git20230121.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_w3m;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_w3m}"
SRC_URI[x86_64_v2_w3m.sha256sum] = "a3668a74675a585224a934124af6dfa67d48559fa74368a8b66e1b2274827749"
RPROVIDES:w3m:x86_64_v2 = "virtual/text-www-browser"

URI_x86_64_v2_w3m-img = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/w3m-img-0.5.3-65.git20230121.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_w3m-img;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_w3m-img}"
SRC_URI[x86_64_v2_w3m-img.sha256sum] = "d7a5542ad6ed39a5f3c1c17ef90245fe618e6ff1ed7f327483e8263237e83cbb"

URI_aarch64_w3m = "${EPEL_MIRROR}/aarch64/Packages/w/w3m-0.5.3-65.git20230121.el10_0.aarch64.rpm;name=aarch64_w3m;unpack=0"
SRC_URI:append = " ${URI_aarch64_w3m}"
SRC_URI[aarch64_w3m.sha256sum] = "a6c1a0d1033a5cc785b73cf4b0c271a4b5b7f0d81dd11aca889977213fef7d6f"
RPROVIDES:w3m:aarch64 = "virtual/text-www-browser"

URI_aarch64_w3m-img = "${EPEL_MIRROR}/aarch64/Packages/w/w3m-img-0.5.3-65.git20230121.el10_0.aarch64.rpm;name=aarch64_w3m-img;unpack=0"
SRC_URI:append = " ${URI_aarch64_w3m-img}"
SRC_URI[aarch64_w3m-img.sha256sum] = "486c86930f3671f550a9d25211dbd213a2af45960c61008b07fa8f0531c5eddb"

RDEPENDS:w3m = " \
 bash \
 gc \
 glibc \
 gpm-libs \
 ncurses-libs \
 openssl-libs \
 perl-NKF \
 perl-interpreter \
 zlib-ng-compat \
 "
RDEPENDS:w3m-img = " \
 ImageMagick \
 gdk-pixbuf2 \
 gdk-pixbuf2-xlib \
 glib2 \
 glibc \
 libX11 \
 w3m \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/text-www-browser"

PROVIDES:append:aarch64 = " rpm/virtual/text-www-browser"
