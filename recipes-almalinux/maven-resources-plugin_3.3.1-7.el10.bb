# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-resources-plugin"
PV = "3.3.1"
PR = "7.el10"
PACKAGES = " \
 maven-resources-plugin \
 maven-resources-plugin-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-resources-plugin-3.3.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4e03476382533c0dc4c1bf279a806ba4f80cb9548f4a4a5661e36a19582d20c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-resources-plugin-3.3.1-7.el10.noarch.rpm;name=x86_64_v2_maven-resources-plugin;unpack=0"
SRC_URI[x86_64_v2_maven-resources-plugin.sha256sum] = "70a994b506f3bed266d427f1cc44b20d5d29bc468248aff945a56410e9ddb1cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-resources-plugin-javadoc-3.3.1-7.el10.noarch.rpm;name=x86_64_v2_maven-resources-plugin-javadoc;unpack=0"
SRC_URI[x86_64_v2_maven-resources-plugin-javadoc.sha256sum] = "e953f6aee4429ca3257bc2dd83d67408560d3930b516453c53c9f4709e6a2aed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-resources-plugin-3.3.1-7.el10.noarch.rpm;name=aarch64_maven-resources-plugin;unpack=0"
SRC_URI[aarch64_maven-resources-plugin.sha256sum] = "70a994b506f3bed266d427f1cc44b20d5d29bc468248aff945a56410e9ddb1cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-resources-plugin-javadoc-3.3.1-7.el10.noarch.rpm;name=aarch64_maven-resources-plugin-javadoc;unpack=0"
SRC_URI[aarch64_maven-resources-plugin-javadoc.sha256sum] = "e953f6aee4429ca3257bc2dd83d67408560d3930b516453c53c9f4709e6a2aed"

RDEPENDS:maven-resources-plugin = " \
 apache-commons-io \
 apache-commons-lang3 \
 javapackages-filesystem \
 maven-filtering \
 plexus-interpolation \
 plexus-utils \
 "
RDEPENDS:maven-resources-plugin-javadoc = " \
 javapackages-filesystem \
 "
