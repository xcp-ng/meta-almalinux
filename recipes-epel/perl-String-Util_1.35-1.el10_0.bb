# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-String-Util"
PV = "1.35"
PR = "1.el10_0"
PACKAGES = " \
 perl-String-Util \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-String-Util-1.35-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7dff650d5972176f7b3b16fb6d23d180d6b81c0a23d3355db22548897091c048"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-String-Util-1.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-String-Util;unpack=0"
SRC_URI[x86_64_v2_perl-String-Util.sha256sum] = "be7ce751b8bd3a01bcc55cf08bd0d6df2245c76789f8d7b2bcb2eb3616ee10a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-String-Util-1.35-1.el10_0.noarch.rpm;name=aarch64_perl-String-Util;unpack=0"
SRC_URI[aarch64_perl-String-Util.sha256sum] = "ae319b762eeecb40094466917882750f653068104325afd1c6c87d62996d2055"

RDEPENDS:perl-String-Util = " \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-vars \
 "
