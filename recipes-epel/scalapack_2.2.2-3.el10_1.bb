# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scalapack"
PV = "2.2.2"
PR = "3.el10_1"
PACKAGES = " \
 scalapack-common \
 scalapack-mpich \
 scalapack-mpich-devel \
 scalapack-mpich-static \
 scalapack-openmpi \
 scalapack-openmpi-devel \
 scalapack-openmpi-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scalapack-2.2.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2e69e63fcb6fa4a9fed558d509c58b24da3f4ca5443c82ea8b375abbe4f7ed1"

URI_x86_64_v2_scalapack-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-common-2.2.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-common}"
SRC_URI[x86_64_v2_scalapack-common.sha256sum] = "a3b8cf3eae25e5f37fd0ff7845bf58ef2574f7cac9053b917ed86654a98507b3"

URI_x86_64_v2_scalapack-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-mpich-2.2.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-mpich}"
SRC_URI[x86_64_v2_scalapack-mpich.sha256sum] = "544a718480757e146571e2bce6a679641f53c47937015cf41bf3801925d00bec"

URI_x86_64_v2_scalapack-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-mpich-devel-2.2.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-mpich-devel}"
SRC_URI[x86_64_v2_scalapack-mpich-devel.sha256sum] = "d0e6168796e1986ae1fb1211918b925c2586333ef73b85c712172cfd9b23f362"

URI_x86_64_v2_scalapack-mpich-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-mpich-static-2.2.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-mpich-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-mpich-static}"
SRC_URI[x86_64_v2_scalapack-mpich-static.sha256sum] = "2da76f75f7a0684033893efc7b9c87612ca02d73cf813e970a3c8af68ba4610c"

URI_x86_64_v2_scalapack-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-openmpi-2.2.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-openmpi}"
SRC_URI[x86_64_v2_scalapack-openmpi.sha256sum] = "d8494d78b1b434da02f601537d1c6fb899fde959fac8509cfa188757fec65d82"

URI_x86_64_v2_scalapack-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-openmpi-devel-2.2.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-openmpi-devel}"
SRC_URI[x86_64_v2_scalapack-openmpi-devel.sha256sum] = "54a430ceb1deeb6c9b7e6304541995dd0de5879aa4c817b90215e6eb530404b6"

URI_x86_64_v2_scalapack-openmpi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalapack-openmpi-static-2.2.2-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalapack-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalapack-openmpi-static}"
SRC_URI[x86_64_v2_scalapack-openmpi-static.sha256sum] = "7a5b7951761f2ee7d0b0632c43a8113d039670e58da0b8c8878c775e2f9f1c45"

URI_aarch64_scalapack-common = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-common-2.2.2-3.el10_1.aarch64.rpm;name=aarch64_scalapack-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-common}"
SRC_URI[aarch64_scalapack-common.sha256sum] = "dce88162608841e752510629d2bcf3738b8d1e259ebd6bd123959274e2bc1679"

URI_aarch64_scalapack-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-mpich-2.2.2-3.el10_1.aarch64.rpm;name=aarch64_scalapack-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-mpich}"
SRC_URI[aarch64_scalapack-mpich.sha256sum] = "3a7105c14f8319e5a319db86a67e33968dcd555909e12f7f550eb8899ba2d862"

URI_aarch64_scalapack-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-mpich-devel-2.2.2-3.el10_1.aarch64.rpm;name=aarch64_scalapack-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-mpich-devel}"
SRC_URI[aarch64_scalapack-mpich-devel.sha256sum] = "f38ecaff4032c2575859234d6978b08e8986976c0084c6556be8413244afc1bd"

URI_aarch64_scalapack-mpich-static = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-mpich-static-2.2.2-3.el10_1.aarch64.rpm;name=aarch64_scalapack-mpich-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-mpich-static}"
SRC_URI[aarch64_scalapack-mpich-static.sha256sum] = "a0d3e7b6314927d2b3bd23370dbb68e56debb82ded8335eba2f67e041a385de6"

URI_aarch64_scalapack-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-openmpi-2.2.2-3.el10_1.aarch64.rpm;name=aarch64_scalapack-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-openmpi}"
SRC_URI[aarch64_scalapack-openmpi.sha256sum] = "ad791e294ced69405821c829531bb89fc245d67bf974827c572f23e5bc335468"

URI_aarch64_scalapack-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-openmpi-devel-2.2.2-3.el10_1.aarch64.rpm;name=aarch64_scalapack-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-openmpi-devel}"
SRC_URI[aarch64_scalapack-openmpi-devel.sha256sum] = "a8ae2e91d7bf60c7edaa6bfcc6da42028872be7a66e300d66a7be0dd4e0ef679"

URI_aarch64_scalapack-openmpi-static = "${EPEL_MIRROR}/aarch64/Packages/s/scalapack-openmpi-static-2.2.2-3.el10_1.aarch64.rpm;name=aarch64_scalapack-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalapack-openmpi-static}"
SRC_URI[aarch64_scalapack-openmpi-static.sha256sum] = "92f6853d33837da92a59702e1b192ca54823760755dc1efaca77f268df9349ac"

RDEPENDS:scalapack-common = " \
 cmake-filesystem \
 "
RDEPENDS:scalapack-mpich = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 mpich \
 scalapack-common \
 "
RDEPENDS:scalapack-mpich-devel = " \
 mpich-devel \
 scalapack-mpich \
 "
RDEPENDS:scalapack-mpich-static = " \
 scalapack-mpich-devel \
 "
RDEPENDS:scalapack-openmpi = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 openmpi \
 scalapack-common \
 "
RDEPENDS:scalapack-openmpi-devel = " \
 openmpi-devel \
 scalapack-openmpi \
 "
RDEPENDS:scalapack-openmpi-static = " \
 scalapack-openmpi-devel \
 "
