# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fapolicy-analyzer"
PV = "1.5.0"
PR = "3.el10_1"
PACKAGES = " \
 fapolicy-analyzer \
 fapolicy-analyzer-cli \
 fapolicy-analyzer-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fapolicy-analyzer-1.5.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffbceb8bf16eedd6f6d1f1e55b57d03a74c8f360308054216a0285e45f728f41"

URI_x86_64_v2_fapolicy-analyzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fapolicy-analyzer-1.5.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fapolicy-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicy-analyzer}"
SRC_URI[x86_64_v2_fapolicy-analyzer.sha256sum] = "0c6727441a9e6cbe38e287085408be4375badd98f720d8fb026000a46fba7536"

URI_x86_64_v2_fapolicy-analyzer-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fapolicy-analyzer-cli-1.5.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fapolicy-analyzer-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicy-analyzer-cli}"
SRC_URI[x86_64_v2_fapolicy-analyzer-cli.sha256sum] = "8864153d6ceed88a443cef24504435b347588ce466d01038d2d2067fc486f1ba"

URI_x86_64_v2_fapolicy-analyzer-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fapolicy-analyzer-gui-1.5.0-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fapolicy-analyzer-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicy-analyzer-gui}"
SRC_URI[x86_64_v2_fapolicy-analyzer-gui.sha256sum] = "4b31d2d015372a88828df47abb64caf91a834a352ec04aa7a4d7c27f1eacf49d"

URI_aarch64_fapolicy-analyzer = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-1.5.0-3.el10_1.aarch64.rpm;name=aarch64_fapolicy-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer}"
SRC_URI[aarch64_fapolicy-analyzer.sha256sum] = "f3b5fa25343178331bc56f2acc8228aff110f8ad4d6c016eb21c5aa0a0365e16"

URI_aarch64_fapolicy-analyzer-cli = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-cli-1.5.0-3.el10_1.aarch64.rpm;name=aarch64_fapolicy-analyzer-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer-cli}"
SRC_URI[aarch64_fapolicy-analyzer-cli.sha256sum] = "e8e78ee508c28dc8bb26532328843704596d275aba10b644419c7888bf82f3ca"

URI_aarch64_fapolicy-analyzer-gui = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-gui-1.5.0-3.el10_1.aarch64.rpm;name=aarch64_fapolicy-analyzer-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer-gui}"
SRC_URI[aarch64_fapolicy-analyzer-gui.sha256sum] = "9427799872427171ac5ef0742e29237493294b17aff5e78d5bc554aeb434902d"

RDEPENDS:fapolicy-analyzer = " \
 fapolicy-analyzer-cli \
 fapolicy-analyzer-gui \
 "
RDEPENDS:fapolicy-analyzer-cli = " \
 audit-libs \
 dbus-libs \
 glibc \
 libgcc \
 lmdb-libs \
 "
RDEPENDS:fapolicy-analyzer-gui = " \
 audit-libs \
 bash \
 dbus-libs \
 glibc \
 gnome-icon-theme \
 gtk3 \
 gtksourceview3 \
 libgcc \
 lmdb-libs \
 mesa-dri-drivers \
 python3 \
 python3-configargparse \
 python3-gobject \
 python3-more-itertools \
 python3-rx \
 python3-tomli \
 webkit2gtk4.1 \
 "
