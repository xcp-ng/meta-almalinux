# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plutosvg"
PV = "0.0.8"
PR = "2.el10_3"
PACKAGES = " \
 plutosvg \
 plutosvg-devel \
 plutosvg-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plutosvg-0.0.8-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf0be1baf186cdaef2206010be6292cd6355be13ba4ce9b026ef5ebeb59387cb"

URI_x86_64_v2_plutosvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-0.0.8-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg}"
SRC_URI[x86_64_v2_plutosvg.sha256sum] = "fcfd5e97f5fb95928db8fd452823ee70ebf53c7b99cc1b1a0c7a58bb5053695a"

URI_x86_64_v2_plutosvg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-devel-0.0.8-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg-devel}"
SRC_URI[x86_64_v2_plutosvg-devel.sha256sum] = "b57add5c58f28dd02fec8a714352637ae807e3af0a17029d1c663d788bc66d01"

URI_x86_64_v2_plutosvg-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plutosvg-samples-0.0.8-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plutosvg-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plutosvg-samples}"
SRC_URI[x86_64_v2_plutosvg-samples.sha256sum] = "009c8c1302fd0d88fce54fae9c5cf5da9de5542385c80104f6f36f09770ac157"

URI_aarch64_plutosvg = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-0.0.8-2.el10_3.aarch64.rpm;name=aarch64_plutosvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg}"
SRC_URI[aarch64_plutosvg.sha256sum] = "1bb80047f51914ca13199c6920622fae03795c6ef4e1445693db095056762eb1"

URI_aarch64_plutosvg-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-devel-0.0.8-2.el10_3.aarch64.rpm;name=aarch64_plutosvg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg-devel}"
SRC_URI[aarch64_plutosvg-devel.sha256sum] = "048744f73aa7e51b8d6f6e893914f18f6af8110f3b7f95bf0fc6b4b4cb9d1f6a"

URI_aarch64_plutosvg-samples = "${EPEL_MIRROR}/aarch64/Packages/p/plutosvg-samples-0.0.8-2.el10_3.aarch64.rpm;name=aarch64_plutosvg-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_plutosvg-samples}"
SRC_URI[aarch64_plutosvg-samples.sha256sum] = "d143f26312392df8650afe3f8618a8530f9ad761668f11dada1aa402799be57a"

RDEPENDS:plutosvg = " \
 freetype \
 glibc \
 plutovg \
 "
RDEPENDS:plutosvg-devel = " \
 cmake-filesystem \
 freetype-devel \
 pkgconf-pkg-config \
 plutosvg \
 plutovg-devel \
 "
RDEPENDS:plutosvg-samples = " \
 freetype \
 glibc \
 plutosvg \
 plutovg \
 "
