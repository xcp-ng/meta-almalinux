# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-license-data"
PV = "1.57"
PR = "1.el10_0"
PACKAGES = " \
 fedora-license-data \
 rpmlint-fedora-license-data \
 rpmlint-fedora-license-data-legacy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-license-data-1.57-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6a6307abaf9b772a8dca78e19e8ee474592d2add06734e33f49263ea5ba90e4"

URI_x86_64_v2_fedora-license-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-license-data-1.57-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-license-data}"
SRC_URI[x86_64_v2_fedora-license-data.sha256sum] = "b0e5951dde9ee3b64a9011fa16e15de7a21921b1766df1d288166e812a5ea70c"

URI_x86_64_v2_rpmlint-fedora-license-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-1.57-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmlint-fedora-license-data}"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data.sha256sum] = "6d73083fde7270d9399e5cc7ed912ce6730c4d088349ae5d842bbfa80b9e1146"

URI_x86_64_v2_rpmlint-fedora-license-data-legacy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-fedora-license-data-legacy-1.57-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmlint-fedora-license-data-legacy}"
SRC_URI[x86_64_v2_rpmlint-fedora-license-data-legacy.sha256sum] = "37c2e4d745ca6169b5abcdb0e39aff6c8ec43a2efd84f71c87ce2b4cf6ef91ff"

URI_aarch64_fedora-license-data = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-license-data-1.57-1.el10_0.noarch.rpm;name=aarch64_fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-license-data}"
SRC_URI[aarch64_fedora-license-data.sha256sum] = "c3fd9fadbf16def72789427491da8952042927c2ac889add0b007cde471ca6aa"

URI_aarch64_rpmlint-fedora-license-data = "${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-1.57-1.el10_0.noarch.rpm;name=aarch64_rpmlint-fedora-license-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmlint-fedora-license-data}"
SRC_URI[aarch64_rpmlint-fedora-license-data.sha256sum] = "587c527fcccb4dfe0aa27dd7ff38593e4304ae4b2632b9a7e02882c088c73f23"

URI_aarch64_rpmlint-fedora-license-data-legacy = "${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-fedora-license-data-legacy-1.57-1.el10_0.noarch.rpm;name=aarch64_rpmlint-fedora-license-data-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmlint-fedora-license-data-legacy}"
SRC_URI[aarch64_rpmlint-fedora-license-data-legacy.sha256sum] = "fdd5458c9adda29e20a8ab37ea5f03829909e8339edc041ff7eb4e03342457c8"

RDEPENDS:fedora-license-data = " \
 "
RDEPENDS:rpmlint-fedora-license-data = " \
 rpmlint \
 "
RDEPENDS:rpmlint-fedora-license-data-legacy = " \
 rpmlint \
 "
