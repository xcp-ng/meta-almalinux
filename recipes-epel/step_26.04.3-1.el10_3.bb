# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "step"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 step \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/step-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb538ae79c4975b9f3a395f21bba21ee93853b6a18747927f3322c0ffb7e4f06"

URI_x86_64_v2_step = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/step-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_step;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_step}"
SRC_URI[x86_64_v2_step.sha256sum] = "5bac6ec0fca766d006bf65f4d44f1e9bd2603ca9f9fe2880bd83aa5f6798bf46"

URI_aarch64_step = "${EPEL_MIRROR}/aarch64/Packages/s/step-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_step;unpack=0"
SRC_URI:append = " ${URI_aarch64_step}"
SRC_URI[aarch64_step.sha256sum] = "647edd7deef1606ea2e1caa0cb23e8d329bf81c19c75cbc7f19d63237adeebff"

RDEPENDS:step = " \
 glibc \
 gsl \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-kplotting \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libqalculate \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
