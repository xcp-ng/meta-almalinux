# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clustershell"
PV = "1.9.3"
PR = "1.el10_0"
PACKAGES = " \
 clustershell \
 python3-clustershell \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clustershell-1.9.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05c4c53c4bbd38ebd9df359f8e247d6dd87a0fbf6d6cee8ceefbcdd34eaf5856"

URI_x86_64_v2_clustershell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clustershell-1.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_clustershell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clustershell}"
SRC_URI[x86_64_v2_clustershell.sha256sum] = "a8dbb91e9823857b0d117b61d775d9333ebad5af6ae2d2bed1afe85f502a0fcc"

URI_x86_64_v2_python3-clustershell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-clustershell-1.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-clustershell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-clustershell}"
SRC_URI[x86_64_v2_python3-clustershell.sha256sum] = "1d8bd728be8bf4697ddca3e2be1da1fb43e4be22c6bb0ef4596441aeffd1309d"

URI_aarch64_clustershell = "${EPEL_MIRROR}/aarch64/Packages/c/clustershell-1.9.3-1.el10_0.noarch.rpm;name=aarch64_clustershell;unpack=0"
SRC_URI:append = " ${URI_aarch64_clustershell}"
SRC_URI[aarch64_clustershell.sha256sum] = "e554d4259fd3378651d8a5c16efedf488fb73af830fc045140295de98ff6a184"

URI_aarch64_python3-clustershell = "${EPEL_MIRROR}/aarch64/Packages/p/python3-clustershell-1.9.3-1.el10_0.noarch.rpm;name=aarch64_python3-clustershell;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-clustershell}"
SRC_URI[aarch64_python3-clustershell.sha256sum] = "a4d16741d9cf6a17f447c2c2b9fff78eb9b3062ac5eb4c1f524c37a937afc6ea"

RDEPENDS:clustershell = " \
 python3-clustershell \
 vim-filesystem \
 "
RDEPENDS:python3-clustershell = " \
 python3 \
 python3-pyyaml \
 python3-setuptools \
 "
