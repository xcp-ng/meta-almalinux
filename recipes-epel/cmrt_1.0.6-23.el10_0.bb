# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cmrt"
PV = "1.0.6"
PR = "23.el10_0"
PACKAGES:x86_64_v2 = " \
 cmrt \
 cmrt-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/c/cmrt-1.0.6-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88a144b5056f6e621bfd8251e9c3c7bf24c61dda5df3eeaccdae384633d018fa"

URI_x86_64_v2_cmrt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cmrt-1.0.6-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cmrt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmrt}"
SRC_URI[x86_64_v2_cmrt.sha256sum] = "19dd76589145ae80eae3ac9dbf12d1f1bc37459b19b66e1a5696eee432c36a97"

URI_x86_64_v2_cmrt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cmrt-devel-1.0.6-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cmrt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cmrt-devel}"
SRC_URI[x86_64_v2_cmrt-devel.sha256sum] = "cdc87e5f38cd9791c714be3c4a1ed5f9549a948e98a703e8fba27c466d7615a5"

RDEPENDS:cmrt = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 "
RDEPENDS:cmrt-devel = " \
 cmrt \
 pkgconf-pkg-config \
 "
