# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aho-corasick"
PV = "1.1.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-aho-corasick+default-devel \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aho-corasick-1.1.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "740e8d5ef47de8922fe1b11d2e461f00330928e8471e53736e97116524b4d5b8"

URI_x86_64_v2_rust-aho-corasick+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+default-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+default-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+default-devel.sha256sum] = "5f3e16510c5a8474ade3b60212f04f7e7184c4435aa507f3ff9186a6b6500adc"

URI_x86_64_v2_rust-aho-corasick+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+logging-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+logging-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+logging-devel.sha256sum] = "1a6c8eb15c699760b70e2709ccb9834adbac3cc115f33855b01d726e6f199d90"

URI_x86_64_v2_rust-aho-corasick+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+perf-literal-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+perf-literal-devel.sha256sum] = "789745c45bfd210ffb1cc604644a8a39e0c745d4859043f6014bcd960214d444"

URI_x86_64_v2_rust-aho-corasick+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick+std-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick+std-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick+std-devel.sha256sum] = "4222e5fbd7af39db2d600a5c69cf0fdbe34559a88be8b53bf4fe6351c9888781"

URI_x86_64_v2_rust-aho-corasick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aho-corasick-devel-1.1.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aho-corasick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aho-corasick-devel}"
SRC_URI[x86_64_v2_rust-aho-corasick-devel.sha256sum] = "69994bb4c85f3f2485971d27d76750e580b32a03d38d5ade8f71a5a6f1b28246"

URI_aarch64_rust-aho-corasick+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+default-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-aho-corasick+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+default-devel}"
SRC_URI[aarch64_rust-aho-corasick+default-devel.sha256sum] = "8de2841a7a4c150481d161e48f8e2846a7bca2e118c1c7eb6b47927c627c6019"

URI_aarch64_rust-aho-corasick+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+logging-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-aho-corasick+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+logging-devel}"
SRC_URI[aarch64_rust-aho-corasick+logging-devel.sha256sum] = "5dcb5f3d89011a2128a85f7e6cf9b6be3f11ed9dc582926c562d2da87d8df865"

URI_aarch64_rust-aho-corasick+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+perf-literal-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-aho-corasick+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+perf-literal-devel}"
SRC_URI[aarch64_rust-aho-corasick+perf-literal-devel.sha256sum] = "51032d8a072cc5370cfb3ade4e8c53d75d628d51acf8f994b38b221e6b756aff"

URI_aarch64_rust-aho-corasick+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick+std-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-aho-corasick+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick+std-devel}"
SRC_URI[aarch64_rust-aho-corasick+std-devel.sha256sum] = "66ea83e6c1861627607ec6f4691547be0560995dc1e0cc8662541aa08773e77b"

URI_aarch64_rust-aho-corasick-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aho-corasick-devel-1.1.5-1.el10_2.noarch.rpm;name=aarch64_rust-aho-corasick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aho-corasick-devel}"
SRC_URI[aarch64_rust-aho-corasick-devel.sha256sum] = "d543a18ccc23e0f5ac871bcb98030e7d4feed43ce54c978c00dd8f2a1b8475ba"

RDEPENDS:rust-aho-corasick+default-devel = " \
 cargo \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 "
RDEPENDS:rust-aho-corasick+logging-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-aho-corasick+perf-literal-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-aho-corasick+std-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-aho-corasick-devel = " \
 cargo \
 rust \
 "
