# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-package-information"
PV = "0.4.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-package-information \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-package-information-0.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "88f1ec578af50ff8e849b67a133a880c3de14bc3bfbd85d5aff08ea4cb386bc1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-package-information-0.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-package-information;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-package-information.sha256sum] = "d134ac4274db71dc5e6acb4a52c584e0251608f23631f406938dffa519834d69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-package-information-0.4.1-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-package-information;unpack=0"
SRC_URI[aarch64_python3-colcon-package-information.sha256sum] = "b46929c60f154cc64aa914430bc8ba8739d234abb6cf2a238b6f95cce959a587"

RDEPENDS:python3-colcon-package-information = " \
 python3 \
 python3-colcon-core \
 python3-packaging \
 "
