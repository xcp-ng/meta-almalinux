# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml0.8"
PV = "0.8.23"
PR = "1.el10_1"
PACKAGES = " \
 rust-toml0.8+default-devel \
 rust-toml0.8+display-devel \
 rust-toml0.8+indexmap-devel \
 rust-toml0.8+parse-devel \
 rust-toml0.8+preserve_order-devel \
 rust-toml0.8+unbounded-devel \
 rust-toml0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml0.8-0.8.23-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f26fb1489e27a91e3843c9479cbc67bad282a0ac6d0c64853c69144f39a6c50"

URI_x86_64_v2_rust-toml0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.8+default-devel-0.8.23-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.8+default-devel}"
SRC_URI[x86_64_v2_rust-toml0.8+default-devel.sha256sum] = "d1a6319743af88848a46f91173b444b760053d34b0898fef2b4972547de25735"

URI_x86_64_v2_rust-toml0.8+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.8+display-devel-0.8.23-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.8+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.8+display-devel}"
SRC_URI[x86_64_v2_rust-toml0.8+display-devel.sha256sum] = "f94d439e750823d729704e9e86c1bae8e3dff9d8f853363a94237a1e3a77952d"

URI_x86_64_v2_rust-toml0.8+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.8+indexmap-devel-0.8.23-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.8+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.8+indexmap-devel}"
SRC_URI[x86_64_v2_rust-toml0.8+indexmap-devel.sha256sum] = "208dd81c15e06ec31d117a10dbbe2011bc322c533f30840858062500be581dac"

URI_x86_64_v2_rust-toml0.8+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.8+parse-devel-0.8.23-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.8+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.8+parse-devel}"
SRC_URI[x86_64_v2_rust-toml0.8+parse-devel.sha256sum] = "c204e6baef2b5f01e6aceb92f9b5170968c8cade5b792d0b109a01daaac19cb5"

URI_x86_64_v2_rust-toml0.8+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.8+preserve_order-devel-0.8.23-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.8+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.8+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-toml0.8+preserve_order-devel.sha256sum] = "8a5c4618772565ba04c1482aaa89b824f6819465a139e27e127e283824bc1c19"

URI_x86_64_v2_rust-toml0.8+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.8+unbounded-devel-0.8.23-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.8+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.8+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml0.8+unbounded-devel.sha256sum] = "291f3ce6818abf17097dc8213eec2f740562bb317270422e40b7721dae69049b"

URI_x86_64_v2_rust-toml0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml0.8-devel-0.8.23-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml0.8-devel}"
SRC_URI[x86_64_v2_rust-toml0.8-devel.sha256sum] = "6f3a940629603a27c7105fdee0c2aeb86f312bfb9ded3c9f039e86dc4e3ec98e"

URI_aarch64_rust-toml0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.8+default-devel-0.8.23-1.el10_1.noarch.rpm;name=aarch64_rust-toml0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.8+default-devel}"
SRC_URI[aarch64_rust-toml0.8+default-devel.sha256sum] = "813a925e669239a11a1d794fa07df8eafd6ee8d1b7a88479e6d557139d99f843"

URI_aarch64_rust-toml0.8+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.8+display-devel-0.8.23-1.el10_1.noarch.rpm;name=aarch64_rust-toml0.8+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.8+display-devel}"
SRC_URI[aarch64_rust-toml0.8+display-devel.sha256sum] = "24042b3e818b0c6fd6dcbc44fd44edb51c610c378495e98f329b5d53b1305cca"

URI_aarch64_rust-toml0.8+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.8+indexmap-devel-0.8.23-1.el10_1.noarch.rpm;name=aarch64_rust-toml0.8+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.8+indexmap-devel}"
SRC_URI[aarch64_rust-toml0.8+indexmap-devel.sha256sum] = "4b8ee623520111ae2bb342d79c3a3af76433f9dd4e50ed01be99994423f2b17b"

URI_aarch64_rust-toml0.8+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.8+parse-devel-0.8.23-1.el10_1.noarch.rpm;name=aarch64_rust-toml0.8+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.8+parse-devel}"
SRC_URI[aarch64_rust-toml0.8+parse-devel.sha256sum] = "b3d4845528a7e3f95b284fb6afb4e4f246ca6af1c65b2101da1c61a9fd0ba519"

URI_aarch64_rust-toml0.8+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.8+preserve_order-devel-0.8.23-1.el10_1.noarch.rpm;name=aarch64_rust-toml0.8+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.8+preserve_order-devel}"
SRC_URI[aarch64_rust-toml0.8+preserve_order-devel.sha256sum] = "eff70f3206473f3db76610f4c1e6722f6439c35bf6e38df91524f2820602f8d4"

URI_aarch64_rust-toml0.8+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.8+unbounded-devel-0.8.23-1.el10_1.noarch.rpm;name=aarch64_rust-toml0.8+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.8+unbounded-devel}"
SRC_URI[aarch64_rust-toml0.8+unbounded-devel.sha256sum] = "b83e8d69d3109a70975fb7c7f83112644637c678eb339c4f213556d669a643d5"

URI_aarch64_rust-toml0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml0.8-devel-0.8.23-1.el10_1.noarch.rpm;name=aarch64_rust-toml0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml0.8-devel}"
SRC_URI[aarch64_rust-toml0.8-devel.sha256sum] = "9eb161879b29c2083fc9ec4a72684c2baf716dde2c724c749614af8f7083adb4"

RDEPENDS:rust-toml0.8+default-devel = " \
 cargo \
 rust-toml0.8+display-devel \
 rust-toml0.8+parse-devel \
 rust-toml0.8-devel \
 "
RDEPENDS:rust-toml0.8+display-devel = " \
 cargo \
 rust-toml0.8-devel \
 rust-toml_edit0.22+display-devel \
 rust-toml_edit0.22+serde-devel \
 rust-toml_edit0.22-devel \
 "
RDEPENDS:rust-toml0.8+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-toml0.8-devel \
 "
RDEPENDS:rust-toml0.8+parse-devel = " \
 cargo \
 rust-toml0.8-devel \
 rust-toml_edit0.22+parse-devel \
 rust-toml_edit0.22+serde-devel \
 rust-toml_edit0.22-devel \
 "
RDEPENDS:rust-toml0.8+preserve_order-devel = " \
 cargo \
 rust-toml0.8+indexmap-devel \
 rust-toml0.8-devel \
 "
RDEPENDS:rust-toml0.8+unbounded-devel = " \
 cargo \
 rust-toml0.8-devel \
 rust-toml_edit0.22+serde-devel \
 rust-toml_edit0.22+unbounded-devel \
 rust-toml_edit0.22-devel \
 "
RDEPENDS:rust-toml0.8-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde_spanned0.6+default-devel \
 rust-serde_spanned0.6+serde-devel \
 rust-toml_datetime0.6+default-devel \
 rust-toml_datetime0.6+serde-devel \
 "
