# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebengine"
PV = "6.8.1"
PR = "4.el10_0"
PACKAGES = " \
 qt6-qtpdf \
 qt6-qtpdf-devel \
 qt6-qtpdf-examples \
 qt6-qtwebengine \
 qt6-qtwebengine-devel \
 qt6-qtwebengine-devtools \
 qt6-qtwebengine-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtwebengine-6.8.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "473352e4d39cfa406aaaae3e9a696c23386004a10fe140233b7b70c2f4133fba"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - qt6-qtwebengine: libavcodec.so.61()(64bit)
# - qt6-qtwebengine: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - qt6-qtwebengine: libavformat.so.61()(64bit)
# - qt6-qtwebengine: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - qt6-qtwebengine: libavutil.so.59()(64bit)
# - qt6-qtwebengine: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_qt6-qtpdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtpdf-6.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpdf}"
SRC_URI[x86_64_v2_qt6-qtpdf.sha256sum] = "a03c7d542cb21cf1ad14320596241ebd3d6e8f3f6a8d522fdadf4b522da37d9a"

URI_x86_64_v2_qt6-qtpdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtpdf-devel-6.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpdf-devel}"
SRC_URI[x86_64_v2_qt6-qtpdf-devel.sha256sum] = "cf5b7cdefb12b686ad79d299037bca5bf1b31ecd55203dc49d8b2eb784d06039"

URI_x86_64_v2_qt6-qtpdf-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtpdf-examples-6.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpdf-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpdf-examples}"
SRC_URI[x86_64_v2_qt6-qtpdf-examples.sha256sum] = "89e693869c10a6cd9983c44723d90389b7991b7fb4e3468d8d545cff74caa5d5"

URI_x86_64_v2_qt6-qtwebengine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-6.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine}"
SRC_URI[x86_64_v2_qt6-qtwebengine.sha256sum] = "137105d978697e3ce5691faee84835574b7c25ea62a757c37da5e3b9507809fd"

URI_x86_64_v2_qt6-qtwebengine-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-devel-6.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine-devel}"
SRC_URI[x86_64_v2_qt6-qtwebengine-devel.sha256sum] = "48bc097969bad6e181cbdbb2579e20fe2432e13bc0a5fdb24ba2da709d646cb4"

URI_x86_64_v2_qt6-qtwebengine-devtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-devtools-6.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine-devtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine-devtools}"
SRC_URI[x86_64_v2_qt6-qtwebengine-devtools.sha256sum] = "ceb452caea5a6a19fef3d56181f4c0f70a34c9ce2b23c49518039e4efb62bbcd"

URI_x86_64_v2_qt6-qtwebengine-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-examples-6.8.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine-examples}"
SRC_URI[x86_64_v2_qt6-qtwebengine-examples.sha256sum] = "585b079e22846aab3d0b4f1b9efd37a545172dd54eacd5ab16f311e227c07d67"

URI_aarch64_qt6-qtpdf = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtpdf-6.8.1-4.el10_0.aarch64.rpm;name=aarch64_qt6-qtpdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpdf}"
SRC_URI[aarch64_qt6-qtpdf.sha256sum] = "fa8685e1ba300081961d91a0aafa45e5e3edf10bfe4193c13fa477c12dea3cce"

URI_aarch64_qt6-qtpdf-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtpdf-devel-6.8.1-4.el10_0.aarch64.rpm;name=aarch64_qt6-qtpdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpdf-devel}"
SRC_URI[aarch64_qt6-qtpdf-devel.sha256sum] = "e81f5c488db85c4510dae24119a6c4906d7955dd9798133c64d88923d1de9aef"

URI_aarch64_qt6-qtpdf-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtpdf-examples-6.8.1-4.el10_0.aarch64.rpm;name=aarch64_qt6-qtpdf-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpdf-examples}"
SRC_URI[aarch64_qt6-qtpdf-examples.sha256sum] = "00f85a3f4b0005d8d7d0b49f099ea8cd00606060a19fea5a9f158183b7344f50"

URI_aarch64_qt6-qtwebengine = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-6.8.1-4.el10_0.aarch64.rpm;name=aarch64_qt6-qtwebengine;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine}"
SRC_URI[aarch64_qt6-qtwebengine.sha256sum] = "2af8f46b65fc1e9c5fcaae7e3de5fdc1d3bf7547ba4a30cdb5e8597d5188d574"

URI_aarch64_qt6-qtwebengine-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-devel-6.8.1-4.el10_0.aarch64.rpm;name=aarch64_qt6-qtwebengine-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine-devel}"
SRC_URI[aarch64_qt6-qtwebengine-devel.sha256sum] = "5f09b74345e3314d038204923dc6bbaa8d259d9b8600fc6a067f443418604066"

URI_aarch64_qt6-qtwebengine-devtools = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-devtools-6.8.1-4.el10_0.aarch64.rpm;name=aarch64_qt6-qtwebengine-devtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine-devtools}"
SRC_URI[aarch64_qt6-qtwebengine-devtools.sha256sum] = "e8e8e4ce5dd81532e6fac3a9ac1163a1722b1de340deae25dd639ef09505a34d"

URI_aarch64_qt6-qtwebengine-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-examples-6.8.1-4.el10_0.aarch64.rpm;name=aarch64_qt6-qtwebengine-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine-examples}"
SRC_URI[aarch64_qt6-qtwebengine-examples.sha256sum] = "49fa21001fd27819342eb6244590b1101e3307987cbff42e2a05e5df699213ea"

RDEPENDS:qt6-qtpdf = " \
 glibc \
 libgcc \
 libicu \
 libpng \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qtpdf-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtpdf \
 qt6-qtpdf-devel \
 "
RDEPENDS:qt6-qtpdf-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 "
RDEPENDS:qt6-qtwebengine:x86_64_v2 = " \
 alsa-lib \
 bash \
 dbus-libs \
 expat \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 lcms2 \
 libX11 \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libXtst \
 libdrm \
 libevent \
 libgcc \
 libicu \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libwebp \
 libxcb \
 libxkbcommon \
 libxkbfile \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 opus \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 qt6-qtpositioning \
 qt6-qtwebchannel \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qt6-qtwebengine:aarch64 = " \
 alsa-lib \
 bash \
 dbus-libs \
 expat \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 lcms2 \
 libX11 \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libXtst \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libdrm \
 libevent \
 libgcc \
 libicu \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libwebp \
 libxcb \
 libxkbcommon \
 libxkbfile \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 opus \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 qt6-qtpositioning \
 qt6-qtwebchannel \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qt6-qtwebengine-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative-devel \
 qt6-qtpdf-devel \
 qt6-qtpositioning-devel \
 qt6-qtwebchannel-devel \
 qt6-qtwebengine \
 qt6-qtwebengine-devel \
 qt6-qtwebengine-devtools \
 "
RDEPENDS:qt6-qtwebengine-devtools = " \
 qt6-qtwebengine \
 "
RDEPENDS:qt6-qtwebengine-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
