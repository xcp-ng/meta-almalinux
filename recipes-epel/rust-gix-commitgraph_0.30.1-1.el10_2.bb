# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-commitgraph"
PV = "0.30.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-commitgraph+default-devel \
 rust-gix-commitgraph+document-features-devel \
 rust-gix-commitgraph+serde-devel \
 rust-gix-commitgraph-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-commitgraph-0.30.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "049259b5d3589b63e24d7389801689cad594f9ee8b3d5407ff41e715c5423215"

URI_x86_64_v2_rust-gix-commitgraph+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+default-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+default-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+default-devel.sha256sum] = "efc38dbcd79ba313df7b1f7bbe90a05793521420ba83cf49c0fbd8b7b0237fda"

URI_x86_64_v2_rust-gix-commitgraph+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+document-features-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+document-features-devel.sha256sum] = "b0f855782cdfface8bc2229b9481feb33fb736e6dd31474e651315c1d80d71e4"

URI_x86_64_v2_rust-gix-commitgraph+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+serde-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+serde-devel.sha256sum] = "64f5d2cdf9e9169edef472d85c3bc65b09f49195c4ad8406dd8e4bcf40971abb"

URI_x86_64_v2_rust-gix-commitgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph-devel-0.30.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph-devel.sha256sum] = "2c37f21905845954b496874a90e44b9be55e732dd0de8cbe91e2e80eebbb9e83"

URI_aarch64_rust-gix-commitgraph+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+default-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-commitgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+default-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+default-devel.sha256sum] = "b4a4afae56748083c7737e15db5545071e56d56c172c235ed7b7fc574261bdc7"

URI_aarch64_rust-gix-commitgraph+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+document-features-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-commitgraph+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+document-features-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+document-features-devel.sha256sum] = "019407ba02e53a7cc17f93aee7b44da3986627ffcb7245189b6f20e6de159c11"

URI_aarch64_rust-gix-commitgraph+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+serde-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-commitgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+serde-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+serde-devel.sha256sum] = "a69a84815012e728e501e05e2a8d024eda6be7a4c0032aa24b8b753dda6332c6"

URI_aarch64_rust-gix-commitgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph-devel-0.30.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-commitgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph-devel}"
SRC_URI[aarch64_rust-gix-commitgraph-devel.sha256sum] = "d2a4fc62d64836b5b261266cd9603b4258d3318d99e4bca944cfd4c57ab71f73"

RDEPENDS:rust-gix-commitgraph+default-devel = " \
 cargo \
 rust-gix-commitgraph-devel \
 "
RDEPENDS:rust-gix-commitgraph+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-commitgraph-devel \
 "
RDEPENDS:rust-gix-commitgraph+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-commitgraph-devel \
 rust-gix-hash+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-commitgraph-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-chunk+default-devel \
 rust-gix-hash+default-devel \
 rust-memmap2+default-devel \
 rust-thiserror+default-devel \
 "
