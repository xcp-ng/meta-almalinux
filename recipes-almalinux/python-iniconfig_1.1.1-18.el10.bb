# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-iniconfig"
PV = "1.1.1"
PR = "18.el10"
PACKAGES = " \
 python3-iniconfig \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-iniconfig-1.1.1-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f05dce455ad186e0ad6febd6d13eaee027a322033e596dbdafcf000142b6aa2b"

URI_x86_64_v2_python3-iniconfig = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-iniconfig-1.1.1-18.el10.noarch.rpm;name=x86_64_v2_python3-iniconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-iniconfig}"
SRC_URI[x86_64_v2_python3-iniconfig.sha256sum] = "e4ac79eb5b9ab35dd750e4ae069311f3f0fd35ed367fb450290fef6dd890a019"

URI_aarch64_python3-iniconfig = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-iniconfig-1.1.1-18.el10.noarch.rpm;name=aarch64_python3-iniconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-iniconfig}"
SRC_URI[aarch64_python3-iniconfig.sha256sum] = "e4ac79eb5b9ab35dd750e4ae069311f3f0fd35ed367fb450290fef6dd890a019"

RDEPENDS:python3-iniconfig = " \
 python3 \
 "
