# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-uvloop"
PV = "0.21.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-uvloop \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-uvloop-0.21.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dfe0fe3ed1ba10265b6ec0cbaa59e53234821e8f1d9e973e42fc5b6e2b484c8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uvloop-0.21.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-uvloop;unpack=0"
SRC_URI[x86_64_v2_python3-uvloop.sha256sum] = "f37a43519388ed8049f8e4d1fed323f39740ca584470d3c01fd7dc4ffd7c6498"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-uvloop-0.21.0-1.el10_0.aarch64.rpm;name=aarch64_python3-uvloop;unpack=0"
SRC_URI[aarch64_python3-uvloop.sha256sum] = "59c3982dd92284037bc427ad6625d88fcffc5253e304a207a3a38d3b4e6b2ddc"

RDEPENDS:python3-uvloop = " \
 glibc \
 libuv \
 python3 \
 "
