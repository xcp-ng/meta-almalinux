# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-void"
PV = "0.7.3"
PR = "23.el10_0"
PACKAGES = " \
 ghc-void \
 ghc-void-devel \
 ghc-void-doc \
 ghc-void-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-void-0.7.3-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0722ec33700ae00f78acaf7abac5f06d35441227519d36e307a60d8ec7410843"

URI_x86_64_v2_ghc-void = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-void-0.7.3-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-void;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-void}"
SRC_URI[x86_64_v2_ghc-void.sha256sum] = "3425338da62aeb67dee687effff3cb1479533f2658255244d550c8e77063504f"

URI_x86_64_v2_ghc-void-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-void-devel-0.7.3-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-void-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-void-devel}"
SRC_URI[x86_64_v2_ghc-void-devel.sha256sum] = "8c642ca8f012b00a68d3f751ea6e77c7673c4879002ca8392febcc12986948dc"

URI_x86_64_v2_ghc-void-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-void-doc-0.7.3-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-void-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-void-doc}"
SRC_URI[x86_64_v2_ghc-void-doc.sha256sum] = "0343bc48b758aa0f9d4d8ed9d1ed00625076824a3b36d09360e54b715139e71d"

URI_x86_64_v2_ghc-void-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-void-prof-0.7.3-23.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-void-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-void-prof}"
SRC_URI[x86_64_v2_ghc-void-prof.sha256sum] = "a6fc727cdab009698b12d9ea44a101393d564d045bc2e565067540dd86f2ecd0"

URI_aarch64_ghc-void = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-void-0.7.3-23.el10_0.aarch64.rpm;name=aarch64_ghc-void;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-void}"
SRC_URI[aarch64_ghc-void.sha256sum] = "28e84ae833ac000b60745159957ebed877a569118c72acd94c150d12d891d960"

URI_aarch64_ghc-void-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-void-devel-0.7.3-23.el10_0.aarch64.rpm;name=aarch64_ghc-void-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-void-devel}"
SRC_URI[aarch64_ghc-void-devel.sha256sum] = "bb44e06a7c2f4594da381948ed92fd35742b060234f120635e173c6726d368b2"

URI_aarch64_ghc-void-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-void-doc-0.7.3-23.el10_0.noarch.rpm;name=aarch64_ghc-void-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-void-doc}"
SRC_URI[aarch64_ghc-void-doc.sha256sum] = "dfdbe14b4928a3363951da62428181fbfe8383e3f458156832cc506d0c5a7369"

URI_aarch64_ghc-void-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-void-prof-0.7.3-23.el10_0.aarch64.rpm;name=aarch64_ghc-void-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-void-prof}"
SRC_URI[aarch64_ghc-void-prof.sha256sum] = "d73a18be027de2ba1af8cdf72ab8c0717ad219e2811228149c29c4bd27074a77"

RDEPENDS:ghc-void = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-void-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-void \
 "
RDEPENDS:ghc-void-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-void-prof = " \
 ghc-base-prof \
 ghc-void-devel \
 "
