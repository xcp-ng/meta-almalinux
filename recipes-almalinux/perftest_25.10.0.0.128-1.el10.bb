# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perftest"
PV = "25.10.0.0.128"
PR = "1.el10"
PACKAGES = " \
 perftest \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/perftest-25.10.0.0.128-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1f55c6d286e8bc74c923ccd7733030c196b70f62505fdd5a62684831030bbef"

URI_x86_64_v2_perftest = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/perftest-25.10.0.0.128-1.el10.x86_64_v2.rpm;name=x86_64_v2_perftest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perftest}"
SRC_URI[x86_64_v2_perftest.sha256sum] = "0575b16892b5158d38e1e0d44dd70d2418774da58c201b7b19f0fed980e126cd"

URI_aarch64_perftest = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/perftest-25.10.0.0.128-1.el10.aarch64.rpm;name=aarch64_perftest;unpack=0"
SRC_URI:append = " ${URI_aarch64_perftest}"
SRC_URI[aarch64_perftest.sha256sum] = "fcb1e277bea90cca87090bbe3e8874b1d52f54820b188c7f9877b1abf7e10d20"

RDEPENDS:perftest = " \
 glibc \
 libibumad \
 libibverbs \
 librdmacm \
 pciutils-libs \
 "
