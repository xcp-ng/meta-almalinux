# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtasn1"
PV = "4.20.0"
PR = "5.el10"
PACKAGES = " \
 libtasn1 \
 libtasn1-devel \
 libtasn1-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtasn1-4.20.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "032a7f4829c3ed60b55cf0ffb53ad1ee7a6ed48ac8d54abf228aae9146dd97b6"

URI_x86_64_v2_libtasn1 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtasn1-4.20.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libtasn1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtasn1}"
SRC_URI[x86_64_v2_libtasn1.sha256sum] = "286523b8e5e64d96a3c1c569da04cbfa6b044ce314470fa542529e71b58e7fe0"

URI_x86_64_v2_libtasn1-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtasn1-devel-4.20.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libtasn1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtasn1-devel}"
SRC_URI[x86_64_v2_libtasn1-devel.sha256sum] = "c418179871a720087ad35ce80694dd5121f7b392ded34f5e499c77ebf759e9f8"

URI_x86_64_v2_libtasn1-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtasn1-tools-4.20.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libtasn1-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtasn1-tools}"
SRC_URI[x86_64_v2_libtasn1-tools.sha256sum] = "ee0d64d9957ea2c1ce3c490f4a37373240cb919e5fc8484fa97fed62bfa0cdb6"

URI_aarch64_libtasn1 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtasn1-4.20.0-5.el10.aarch64.rpm;name=aarch64_libtasn1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtasn1}"
SRC_URI[aarch64_libtasn1.sha256sum] = "291a50b453c4a4ccf6d805b5ba82ebdffd10e8331b53ef4b0abc66855de85b52"

URI_aarch64_libtasn1-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtasn1-devel-4.20.0-5.el10.aarch64.rpm;name=aarch64_libtasn1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtasn1-devel}"
SRC_URI[aarch64_libtasn1-devel.sha256sum] = "829f74e2cf183fea9c61de78332e2e70c9caecd301ae3a1a3aca087801a0410b"

URI_aarch64_libtasn1-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtasn1-tools-4.20.0-5.el10.aarch64.rpm;name=aarch64_libtasn1-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtasn1-tools}"
SRC_URI[aarch64_libtasn1-tools.sha256sum] = "63347b67c712426c232e4c0f931817d2a526f88ad5f23a5db3a3fbcdc6be566c"

RDEPENDS:libtasn1 = " \
 glibc \
 "
RDEPENDS:libtasn1-devel = " \
 libtasn1 \
 libtasn1-tools \
 pkgconf-pkg-config \
 "
RDEPENDS:libtasn1-tools = " \
 glibc \
 libtasn1 \
 "
