# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chardetng"
PV = "0.1.17"
PR = "6.el10_1"
PACKAGES = " \
 rust-chardetng+arrayvec-devel \
 rust-chardetng+default-devel \
 rust-chardetng+multithreading-devel \
 rust-chardetng+rayon-devel \
 rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel \
 rust-chardetng-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chardetng-0.1.17-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98d0cb637ce531d31460d5973c4814bb54ea553873fdce5e7a8e02b7ad5d3516"

URI_x86_64_v2_rust-chardetng+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+arrayvec-devel-0.1.17-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-chardetng+arrayvec-devel.sha256sum] = "24d981083b5bb78fd65eed5ee0d8d6de18f6f4f916a4e871f822381010e74626"

URI_x86_64_v2_rust-chardetng+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+default-devel-0.1.17-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+default-devel}"
SRC_URI[x86_64_v2_rust-chardetng+default-devel.sha256sum] = "340d2789dabef54ad55586f0257fd4df05b692b9ce112aa1e0a7c7e62b3b6cfc"

URI_x86_64_v2_rust-chardetng+multithreading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+multithreading-devel-0.1.17-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+multithreading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+multithreading-devel}"
SRC_URI[x86_64_v2_rust-chardetng+multithreading-devel.sha256sum] = "0dc59130af0add5238806b108314fd03a7c59ab5febffed97a238d26a81b08b2"

URI_x86_64_v2_rust-chardetng+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+rayon-devel-0.1.17-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+rayon-devel}"
SRC_URI[x86_64_v2_rust-chardetng+rayon-devel.sha256sum] = "96ec4ed979613d02ae5ff37a761aa8577f3ca87c1effea7d6af8d7a030b4d298"

URI_x86_64_v2_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel-0.1.17-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel}"
SRC_URI[x86_64_v2_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel.sha256sum] = "528edfee0f771230c3635fc0a3e59ba6a0e0d9d7c3cc6d7e3d91d99548704565"

URI_x86_64_v2_rust-chardetng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chardetng-devel-0.1.17-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chardetng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chardetng-devel}"
SRC_URI[x86_64_v2_rust-chardetng-devel.sha256sum] = "4bea5736c54d3c53c8c14b8af98143b5be57ae7639d377eed59f396ca0cdd8d0"

URI_aarch64_rust-chardetng+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+arrayvec-devel-0.1.17-6.el10_1.noarch.rpm;name=aarch64_rust-chardetng+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+arrayvec-devel}"
SRC_URI[aarch64_rust-chardetng+arrayvec-devel.sha256sum] = "088e616f7c6b99fa7b4ff2727b79727d0a6d0631495b85c1ddddacaa12d13d21"

URI_aarch64_rust-chardetng+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+default-devel-0.1.17-6.el10_1.noarch.rpm;name=aarch64_rust-chardetng+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+default-devel}"
SRC_URI[aarch64_rust-chardetng+default-devel.sha256sum] = "625fbf738626dadfbb1c51a8c38b8571808babc1122d813430f944d7578edaee"

URI_aarch64_rust-chardetng+multithreading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+multithreading-devel-0.1.17-6.el10_1.noarch.rpm;name=aarch64_rust-chardetng+multithreading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+multithreading-devel}"
SRC_URI[aarch64_rust-chardetng+multithreading-devel.sha256sum] = "676b8907ba8c8aeb1058fda57baaa2f957b41e9306caca1812ae2dbb958f2c0f"

URI_aarch64_rust-chardetng+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+rayon-devel-0.1.17-6.el10_1.noarch.rpm;name=aarch64_rust-chardetng+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+rayon-devel}"
SRC_URI[aarch64_rust-chardetng+rayon-devel.sha256sum] = "b04e82c671b5c6f52eee8e272824d9639eee9dc24da8d75d393d171e96bb616a"

URI_aarch64_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel-0.1.17-6.el10_1.noarch.rpm;name=aarch64_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel}"
SRC_URI[aarch64_rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel.sha256sum] = "71596098e7e6f297f7dae3302ee2128f8249d58425a2233e8eb719d2cc0a0e80"

URI_aarch64_rust-chardetng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chardetng-devel-0.1.17-6.el10_1.noarch.rpm;name=aarch64_rust-chardetng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chardetng-devel}"
SRC_URI[aarch64_rust-chardetng-devel.sha256sum] = "0662414349f87eb51946cf0e9bbde6cc497cd5f4a141310e39b18ac2a6467719"

RDEPENDS:rust-chardetng+arrayvec-devel = " \
 cargo \
 rust-arrayvec+default-devel \
 rust-chardetng-devel \
 "
RDEPENDS:rust-chardetng+default-devel = " \
 cargo \
 rust-chardetng-devel \
 "
RDEPENDS:rust-chardetng+multithreading-devel = " \
 cargo \
 rust-chardetng+arrayvec-devel \
 rust-chardetng+rayon-devel \
 rust-chardetng-devel \
 "
RDEPENDS:rust-chardetng+rayon-devel = " \
 cargo \
 rust-chardetng-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-chardetng+testing-only-no-semver-guarantees-do-not-use-devel = " \
 cargo \
 rust-chardetng-devel \
 "
RDEPENDS:rust-chardetng-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-encoding_rs+alloc-devel \
 rust-encoding_rs-devel \
 rust-memchr-devel \
 "
