# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pacemaker"
PV = "3.0.3"
PR = "1.el10"
PACKAGES = " \
 pacemaker-cluster-libs \
 pacemaker-libs \
 pacemaker-schemas \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pacemaker-3.0.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcfeca80ec0bfffb2e1422041a224b8ab8a3b9e92091cea26a21ac6a31ecf0cc"

URI_x86_64_v2_pacemaker-cluster-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pacemaker-cluster-libs-3.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_pacemaker-cluster-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacemaker-cluster-libs}"
SRC_URI[x86_64_v2_pacemaker-cluster-libs.sha256sum] = "c1583d55a192ba213f3db94d1e79f3096c630f775e08f9324a027e70e4734c0b"

URI_x86_64_v2_pacemaker-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pacemaker-libs-3.0.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_pacemaker-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacemaker-libs}"
SRC_URI[x86_64_v2_pacemaker-libs.sha256sum] = "d869755a628364ab721e5d623759d568e04af3a8cc182d4415e375ebbef0e0f2"

URI_x86_64_v2_pacemaker-schemas = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pacemaker-schemas-3.0.3-1.el10.noarch.rpm;name=x86_64_v2_pacemaker-schemas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pacemaker-schemas}"
SRC_URI[x86_64_v2_pacemaker-schemas.sha256sum] = "437e8b66855dc9a2e9498f7ffb20e6bd4f08b75cfb624bcadda1099120072141"

URI_aarch64_pacemaker-cluster-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pacemaker-cluster-libs-3.0.3-1.el10.aarch64.rpm;name=aarch64_pacemaker-cluster-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacemaker-cluster-libs}"
SRC_URI[aarch64_pacemaker-cluster-libs.sha256sum] = "143e51df9e085d8222e187bc30d2b69f1d498e6d8966e8224745b523b0952ce7"

URI_aarch64_pacemaker-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pacemaker-libs-3.0.3-1.el10.aarch64.rpm;name=aarch64_pacemaker-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacemaker-libs}"
SRC_URI[aarch64_pacemaker-libs.sha256sum] = "475024ef77d8e9236dc634b0a625e8d1c3cd1b957b080227b4d80d283addba2c"

URI_aarch64_pacemaker-schemas = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pacemaker-schemas-3.0.3-1.el10.noarch.rpm;name=aarch64_pacemaker-schemas;unpack=0"
SRC_URI:append = " ${URI_aarch64_pacemaker-schemas}"
SRC_URI[aarch64_pacemaker-schemas.sha256sum] = "437e8b66855dc9a2e9498f7ffb20e6bd4f08b75cfb624bcadda1099120072141"

RDEPENDS:pacemaker-cluster-libs = " \
 bzip2-libs \
 corosynclib \
 dbus-libs \
 glib2 \
 glibc \
 gnutls \
 libqb \
 libuuid \
 libxml2 \
 libxslt \
 pacemaker-libs \
 "
RDEPENDS:pacemaker-libs = " \
 bash \
 bzip2-libs \
 dbus-libs \
 glib2 \
 glibc \
 gnutls \
 libqb \
 libuuid \
 libxml2 \
 libxslt \
 pacemaker-schemas \
 shadow-utils \
 "
RDEPENDS:pacemaker-schemas = " \
 pkgconf-pkg-config \
 "
