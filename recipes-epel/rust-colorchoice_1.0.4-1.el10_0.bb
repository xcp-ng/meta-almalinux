# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-colorchoice"
PV = "1.0.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-colorchoice+default-devel \
 rust-colorchoice-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-colorchoice-1.0.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7673f34e73ca94d20a3058a6888ae5114c88ffa414a6fd10f950d3281843a85"

URI_x86_64_v2_rust-colorchoice+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colorchoice+default-devel-1.0.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colorchoice+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colorchoice+default-devel}"
SRC_URI[x86_64_v2_rust-colorchoice+default-devel.sha256sum] = "f4de402f8d99bd6b12e6442c16fb935efbed24ffc45a1ed30c6df567f16e449b"

URI_x86_64_v2_rust-colorchoice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-colorchoice-devel-1.0.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-colorchoice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-colorchoice-devel}"
SRC_URI[x86_64_v2_rust-colorchoice-devel.sha256sum] = "f8fe976f1d596b77c8725f1675d99e097241aff00dfd00dcb34de2da3612fa2f"

URI_aarch64_rust-colorchoice+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colorchoice+default-devel-1.0.4-1.el10_0.noarch.rpm;name=aarch64_rust-colorchoice+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colorchoice+default-devel}"
SRC_URI[aarch64_rust-colorchoice+default-devel.sha256sum] = "97cfcb4b1ed3554f0ae57a5b5d7653b4f636129ddc4789bd7e06f71256db485e"

URI_aarch64_rust-colorchoice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-colorchoice-devel-1.0.4-1.el10_0.noarch.rpm;name=aarch64_rust-colorchoice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-colorchoice-devel}"
SRC_URI[aarch64_rust-colorchoice-devel.sha256sum] = "2157701288d7a6f146dd3667930354d3590daa0011f19598ccbdb7700a3f9a32"

RDEPENDS:rust-colorchoice+default-devel = " \
 cargo \
 rust-colorchoice-devel \
 "
RDEPENDS:rust-colorchoice-devel = " \
 cargo \
 rust \
 "
