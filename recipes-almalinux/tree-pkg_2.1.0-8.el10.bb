# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tree-pkg"
PV = "2.1.0"
PR = "8.el10"
PACKAGES = " \
 tree \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tree-pkg-2.1.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74bd1881014b961ab7bcf76904571b9071bc63c01863b9052f424c9cae9513df"

URI_x86_64_v2_tree = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tree-2.1.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_tree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tree}"
SRC_URI[x86_64_v2_tree.sha256sum] = "4c4e44b277d89c01fc9d7eadd0b5b71c28e3b512b71ee1f140e94c269b565f23"

URI_aarch64_tree = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tree-2.1.0-8.el10.aarch64.rpm;name=aarch64_tree;unpack=0"
SRC_URI:append = " ${URI_aarch64_tree}"
SRC_URI[aarch64_tree.sha256sum] = "3198416c3837427f7e5330763a191b4d618f0ecc06496de5f5456f97d2b6185c"

RDEPENDS:tree = " \
 glibc \
 "
