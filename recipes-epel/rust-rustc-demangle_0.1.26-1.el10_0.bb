# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustc-demangle"
PV = "0.1.26"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustc-demangle+default-devel \
 rust-rustc-demangle+std-devel \
 rust-rustc-demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustc-demangle-0.1.26-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12bf5c0547fd6e2f7662949abb0fcd20c4bba6dd03f3616589d578d47e7ee439"

URI_x86_64_v2_rust-rustc-demangle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle+default-devel-0.1.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle+default-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle+default-devel.sha256sum] = "6fd9ac4d6d9bee397f073066055ba2a1e50a574d241fab31ef696caecbfca791"

URI_x86_64_v2_rust-rustc-demangle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle+std-devel-0.1.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle+std-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle+std-devel.sha256sum] = "cbac283900a3db9c15e352af12eab9111f1d352b6802d49c2f73ad37acc1017c"

URI_x86_64_v2_rust-rustc-demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustc-demangle-devel-0.1.26-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustc-demangle-devel}"
SRC_URI[x86_64_v2_rust-rustc-demangle-devel.sha256sum] = "f391a8b892337f841cf7dc749e308afae929b965641ef0be941c98b072652dda"

URI_aarch64_rust-rustc-demangle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle+default-devel-0.1.26-1.el10_0.noarch.rpm;name=aarch64_rust-rustc-demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle+default-devel}"
SRC_URI[aarch64_rust-rustc-demangle+default-devel.sha256sum] = "d2182c7384b2d102798aaff1a162dfd6cacc8a6eeed5e4c806ddbe025d5b31b9"

URI_aarch64_rust-rustc-demangle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle+std-devel-0.1.26-1.el10_0.noarch.rpm;name=aarch64_rust-rustc-demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle+std-devel}"
SRC_URI[aarch64_rust-rustc-demangle+std-devel.sha256sum] = "0d25b6d8164b67132109b034082e440064f135f5aa49d3daf491c1c8ed23da44"

URI_aarch64_rust-rustc-demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustc-demangle-devel-0.1.26-1.el10_0.noarch.rpm;name=aarch64_rust-rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustc-demangle-devel}"
SRC_URI[aarch64_rust-rustc-demangle-devel.sha256sum] = "8ac4a3f4d8e844263d5c702175bad8a3c505033c3bc0113341685eb10784beea"

RDEPENDS:rust-rustc-demangle+default-devel = " \
 cargo \
 rust-rustc-demangle-devel \
 "
RDEPENDS:rust-rustc-demangle+std-devel = " \
 cargo \
 rust-rustc-demangle-devel \
 "
RDEPENDS:rust-rustc-demangle-devel = " \
 cargo \
 "
