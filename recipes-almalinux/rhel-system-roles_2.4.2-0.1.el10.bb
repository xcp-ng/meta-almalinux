# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rhel-system-roles"
PV = "2.4.2"
PR = "0.1.el10"
PACKAGES = " \
 rhel-system-roles \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rhel-system-roles-2.4.2-0.1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "486c51e3bfb70c413017039f0c00fb774aaad3924ccd4856b298970f81bd558c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rhel-system-roles-2.4.2-0.1.el10.noarch.rpm;name=x86_64_v2_rhel-system-roles;unpack=0"
SRC_URI[x86_64_v2_rhel-system-roles.sha256sum] = "b629a891ff7796bd919f95baba0eab3d9313e4c69b74a7782542933c000bca65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rhel-system-roles-2.4.2-0.1.el10.noarch.rpm;name=aarch64_rhel-system-roles;unpack=0"
SRC_URI[aarch64_rhel-system-roles.sha256sum] = "b629a891ff7796bd919f95baba0eab3d9313e4c69b74a7782542933c000bca65"

RDEPENDS:rhel-system-roles = " \
 ansible-core \
 bash \
 python-unversioned-command \
 virtual//usr/bin/env \
 "
