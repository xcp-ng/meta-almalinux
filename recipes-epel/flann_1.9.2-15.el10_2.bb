# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flann"
PV = "1.9.2"
PR = "15.el10_2"
PACKAGES = " \
 flann \
 flann-devel \
 flann-static \
 python3-flann \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flann-1.9.2-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e62a087ad793ef945d82b3030d2f8ec5d18f533a8cb457961c9e471dcc9887c"

URI_x86_64_v2_flann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flann-1.9.2-15.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flann}"
SRC_URI[x86_64_v2_flann.sha256sum] = "56dff14fd55fd603c6581b36a97b6aa5df9373d0b9f1a5dae81fd412643ef90d"

URI_x86_64_v2_flann-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flann-devel-1.9.2-15.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flann-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flann-devel}"
SRC_URI[x86_64_v2_flann-devel.sha256sum] = "ae037e12a68b55979d9e31b24be88acd5edb714feae1b6acb71832f7f1c00e80"

URI_x86_64_v2_flann-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flann-static-1.9.2-15.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flann-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flann-static}"
SRC_URI[x86_64_v2_flann-static.sha256sum] = "1d49785a836a7d9de761875653bb610ab974018ea04182be6d58769d37cc3bd2"

URI_x86_64_v2_python3-flann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flann-1.9.2-15.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-flann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flann}"
SRC_URI[x86_64_v2_python3-flann.sha256sum] = "91c8ea8993e64d09b153f087729cfe832d7d08c4cd24ef0de9ad34bdf5ab3161"

URI_aarch64_flann = "${EPEL_MIRROR}/aarch64/Packages/f/flann-1.9.2-15.el10_2.aarch64.rpm;name=aarch64_flann;unpack=0"
SRC_URI:append = " ${URI_aarch64_flann}"
SRC_URI[aarch64_flann.sha256sum] = "b0680e3d6684e2ff1a9a6833e2f2aee6faecbf79882b95258020501620a46b67"

URI_aarch64_flann-devel = "${EPEL_MIRROR}/aarch64/Packages/f/flann-devel-1.9.2-15.el10_2.aarch64.rpm;name=aarch64_flann-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_flann-devel}"
SRC_URI[aarch64_flann-devel.sha256sum] = "35c8315cb867ecb6db16b40dee074da4062f137ea3e5346afc3363a9a5e95311"

URI_aarch64_flann-static = "${EPEL_MIRROR}/aarch64/Packages/f/flann-static-1.9.2-15.el10_2.aarch64.rpm;name=aarch64_flann-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_flann-static}"
SRC_URI[aarch64_flann-static.sha256sum] = "1e8063bb33c994c77b3b80c6ab96e4601612897605a1ba0de9fb108e5b5d1edd"

URI_aarch64_python3-flann = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flann-1.9.2-15.el10_2.aarch64.rpm;name=aarch64_python3-flann;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flann}"
SRC_URI[aarch64_python3-flann.sha256sum] = "e69eaad8639b3783ddf922cb593e5dc036da32d05f37ce9ac4de77a6ae0e6166"

RDEPENDS:flann = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 lz4-libs \
 "
RDEPENDS:flann-devel = " \
 boost-devel \
 cmake-filesystem \
 flann \
 flann-static \
 lz4-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:flann-static = " \
 flann-devel \
 "
RDEPENDS:python3-flann = " \
 flann \
 python3 \
 python3-numpy \
 "
