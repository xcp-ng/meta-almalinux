# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkmahjongg"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkmahjongg \
 libkmahjongg-data \
 libkmahjongg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkmahjongg-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5f739d3e82a236dced21f12232dc82b9e41c9a6a56d200f6acd5e633cf56e8e"

URI_x86_64_v2_libkmahjongg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkmahjongg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkmahjongg}"
SRC_URI[x86_64_v2_libkmahjongg.sha256sum] = "fb7d2d57853c74e37db340e7e5613fa5f2e688f1a9c562ab6096917bca1018e5"

URI_x86_64_v2_libkmahjongg-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-data-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libkmahjongg-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkmahjongg-data}"
SRC_URI[x86_64_v2_libkmahjongg-data.sha256sum] = "75cb62cc8d661a8356feb294f2c1f1e2647da868596678fc5efd453c955b386f"

URI_x86_64_v2_libkmahjongg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkmahjongg-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkmahjongg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkmahjongg-devel}"
SRC_URI[x86_64_v2_libkmahjongg-devel.sha256sum] = "d860ddae0ad22b7eea2affc4a0d4da46da16d115abf94e2e671a9f2100161a68"

URI_aarch64_libkmahjongg = "${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkmahjongg;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkmahjongg}"
SRC_URI[aarch64_libkmahjongg.sha256sum] = "12accc2a76c4229a5bdfea7681adab1f960128da9b0f66adf133084c852077bb"

URI_aarch64_libkmahjongg-data = "${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-data-25.12.3-1.el10_2.noarch.rpm;name=aarch64_libkmahjongg-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkmahjongg-data}"
SRC_URI[aarch64_libkmahjongg-data.sha256sum] = "fdcdeb825eaa3c9d9b4d179eb9e68e628bca5a40818f7a63a7c8ac9f92c5f43a"

URI_aarch64_libkmahjongg-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkmahjongg-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkmahjongg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkmahjongg-devel}"
SRC_URI[aarch64_libkmahjongg-devel.sha256sum] = "20d1b2545338dbecc94893e327aa827a0f7c6df7ab168aa293ab8873967a70bc"

RDEPENDS:libkmahjongg = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libkmahjongg-data \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:libkmahjongg-data = " \
 "
RDEPENDS:libkmahjongg-devel = " \
 cmake-filesystem \
 kf6-kconfigwidgets-devel \
 libkmahjongg \
 qt6-qtbase-devel \
 "
