# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdialog"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdialog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdialog-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1936d46f8eae8eee3adbe095da6f3678d6ada8eaba8f5cb84cf891e9accdd559"

URI_x86_64_v2_kdialog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdialog-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdialog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdialog}"
SRC_URI[x86_64_v2_kdialog.sha256sum] = "9c1c7dd571c12e2982799eb0cfa7f35f598dd6f98bde3019068a08f1e732971e"

URI_aarch64_kdialog = "${EPEL_MIRROR}/aarch64/Packages/k/kdialog-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdialog;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdialog}"
SRC_URI[aarch64_kdialog.sha256sum] = "abd93daa7c0b90e73608d03ff7fa98c85f17d0870c3f76170fc87a2ae26548bc"

RDEPENDS:kdialog = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
