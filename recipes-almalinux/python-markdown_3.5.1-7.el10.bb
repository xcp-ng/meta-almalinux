# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-markdown"
PV = "3.5.1"
PR = "7.el10"
PACKAGES = " \
 python3-markdown \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-markdown-3.5.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03a526ce650cb91269bb874c421c4797dc0446cc6083527e73ff8bb4246049a5"

URI_x86_64_v2_python3-markdown = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-markdown-3.5.1-7.el10.noarch.rpm;name=x86_64_v2_python3-markdown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-markdown}"
SRC_URI[x86_64_v2_python3-markdown.sha256sum] = "09456d656567aa9d5b34f6532767659918607853f7f430d426d17c8b405a43e0"

URI_aarch64_python3-markdown = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-markdown-3.5.1-7.el10.noarch.rpm;name=aarch64_python3-markdown;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-markdown}"
SRC_URI[aarch64_python3-markdown.sha256sum] = "09456d656567aa9d5b34f6532767659918607853f7f430d426d17c8b405a43e0"

RDEPENDS:python3-markdown = " \
 python3 \
 "
