# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-l2tp"
PV = "1.52.6"
PR = "1.el10_3"
PACKAGES = " \
 NetworkManager-l2tp \
 NetworkManager-l2tp-gnome \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-l2tp-1.52.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95f5fef1673e3ccd3e6e11e48b0ef113b5dc78e912374e2bb023486377963f73"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-1.52.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-l2tp.sha256sum] = "0fa04a58595ed767e766cbcface724fe3d1e8bb5e16ce1a218a29aaf94304aca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-gnome-1.52.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-l2tp-gnome.sha256sum] = "c78f3422ad15372948bbe20c52c56c13e79017669ae84e323bcbb4e419e3c21b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-1.52.6-1.el10_3.aarch64.rpm;name=aarch64_NetworkManager-l2tp;unpack=0"
SRC_URI[aarch64_NetworkManager-l2tp.sha256sum] = "1f0ef34b1d85a430c11a26e73a192c88ff2cc8bf827c3257de5e71aaa0cb668d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-gnome-1.52.6-1.el10_3.aarch64.rpm;name=aarch64_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI[aarch64_NetworkManager-l2tp-gnome.sha256sum] = "0a9bb52a7b21c7bbab0da711361ef59cf1e230ba9a7aede1169a7440f2c124f6"

RDEPENDS:NetworkManager-l2tp = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 nspr \
 nss \
 openssl-libs \
 ppp \
 xl2tpd \
 "
RDEPENDS:NetworkManager-l2tp-gnome = " \
 NetworkManager-l2tp \
 NetworkManager-libnm \
 glib2 \
 glibc \
 gtk3 \
 gtk4 \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 openssl-libs \
 "
