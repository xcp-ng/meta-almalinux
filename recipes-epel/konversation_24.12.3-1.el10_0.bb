# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konversation"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 konversation \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konversation-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdabf612209d4888f099f39f1483ccb72438813ef517df516ff27de8b8b67bdc"

URI_x86_64_v2_konversation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konversation-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konversation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konversation}"
SRC_URI[x86_64_v2_konversation.sha256sum] = "36eb0dcecea8a2b796761e49d79a7cbab9a97a58bf3965b321a15e719296f93f"

URI_aarch64_konversation = "${EPEL_MIRROR}/aarch64/Packages/k/konversation-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_konversation;unpack=0"
SRC_URI:append = " ${URI_aarch64_konversation}"
SRC_URI[aarch64_konversation.sha256sum] = "a9d59f08ad523500c49f900fe1a82cea0b2871ce0bdbb4fae7f3e4ca8def5644"

RDEPENDS:konversation = " \
 bash \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 perl-interpreter \
 python3 \
 qca-qt6 \
 qca-qt6-ossl \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
