# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aead"
PV = "0.5.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-aead+alloc-devel \
 rust-aead+arrayvec-devel \
 rust-aead+blobby-devel \
 rust-aead+bytes-devel \
 rust-aead+default-devel \
 rust-aead+dev-devel \
 rust-aead+getrandom-devel \
 rust-aead+heapless-devel \
 rust-aead+rand_core-devel \
 rust-aead+std-devel \
 rust-aead+stream-devel \
 rust-aead-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aead-0.5.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94f375c9fd2dc5b7a7890aac9200c2017e4fb78f2beb52e5d3efbee3ecc5e79c"

URI_x86_64_v2_rust-aead+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+alloc-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+alloc-devel}"
SRC_URI[x86_64_v2_rust-aead+alloc-devel.sha256sum] = "e6bdb3b25595c69eb377fd498454fc90baff9096323e5e0a14a12e15155c5fcc"

URI_x86_64_v2_rust-aead+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+arrayvec-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-aead+arrayvec-devel.sha256sum] = "7c241aa0824724353d27ff3285f6163835fcb3e3ee33a8693c7f8cf5ba518ab9"

URI_x86_64_v2_rust-aead+blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+blobby-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+blobby-devel}"
SRC_URI[x86_64_v2_rust-aead+blobby-devel.sha256sum] = "5f0192962f8f7d2a9fea513d66b8a68e78507027d956449ac4d663d91c21edeb"

URI_x86_64_v2_rust-aead+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+bytes-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+bytes-devel}"
SRC_URI[x86_64_v2_rust-aead+bytes-devel.sha256sum] = "a5a7c1011a5affe03bc98254448d5a3b87c6c5d18da5d389e0a66dee76bcc918"

URI_x86_64_v2_rust-aead+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+default-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+default-devel}"
SRC_URI[x86_64_v2_rust-aead+default-devel.sha256sum] = "363c377ffa433484f72ba06ea137dd555d23526c9513bd82ebd7ee3ec2779def"

URI_x86_64_v2_rust-aead+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+dev-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+dev-devel}"
SRC_URI[x86_64_v2_rust-aead+dev-devel.sha256sum] = "33e77e7c4c164e4f94dd3ee8a7852846006a94d644954aa0d7e9cb18f82d888b"

URI_x86_64_v2_rust-aead+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+getrandom-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+getrandom-devel}"
SRC_URI[x86_64_v2_rust-aead+getrandom-devel.sha256sum] = "048305f773932910269d46e8427befe5e18b1395711f37136befed95c367a234"

URI_x86_64_v2_rust-aead+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+heapless-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+heapless-devel}"
SRC_URI[x86_64_v2_rust-aead+heapless-devel.sha256sum] = "61a4042d031b5093494733dcf4dc48ab1f9925ae60621903091dcd3a30f632d9"

URI_x86_64_v2_rust-aead+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+rand_core-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+rand_core-devel}"
SRC_URI[x86_64_v2_rust-aead+rand_core-devel.sha256sum] = "3d7db4d94c3604b334e413c67f9046f796e2c96094634fccacbb4bbbf8e7b7a9"

URI_x86_64_v2_rust-aead+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+std-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+std-devel}"
SRC_URI[x86_64_v2_rust-aead+std-devel.sha256sum] = "cbc22b6af777af3e79293eac06471f7b184701c61fe1983cdf1175e2cdfc6fe7"

URI_x86_64_v2_rust-aead+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead+stream-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead+stream-devel}"
SRC_URI[x86_64_v2_rust-aead+stream-devel.sha256sum] = "f4c6a00f975a8fe9baa17b3078968060bc8ca88c6e9fd3bd3137da49b9a38b2f"

URI_x86_64_v2_rust-aead-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aead-devel-0.5.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aead-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aead-devel}"
SRC_URI[x86_64_v2_rust-aead-devel.sha256sum] = "1b0dfb86a1173ae5163417547f8857a41f4b5298db7e97d6f16977dea3b8eb2b"

URI_aarch64_rust-aead+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+alloc-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+alloc-devel}"
SRC_URI[aarch64_rust-aead+alloc-devel.sha256sum] = "7cb842644c2366462c01cad9dccc2dca8cb79a4abc3746d2c9ca0f78df19c7a0"

URI_aarch64_rust-aead+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+arrayvec-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+arrayvec-devel}"
SRC_URI[aarch64_rust-aead+arrayvec-devel.sha256sum] = "999291df876f438049ea297de59dd5077e5c39cce80bbdcda588dca10ff6186d"

URI_aarch64_rust-aead+blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+blobby-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+blobby-devel}"
SRC_URI[aarch64_rust-aead+blobby-devel.sha256sum] = "243dc79614bcf07965c9fb5e67d9bffb014aceae04315f8e7135aba282b7dfa7"

URI_aarch64_rust-aead+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+bytes-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+bytes-devel}"
SRC_URI[aarch64_rust-aead+bytes-devel.sha256sum] = "b376568a35869f9720562a1ee6fcd25900d14f8ffe5a820ebce23e216256b78e"

URI_aarch64_rust-aead+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+default-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+default-devel}"
SRC_URI[aarch64_rust-aead+default-devel.sha256sum] = "52171d2137c2b334ea84dcb955fc988c19f7d4a487f5abf1dbfa8c25d21f3d4b"

URI_aarch64_rust-aead+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+dev-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+dev-devel}"
SRC_URI[aarch64_rust-aead+dev-devel.sha256sum] = "0b0e90c45991ac1a00e94bbe51d175ec2d96a7b945bafe23b7d6c77404668aed"

URI_aarch64_rust-aead+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+getrandom-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+getrandom-devel}"
SRC_URI[aarch64_rust-aead+getrandom-devel.sha256sum] = "30aa230cac6cbd44e77d5e3d9c86e9140c53f5b1240f8db687e46095aa0c515b"

URI_aarch64_rust-aead+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+heapless-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+heapless-devel}"
SRC_URI[aarch64_rust-aead+heapless-devel.sha256sum] = "821b85c7ac3a49589a6c97831ecb6ab07ba6e8b718b4ab68952fe41ab1824527"

URI_aarch64_rust-aead+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+rand_core-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+rand_core-devel}"
SRC_URI[aarch64_rust-aead+rand_core-devel.sha256sum] = "5be70f459083e1c895125c59f10f27b5359cfa4b1fceaca159c4e5917321fd11"

URI_aarch64_rust-aead+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+std-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+std-devel}"
SRC_URI[aarch64_rust-aead+std-devel.sha256sum] = "abe6eb09e23445c7054904b9d9955e2ac34e5cd2605dc392befb437b63f346e1"

URI_aarch64_rust-aead+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead+stream-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead+stream-devel}"
SRC_URI[aarch64_rust-aead+stream-devel.sha256sum] = "35d9b448ee212e37904fa4894cf3bd2a5ea92b0d13423ba175a4ad6bd75baec8"

URI_aarch64_rust-aead-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aead-devel-0.5.2-4.el10_0.noarch.rpm;name=aarch64_rust-aead-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aead-devel}"
SRC_URI[aarch64_rust-aead-devel.sha256sum] = "8af59c47d61710771a6426343e989802448fc91cecf2dfe67dec6e02ca92f0f2"

RDEPENDS:rust-aead+alloc-devel = " \
 cargo \
 rust-aead-devel \
 "
RDEPENDS:rust-aead+arrayvec-devel = " \
 cargo \
 rust-aead-devel \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-aead+blobby-devel = " \
 cargo \
 rust-aead-devel \
 rust-blobby+default-devel \
 "
RDEPENDS:rust-aead+bytes-devel = " \
 cargo \
 rust-aead-devel \
 rust-bytes-devel \
 "
RDEPENDS:rust-aead+default-devel = " \
 cargo \
 rust-aead+rand_core-devel \
 rust-aead-devel \
 "
RDEPENDS:rust-aead+dev-devel = " \
 cargo \
 rust-aead+blobby-devel \
 rust-aead-devel \
 "
RDEPENDS:rust-aead+getrandom-devel = " \
 cargo \
 rust-aead+rand_core-devel \
 rust-aead-devel \
 rust-crypto-common+getrandom-devel \
 "
RDEPENDS:rust-aead+heapless-devel = " \
 cargo \
 rust-aead-devel \
 rust-heapless0.7-devel \
 "
RDEPENDS:rust-aead+rand_core-devel = " \
 cargo \
 rust-aead-devel \
 rust-crypto-common+rand_core-devel \
 "
RDEPENDS:rust-aead+std-devel = " \
 cargo \
 rust-aead+alloc-devel \
 rust-aead-devel \
 rust-crypto-common+std-devel \
 "
RDEPENDS:rust-aead+stream-devel = " \
 cargo \
 rust-aead-devel \
 "
RDEPENDS:rust-aead-devel = " \
 cargo \
 rust \
 rust-crypto-common+default-devel \
 rust-generic-array-devel \
 "
