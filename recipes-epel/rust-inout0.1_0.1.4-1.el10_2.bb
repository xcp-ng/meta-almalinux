# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inout0.1"
PV = "0.1.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-inout0.1+block-padding-devel \
 rust-inout0.1+default-devel \
 rust-inout0.1+std-devel \
 rust-inout0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inout0.1-0.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "758fca420975b77212acb14246f1ee80901ca263f4f205f6a35f4a5d59558f4b"

URI_x86_64_v2_rust-inout0.1+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout0.1+block-padding-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout0.1+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout0.1+block-padding-devel}"
SRC_URI[x86_64_v2_rust-inout0.1+block-padding-devel.sha256sum] = "92c3641e1fc83773dbbdae1b9058224462dfc181f6254e560d8cecc9ff435d95"

URI_x86_64_v2_rust-inout0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout0.1+default-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout0.1+default-devel}"
SRC_URI[x86_64_v2_rust-inout0.1+default-devel.sha256sum] = "41ba719c8805c6f85af17ea217e6702803dca371d4a8ae7f67d63e111629bae9"

URI_x86_64_v2_rust-inout0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout0.1+std-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout0.1+std-devel}"
SRC_URI[x86_64_v2_rust-inout0.1+std-devel.sha256sum] = "c2e37eeda0c85b529af1ade0072bc4f57c356f84d4664710ca917566e00aa44a"

URI_x86_64_v2_rust-inout0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout0.1-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout0.1-devel}"
SRC_URI[x86_64_v2_rust-inout0.1-devel.sha256sum] = "bc72d8a2df9019753ff54061dc1cf14996adb2dd7f7bbf99bf841a73e8cb1139"

URI_aarch64_rust-inout0.1+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout0.1+block-padding-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-inout0.1+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout0.1+block-padding-devel}"
SRC_URI[aarch64_rust-inout0.1+block-padding-devel.sha256sum] = "2a6f30a8364a04729f6e47d1c79dff532dd6d722ebd84bbf8f6e23738dd20b70"

URI_aarch64_rust-inout0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout0.1+default-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-inout0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout0.1+default-devel}"
SRC_URI[aarch64_rust-inout0.1+default-devel.sha256sum] = "359cc024e86e5af03a09e63b7742ded7b3ebf07e0aa3516342b6d455d13ca838"

URI_aarch64_rust-inout0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout0.1+std-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-inout0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout0.1+std-devel}"
SRC_URI[aarch64_rust-inout0.1+std-devel.sha256sum] = "12128ce152aca30f98a8d6f6cbb32033b242305581469a55a7aae8fda1e6f9a4"

URI_aarch64_rust-inout0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout0.1-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-inout0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout0.1-devel}"
SRC_URI[aarch64_rust-inout0.1-devel.sha256sum] = "2baa318e09e09d4bb240bafa4d1e56681b471986fc6a7bbf4d548789c1c642fb"

RDEPENDS:rust-inout0.1+block-padding-devel = " \
 cargo \
 rust-block-padding0.3+default-devel \
 rust-inout0.1-devel \
 "
RDEPENDS:rust-inout0.1+default-devel = " \
 cargo \
 rust-inout0.1-devel \
 "
RDEPENDS:rust-inout0.1+std-devel = " \
 cargo \
 rust-block-padding0.3+default-devel \
 rust-block-padding0.3+std-devel \
 rust-inout0.1-devel \
 "
RDEPENDS:rust-inout0.1-devel = " \
 cargo \
 rust \
 rust-generic-array+default-devel \
 "
