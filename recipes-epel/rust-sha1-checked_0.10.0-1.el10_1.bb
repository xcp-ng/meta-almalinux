# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha1-checked"
PV = "0.10.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-sha1-checked+default-devel \
 rust-sha1-checked+oid-devel \
 rust-sha1-checked+std-devel \
 rust-sha1-checked+zeroize-devel \
 rust-sha1-checked-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha1-checked-0.10.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "554b133317e2f4c47e15c3afa0a7cceb3cdbf49dde61262c580c55456359b7f2"

URI_x86_64_v2_rust-sha1-checked+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked+default-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked+default-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked+default-devel.sha256sum] = "6cef35951b9d649330edadb4918d08246d503e696999dc95f2707649838a97df"

URI_x86_64_v2_rust-sha1-checked+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked+oid-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked+oid-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked+oid-devel.sha256sum] = "4d82f6ab1fcccf4ead765545405138a64b7dc05de6cc0cb40f71806dfc5a7ebf"

URI_x86_64_v2_rust-sha1-checked+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked+std-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked+std-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked+std-devel.sha256sum] = "0a77999304ed2bdcbc45b994d130e08c233ca8d7f2eb48478b54fbffc05fc1e5"

URI_x86_64_v2_rust-sha1-checked+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked+zeroize-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked+zeroize-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked+zeroize-devel.sha256sum] = "25e26f38ef96548ef47f2d00035d666f976bce77390af7c2aa1d238647096e2e"

URI_x86_64_v2_rust-sha1-checked-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-checked-devel-0.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-checked-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-checked-devel}"
SRC_URI[x86_64_v2_rust-sha1-checked-devel.sha256sum] = "ea809de292d57465ec75476c933aff14565519fe6ead8bbbb507845c0f22ecfe"

URI_aarch64_rust-sha1-checked+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked+default-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-sha1-checked+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked+default-devel}"
SRC_URI[aarch64_rust-sha1-checked+default-devel.sha256sum] = "f718cbfce07c2e854a7ec7e77e4cb0ab5f791b7f7916bae5fb83127166e35f36"

URI_aarch64_rust-sha1-checked+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked+oid-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-sha1-checked+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked+oid-devel}"
SRC_URI[aarch64_rust-sha1-checked+oid-devel.sha256sum] = "6f1e0ec52f0f9051cc654e769578495d29f5762d56b9d56bd784249c540c4299"

URI_aarch64_rust-sha1-checked+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked+std-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-sha1-checked+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked+std-devel}"
SRC_URI[aarch64_rust-sha1-checked+std-devel.sha256sum] = "8c5e7cd80b5980ada5d4ba3cda54be3316856a844d755132f5eccf2528ac9b4d"

URI_aarch64_rust-sha1-checked+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked+zeroize-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-sha1-checked+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked+zeroize-devel}"
SRC_URI[aarch64_rust-sha1-checked+zeroize-devel.sha256sum] = "58d8c7aef34dd5a1f7aee7534378ff8d52bbc3e4ef6471dced6d9eb7ad87770b"

URI_aarch64_rust-sha1-checked-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-checked-devel-0.10.0-1.el10_1.noarch.rpm;name=aarch64_rust-sha1-checked-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-checked-devel}"
SRC_URI[aarch64_rust-sha1-checked-devel.sha256sum] = "d7a7b2e46044c4fd63a764058facfb59d9b0577371171eaec95d4e2c8de5bd6d"

RDEPENDS:rust-sha1-checked+default-devel = " \
 cargo \
 rust-sha1-checked+oid-devel \
 rust-sha1-checked+std-devel \
 rust-sha1-checked-devel \
 "
RDEPENDS:rust-sha1-checked+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-sha1+oid-devel \
 rust-sha1-checked-devel \
 "
RDEPENDS:rust-sha1-checked+std-devel = " \
 cargo \
 rust-digest+std-devel \
 rust-sha1+std-devel \
 rust-sha1-checked-devel \
 "
RDEPENDS:rust-sha1-checked+zeroize-devel = " \
 cargo \
 rust-sha1-checked-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-sha1-checked-devel = " \
 cargo \
 rust \
 rust-digest+default-devel \
 rust-sha1+compress-devel \
 rust-sha1-devel \
 "
