# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-retry"
PV = "0.9.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqwest-retry+default-devel \
 rust-reqwest-retry+tracing-devel \
 rust-reqwest-retry-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-retry-0.9.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8d21b398a52f124b52b90a13b8b33bb1ac3c5be6fdcc03ac2dffdf0f9e51839"

URI_x86_64_v2_rust-reqwest-retry+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry+default-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry+default-devel.sha256sum] = "2322d44fc0868816a9ef83644266d77c6e8d9fb3ee9e013a81ecb140222d8fc8"

URI_x86_64_v2_rust-reqwest-retry+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry+tracing-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry+tracing-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry+tracing-devel.sha256sum] = "4d27ebca85aa8de1729698eb1d1e3f86e136abe211a51cc44b9c668237fa743f"

URI_x86_64_v2_rust-reqwest-retry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-retry-devel-0.9.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-retry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-retry-devel}"
SRC_URI[x86_64_v2_rust-reqwest-retry-devel.sha256sum] = "008f70bc9ce8aba80055a19a97b7b0912d147c8d4f854967af923eef76daaab9"

URI_aarch64_rust-reqwest-retry+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry+default-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-retry+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry+default-devel}"
SRC_URI[aarch64_rust-reqwest-retry+default-devel.sha256sum] = "93c8c70eef57dadc00b588587174056654bd64061a7fae0c1bc3c7aba46f017f"

URI_aarch64_rust-reqwest-retry+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry+tracing-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-retry+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry+tracing-devel}"
SRC_URI[aarch64_rust-reqwest-retry+tracing-devel.sha256sum] = "912ff97dd7ffe54b7c2726dfd86142b68d4ad2c5c63182b37f301ec9b1804baf"

URI_aarch64_rust-reqwest-retry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-retry-devel-0.9.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-retry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-retry-devel}"
SRC_URI[aarch64_rust-reqwest-retry-devel.sha256sum] = "fef3ed5f180f44c3131f055ead12b34bb359f029c2fc02e50dfa8a073003589e"

RDEPENDS:rust-reqwest-retry+default-devel = " \
 cargo \
 rust-reqwest-retry+tracing-devel \
 rust-reqwest-retry-devel \
 "
RDEPENDS:rust-reqwest-retry+tracing-devel = " \
 cargo \
 rust-reqwest-retry-devel \
 rust-tracing+default-devel \
 "
RDEPENDS:rust-reqwest-retry-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-futures+default-devel \
 rust-http+default-devel \
 rust-hyper+default-devel \
 rust-reqwest-devel \
 rust-reqwest-middleware+default-devel \
 rust-retry-policies+default-devel \
 rust-thiserror+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
