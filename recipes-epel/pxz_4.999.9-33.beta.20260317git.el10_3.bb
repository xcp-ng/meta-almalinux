# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pxz"
PV = "4.999.9"
PR = "33.beta.20260317git.el10_3"
PACKAGES = " \
 pxz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pxz-4.999.9-33.beta.20260317git.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d405bb305ac5f1a59c03c422b5ed347e0d6a156b585d0bf6313e6c8681a8ab7c"

URI_x86_64_v2_pxz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pxz-4.999.9-33.beta.20260317git.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pxz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pxz}"
SRC_URI[x86_64_v2_pxz.sha256sum] = "2bba0a9f03b7a0352a6177ac53b9e3f44c4254a38a99a89ece694157655455b0"

URI_aarch64_pxz = "${EPEL_MIRROR}/aarch64/Packages/p/pxz-4.999.9-33.beta.20260317git.el10_3.aarch64.rpm;name=aarch64_pxz;unpack=0"
SRC_URI:append = " ${URI_aarch64_pxz}"
SRC_URI[aarch64_pxz.sha256sum] = "a6ab81a3c587d9c8cfedae4862bfb2fa2cca89dafaa5eb2e3c0caacb9d91bf2d"

RDEPENDS:pxz = " \
 glibc \
 libgcc \
 libgomp \
 xz \
 xz-libs \
 "
