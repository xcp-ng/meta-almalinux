# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-ml"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = " \
 hyphen-ml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-ml-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90bae923ad4860a9240b9b4f17270f7bafbef9bdf7446da2d1fea813062a075a"

URI_x86_64_v2_hyphen-ml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-ml-0.7.0-27.el10.noarch.rpm;name=x86_64_v2_hyphen-ml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-ml}"
SRC_URI[x86_64_v2_hyphen-ml.sha256sum] = "09ac58a0b4426871a1657df8cd185ba4eaa091d130e31d049b916ae1901afff2"

URI_aarch64_hyphen-ml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-ml-0.7.0-27.el10.noarch.rpm;name=aarch64_hyphen-ml;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-ml}"
SRC_URI[aarch64_hyphen-ml.sha256sum] = "09ac58a0b4426871a1657df8cd185ba4eaa091d130e31d049b916ae1901afff2"

RDEPENDS:hyphen-ml = " \
 hyphen \
 "
