# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scap-security-guide"
PV = "0.1.80"
PR = "1.el10_1.alma.1"
PACKAGES = " \
 scap-security-guide \
 scap-security-guide-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/scap-security-guide-0.1.80-1.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b587e129cdd9f0d2cc04249736a10fd8314500b9830c37725193e9654b3dc70b"

URI_x86_64_v2_scap-security-guide = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-0.1.80-1.el10_1.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scap-security-guide}"
SRC_URI[x86_64_v2_scap-security-guide.sha256sum] = "b40e91cd6e1ce592c8028324238604872d6bfc1b28ad9c681054d0b29789058a"

URI_x86_64_v2_scap-security-guide-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-doc-0.1.80-1.el10_1.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scap-security-guide-doc}"
SRC_URI[x86_64_v2_scap-security-guide-doc.sha256sum] = "05f343b804fe64c03c5732953eacf3774ad5583d7a61ea4d439830b61e16c11f"

URI_aarch64_scap-security-guide = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-0.1.80-1.el10_1.alma.1.noarch.rpm;name=aarch64_scap-security-guide;unpack=0"
SRC_URI:append = " ${URI_aarch64_scap-security-guide}"
SRC_URI[aarch64_scap-security-guide.sha256sum] = "b40e91cd6e1ce592c8028324238604872d6bfc1b28ad9c681054d0b29789058a"

URI_aarch64_scap-security-guide-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-doc-0.1.80-1.el10_1.alma.1.noarch.rpm;name=aarch64_scap-security-guide-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scap-security-guide-doc}"
SRC_URI[aarch64_scap-security-guide-doc.sha256sum] = "05f343b804fe64c03c5732953eacf3774ad5583d7a61ea4d439830b61e16c11f"

RDEPENDS:scap-security-guide = " \
 openscap-scanner \
 xml-common \
 "
RDEPENDS:scap-security-guide-doc = " \
 scap-security-guide \
 "
