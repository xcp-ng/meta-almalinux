# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-metadata"
PV = "0.3.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-metadata \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-metadata-0.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ca168ce3ce9cd15290b4e1990c3b614ef22be6bbfc146526d866a0c5a34aa550"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-metadata-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-metadata;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-metadata.sha256sum] = "01f9f994cd3b0a749cfd60fd15eace0a94e9b0c53e79fae2db6507b2782859ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-metadata-0.3.1-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-metadata;unpack=0"
SRC_URI[aarch64_python3-colcon-metadata.sha256sum] = "96870127785bec644b1e28733368d2a5d085ebe6953596e2bb5c5a7b974b9aff"

RDEPENDS:python3-colcon-metadata = " \
 python3 \
 python3-colcon-core \
 python3-pyyaml \
 "
