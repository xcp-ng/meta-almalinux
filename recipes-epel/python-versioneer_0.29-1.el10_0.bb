# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-versioneer"
PV = "0.29"
PR = "1.el10_0"
PACKAGES = " \
 python3-versioneer \
 python3-versioneer+toml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-versioneer-0.29-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63b98e08e968cf3b8fee58038880063584cc6eb66a2847c9ccc54231ed484240"

URI_x86_64_v2_python3-versioneer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-versioneer-0.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-versioneer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-versioneer}"
SRC_URI[x86_64_v2_python3-versioneer.sha256sum] = "8e652f890fe39f74cd55986505e424539f1955324964ddf987d28dbb9c85dd1d"

URI_x86_64_v2_python3-versioneer+toml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-versioneer+toml-0.29-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-versioneer+toml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-versioneer+toml}"
SRC_URI[x86_64_v2_python3-versioneer+toml.sha256sum] = "e8b7cff64918ce54d0a84072c319fa1d30afe573f992b326f27f2ec4b54628cd"

URI_aarch64_python3-versioneer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-versioneer-0.29-1.el10_0.noarch.rpm;name=aarch64_python3-versioneer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-versioneer}"
SRC_URI[aarch64_python3-versioneer.sha256sum] = "f2311b36e47e665418016a89cd5fa4623f887f5217d7e5c836e2c570db18e312"

URI_aarch64_python3-versioneer+toml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-versioneer+toml-0.29-1.el10_0.noarch.rpm;name=aarch64_python3-versioneer+toml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-versioneer+toml}"
SRC_URI[aarch64_python3-versioneer+toml.sha256sum] = "fa878326cd3bc293a012978014099704b62d5b511897861e5e19ee3af79f56b2"

RDEPENDS:python3-versioneer = " \
 python3 \
 "
RDEPENDS:python3-versioneer+toml = " \
 python3 \
 python3-versioneer \
 "
