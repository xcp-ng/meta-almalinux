# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aes-siv"
PV = "0.7.0"
PR = "6.el10_1"
PACKAGES = " \
 rust-aes-siv+alloc-devel \
 rust-aes-siv+default-devel \
 rust-aes-siv+getrandom-devel \
 rust-aes-siv+heapless-devel \
 rust-aes-siv+pmac-devel \
 rust-aes-siv+std-devel \
 rust-aes-siv+stream-devel \
 rust-aes-siv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aes-siv-0.7.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "478081aae1fe7ea636014b75e8c2e8038b9a3beffb0b5b735a3e4a788ae9c603"

URI_x86_64_v2_rust-aes-siv+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+alloc-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+alloc-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+alloc-devel.sha256sum] = "40d66ed74934627ac36cfb193f8f0471f5a687ada1f384d2f8a961c0f6334dfc"

URI_x86_64_v2_rust-aes-siv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+default-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+default-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+default-devel.sha256sum] = "82fc58ae985c82ea35c60b6bacabe648e53b22a7eb043b3a921b39c9b6ce291f"

URI_x86_64_v2_rust-aes-siv+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+getrandom-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+getrandom-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+getrandom-devel.sha256sum] = "29561e118c9131a7bfca20a7c43d81ab9cf3f3e79768f3bfd494d94d63bf8d65"

URI_x86_64_v2_rust-aes-siv+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+heapless-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+heapless-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+heapless-devel.sha256sum] = "715f1e9eb2eebe4024dae59db9cacd206537f4c89513177bab75308e760d556d"

URI_x86_64_v2_rust-aes-siv+pmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+pmac-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+pmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+pmac-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+pmac-devel.sha256sum] = "db9ff62f6af038a43cafbaeb754097224818eeac736ce0f2dc73b39690c1ca1c"

URI_x86_64_v2_rust-aes-siv+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+std-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+std-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+std-devel.sha256sum] = "9de3dff7c1f91fe816b5ee0dca0a55a71a91cfc820f1c2d9c51afe35e687a8cd"

URI_x86_64_v2_rust-aes-siv+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv+stream-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv+stream-devel}"
SRC_URI[x86_64_v2_rust-aes-siv+stream-devel.sha256sum] = "fd0fb3fe31cf57150cb8ba9816f2ef3e432c6bcc03643dfb97cf41200d2156e9"

URI_x86_64_v2_rust-aes-siv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aes-siv-devel-0.7.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aes-siv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aes-siv-devel}"
SRC_URI[x86_64_v2_rust-aes-siv-devel.sha256sum] = "f906d3d8968e77583e25eb13e7189822318fbfa744ce65a11f3ff8fff49ffa25"

URI_aarch64_rust-aes-siv+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+alloc-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-aes-siv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+alloc-devel}"
SRC_URI[aarch64_rust-aes-siv+alloc-devel.sha256sum] = "927ce88c1823bef3502bb37bfaa893897240e4fb55708c454eabc88dd4e10a92"

URI_aarch64_rust-aes-siv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+default-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-aes-siv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+default-devel}"
SRC_URI[aarch64_rust-aes-siv+default-devel.sha256sum] = "1a27338c44d29c540ee317d7a1b08fca34a5b24a0686d652259c053563ba2897"

URI_aarch64_rust-aes-siv+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+getrandom-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-aes-siv+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+getrandom-devel}"
SRC_URI[aarch64_rust-aes-siv+getrandom-devel.sha256sum] = "66c21e36017fc5180bd192f337a8aa92dc5d96f8ecb8e0e0ea93a765d6ee9cb4"

URI_aarch64_rust-aes-siv+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+heapless-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-aes-siv+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+heapless-devel}"
SRC_URI[aarch64_rust-aes-siv+heapless-devel.sha256sum] = "174217b1a95a7995398196b6e98c1ee44c0768b906d47fb75d27e99b5b3585b8"

URI_aarch64_rust-aes-siv+pmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+pmac-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-aes-siv+pmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+pmac-devel}"
SRC_URI[aarch64_rust-aes-siv+pmac-devel.sha256sum] = "d7d6a92281739ac3b23eb70a7404ab6cc337b03e86a67d75bd4b62e1a09c6a68"

URI_aarch64_rust-aes-siv+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+std-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-aes-siv+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+std-devel}"
SRC_URI[aarch64_rust-aes-siv+std-devel.sha256sum] = "eaf26d0467bac4887a48bba1ed03c6e56693da2ac2038d726459e3b08c47710b"

URI_aarch64_rust-aes-siv+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv+stream-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-aes-siv+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv+stream-devel}"
SRC_URI[aarch64_rust-aes-siv+stream-devel.sha256sum] = "fd51689a07a8c8d86e0db4168e8008fb3e8970776619d013dff1498f61f9d9f9"

URI_aarch64_rust-aes-siv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aes-siv-devel-0.7.0-6.el10_1.noarch.rpm;name=aarch64_rust-aes-siv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aes-siv-devel}"
SRC_URI[aarch64_rust-aes-siv-devel.sha256sum] = "f98ab65bb67a1dc964a9918183537592d42480596fe02e8d4cb27aebf6b92422"

RDEPENDS:rust-aes-siv+alloc-devel = " \
 cargo \
 rust-aead+alloc-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+default-devel = " \
 cargo \
 rust-aes-siv+alloc-devel \
 rust-aes-siv+getrandom-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+getrandom-devel = " \
 cargo \
 rust-aead+getrandom-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+heapless-devel = " \
 cargo \
 rust-aead+heapless-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+pmac-devel = " \
 cargo \
 rust-aes-siv-devel \
 rust-pmac+default-devel \
 "
RDEPENDS:rust-aes-siv+std-devel = " \
 cargo \
 rust-aead+std-devel \
 rust-aes-siv+alloc-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv+stream-devel = " \
 cargo \
 rust-aead+stream-devel \
 rust-aes-siv-devel \
 "
RDEPENDS:rust-aes-siv-devel = " \
 cargo \
 rust \
 rust-aead+default-devel \
 rust-aes+default-devel \
 rust-cipher+default-devel \
 rust-cmac+default-devel \
 rust-ctr+default-devel \
 rust-dbl+default-devel \
 rust-digest+default-devel \
 rust-digest+mac-devel \
 rust-zeroize-devel \
 "
