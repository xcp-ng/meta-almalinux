# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "util-linux"
PV = "2.40.2"
PR = "10.el10"
PACKAGES = " \
 libblkid \
 libblkid-devel \
 libfdisk \
 libfdisk-devel \
 libmount \
 libmount-devel \
 libsmartcols \
 libsmartcols-devel \
 libuuid \
 libuuid-devel \
 python3-libmount \
 util-linux \
 util-linux-core \
 uuidd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/util-linux-2.40.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eff49d41760112c82d4012a8d4328dcd1b51fb4441eb23b1dfe17b76b51b0c9"

URI_x86_64_v2_libblkid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libblkid-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libblkid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkid}"
SRC_URI[x86_64_v2_libblkid.sha256sum] = "bfe7ae86ee4fd922864bd0b3d3b06639f5c04b207ddf993119b83f8c82d2848f"

URI_x86_64_v2_libblkid-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblkid-devel-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libblkid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkid-devel}"
SRC_URI[x86_64_v2_libblkid-devel.sha256sum] = "659a712edc12521326100b196cf2c3f81a5a806a6b82c9350c80cefed4cf39c7"

URI_x86_64_v2_libfdisk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libfdisk-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libfdisk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdisk}"
SRC_URI[x86_64_v2_libfdisk.sha256sum] = "36fc44a075a97301e0872fc27b23302de9a9efb6ec0e5d2b146ec0ce388d7ba7"

URI_x86_64_v2_libfdisk-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfdisk-devel-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libfdisk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdisk-devel}"
SRC_URI[x86_64_v2_libfdisk-devel.sha256sum] = "305602a96be3f70b0db9b7bf216450b2736b0699c130ac140fb4738f292d109c"

URI_x86_64_v2_libmount = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libmount-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libmount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmount}"
SRC_URI[x86_64_v2_libmount.sha256sum] = "a0217b313ca72bc39dfce5cd2f720151a0911c6e2488f0d532990f091b40cd66"

URI_x86_64_v2_libmount-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmount-devel-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libmount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmount-devel}"
SRC_URI[x86_64_v2_libmount-devel.sha256sum] = "f089f665fe3c2792e68b4ad42a77541c62f766dc65b33ffdce07c7cbdbbfcf2d"

URI_x86_64_v2_libsmartcols = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmartcols-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libsmartcols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmartcols}"
SRC_URI[x86_64_v2_libsmartcols.sha256sum] = "afddc119a8b68b5533328884ab40fdaea0b6589dd83995e4de1f78ce031f30e9"

URI_x86_64_v2_libsmartcols-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmartcols-devel-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libsmartcols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmartcols-devel}"
SRC_URI[x86_64_v2_libsmartcols-devel.sha256sum] = "c6f5d13039821e92f69c122020b002cbf0af2c13ab7ac1e34415b40be537ee98"

URI_x86_64_v2_libuuid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libuuid-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libuuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuuid}"
SRC_URI[x86_64_v2_libuuid.sha256sum] = "99f0f12d1f57dd818419dc0e518bc70256d45658679ce376ca857545d87e37d7"

URI_x86_64_v2_libuuid-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuuid-devel-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_libuuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuuid-devel}"
SRC_URI[x86_64_v2_libuuid-devel.sha256sum] = "d750a4844f41d9ec88f329fda7d0645cf3895314c7d57e8b844016b8f688a748"

URI_x86_64_v2_python3-libmount = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libmount-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libmount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libmount}"
SRC_URI[x86_64_v2_python3-libmount.sha256sum] = "f2f272bb00d2a836d972ed596e5eb273e6ea27c2d1f863fedc72304bb4081dc9"

URI_x86_64_v2_util-linux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_util-linux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_util-linux}"
SRC_URI[x86_64_v2_util-linux.sha256sum] = "164eef71aa979d0f1f782fd5c3d77074067eb61da76f67d56267f7096bd2ab3e"
RPROVIDES:util-linux:x86_64_v2 = "virtual/util-linux-core_or_util-linux"

URI_x86_64_v2_util-linux-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-core-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_util-linux-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_util-linux-core}"
SRC_URI[x86_64_v2_util-linux-core.sha256sum] = "bd4709bab9efe54f2914eea1266b16dae5ad8752b67f8934cd54a1b353e51eaa"
RPROVIDES:util-linux-core:x86_64_v2 = "virtual/util-linux-core_or_util-linux"

URI_x86_64_v2_uuidd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uuidd-2.40.2-10.el10.x86_64_v2.rpm;name=x86_64_v2_uuidd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uuidd}"
SRC_URI[x86_64_v2_uuidd.sha256sum] = "508588d206eb1cfde73aa06dafba48da4a13019859ffeea17a0b450c32e4c6ae"

URI_aarch64_libblkid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libblkid-2.40.2-10.el10.aarch64.rpm;name=aarch64_libblkid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkid}"
SRC_URI[aarch64_libblkid.sha256sum] = "21412773cf449de7786d3ae6207d20d136af11a4851549ec5a1c4e2c2456090b"

URI_aarch64_libblkid-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblkid-devel-2.40.2-10.el10.aarch64.rpm;name=aarch64_libblkid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkid-devel}"
SRC_URI[aarch64_libblkid-devel.sha256sum] = "fe6e38a8fdd3a01e818bfbcb9ee733018ab0bf79133326c2a238b22d781f42e1"

URI_aarch64_libfdisk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libfdisk-2.40.2-10.el10.aarch64.rpm;name=aarch64_libfdisk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdisk}"
SRC_URI[aarch64_libfdisk.sha256sum] = "7793b683fb090455b88f59cc00664af22de9deed9511cb4c24649eab28340873"

URI_aarch64_libfdisk-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfdisk-devel-2.40.2-10.el10.aarch64.rpm;name=aarch64_libfdisk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdisk-devel}"
SRC_URI[aarch64_libfdisk-devel.sha256sum] = "ea68e4d53813b459f59be5b414c3bcd47f207b37d0175f9db3e99fde3562f7ad"

URI_aarch64_libmount = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libmount-2.40.2-10.el10.aarch64.rpm;name=aarch64_libmount;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmount}"
SRC_URI[aarch64_libmount.sha256sum] = "3c8e74f64c90efef0a3b58c95fa218e106a054647fd7441fcdfe8fda2a281dca"

URI_aarch64_libmount-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmount-devel-2.40.2-10.el10.aarch64.rpm;name=aarch64_libmount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmount-devel}"
SRC_URI[aarch64_libmount-devel.sha256sum] = "025fd3611548c870a7c553c7491858c031a53ba26c60c40826fb24b35b7e23e5"

URI_aarch64_libsmartcols = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmartcols-2.40.2-10.el10.aarch64.rpm;name=aarch64_libsmartcols;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmartcols}"
SRC_URI[aarch64_libsmartcols.sha256sum] = "055f121bb96bb6634dcdac841fdb97fc94a9b8ceeaea8eaa369bd8d60be0bba9"

URI_aarch64_libsmartcols-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmartcols-devel-2.40.2-10.el10.aarch64.rpm;name=aarch64_libsmartcols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmartcols-devel}"
SRC_URI[aarch64_libsmartcols-devel.sha256sum] = "7b674b5875a1f7b3b647bd6ad30be4b8a01eec87958eca4071a2a549d3c98b8e"

URI_aarch64_libuuid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libuuid-2.40.2-10.el10.aarch64.rpm;name=aarch64_libuuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuuid}"
SRC_URI[aarch64_libuuid.sha256sum] = "cec8efc583aebc39d4d2f29c8bad29531474d77db8fc1a8736809f5f64777297"

URI_aarch64_libuuid-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuuid-devel-2.40.2-10.el10.aarch64.rpm;name=aarch64_libuuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuuid-devel}"
SRC_URI[aarch64_libuuid-devel.sha256sum] = "13ed096755ac7bcbbc930f39d80c556877f9e8ee161466ed9bf85d5942650104"

URI_aarch64_python3-libmount = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libmount-2.40.2-10.el10.aarch64.rpm;name=aarch64_python3-libmount;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libmount}"
SRC_URI[aarch64_python3-libmount.sha256sum] = "d290c6f8d6da42e7ca5a9d3603c3f692770fdd51ad9ce0f3578eb07c1e0f4474"

URI_aarch64_util-linux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-2.40.2-10.el10.aarch64.rpm;name=aarch64_util-linux;unpack=0"
SRC_URI:append = " ${URI_aarch64_util-linux}"
SRC_URI[aarch64_util-linux.sha256sum] = "bfde420f66eb002de9b035932cb71c45e48d228de7b8eb5b3fbd1a241c082390"
RPROVIDES:util-linux:aarch64 = "virtual/util-linux-core_or_util-linux"

URI_aarch64_util-linux-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-core-2.40.2-10.el10.aarch64.rpm;name=aarch64_util-linux-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_util-linux-core}"
SRC_URI[aarch64_util-linux-core.sha256sum] = "283f9fd2f08eb46e4ac99814dc453fbae6f8d5c9e9911cdad98ac7cc1cfa2827"
RPROVIDES:util-linux-core:aarch64 = "virtual/util-linux-core_or_util-linux"

URI_aarch64_uuidd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uuidd-2.40.2-10.el10.aarch64.rpm;name=aarch64_uuidd;unpack=0"
SRC_URI:append = " ${URI_aarch64_uuidd}"
SRC_URI[aarch64_uuidd.sha256sum] = "76932a837d21632b494ba1d2e321b2b6cb2ab4dbc65d04156d15a3e0ca05a5f6"

RDEPENDS:libblkid = " \
 glibc \
 libuuid \
 "
RDEPENDS:libblkid-devel = " \
 libblkid \
 pkgconf-pkg-config \
 "
RDEPENDS:libfdisk = " \
 glibc \
 libblkid \
 libuuid \
 "
RDEPENDS:libfdisk-devel = " \
 libblkid-devel \
 libfdisk \
 libuuid-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libmount = " \
 glibc \
 libblkid \
 libselinux \
 libuuid \
 "
RDEPENDS:libmount-devel = " \
 libblkid-devel \
 libmount \
 libselinux-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmartcols = " \
 glibc \
 "
RDEPENDS:libsmartcols-devel = " \
 libsmartcols \
 pkgconf-pkg-config \
 "
RDEPENDS:libuuid = " \
 glibc \
 "
RDEPENDS:libuuid-devel = " \
 libuuid \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libmount = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 python3 \
 "
RDEPENDS:util-linux = " \
 audit-libs \
 authselect-libs \
 bash \
 glibc \
 libblkid \
 libcap-ng \
 libfdisk \
 libmount \
 libselinux \
 libsmartcols \
 libutempter \
 libuuid \
 ncurses-libs \
 pam \
 pam-libs \
 readline \
 systemd-libs \
 util-linux-core \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:util-linux-core = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 libsmartcols \
 libuuid \
 libxcrypt \
 ncurses-libs \
 systemd-libs \
 "
RDEPENDS:uuidd = " \
 bash \
 glibc \
 libuuid \
 shadow-utils \
 systemd-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/util-linux-core_or_util-linux"

PROVIDES:append:aarch64 = " rpm/virtual/util-linux-core_or_util-linux"
