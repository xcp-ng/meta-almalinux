# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-02Packages-Search"
PV = "0.100"
PR = "5.el10_0"
PACKAGES = " \
 perl-CPAN-02Packages-Search \
 perl-CPAN-02Packages-Search-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CPAN-02Packages-Search-0.100-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec856bf9e81301a4e23896a6fa515d03f66ebc36709e1d89b7e685bd019be92c"

URI_x86_64_v2_perl-CPAN-02Packages-Search = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-02Packages-Search-0.100-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-02Packages-Search;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-02Packages-Search}"
SRC_URI[x86_64_v2_perl-CPAN-02Packages-Search.sha256sum] = "1010ce942421bec9dc71a33c994eebf97ece90df98b4f3c418215bad4d5c2705"

URI_x86_64_v2_perl-CPAN-02Packages-Search-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CPAN-02Packages-Search-tests-0.100-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CPAN-02Packages-Search-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN-02Packages-Search-tests}"
SRC_URI[x86_64_v2_perl-CPAN-02Packages-Search-tests.sha256sum] = "152344c77eb903d2e03db97d0131ba995f2b01db71bbb0b3c27033642474cc29"

URI_aarch64_perl-CPAN-02Packages-Search = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-02Packages-Search-0.100-5.el10_0.noarch.rpm;name=aarch64_perl-CPAN-02Packages-Search;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-02Packages-Search}"
SRC_URI[aarch64_perl-CPAN-02Packages-Search.sha256sum] = "0d8638622d5d6d4e55f4b36ae8d236890788c507e707e6b40078beb5b5b8148c"

URI_aarch64_perl-CPAN-02Packages-Search-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CPAN-02Packages-Search-tests-0.100-5.el10_0.noarch.rpm;name=aarch64_perl-CPAN-02Packages-Search-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN-02Packages-Search-tests}"
SRC_URI[aarch64_perl-CPAN-02Packages-Search-tests.sha256sum] = "6b1df97973ac5572ccc8a4bebf70b42be41a40cb2485c8bb4e9c0847cec45506"

RDEPENDS:perl-CPAN-02Packages-Search = " \
 perl-Search-Dict \
 perl-Symbol \
 perl-Tie-Handle-Offset \
 perl-libs \
 "
RDEPENDS:perl-CPAN-02Packages-Search-tests = " \
 bash \
 perl-CPAN-02Packages-Search \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
