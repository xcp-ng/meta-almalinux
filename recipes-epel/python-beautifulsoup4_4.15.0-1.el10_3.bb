# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-beautifulsoup4"
PV = "4.15.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-beautifulsoup4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-beautifulsoup4-4.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d63a576e8efac58ade20ad6729f6770f568383f349440f3231de954255519d7"

URI_x86_64_v2_python3-beautifulsoup4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-beautifulsoup4-4.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-beautifulsoup4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-beautifulsoup4}"
SRC_URI[x86_64_v2_python3-beautifulsoup4.sha256sum] = "891a1f615f6a708ff687a64c470acd16aa28b47c692ee253d8c873f0f8fd9a2a"

URI_aarch64_python3-beautifulsoup4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-beautifulsoup4-4.15.0-1.el10_3.noarch.rpm;name=aarch64_python3-beautifulsoup4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-beautifulsoup4}"
SRC_URI[aarch64_python3-beautifulsoup4.sha256sum] = "173bbf17043aac5b800439dc2f1ea18f8f58d8b8be8986d5e890cfa70fb04e75"

RDEPENDS:python3-beautifulsoup4 = " \
 python3 \
 python3-lxml \
 python3-soupsieve \
 python3-typing-extensions \
 "
