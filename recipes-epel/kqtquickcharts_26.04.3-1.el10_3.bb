# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kqtquickcharts"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kqtquickcharts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kqtquickcharts-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77c5443f58c5a88e1da98925ec9707c5f7b1b96ce9601a686132914b4c6dfc13"

URI_x86_64_v2_kqtquickcharts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kqtquickcharts-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kqtquickcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kqtquickcharts}"
SRC_URI[x86_64_v2_kqtquickcharts.sha256sum] = "8a0b9feae47fa8f2ae2f37cd8725418eb2b9af07f64745c1e36b8ea3c7ff7a39"

URI_aarch64_kqtquickcharts = "${EPEL_MIRROR}/aarch64/Packages/k/kqtquickcharts-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kqtquickcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kqtquickcharts}"
SRC_URI[aarch64_kqtquickcharts.sha256sum] = "eddacb1ba9762ed00a2e808e5f0e51f05e7f9d65b7257a17cfa78bc407b1b4fd"

RDEPENDS:kqtquickcharts = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
