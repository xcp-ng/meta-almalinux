# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcharselect"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kcharselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcharselect-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c3ab644efe294496ed1edf35543bf7795dbde1cb4577cc3da0d4bbafdec98b2"

URI_x86_64_v2_kcharselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcharselect-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcharselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcharselect}"
SRC_URI[x86_64_v2_kcharselect.sha256sum] = "c55ee138e3073ccd41384b7404e56db4cb451bcecbe31be6a99f5978b4470bba"

URI_aarch64_kcharselect = "${EPEL_MIRROR}/aarch64/Packages/k/kcharselect-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kcharselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcharselect}"
SRC_URI[aarch64_kcharselect.sha256sum] = "8d3a504aa83de0a2c85233699f3a29d2da66e2fc1e15707bd0d4058af4fb2f46"

RDEPENDS:kcharselect = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
