# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-orjson"
PV = "3.11.7"
PR = "1.el10_2"
PACKAGES = " \
 python3-orjson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-orjson-3.11.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e59395d6b5b4746ac8aaf88c979f821f5caddff8af2f17b0de6a5af0869b41e"

URI_x86_64_v2_python3-orjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-orjson-3.11.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-orjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-orjson}"
SRC_URI[x86_64_v2_python3-orjson.sha256sum] = "8afc2d824d078d3df91192465781894c4c44eb755623a57e90ff76954e45bdb9"

URI_aarch64_python3-orjson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-orjson-3.11.7-1.el10_2.aarch64.rpm;name=aarch64_python3-orjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-orjson}"
SRC_URI[aarch64_python3-orjson.sha256sum] = "e37eb53b18f47548eaf66f3f98a803b27019e5d23a626bd9fad40799165b7496"

RDEPENDS:python3-orjson = " \
 glibc \
 libgcc \
 python3 \
 "
