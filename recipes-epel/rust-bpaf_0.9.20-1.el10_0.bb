# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bpaf"
PV = "0.9.20"
PR = "1.el10_0"
PACKAGES = " \
 rust-bpaf+autocomplete-devel \
 rust-bpaf+batteries-devel \
 rust-bpaf+bpaf_derive-devel \
 rust-bpaf+bright-color-devel \
 rust-bpaf+color-devel \
 rust-bpaf+default-devel \
 rust-bpaf+derive-devel \
 rust-bpaf+docgen-devel \
 rust-bpaf+dull-color-devel \
 rust-bpaf+extradocs-devel \
 rust-bpaf+owo-colors-devel \
 rust-bpaf+supports-color-devel \
 rust-bpaf+unstable-docs-devel \
 rust-bpaf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bpaf-0.9.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1033efd2fa1c48e36a036d3a914bb31e22b4a5de7d485efe7af1809dedd1d6c8"

URI_x86_64_v2_rust-bpaf+autocomplete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+autocomplete-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+autocomplete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+autocomplete-devel}"
SRC_URI[x86_64_v2_rust-bpaf+autocomplete-devel.sha256sum] = "4ae04846cb91e14bca492bf360fcea35aba942144a48cd96809fffeac6658484"

URI_x86_64_v2_rust-bpaf+batteries-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+batteries-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+batteries-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+batteries-devel}"
SRC_URI[x86_64_v2_rust-bpaf+batteries-devel.sha256sum] = "89cb9e4b8b450d5201f381ff0889c9248cfad2f97e92d2e8352660bb6abde38b"

URI_x86_64_v2_rust-bpaf+bpaf_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+bpaf_derive-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+bpaf_derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf+bpaf_derive-devel.sha256sum] = "fd746a79a282f87dcc6716f7368721db612b57ed61bf0623d5ec4887d5ceced6"

URI_x86_64_v2_rust-bpaf+bright-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+bright-color-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+bright-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+bright-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+bright-color-devel.sha256sum] = "89c5e58e2f827f877615f4251116d5f6c910dbfc5488eaf035d6f391748c91fc"

URI_x86_64_v2_rust-bpaf+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+color-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+color-devel.sha256sum] = "51616920bb366a2ebb880c7358e1bce35704946b609d023d51b8a0ffdc9cd4b7"

URI_x86_64_v2_rust-bpaf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+default-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+default-devel}"
SRC_URI[x86_64_v2_rust-bpaf+default-devel.sha256sum] = "12a54175907021e70beea2a0bf14f910e0a16ba74d8f65819ae03c83d74ac1e3"

URI_x86_64_v2_rust-bpaf+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+derive-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+derive-devel}"
SRC_URI[x86_64_v2_rust-bpaf+derive-devel.sha256sum] = "0ad359e6c73a7df602266f3991b9ab7aa5fdc8fac2d4b6c942e6e5688ace80a6"

URI_x86_64_v2_rust-bpaf+docgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+docgen-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+docgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+docgen-devel}"
SRC_URI[x86_64_v2_rust-bpaf+docgen-devel.sha256sum] = "2410f007b749f185a438fec8cf91618545c06a60a4f39347958d319489a093f5"

URI_x86_64_v2_rust-bpaf+dull-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+dull-color-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+dull-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+dull-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+dull-color-devel.sha256sum] = "f85ebdb7050bd8725916750a70d309bd4fdf333c7766399be70a8a5cc0ff1499"

URI_x86_64_v2_rust-bpaf+extradocs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+extradocs-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+extradocs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+extradocs-devel}"
SRC_URI[x86_64_v2_rust-bpaf+extradocs-devel.sha256sum] = "c6c1269dff84160ee3bbf2daa5f83d67359753f44e9870429f0a329fa7e12683"

URI_x86_64_v2_rust-bpaf+owo-colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+owo-colors-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+owo-colors-devel}"
SRC_URI[x86_64_v2_rust-bpaf+owo-colors-devel.sha256sum] = "770bd3a1f99ae866678cf33136e678ff084f0fac38b1d19d893f1b021f47c8bc"

URI_x86_64_v2_rust-bpaf+supports-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+supports-color-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+supports-color-devel}"
SRC_URI[x86_64_v2_rust-bpaf+supports-color-devel.sha256sum] = "1d176e35661c6af30bf04db1c677265fa28b309f6b147ffd531a5f400f0e5a58"

URI_x86_64_v2_rust-bpaf+unstable-docs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf+unstable-docs-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf+unstable-docs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf+unstable-docs-devel}"
SRC_URI[x86_64_v2_rust-bpaf+unstable-docs-devel.sha256sum] = "0bf3638da02c86a43a50886cea30ad7c32f20f595805fb47343a5d731399e344"

URI_x86_64_v2_rust-bpaf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bpaf-devel-0.9.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bpaf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bpaf-devel}"
SRC_URI[x86_64_v2_rust-bpaf-devel.sha256sum] = "1932a2ee0d937be035d385c918d9bb3e20bbdfa62b97bb8de85a52f0ba0b30b9"

URI_aarch64_rust-bpaf+autocomplete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+autocomplete-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+autocomplete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+autocomplete-devel}"
SRC_URI[aarch64_rust-bpaf+autocomplete-devel.sha256sum] = "be13ab50215b5360f0b81f2ede09461053ad899f0a0bc3d2823e73923f4971e9"

URI_aarch64_rust-bpaf+batteries-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+batteries-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+batteries-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+batteries-devel}"
SRC_URI[aarch64_rust-bpaf+batteries-devel.sha256sum] = "d13d83523db122ab6585d4a5eae80844394024f719e1ccaf8f5c9c1fa66101da"

URI_aarch64_rust-bpaf+bpaf_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+bpaf_derive-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+bpaf_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+bpaf_derive-devel}"
SRC_URI[aarch64_rust-bpaf+bpaf_derive-devel.sha256sum] = "3d54439cca45d33b7805477f703bd5220469dee313ae0000dfd2ea034a4e89b3"

URI_aarch64_rust-bpaf+bright-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+bright-color-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+bright-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+bright-color-devel}"
SRC_URI[aarch64_rust-bpaf+bright-color-devel.sha256sum] = "17ee78d7349626cdced97460588bf087b3923d4df4b91c8b1eded2e23236aa0f"

URI_aarch64_rust-bpaf+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+color-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+color-devel}"
SRC_URI[aarch64_rust-bpaf+color-devel.sha256sum] = "59157433a371db533a167b6877b5bd8b52c753e918a672a57e32aafedf0176e1"

URI_aarch64_rust-bpaf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+default-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+default-devel}"
SRC_URI[aarch64_rust-bpaf+default-devel.sha256sum] = "f822b2f014f64c6c5963f90482da6a29f5cd8a8f9b09634a60aa426963b5ee46"

URI_aarch64_rust-bpaf+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+derive-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+derive-devel}"
SRC_URI[aarch64_rust-bpaf+derive-devel.sha256sum] = "3843f59d0affbeb5358f01676633defe629a5c8715685e67024bf9743965aa4c"

URI_aarch64_rust-bpaf+docgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+docgen-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+docgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+docgen-devel}"
SRC_URI[aarch64_rust-bpaf+docgen-devel.sha256sum] = "a13060b5f64161202c93b390cea501fb423eae15ebe4409040a875eef0fc308c"

URI_aarch64_rust-bpaf+dull-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+dull-color-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+dull-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+dull-color-devel}"
SRC_URI[aarch64_rust-bpaf+dull-color-devel.sha256sum] = "bdc3d52ec488f2099bbbd15b44ed707b62a6364bd4b2b3b5e1e15eb9f93d8a7b"

URI_aarch64_rust-bpaf+extradocs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+extradocs-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+extradocs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+extradocs-devel}"
SRC_URI[aarch64_rust-bpaf+extradocs-devel.sha256sum] = "edf2fe55e22fb94e43d868f34ce053203589d325516bbc3b885979f9809c86a2"

URI_aarch64_rust-bpaf+owo-colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+owo-colors-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+owo-colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+owo-colors-devel}"
SRC_URI[aarch64_rust-bpaf+owo-colors-devel.sha256sum] = "8ecf49f06956bcb703ac6360b850e99766d5b907bf39acddd572cd0b677b83fa"

URI_aarch64_rust-bpaf+supports-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+supports-color-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+supports-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+supports-color-devel}"
SRC_URI[aarch64_rust-bpaf+supports-color-devel.sha256sum] = "52106f533162347532118cbd1b36fa900a96f2685731ff15a84078bfc8c367bc"

URI_aarch64_rust-bpaf+unstable-docs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf+unstable-docs-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf+unstable-docs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf+unstable-docs-devel}"
SRC_URI[aarch64_rust-bpaf+unstable-docs-devel.sha256sum] = "93b75ffb36fa670040306dce4af99f4055002fb81504af31f1d851fa125c726c"

URI_aarch64_rust-bpaf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bpaf-devel-0.9.20-1.el10_0.noarch.rpm;name=aarch64_rust-bpaf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bpaf-devel}"
SRC_URI[aarch64_rust-bpaf-devel.sha256sum] = "62d6c79c318282c8a2c9a459c84b17a95aee0fe41cdba1c7bc1c65f4bcced2d4"

RDEPENDS:rust-bpaf+autocomplete-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+batteries-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+bpaf_derive-devel = " \
 cargo \
 rust-bpaf-devel \
 rust-bpaf_derive+default-devel \
 "
RDEPENDS:rust-bpaf+bright-color-devel = " \
 cargo \
 rust-bpaf+color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+color-devel = " \
 cargo \
 rust-bpaf+owo-colors-devel \
 rust-bpaf+supports-color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+default-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+derive-devel = " \
 cargo \
 rust-bpaf+bpaf_derive-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+docgen-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+dull-color-devel = " \
 cargo \
 rust-bpaf+color-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+extradocs-devel = " \
 cargo \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf+owo-colors-devel = " \
 cargo \
 rust-bpaf-devel \
 virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~ \
 "
RDEPENDS:rust-bpaf+supports-color-devel = " \
 cargo \
 rust-bpaf-devel \
 virtual/crate_supports-color/default__ge_2.0.0_with_crate_supports-color/default__lt_4.0.0~ \
 "
RDEPENDS:rust-bpaf+unstable-docs-devel = " \
 cargo \
 rust-bpaf+autocomplete-devel \
 rust-bpaf+batteries-devel \
 rust-bpaf+derive-devel \
 rust-bpaf+docgen-devel \
 rust-bpaf+extradocs-devel \
 rust-bpaf-devel \
 "
RDEPENDS:rust-bpaf-devel = " \
 cargo \
 rust \
 "
