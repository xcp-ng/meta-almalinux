# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-config"
PE = "2"
PV = "10.3.0"
PR = "5.el10_2"
PACKAGES = " \
 python-oslo-config-doc \
 python3-oslo-config \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-config-10.3.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "287c2b8c37d8922d2aa4f1cc3b06563dbda3c70cc3a83c3ba3cefc13657e651b"

URI_x86_64_v2_python-oslo-config-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-config-doc-10.3.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-config-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-config-doc}"
SRC_URI[x86_64_v2_python-oslo-config-doc.sha256sum] = "8c43f988331501bd5c834720e99f2c458cba10031700d468ef4c7c7b42730d35"

URI_x86_64_v2_python3-oslo-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-config-10.3.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-config}"
SRC_URI[x86_64_v2_python3-oslo-config.sha256sum] = "618265c69913342a5ff2d757bec7911bac260588e0103fd3aa87109153910ec9"

URI_aarch64_python-oslo-config-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-config-doc-10.3.0-5.el10_2.noarch.rpm;name=aarch64_python-oslo-config-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-config-doc}"
SRC_URI[aarch64_python-oslo-config-doc.sha256sum] = "55c250395526d88753f12bef32cbcd4e75ca6c2e42420a1336b126fea2560f59"

URI_aarch64_python3-oslo-config = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-config-10.3.0-5.el10_2.noarch.rpm;name=aarch64_python3-oslo-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-config}"
SRC_URI[aarch64_python3-oslo-config.sha256sum] = "323bcd10a3c2803f02be6a5af234f9f01d28c3d8edeca97f08831cd463814022"

RDEPENDS:python-oslo-config-doc = " \
 "
RDEPENDS:python3-oslo-config = " \
 python3 \
 python3-netaddr \
 python3-oslo-i18n \
 python3-pyyaml \
 python3-requests \
 python3-rfc3986 \
 python3-stevedore \
 "
