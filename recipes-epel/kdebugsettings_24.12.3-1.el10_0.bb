# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdebugsettings"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdebugsettings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdebugsettings-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e52578f2cd068fe0ff18d3e4ba7553602b7a5b1a55b30d8cd48428f836596f1"

URI_x86_64_v2_kdebugsettings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdebugsettings-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdebugsettings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdebugsettings}"
SRC_URI[x86_64_v2_kdebugsettings.sha256sum] = "8fc50fab61ff994f2358124bae517aa59b0a9c3bb820e0a91d20ac460fd909f0"

URI_aarch64_kdebugsettings = "${EPEL_MIRROR}/aarch64/Packages/k/kdebugsettings-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdebugsettings;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdebugsettings}"
SRC_URI[aarch64_kdebugsettings.sha256sum] = "1214de7b398c5f53729e286c7b2254facdbc72549afb419fd46a426870b02352"

RDEPENDS:kdebugsettings = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
