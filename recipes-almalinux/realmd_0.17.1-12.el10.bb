# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "realmd"
PV = "0.17.1"
PR = "12.el10"
PACKAGES = " \
 realmd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/realmd-0.17.1-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e88e320c3e2184fb0315d1a3ffaacf821ef30bd5dc656f4cda3b22acdd96dfc"

URI_x86_64_v2_realmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realmd-0.17.1-12.el10.x86_64_v2.rpm;name=x86_64_v2_realmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_realmd}"
SRC_URI[x86_64_v2_realmd.sha256sum] = "bd77b1d503a72c45ad0c6b7baeb49d4cd3839f9bb97e0ef88684d54cb5592372"

URI_aarch64_realmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realmd-0.17.1-12.el10.aarch64.rpm;name=aarch64_realmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_realmd}"
SRC_URI[aarch64_realmd.sha256sum] = "775f4e482c3e24182f94b134f4d370803de0c18e31003650182ce6b42b9dee0e"

RDEPENDS:realmd = " \
 authselect \
 bash \
 glib2 \
 glibc \
 krb5-libs \
 openldap \
 polkit \
 polkit-libs \
 systemd-libs \
 "
