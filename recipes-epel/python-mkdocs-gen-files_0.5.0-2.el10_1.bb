# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-gen-files"
PV = "0.5.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-mkdocs-gen-files \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-gen-files-0.5.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4732c965ddd4d566731f045299471364420c6937cc8e52403d376a39f1d3e843"

URI_x86_64_v2_python3-mkdocs-gen-files = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-gen-files-0.5.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-gen-files;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-gen-files}"
SRC_URI[x86_64_v2_python3-mkdocs-gen-files.sha256sum] = "6366e2189ba17a178872e620ea0562b66af787992ce13c9f23212691930d435e"

URI_aarch64_python3-mkdocs-gen-files = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-gen-files-0.5.0-2.el10_1.noarch.rpm;name=aarch64_python3-mkdocs-gen-files;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-gen-files}"
SRC_URI[aarch64_python3-mkdocs-gen-files.sha256sum] = "afee7a4ee6fd04785e71fe31c52b987de7d86c879b3705d4785c227af26b4b76"

RDEPENDS:python3-mkdocs-gen-files = " \
 mkdocs \
 python3 \
 "
