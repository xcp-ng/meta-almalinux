# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-http-query"
PV = "0.1.3"
PR = "11.el10_0"
PACKAGES = " \
 ghc-http-query \
 ghc-http-query-devel \
 ghc-http-query-doc \
 ghc-http-query-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-http-query-0.1.3-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff0addb831520864f91b8ea0adb0fee8a7b82e02de0575f748781b4371818428"

URI_x86_64_v2_ghc-http-query = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-query-0.1.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-query;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-query}"
SRC_URI[x86_64_v2_ghc-http-query.sha256sum] = "41e55e0d3051b1040b7a5b2a5dac0b12dd53786b59a0283c395c76636d030b56"

URI_x86_64_v2_ghc-http-query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-query-devel-0.1.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-query-devel}"
SRC_URI[x86_64_v2_ghc-http-query-devel.sha256sum] = "10a25e23d32120eb0c3edb40cfaa598a55ff6b1bf2d4fc5fdcaae46b8e739534"

URI_x86_64_v2_ghc-http-query-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-query-doc-0.1.3-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-http-query-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-query-doc}"
SRC_URI[x86_64_v2_ghc-http-query-doc.sha256sum] = "6b0ef800a4b5a5a1db735e778de39c1f836c949cc108eeb1626b0efb25a20943"

URI_x86_64_v2_ghc-http-query-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-query-prof-0.1.3-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-query-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-query-prof}"
SRC_URI[x86_64_v2_ghc-http-query-prof.sha256sum] = "20bc06128fbe7d3a3bcad52b0ae279faa6a0c153c73f81219d36ba3151c890eb"

URI_aarch64_ghc-http-query = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-query-0.1.3-11.el10_0.aarch64.rpm;name=aarch64_ghc-http-query;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-query}"
SRC_URI[aarch64_ghc-http-query.sha256sum] = "a2850f1a7d72d120ac3f97305bf9a7a6f95ff9930d7e6b29844f2bcc2d441831"

URI_aarch64_ghc-http-query-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-query-devel-0.1.3-11.el10_0.aarch64.rpm;name=aarch64_ghc-http-query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-query-devel}"
SRC_URI[aarch64_ghc-http-query-devel.sha256sum] = "cac1f31325441a85920bcdcae451a19f545911e3cb385a27abc5407ce3ccc83f"

URI_aarch64_ghc-http-query-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-query-doc-0.1.3-11.el10_0.noarch.rpm;name=aarch64_ghc-http-query-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-query-doc}"
SRC_URI[aarch64_ghc-http-query-doc.sha256sum] = "3c347a238bb3316215d09b6b2bc437ddca4a42a169d7cedfd41c85b910a710d9"

URI_aarch64_ghc-http-query-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-query-prof-0.1.3-11.el10_0.aarch64.rpm;name=aarch64_ghc-http-query-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-query-prof}"
SRC_URI[aarch64_ghc-http-query-prof.sha256sum] = "6efc9e2e4c9e615ca69ff9d97e61b0df93a66e3d05985337bb13edca106d0a12"

RDEPENDS:ghc-http-query = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-http-query-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-http-conduit-devel \
 ghc-http-query \
 ghc-network-uri-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-http-query-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-http-query-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-http-conduit-prof \
 ghc-http-query-devel \
 ghc-network-uri-prof \
 ghc-text-prof \
 "
