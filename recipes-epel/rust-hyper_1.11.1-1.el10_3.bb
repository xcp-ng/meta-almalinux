# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper"
PV = "1.11.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-hyper+capi-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+ffi-devel \
 rust-hyper+full-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper+tracing-devel \
 rust-hyper-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-1.11.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b0e2e06c6213d0333c54b5f621d6471b83492df0634df94688931d7f8a0e2311"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+capi-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+capi-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+capi-devel.sha256sum] = "14ceaa9de6697b53504ed19fc7d2a76b0d2c3bc80535e1a7ad3f4a54ab017ede"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+client-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+client-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+client-devel.sha256sum] = "19fe5440164e6e2a1363428feebdab3d6d158a6711936576a86b0ab1338d9c2b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+default-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+default-devel.sha256sum] = "99a9861f2652d3752ce9009f6d0fa78afb0efb1122fa004accddd020d459c4ee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+ffi-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+ffi-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+ffi-devel.sha256sum] = "7a985f6ea21bf571acd0c3e737649312737e3965c2dd0c0e10a7003631ec69c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+full-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+full-devel.sha256sum] = "07585d78894124a0c15bd09fbb6fcaac80d9214adf8b786015e9d9cc84daee92"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http1-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+http1-devel.sha256sum] = "b68d8cf5e70bda053e371900e4eecba18cca853a6c3cf5649eaf51b4c683e6e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http2-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+http2-devel.sha256sum] = "637271e0656e37610e7d8319f4f3c421cec27ec3fe3e8d0f05285202bda24417"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+server-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+server-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+server-devel.sha256sum] = "6bc8867551909cd0fd1077813822a46deeff87ce7878eb6cb41a42a30806e217"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+tracing-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper+tracing-devel.sha256sum] = "2db6db8fc26c6756a07db9f2c215a5bb6a819c50ee14cbdf188e218cf9fdee4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-devel-1.11.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hyper-devel.sha256sum] = "bf8e8131c5f4641f20e5cf77b2406bd9746893be2171420c3ceb2389d523f7f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+capi-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+capi-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+capi-devel.sha256sum] = "95152416239fe2d244951f0a6ef3cb3b105c25b011d9407238bac4f7fca771ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+client-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+client-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+client-devel.sha256sum] = "d671cbd53db65cb257281e46f68f41987e1c9966e774fc0636398a400eae24cd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+default-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+default-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+default-devel.sha256sum] = "e710842acead9cc67f786f79da9fda31b356c2c0a029cc172e4d7e626fade996"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+ffi-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+ffi-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+ffi-devel.sha256sum] = "37cfaf1609d0ebd5a82bc93895b0430ba820293179797070a209f16f1c4003fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+full-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+full-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+full-devel.sha256sum] = "0441c1d52a79b8c2ef961bb0dde81da402985373555af2fa256602e068bced33"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http1-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+http1-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+http1-devel.sha256sum] = "72e006ac1957a30c43f0b8c7e700848bc073bed6610601c7d9cf27c729ae9dc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http2-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+http2-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+http2-devel.sha256sum] = "7fb7d588514013d1d5d3453dcaeb871d85e2941ba6f9cd6b11645df706ef22ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+server-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+server-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+server-devel.sha256sum] = "de48fbc055be2220b07915c85cbdb31d9576853b8b47ba7c214a00e3ffe10935"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+tracing-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-hyper+tracing-devel.sha256sum] = "be52e7b4ea06eff93bb19143b544d1212b82f84551931ef67378475f24217194"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-devel-1.11.1-1.el10_3.noarch.rpm;name=aarch64_rust-hyper-devel;unpack=0"
SRC_URI[aarch64_rust-hyper-devel.sha256sum] = "a3bc7b6bf2ca1616298cafb72f0bad61ec03a2551af38abdfd6e58d32645f933"

RDEPENDS:rust-hyper+capi-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+client-devel = " \
 cargo \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-want+default-devel \
 "
RDEPENDS:rust-hyper+default-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+ffi-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body-util+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+full-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+http1-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-httparse+default-devel \
 rust-hyper-devel \
 rust-itoa+default-devel \
 "
RDEPENDS:rust-hyper+http2-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-h2+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+server-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-hyper+tracing-devel = " \
 cargo \
 rust-hyper-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
