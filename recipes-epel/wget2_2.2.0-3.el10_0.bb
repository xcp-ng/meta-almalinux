# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wget2"
PV = "2.2.0"
PR = "3.el10_0"
PACKAGES = " \
 wget2 \
 wget2-devel \
 wget2-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wget2-2.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab802bab0ea6ec658527c453f17a9253cf7213064ffdfa22deaee836d6d8a3af"

URI_x86_64_v2_wget2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wget2-2.2.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wget2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wget2}"
SRC_URI[x86_64_v2_wget2.sha256sum] = "15cea4dfd06177ecd968a5b865327e9eca9b16eed9d1dcbd72829a8dec0126ee"

URI_x86_64_v2_wget2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wget2-devel-2.2.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wget2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wget2-devel}"
SRC_URI[x86_64_v2_wget2-devel.sha256sum] = "603fa0c2afc742cfb24be7114a60e278803d805f659cb8dd27a7cac64afc9190"

URI_x86_64_v2_wget2-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wget2-libs-2.2.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wget2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wget2-libs}"
SRC_URI[x86_64_v2_wget2-libs.sha256sum] = "e33a403c1b4ea138072353b38db646af15cccc80e466ea402df54a487b7e216c"

URI_aarch64_wget2 = "${EPEL_MIRROR}/aarch64/Packages/w/wget2-2.2.0-3.el10_0.aarch64.rpm;name=aarch64_wget2;unpack=0"
SRC_URI:append = " ${URI_aarch64_wget2}"
SRC_URI[aarch64_wget2.sha256sum] = "b28bf436bd257f7887cf3df5254b488cc3e87b02f8cd9dceb0f2deddafb003f5"

URI_aarch64_wget2-devel = "${EPEL_MIRROR}/aarch64/Packages/w/wget2-devel-2.2.0-3.el10_0.aarch64.rpm;name=aarch64_wget2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wget2-devel}"
SRC_URI[aarch64_wget2-devel.sha256sum] = "e332ebd62319fdc2a4ebc19d9e7ada4e8224b7bc538f68f107b553aea52498be"

URI_aarch64_wget2-libs = "${EPEL_MIRROR}/aarch64/Packages/w/wget2-libs-2.2.0-3.el10_0.aarch64.rpm;name=aarch64_wget2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_wget2-libs}"
SRC_URI[aarch64_wget2-libs.sha256sum] = "7179ebe88df19c19a6eb9a36737a95da848e7a43b5eea30282e757991a8d49eb"

RDEPENDS:wget2 = " \
 glibc \
 gpgme \
 pcre2 \
 wget2-libs \
 "
RDEPENDS:wget2-devel = " \
 pkgconf-pkg-config \
 wget2-libs \
 "
RDEPENDS:wget2-libs = " \
 glibc \
 gnutls \
 gnutls-dane \
 gpgme \
 libbrotli \
 libidn2 \
 libnghttp2 \
 libpsl \
 libzstd \
 pcre2 \
 zlib-ng-compat \
 "
