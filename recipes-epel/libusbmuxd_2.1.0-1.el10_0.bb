# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libusbmuxd"
PV = "2.1.0"
PR = "1.el10_0"
PACKAGES = " \
 libusbmuxd \
 libusbmuxd-devel \
 libusbmuxd-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libusbmuxd-2.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65644c9d9e0d282fef00299eb1e26898d8a55bf6b04b88f40626c0e6147a6633"

URI_x86_64_v2_libusbmuxd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusbmuxd-2.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusbmuxd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusbmuxd}"
SRC_URI[x86_64_v2_libusbmuxd.sha256sum] = "800d0c4a786d0444a59caca324a97df2ebe4394015e63ace8f4f6954f229c9dc"

URI_x86_64_v2_libusbmuxd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusbmuxd-devel-2.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusbmuxd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusbmuxd-devel}"
SRC_URI[x86_64_v2_libusbmuxd-devel.sha256sum] = "df6f31d5a5ea1b90a2a7ea04308a4bd279c10a8e1df67d2f57378b8dc0a8a0b5"

URI_x86_64_v2_libusbmuxd-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusbmuxd-utils-2.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusbmuxd-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusbmuxd-utils}"
SRC_URI[x86_64_v2_libusbmuxd-utils.sha256sum] = "fb54d9b42fa43c481d5ad82e241fd42cd91808f9740384713af6c11b25d0b5ab"

URI_aarch64_libusbmuxd = "${EPEL_MIRROR}/aarch64/Packages/l/libusbmuxd-2.1.0-1.el10_0.aarch64.rpm;name=aarch64_libusbmuxd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusbmuxd}"
SRC_URI[aarch64_libusbmuxd.sha256sum] = "53325e61659e22592f1489c3b9ce3d502561493ee1296536022aae3f07a88df1"

URI_aarch64_libusbmuxd-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libusbmuxd-devel-2.1.0-1.el10_0.aarch64.rpm;name=aarch64_libusbmuxd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusbmuxd-devel}"
SRC_URI[aarch64_libusbmuxd-devel.sha256sum] = "1a00cef03a809cf2494ea804653f760c0839be35cec41b22809da1c6fb3b43f8"

URI_aarch64_libusbmuxd-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libusbmuxd-utils-2.1.0-1.el10_0.aarch64.rpm;name=aarch64_libusbmuxd-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusbmuxd-utils}"
SRC_URI[aarch64_libusbmuxd-utils.sha256sum] = "ad09a47b25ec5236884fa3aac34b342aa2e7075da40e7b28c0f3032ce0a7bf8f"

RDEPENDS:libusbmuxd = " \
 glibc \
 libgcc \
 libimobiledevice-glue \
 libplist \
 "
RDEPENDS:libusbmuxd-devel = " \
 libimobiledevice-glue-devel \
 libplist-devel \
 libusbmuxd \
 pkgconf-pkg-config \
 "
RDEPENDS:libusbmuxd-utils = " \
 glibc \
 libimobiledevice-glue \
 libusbmuxd \
 "
