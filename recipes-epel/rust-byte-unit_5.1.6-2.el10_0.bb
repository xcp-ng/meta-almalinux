# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-byte-unit"
PV = "5.1.6"
PR = "2.el10_0"
PACKAGES = " \
 rust-byte-unit+bit-devel \
 rust-byte-unit+byte-devel \
 rust-byte-unit+default-devel \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit+serde-devel \
 rust-byte-unit+std-devel \
 rust-byte-unit+u128-devel \
 rust-byte-unit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-byte-unit-5.1.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d424a046ce422776aa1218329e1aedaae5324cadf111b21ab0d76d2b021c7167"

URI_x86_64_v2_rust-byte-unit+bit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+bit-devel-5.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+bit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+bit-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+bit-devel.sha256sum] = "5be34af92a49b4e9c79fdd6808b9e851a64138390bbcd3c114cf479452b66902"

URI_x86_64_v2_rust-byte-unit+byte-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+byte-devel-5.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+byte-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+byte-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+byte-devel.sha256sum] = "01001bce2f5d8b1fc99ce7ac2894f1f94570ac19b6cc57692f05539d43a2c8c4"

URI_x86_64_v2_rust-byte-unit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+default-devel-5.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+default-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+default-devel.sha256sum] = "37b84ad351c67b3121e45eceeac21a5bf2aac29a20880f318188aa824004ba0b"

URI_x86_64_v2_rust-byte-unit+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+rust_decimal-devel-5.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+rust_decimal-devel.sha256sum] = "d78bf3ac94dc17ad5054e05636ffb2a4b84c4eacee940d1da66ab7a8333c38dd"

URI_x86_64_v2_rust-byte-unit+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+serde-devel-5.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+serde-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+serde-devel.sha256sum] = "527591517248a9625e0175add66a2e9c6622345358fb356338c7fe9f90239fc9"

URI_x86_64_v2_rust-byte-unit+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+std-devel-5.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+std-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+std-devel.sha256sum] = "fb3ec96573683c8a158b304a208a83b4a542ee10ebdb1b6a3ab0ae412cdcb1be"

URI_x86_64_v2_rust-byte-unit+u128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit+u128-devel-5.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit+u128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit+u128-devel}"
SRC_URI[x86_64_v2_rust-byte-unit+u128-devel.sha256sum] = "080504bb54221a25f9906bccd23fe3c4b1b705486abe6c2ed153ea671ac4cd3f"

URI_x86_64_v2_rust-byte-unit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byte-unit-devel-5.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byte-unit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-byte-unit-devel}"
SRC_URI[x86_64_v2_rust-byte-unit-devel.sha256sum] = "dee035871dccfc5066ffb29ea72cac64c3db1f56c0e2aba7bd1a378cbb9cbdce"

URI_aarch64_rust-byte-unit+bit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+bit-devel-5.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-byte-unit+bit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+bit-devel}"
SRC_URI[aarch64_rust-byte-unit+bit-devel.sha256sum] = "85043575ae93a9d8de6b75cf859dcc507fd6e101abf2b1cbde728ac6b388ca30"

URI_aarch64_rust-byte-unit+byte-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+byte-devel-5.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-byte-unit+byte-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+byte-devel}"
SRC_URI[aarch64_rust-byte-unit+byte-devel.sha256sum] = "e170000278ddf8064af9b8c9ad1e7a46078fd52fcec28abeaeb44f8ddf4132ce"

URI_aarch64_rust-byte-unit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+default-devel-5.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-byte-unit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+default-devel}"
SRC_URI[aarch64_rust-byte-unit+default-devel.sha256sum] = "0bf2d0d64205d8c7603ef0fa9a88a16bd12aab66be15ce70cd8cfb7c978a5fd2"

URI_aarch64_rust-byte-unit+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+rust_decimal-devel-5.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-byte-unit+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+rust_decimal-devel}"
SRC_URI[aarch64_rust-byte-unit+rust_decimal-devel.sha256sum] = "9e7aa2a276f9f92d801aa1907bf25606b23425f53eb19c88a2e3f6a6f6bd7ef6"

URI_aarch64_rust-byte-unit+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+serde-devel-5.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-byte-unit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+serde-devel}"
SRC_URI[aarch64_rust-byte-unit+serde-devel.sha256sum] = "0330d60eb2d4bcefa44424b09e386b3c362afefe188d15cf54eafb2e23dccea7"

URI_aarch64_rust-byte-unit+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+std-devel-5.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-byte-unit+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+std-devel}"
SRC_URI[aarch64_rust-byte-unit+std-devel.sha256sum] = "957e5052bd3469ef4b5a7d0bcc693b8da8cb35868641343e887bcb69212174d1"

URI_aarch64_rust-byte-unit+u128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit+u128-devel-5.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-byte-unit+u128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit+u128-devel}"
SRC_URI[aarch64_rust-byte-unit+u128-devel.sha256sum] = "c2b0b6e6a41972f504f5be047c2a6a2d1384a1001a0dd1aecf0fa1bdd0b080dd"

URI_aarch64_rust-byte-unit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-byte-unit-devel-5.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-byte-unit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-byte-unit-devel}"
SRC_URI[aarch64_rust-byte-unit-devel.sha256sum] = "1929c6cda1e3509bf79bd3694114dcca9d07c853910b9e2c0f84dce97a344c6b"

RDEPENDS:rust-byte-unit+bit-devel = " \
 cargo \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+byte-devel = " \
 cargo \
 rust-byte-unit+rust_decimal-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+default-devel = " \
 cargo \
 rust-byte-unit+byte-devel \
 rust-byte-unit+std-devel \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit+rust_decimal-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-byte-unit+serde-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-byte-unit+std-devel = " \
 cargo \
 rust-byte-unit-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-byte-unit+u128-devel = " \
 cargo \
 rust-byte-unit-devel \
 "
RDEPENDS:rust-byte-unit-devel = " \
 cargo \
 rust \
 rust-utf8-width+default-devel \
 "
