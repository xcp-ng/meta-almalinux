# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zvariant_utils"
PV = "3.5.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-zvariant_utils+default-devel \
 rust-zvariant_utils+gvariant-devel \
 rust-zvariant_utils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zvariant_utils-3.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "108d36318f8b351ba07d45b4e69f845f3395b52bb430ada39841cc1997e9a48b"

URI_x86_64_v2_rust-zvariant_utils+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_utils+default-devel-3.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_utils+default-devel}"
SRC_URI[x86_64_v2_rust-zvariant_utils+default-devel.sha256sum] = "1e4e6a860f4a6bb716ecdade52bcb4f79ac5ea963c08fd2fea434d64c2c41d77"

URI_x86_64_v2_rust-zvariant_utils+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_utils+gvariant-devel-3.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_utils+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_utils+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant_utils+gvariant-devel.sha256sum] = "125f2b63e5fe6712f62dc391162e49fda8189af810b12742532a180d81ad3b77"

URI_x86_64_v2_rust-zvariant_utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_utils-devel-3.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_utils-devel}"
SRC_URI[x86_64_v2_rust-zvariant_utils-devel.sha256sum] = "2d0964ee8dc287b55b716a6ade290ef5f254da9f4d80b356a446ce5a86a18661"

URI_aarch64_rust-zvariant_utils+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_utils+default-devel-3.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant_utils+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_utils+default-devel}"
SRC_URI[aarch64_rust-zvariant_utils+default-devel.sha256sum] = "d3bd48b45a3a64303e3d9e3482fd5bc7236a8bae1d35d834a5be615162310bb7"

URI_aarch64_rust-zvariant_utils+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_utils+gvariant-devel-3.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant_utils+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_utils+gvariant-devel}"
SRC_URI[aarch64_rust-zvariant_utils+gvariant-devel.sha256sum] = "23a5ecbc3a6ff26db00a1f545583466b23c10b99aa2153e697cf575c308f87ac"

URI_aarch64_rust-zvariant_utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_utils-devel-3.5.0-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant_utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_utils-devel}"
SRC_URI[aarch64_rust-zvariant_utils-devel.sha256sum] = "4d3be86f7f1f44d918d9cb4e7c609d7dd8816e2ec327d259241838fe41613527"

RDEPENDS:rust-zvariant_utils+default-devel = " \
 cargo \
 rust-zvariant_utils-devel \
 "
RDEPENDS:rust-zvariant_utils+gvariant-devel = " \
 cargo \
 rust-zvariant_utils-devel \
 "
RDEPENDS:rust-zvariant_utils-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-winnow+default-devel \
 "
