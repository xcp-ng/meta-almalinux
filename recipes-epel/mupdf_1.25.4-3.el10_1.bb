# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mupdf"
PV = "1.25.4"
PR = "3.el10_1"
PACKAGES = " \
 mupdf \
 mupdf-cpp-devel \
 mupdf-cpp-libs \
 mupdf-devel \
 mupdf-libs \
 python3-mupdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mupdf-1.25.4-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f871de9ef6443121e14565ec46ff82e5a8e6baea6ab34f6e14b4d0d14fffea16"

URI_x86_64_v2_mupdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-1.25.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf}"
SRC_URI[x86_64_v2_mupdf.sha256sum] = "215a260b61f66ca3bbe63bbb48249300b15d62e905bd5df6731f1ba744bc99d0"

URI_x86_64_v2_mupdf-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-cpp-devel-1.25.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-cpp-devel}"
SRC_URI[x86_64_v2_mupdf-cpp-devel.sha256sum] = "047e2d41a8d465fa799ca92c96be29b4bd233c8982316f68962a370c1e9e4d7b"

URI_x86_64_v2_mupdf-cpp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-cpp-libs-1.25.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-cpp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-cpp-libs}"
SRC_URI[x86_64_v2_mupdf-cpp-libs.sha256sum] = "8c8c284302dfbc8e0a795a65a2423e70d72fcbfb1631469f272ebf4add94e826"

URI_x86_64_v2_mupdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-devel-1.25.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-devel}"
SRC_URI[x86_64_v2_mupdf-devel.sha256sum] = "6bbc09f66e2c18389d6565e2e6e8dfd521315c0b846496834d523432b20e79cc"

URI_x86_64_v2_mupdf-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-libs-1.25.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-libs}"
SRC_URI[x86_64_v2_mupdf-libs.sha256sum] = "6f6c67557d7685b0c3a970b0b34ca954945bc3dad9633d49f430881a7719509a"

URI_x86_64_v2_python3-mupdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mupdf-1.25.4-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-mupdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mupdf}"
SRC_URI[x86_64_v2_python3-mupdf.sha256sum] = "3838be2ca8c9fad37d0527099dd42fc52e4b54939c688dd3fe45872ab6d2ff99"

URI_aarch64_mupdf = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-1.25.4-3.el10_1.aarch64.rpm;name=aarch64_mupdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf}"
SRC_URI[aarch64_mupdf.sha256sum] = "a3cb0ac9e37a98dd75716e22ad9bc1a283d4ff00b26cf79eed2507a666cd8904"

URI_aarch64_mupdf-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-cpp-devel-1.25.4-3.el10_1.aarch64.rpm;name=aarch64_mupdf-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-cpp-devel}"
SRC_URI[aarch64_mupdf-cpp-devel.sha256sum] = "b8acca2c9f5027c6c51d972e093056478b69506986ba74449dbcadeecf53954b"

URI_aarch64_mupdf-cpp-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-cpp-libs-1.25.4-3.el10_1.aarch64.rpm;name=aarch64_mupdf-cpp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-cpp-libs}"
SRC_URI[aarch64_mupdf-cpp-libs.sha256sum] = "0878529d4d5ac43501e3e483e7eb6b96a0230143a661ed6b9c57e51069490469"

URI_aarch64_mupdf-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-devel-1.25.4-3.el10_1.aarch64.rpm;name=aarch64_mupdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-devel}"
SRC_URI[aarch64_mupdf-devel.sha256sum] = "c6a0fbb652a95e0dc6df5775ca38e4ebfa13bda29ccdf1705a0707135bf720cc"

URI_aarch64_mupdf-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-libs-1.25.4-3.el10_1.aarch64.rpm;name=aarch64_mupdf-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-libs}"
SRC_URI[aarch64_mupdf-libs.sha256sum] = "b389be584ef5cd10eec51617ae0b5b6434aedc4f72179dfd5e01d9525d82cea2"

URI_aarch64_python3-mupdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mupdf-1.25.4-3.el10_1.aarch64.rpm;name=aarch64_python3-mupdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mupdf}"
SRC_URI[aarch64_python3-mupdf.sha256sum] = "dc4d13c156a0fff16cfdebfd64b7b99af0908e66ba9450730fe0c195597cda65"

RDEPENDS:mupdf = " \
 freeglut \
 glibc \
 libX11 \
 libXext \
 libglvnd-glx \
 mupdf-libs \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:mupdf-cpp-devel = " \
 mupdf-cpp-libs \
 "
RDEPENDS:mupdf-cpp-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 mupdf-libs \
 "
RDEPENDS:mupdf-devel = " \
 mupdf-libs \
 "
RDEPENDS:mupdf-libs = " \
 freetype \
 glibc \
 gumbo-parser \
 harfbuzz \
 jbig2dec-libs \
 leptonica \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 openjpeg2 \
 tesseract \
 zlib-ng-compat \
 "
RDEPENDS:python3-mupdf = " \
 glibc \
 libgcc \
 libstdc++ \
 mupdf-cpp-libs \
 mupdf-libs \
 python3 \
 "
