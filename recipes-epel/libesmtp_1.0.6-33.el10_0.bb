# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libesmtp"
PV = "1.0.6"
PR = "33.el10_0"
PACKAGES = " \
 libesmtp \
 libesmtp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libesmtp-1.0.6-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13914d8320f8fd3423662a73a4319d62e93511f0f446f52659b15c365217286e"

URI_x86_64_v2_libesmtp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libesmtp-1.0.6-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libesmtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libesmtp}"
SRC_URI[x86_64_v2_libesmtp.sha256sum] = "ee1acfc605f9bbb8cc69fe47b2c843f6c811edef5b3810716790ba14b2a3414a"

URI_x86_64_v2_libesmtp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libesmtp-devel-1.0.6-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libesmtp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libesmtp-devel}"
SRC_URI[x86_64_v2_libesmtp-devel.sha256sum] = "6a122b1c10b873f2e797e4e3a3c6e22217852b69755f96b6f011f9c723bb7ddd"

URI_aarch64_libesmtp = "${EPEL_MIRROR}/aarch64/Packages/l/libesmtp-1.0.6-33.el10_0.aarch64.rpm;name=aarch64_libesmtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libesmtp}"
SRC_URI[aarch64_libesmtp.sha256sum] = "9ec22e5f79fa89e1454c8396016e20e93b245e2b9d0e1ad739ce5b77b625abc9"

URI_aarch64_libesmtp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libesmtp-devel-1.0.6-33.el10_0.aarch64.rpm;name=aarch64_libesmtp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libesmtp-devel}"
SRC_URI[aarch64_libesmtp-devel.sha256sum] = "3db09f6efb4c1c9678eaf37f9a73a2bed576f836fa28a4ebdeefe8164d0e1fde"

RDEPENDS:libesmtp = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:libesmtp-devel = " \
 bash \
 libesmtp \
 openssl-devel \
 pkgconf-pkg-config \
 "
