# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-java"
PV = "0.23.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-java+default-devel \
 rust-tree-sitter-java-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-java-0.23.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87d37890de25c152519bcf101e5b83891756d66145063d6143958c19b11b3000"

URI_x86_64_v2_rust-tree-sitter-java+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-java+default-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-java+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-java+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-java+default-devel.sha256sum] = "2e71369ce6fb19df834c9b10faa7a5916a97d3417fc3e36430290a0c72776e3c"

URI_x86_64_v2_rust-tree-sitter-java-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-java-devel-0.23.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-java-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-java-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-java-devel.sha256sum] = "720c38099f30a30ef6f7a0b6fd1079f69cbe0e879e7e806bf5bcd4883a5bc58b"

URI_aarch64_rust-tree-sitter-java+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-java+default-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-java+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-java+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-java+default-devel.sha256sum] = "297f7d44b876608c5cdb578151b1c9baa2175f079730eb28488172a642c20eda"

URI_aarch64_rust-tree-sitter-java-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-java-devel-0.23.5-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-java-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-java-devel}"
SRC_URI[aarch64_rust-tree-sitter-java-devel.sha256sum] = "2db1295a2767c4d583e417022f67034e76dcd289552b49228bfd3db84f5c85ef"

RDEPENDS:rust-tree-sitter-java+default-devel = " \
 cargo \
 rust-tree-sitter-java-devel \
 "
RDEPENDS:rust-tree-sitter-java-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
