# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-netifaces"
PV = "0.11.0"
PR = "16.el10_2"
PACKAGES = " \
 python3-netifaces \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-netifaces-0.11.0-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f72b6e57703f7edf8f8ddce252c1373b4acb43b0798315b55078afd7bcfda3c8"

URI_x86_64_v2_python3-netifaces = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-netifaces-0.11.0-16.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-netifaces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-netifaces}"
SRC_URI[x86_64_v2_python3-netifaces.sha256sum] = "2a6d7f41e1bd7ed6eea26855bc9ded2945c6c1b4a2f25d05f822286793467cd7"

URI_aarch64_python3-netifaces = "${EPEL_MIRROR}/aarch64/Packages/p/python3-netifaces-0.11.0-16.el10_2.aarch64.rpm;name=aarch64_python3-netifaces;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-netifaces}"
SRC_URI[aarch64_python3-netifaces.sha256sum] = "839824968824dcb99184ef97a2d79655cad63b3fd788213d67f903c52f5523f9"

RDEPENDS:python3-netifaces = " \
 glibc \
 python3 \
 "
