# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatengine"
PV = "1.9.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qatengine \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatengine-1.9.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4dbf2b8427db40a8b36b5424e4b4d4a8eef16e61fbbf383b28d3358d529f448"

URI_x86_64_v2_qatengine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatengine-1.9.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatengine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatengine}"
SRC_URI[x86_64_v2_qatengine.sha256sum] = "7ec53409a2cd57c0caf1729f43d381396dbbf287dd2da7a24b248ea2f0917bef"

RDEPENDS:qatengine = " \
 glibc \
 qatlib \
 "
