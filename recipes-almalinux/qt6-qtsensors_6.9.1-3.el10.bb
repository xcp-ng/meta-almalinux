# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtsensors"
PV = "6.9.1"
PR = "3.el10"
PACKAGES = " \
 qt6-qtsensors \
 qt6-qtsensors-devel \
 qt6-qtsensors-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtsensors-6.9.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49d91776f310bb99ca5154aee6b79d721ab6ad1a3615f3da3cb8644e885a8436"

URI_x86_64_v2_qt6-qtsensors = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsensors-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsensors}"
SRC_URI[x86_64_v2_qt6-qtsensors.sha256sum] = "c2d3aa72a41c98265863153e647880052ddf7dbd2b992189b0f2da59e6fadc4e"

URI_x86_64_v2_qt6-qtsensors-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtsensors-devel-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsensors-devel}"
SRC_URI[x86_64_v2_qt6-qtsensors-devel.sha256sum] = "a1420fa6a598eef61c21f426b4f4c7e44f141b6cea268556b70c37c5a6738191"

URI_x86_64_v2_qt6-qtsensors-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtsensors-examples-6.9.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtsensors-examples}"
SRC_URI[x86_64_v2_qt6-qtsensors-examples.sha256sum] = "20d3b6802cf6baf646d2b6bfa7d0afbeb5016f065f6622cb8d79823c29ef36e4"

URI_aarch64_qt6-qtsensors = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsensors-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtsensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsensors}"
SRC_URI[aarch64_qt6-qtsensors.sha256sum] = "c96d879117769a74163c15e561db0076c9d10c110b84b5d8a2cc82df1286a0b1"

URI_aarch64_qt6-qtsensors-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtsensors-devel-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsensors-devel}"
SRC_URI[aarch64_qt6-qtsensors-devel.sha256sum] = "68dc5a7a24628f7d42ad456cf541b65fa8f22b32940d8b46c6febd21a57b43fe"

URI_aarch64_qt6-qtsensors-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtsensors-examples-6.9.1-3.el10.aarch64.rpm;name=aarch64_qt6-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtsensors-examples}"
SRC_URI[aarch64_qt6-qtsensors-examples.sha256sum] = "2ec3758e3279def87eea8f75ddbc49b3828e7797a763dfcacded49c76ebd9784"

RDEPENDS:qt6-qtsensors = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtsensors-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtsensors \
 qt6-qtsensors-devel \
 "
RDEPENDS:qt6-qtsensors-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 "
