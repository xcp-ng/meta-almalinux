# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger0.8"
PV = "0.8.4"
PR = "13.el10_1"
PACKAGES = " \
 rust-env_logger0.8+atty-devel \
 rust-env_logger0.8+default-devel \
 rust-env_logger0.8+humantime-devel \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8+termcolor-devel \
 rust-env_logger0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger0.8-0.8.4-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae3ae2dbcbd77a3aa1ddfc272b52fc363ceaee62db760800f369b18aac907f41"

URI_x86_64_v2_rust-env_logger0.8+atty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+atty-devel-0.8.4-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+atty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+atty-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+atty-devel.sha256sum] = "e310482b881155b5a024d3a043ed23750eb239b78422c4a6ce6fd291008cef16"

URI_x86_64_v2_rust-env_logger0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+default-devel-0.8.4-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+default-devel.sha256sum] = "2dbb6db8d0ee6e638382eef41bd870e8726a3d7c0c50aeed9f50a44fcdf0fc21"

URI_x86_64_v2_rust-env_logger0.8+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+humantime-devel-0.8.4-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+humantime-devel.sha256sum] = "79db17230121229299f1c7c92fec29c6fb8615c02b5d488d2ea75960d917ca6b"

URI_x86_64_v2_rust-env_logger0.8+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+regex-devel-0.8.4-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+regex-devel.sha256sum] = "c7e9d19bdae87f94bfde31390399bf38757450b568caf24d46ed711687aa32b1"

URI_x86_64_v2_rust-env_logger0.8+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8+termcolor-devel-0.8.4-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8+termcolor-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8+termcolor-devel.sha256sum] = "577bda8a1c869ebf89e59a3f4f0ffdee2b57e172b546636de0bb798042406e77"

URI_x86_64_v2_rust-env_logger0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger0.8-devel-0.8.4-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger0.8-devel}"
SRC_URI[x86_64_v2_rust-env_logger0.8-devel.sha256sum] = "a3c762ef5ea5de87a7573042755704346f112e9cc076b9c25112b1379e41910e"
RPROVIDES:rust-env_logger0.8-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger0.8+atty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+atty-devel-0.8.4-13.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.8+atty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+atty-devel}"
SRC_URI[aarch64_rust-env_logger0.8+atty-devel.sha256sum] = "9bcfd2d5bb290c1c206a0e0c91446f29988801a64efbce0b7a61c7aed867ecea"

URI_aarch64_rust-env_logger0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+default-devel-0.8.4-13.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+default-devel}"
SRC_URI[aarch64_rust-env_logger0.8+default-devel.sha256sum] = "70ced77a795464b8fa6e4be1cce20de58547ed8ad2cdf63fa4084b901002a029"

URI_aarch64_rust-env_logger0.8+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+humantime-devel-0.8.4-13.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.8+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+humantime-devel}"
SRC_URI[aarch64_rust-env_logger0.8+humantime-devel.sha256sum] = "75c1ba2c664903259e2c51acd140385920e6243e6d25d325cdc033fb9e695181"

URI_aarch64_rust-env_logger0.8+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+regex-devel-0.8.4-13.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.8+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+regex-devel}"
SRC_URI[aarch64_rust-env_logger0.8+regex-devel.sha256sum] = "80479e248f3ff1578b5fd75fcb0793630869a50a6bc8909863fec4a7e394a1f3"

URI_aarch64_rust-env_logger0.8+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8+termcolor-devel-0.8.4-13.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.8+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8+termcolor-devel}"
SRC_URI[aarch64_rust-env_logger0.8+termcolor-devel.sha256sum] = "df504884e9ae041f3f40da9e6779d29f2be90cfd4e11994db380ab63e0431768"

URI_aarch64_rust-env_logger0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger0.8-devel-0.8.4-13.el10_1.noarch.rpm;name=aarch64_rust-env_logger0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger0.8-devel}"
SRC_URI[aarch64_rust-env_logger0.8-devel.sha256sum] = "1c9d11c2bcdba4ab636c8c73f7d8a68e4b5d1f3d080adfba5ff5c2b8f5bb5816"
RPROVIDES:rust-env_logger0.8-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger0.8+atty-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 "
RDEPENDS:rust-env_logger0.8+default-devel = " \
 cargo \
 rust-env_logger0.8+atty-devel \
 rust-env_logger0.8+humantime-devel \
 rust-env_logger0.8+regex-devel \
 rust-env_logger0.8+termcolor-devel \
 rust-env_logger0.8-devel \
 "
RDEPENDS:rust-env_logger0.8+humantime-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-humantime+default-devel \
 "
RDEPENDS:rust-env_logger0.8+regex-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_logger0.8+termcolor-devel = " \
 cargo \
 rust-env_logger0.8-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-env_logger0.8-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
