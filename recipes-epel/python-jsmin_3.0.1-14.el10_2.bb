# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsmin"
PV = "3.0.1"
PR = "14.el10_2"
PACKAGES = " \
 python3-jsmin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsmin-3.0.1-14.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1feb200e2a0050bd7bddcc90432f3f24febe281544566e6b492647a44250832d"

URI_x86_64_v2_python3-jsmin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsmin-3.0.1-14.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsmin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsmin}"
SRC_URI[x86_64_v2_python3-jsmin.sha256sum] = "6969ea05332fd67abfe91f072c5a4ea2d6efbb57385040641b244d2e04bc5aa6"

URI_aarch64_python3-jsmin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsmin-3.0.1-14.el10_2.noarch.rpm;name=aarch64_python3-jsmin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsmin}"
SRC_URI[aarch64_python3-jsmin.sha256sum] = "7fc7dd2c8ff2b39326d57078a27899b7b8b82d6a7999ed85495105e8975f31ef"

RDEPENDS:python3-jsmin = " \
 python3 \
 "
