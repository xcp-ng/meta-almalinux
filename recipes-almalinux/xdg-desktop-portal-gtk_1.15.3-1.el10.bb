# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-desktop-portal-gtk"
PV = "1.15.3"
PR = "1.el10"
PACKAGES = " \
 xdg-desktop-portal-gtk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdg-desktop-portal-gtk-1.15.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aebec08dae9da6570d6ea86f8705e912430a10521df99ef246f93eb9874843f2"

URI_x86_64_v2_xdg-desktop-portal-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdg-desktop-portal-gtk-1.15.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_xdg-desktop-portal-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-desktop-portal-gtk}"
SRC_URI[x86_64_v2_xdg-desktop-portal-gtk.sha256sum] = "6fa802616e0a8ee3ecd7f0c69ae578b4fb183b0465d1344e8d2ab118f066919e"

URI_aarch64_xdg-desktop-portal-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdg-desktop-portal-gtk-1.15.3-1.el10.aarch64.rpm;name=aarch64_xdg-desktop-portal-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-desktop-portal-gtk}"
SRC_URI[aarch64_xdg-desktop-portal-gtk.sha256sum] = "69c0a935b8828b165c703157e505d5e8bafe657669449337deb90baeaa75ceca"

RDEPENDS:xdg-desktop-portal-gtk = " \
 bash \
 dbus \
 fontconfig \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gsettings-desktop-schemas \
 gtk3 \
 libgcc \
 xdg-desktop-portal \
 "
