# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yq"
PV = "4.47.1"
PR = "2.el10_1"
PACKAGES = " \
 yq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yq-4.47.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce4a3c3dc1172d3d275c6d9f52313eae3a0c66d784114a70864f0b90eb2db6bf"

URI_x86_64_v2_yq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yq-4.47.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yq}"
SRC_URI[x86_64_v2_yq.sha256sum] = "1d91d8ad9d54bb21dcf3ba3d182e138ae1971838d3425cf9fb771ffce77c8565"

URI_aarch64_yq = "${EPEL_MIRROR}/aarch64/Packages/y/yq-4.47.1-2.el10_1.aarch64.rpm;name=aarch64_yq;unpack=0"
SRC_URI:append = " ${URI_aarch64_yq}"
SRC_URI[aarch64_yq.sha256sum] = "eceef8cb33e2dedc1913ff400f9e725d51c9a7910eb4789eefe25119dad45b2e"

RDEPENDS:yq = " \
 glibc \
 "
