# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-stackbuild-plugin"
PV = "1.0.11"
PR = "1.el10_1"
PACKAGES = " \
 kiwi-stackbuild-plugin \
 python3-kiwi-stackbuild-plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiwi-stackbuild-plugin-1.0.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b6f85ea5319234f798854c20566ffce4f1361a086b9565bbbb7b26b30e8c38b"

URI_x86_64_v2_kiwi-stackbuild-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-stackbuild-plugin-1.0.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-stackbuild-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-stackbuild-plugin}"
SRC_URI[x86_64_v2_kiwi-stackbuild-plugin.sha256sum] = "4df331fcb55463242afeca9193a2c08a652c662a456b25ef16da4fb0e88320c1"

URI_x86_64_v2_python3-kiwi-stackbuild-plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-stackbuild-plugin-1.0.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-stackbuild-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kiwi-stackbuild-plugin}"
SRC_URI[x86_64_v2_python3-kiwi-stackbuild-plugin.sha256sum] = "12c29a0415c941ace70b45b4a9b861e05f8ae5c0f74dc8550a568619d96d14e9"

URI_aarch64_kiwi-stackbuild-plugin = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-stackbuild-plugin-1.0.11-1.el10_1.noarch.rpm;name=aarch64_kiwi-stackbuild-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-stackbuild-plugin}"
SRC_URI[aarch64_kiwi-stackbuild-plugin.sha256sum] = "add9c4d34ad8164016fbd19430daa9948e1125757b066c367d24e88d441d6068"

URI_aarch64_python3-kiwi-stackbuild-plugin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-stackbuild-plugin-1.0.11-1.el10_1.noarch.rpm;name=aarch64_python3-kiwi-stackbuild-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kiwi-stackbuild-plugin}"
SRC_URI[aarch64_python3-kiwi-stackbuild-plugin.sha256sum] = "79855eac36f350777ef87dff9c1ae6f355ffc1b0a6774bc97bd321654ecb2292"

RDEPENDS:kiwi-stackbuild-plugin = " \
 python3-kiwi-stackbuild-plugin \
 "
RDEPENDS:python3-kiwi-stackbuild-plugin = " \
 kiwi-systemdeps-containers \
 python3 \
 python3-docopt-ng \
 python3-kiwi \
 "
