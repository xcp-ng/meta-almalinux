# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syncthing"
PV = "2.1.1"
PR = "1.el10_2"
PACKAGES = " \
 syncthing \
 syncthing-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/syncthing-2.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2a8d6b823475c54464fcaf5c626214b4807390794f3cb01be7727f9e0a04288"

URI_x86_64_v2_syncthing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-2.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syncthing}"
SRC_URI[x86_64_v2_syncthing.sha256sum] = "dbbb9d625bbd21ef2376075a187472e719d98226a4892cb08b7d3fde69eec69c"

URI_x86_64_v2_syncthing-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/syncthing-tools-2.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_syncthing-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syncthing-tools}"
SRC_URI[x86_64_v2_syncthing-tools.sha256sum] = "b4f4e293155865234c5b718388d1d84410f45776f3b8048827eab09c62b5d721"

URI_aarch64_syncthing = "${EPEL_MIRROR}/aarch64/Packages/s/syncthing-2.1.1-1.el10_2.aarch64.rpm;name=aarch64_syncthing;unpack=0"
SRC_URI:append = " ${URI_aarch64_syncthing}"
SRC_URI[aarch64_syncthing.sha256sum] = "5d640d6ea078c3da07a3fd30cf1c5f0331a2f656f93b733281ef4ed8d8df58d8"

URI_aarch64_syncthing-tools = "${EPEL_MIRROR}/aarch64/Packages/s/syncthing-tools-2.1.1-1.el10_2.aarch64.rpm;name=aarch64_syncthing-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_syncthing-tools}"
SRC_URI[aarch64_syncthing-tools.sha256sum] = "aa1715741f7e937b2d38059db778ab6d8572882edf23f57c2ff21fe1b439c3c3"

RDEPENDS:syncthing = " \
 bash \
 glibc \
 hicolor-icon-theme \
 sqlite-libs \
 "
RDEPENDS:syncthing-tools = " \
 glibc \
 syncthing \
 "
