# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tie-RefHash"
PV = "1.40"
PR = "511.el10"
PACKAGES = " \
 perl-Tie-RefHash \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Tie-RefHash-1.40-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c344e035703da2117c587aa7dd3382b4b7be8809b0c592b145e3b65a90c59a56"

URI_x86_64_v2_perl-Tie-RefHash = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Tie-RefHash-1.40-511.el10.noarch.rpm;name=x86_64_v2_perl-Tie-RefHash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-RefHash}"
SRC_URI[x86_64_v2_perl-Tie-RefHash.sha256sum] = "7f6c20d84ee7b8ab89a05c23d3933a20671230751af20162b0cf55c53b1f0534"

URI_aarch64_perl-Tie-RefHash = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Tie-RefHash-1.40-511.el10.noarch.rpm;name=aarch64_perl-Tie-RefHash;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-RefHash}"
SRC_URI[aarch64_perl-Tie-RefHash.sha256sum] = "7f6c20d84ee7b8ab89a05c23d3933a20671230751af20162b0cf55c53b1f0534"

RDEPENDS:perl-Tie-RefHash = " \
 perl-Carp \
 perl-libs \
 perl-overload \
 "
