# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Socket-GetAddrInfo"
PV = "0.22"
PR = "36.el10_2"
PACKAGES = " \
 perl-Socket-GetAddrInfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Socket-GetAddrInfo-0.22-36.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91617787465813021ca7ae85d1d9e36deed2d253d78141dee2c30d51078b8396"

URI_x86_64_v2_perl-Socket-GetAddrInfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Socket-GetAddrInfo-0.22-36.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Socket-GetAddrInfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Socket-GetAddrInfo}"
SRC_URI[x86_64_v2_perl-Socket-GetAddrInfo.sha256sum] = "cc170e2d480f03e7bb20bc5b6d35de426cd35d9bf1cdb6a6cf0d510cc7584468"

URI_aarch64_perl-Socket-GetAddrInfo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Socket-GetAddrInfo-0.22-36.el10_2.noarch.rpm;name=aarch64_perl-Socket-GetAddrInfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Socket-GetAddrInfo}"
SRC_URI[aarch64_perl-Socket-GetAddrInfo.sha256sum] = "01c1181cad3b46e25b42f740a3ecbf9bd992e24224ee9dabd4c65067f159cbf3"

RDEPENDS:perl-Socket-GetAddrInfo = " \
 perl-Carp \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Socket-GetAddrInfo \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
