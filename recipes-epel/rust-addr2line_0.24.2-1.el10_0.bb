# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-addr2line"
PV = "0.24.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-addr2line+cargo-all-devel \
 rust-addr2line+cpp_demangle-devel \
 rust-addr2line+default-devel \
 rust-addr2line+fallible-iterator-devel \
 rust-addr2line+loader-devel \
 rust-addr2line+rustc-demangle-devel \
 rust-addr2line+smallvec-devel \
 rust-addr2line+std-devel \
 rust-addr2line-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-addr2line-0.24.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aeb589811ab327fcd9515e83d6c2411c2989c58b8f8a08035ebf44e25337e43"

URI_x86_64_v2_rust-addr2line+cargo-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+cargo-all-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+cargo-all-devel}"
SRC_URI[x86_64_v2_rust-addr2line+cargo-all-devel.sha256sum] = "227474c1083134a9f08eac4ef4a04f800fb68dccfdbee5d4f1ba16b8e860b4f0"

URI_x86_64_v2_rust-addr2line+cpp_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+cpp_demangle-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+cpp_demangle-devel}"
SRC_URI[x86_64_v2_rust-addr2line+cpp_demangle-devel.sha256sum] = "9bc5011ecd6e34c36aa8acea54758bb3109797e7101ed373a495bcd014e865f8"

URI_x86_64_v2_rust-addr2line+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+default-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+default-devel}"
SRC_URI[x86_64_v2_rust-addr2line+default-devel.sha256sum] = "7f0f721c803dae07be8e02719c1bdc141a3a7912ab94f59c0e1b10a693260490"

URI_x86_64_v2_rust-addr2line+fallible-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+fallible-iterator-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+fallible-iterator-devel}"
SRC_URI[x86_64_v2_rust-addr2line+fallible-iterator-devel.sha256sum] = "0136640b7a3410638b3e37d51ac56be698598ba98adf1b2dc1f84a09ff2944c7"

URI_x86_64_v2_rust-addr2line+loader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+loader-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+loader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+loader-devel}"
SRC_URI[x86_64_v2_rust-addr2line+loader-devel.sha256sum] = "b8360ed3dedcb5308bd76a21b8ffaf52782dfa977077e9878a4b90f5b8ff49b4"

URI_x86_64_v2_rust-addr2line+rustc-demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+rustc-demangle-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+rustc-demangle-devel}"
SRC_URI[x86_64_v2_rust-addr2line+rustc-demangle-devel.sha256sum] = "9247b7d723032129b67c08184afaca1d76a23b8f64e45cde8e052ac14b5a006e"

URI_x86_64_v2_rust-addr2line+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+smallvec-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+smallvec-devel}"
SRC_URI[x86_64_v2_rust-addr2line+smallvec-devel.sha256sum] = "d43e8c0c4fbc70c8cd5c845ee3b857b619c8c25b1ac74e66834ec95c38b06970"

URI_x86_64_v2_rust-addr2line+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+std-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+std-devel}"
SRC_URI[x86_64_v2_rust-addr2line+std-devel.sha256sum] = "46e6bdcbb02186dbe499da5c6380eebe1e54703e145953afb760de8b4fb73700"

URI_x86_64_v2_rust-addr2line-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line-devel}"
SRC_URI[x86_64_v2_rust-addr2line-devel.sha256sum] = "3cfe5e882ac417db28a516d92c246848c9fae9559c160c65aa965e5b5bd53cdc"

URI_aarch64_rust-addr2line+cargo-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+cargo-all-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-addr2line+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+cargo-all-devel}"
SRC_URI[aarch64_rust-addr2line+cargo-all-devel.sha256sum] = "a517618ce666811127afa29721da5c065efa6db12babfe434bf34cb609de13b4"

URI_aarch64_rust-addr2line+cpp_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+cpp_demangle-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-addr2line+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+cpp_demangle-devel}"
SRC_URI[aarch64_rust-addr2line+cpp_demangle-devel.sha256sum] = "de3d08d52e78052332597020dd275262e67faf6ced695a30a822fb50b626ce5e"

URI_aarch64_rust-addr2line+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+default-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-addr2line+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+default-devel}"
SRC_URI[aarch64_rust-addr2line+default-devel.sha256sum] = "f0e2efece57790c03d3f0fb7f1957013297f913cd7edd47706f13832ed563c52"

URI_aarch64_rust-addr2line+fallible-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+fallible-iterator-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-addr2line+fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+fallible-iterator-devel}"
SRC_URI[aarch64_rust-addr2line+fallible-iterator-devel.sha256sum] = "cf2683ddc5f8671138e51260be5f1930f4ce61f2814a4dc26ff2d26c70999e71"

URI_aarch64_rust-addr2line+loader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+loader-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-addr2line+loader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+loader-devel}"
SRC_URI[aarch64_rust-addr2line+loader-devel.sha256sum] = "d51c67406d8b9241f33e74567594f7537a929b28200ffb82f247346bcef86cfe"

URI_aarch64_rust-addr2line+rustc-demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+rustc-demangle-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-addr2line+rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+rustc-demangle-devel}"
SRC_URI[aarch64_rust-addr2line+rustc-demangle-devel.sha256sum] = "1793fe21275e83ece22f2e1c06f92f980ac20c286f63d063b6abe826e163a64b"

URI_aarch64_rust-addr2line+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+smallvec-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-addr2line+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+smallvec-devel}"
SRC_URI[aarch64_rust-addr2line+smallvec-devel.sha256sum] = "cc2016e76f0849668a0f451528e884d0ad5470fbb5fe209d23d2d1d9c3230e1a"

URI_aarch64_rust-addr2line+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+std-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-addr2line+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+std-devel}"
SRC_URI[aarch64_rust-addr2line+std-devel.sha256sum] = "54467ea9a01199f2390397a2a4677f61b0ebcdb19217cb6b28f874da29a2057d"

URI_aarch64_rust-addr2line-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-addr2line-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line-devel}"
SRC_URI[aarch64_rust-addr2line-devel.sha256sum] = "181e06cb233fc948296f5ca4096fad39d5de3454abfd371e6181c4745aa99c1c"

RDEPENDS:rust-addr2line+cargo-all-devel = " \
 cargo \
 rust-addr2line-devel \
 "
RDEPENDS:rust-addr2line+cpp_demangle-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-addr2line+default-devel = " \
 cargo \
 rust-addr2line+cpp_demangle-devel \
 rust-addr2line+fallible-iterator-devel \
 rust-addr2line+loader-devel \
 rust-addr2line+rustc-demangle-devel \
 rust-addr2line+smallvec-devel \
 rust-addr2line-devel \
 "
RDEPENDS:rust-addr2line+fallible-iterator-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-fallible-iterator-devel \
 "
RDEPENDS:rust-addr2line+loader-devel = " \
 cargo \
 rust-addr2line+std-devel \
 rust-addr2line-devel \
 rust-memmap2+default-devel \
 rust-object0.36+compression-devel \
 rust-object0.36+read-devel \
 rust-object0.36-devel \
 rust-typed-arena+default-devel \
 "
RDEPENDS:rust-addr2line+rustc-demangle-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-rustc-demangle+default-devel \
 "
RDEPENDS:rust-addr2line+smallvec-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-addr2line+std-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-gimli+std-devel \
 "
RDEPENDS:rust-addr2line-devel = " \
 cargo \
 rust \
 rust-gimli+read-devel \
 rust-gimli-devel \
 "
