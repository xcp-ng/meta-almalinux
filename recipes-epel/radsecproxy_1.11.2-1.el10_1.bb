# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radsecproxy"
PV = "1.11.2"
PR = "1.el10_1"
PACKAGES = " \
 radsecproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radsecproxy-1.11.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5fc99e8472f4680ab778c77b48b34c59490975642b313bb9f5fab0efa000f98"

URI_x86_64_v2_radsecproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radsecproxy-1.11.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_radsecproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radsecproxy}"
SRC_URI[x86_64_v2_radsecproxy.sha256sum] = "71d569265567c1190cd1aaef9e931106c3e44255e2be9cd7796bd49d28632254"

URI_aarch64_radsecproxy = "${EPEL_MIRROR}/aarch64/Packages/r/radsecproxy-1.11.2-1.el10_1.aarch64.rpm;name=aarch64_radsecproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_radsecproxy}"
SRC_URI[aarch64_radsecproxy.sha256sum] = "725a310694d34dfe1ee6abcabec44dac8825a3cb20d7197fd5032a7999d51d5c"

RDEPENDS:radsecproxy = " \
 bash \
 glibc \
 logrotate \
 nettle \
 openssl-libs \
 shadow-utils \
 systemd \
 "
