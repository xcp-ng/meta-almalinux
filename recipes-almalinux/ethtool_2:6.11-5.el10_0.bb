# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ethtool"
PE = "2"
PV = "6.11"
PR = "5.el10_0"
PACKAGES = " \
 ethtool \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ethtool-6.11-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e5d0310f6e4ee4e3db70df260e837918815a3d177b753b36aceca5a5b02fa4d"

URI_x86_64_v2_ethtool = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ethtool-6.11-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_ethtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ethtool}"
SRC_URI[x86_64_v2_ethtool.sha256sum] = "f55c58f552ccab84f2634d08c4874e7f5ea3122e6a6c6a04de87c592a6f39ed2"

URI_aarch64_ethtool = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ethtool-6.11-5.el10_0.aarch64.rpm;name=aarch64_ethtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_ethtool}"
SRC_URI[aarch64_ethtool.sha256sum] = "b25aca284892efa9deeea84cf52812a20f53ec7380be6ddbe601f99184b964a7"

RDEPENDS:ethtool = " \
 glibc \
 libmnl \
 "
