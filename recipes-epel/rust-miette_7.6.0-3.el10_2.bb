# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miette"
PV = "7.6.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-miette+default-devel \
 rust-miette+derive-devel \
 rust-miette+fancy-base-devel \
 rust-miette+fancy-devel \
 rust-miette+fancy-no-backtrace-devel \
 rust-miette+fancy-no-syscall-devel \
 rust-miette+no-format-args-capture-devel \
 rust-miette+serde-devel \
 rust-miette-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-miette-7.6.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a8a4b07207fab78fc7cbc0dcf91d39c16ce4e31ea27dd89c4c3b72c82693062"

URI_x86_64_v2_rust-miette+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+default-devel-7.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+default-devel}"
SRC_URI[x86_64_v2_rust-miette+default-devel.sha256sum] = "1e96d4bcadf7eaf56d82493fde5b8efcceb91ff6fd237b02a5413c33244f5f22"

URI_x86_64_v2_rust-miette+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+derive-devel-7.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+derive-devel}"
SRC_URI[x86_64_v2_rust-miette+derive-devel.sha256sum] = "795ee31e911c3b66a60eb4b228c19725e854151ee58ebd162b0f32be8f1071b0"

URI_x86_64_v2_rust-miette+fancy-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-base-devel-7.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-base-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-base-devel.sha256sum] = "e993c4e57a5fec66b2de152bdc572fab8efa3e995dfad6a39cb24d4a28961aaa"

URI_x86_64_v2_rust-miette+fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-devel-7.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-devel.sha256sum] = "375a5915e5e1618b3641d40c69afe241739ca31b95097087c1367e2701dcb54d"

URI_x86_64_v2_rust-miette+fancy-no-backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-no-backtrace-devel-7.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-no-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-no-backtrace-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-no-backtrace-devel.sha256sum] = "4c9cf167eaecd6a8ac5fdf59217be603f0af58285bee1682e27ab65ae1b53986"

URI_x86_64_v2_rust-miette+fancy-no-syscall-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+fancy-no-syscall-devel-7.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+fancy-no-syscall-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+fancy-no-syscall-devel}"
SRC_URI[x86_64_v2_rust-miette+fancy-no-syscall-devel.sha256sum] = "7cf4f2a454016104164abe73bf6123d10244f344175446bc2aca15c71c8efbaf"

URI_x86_64_v2_rust-miette+no-format-args-capture-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+no-format-args-capture-devel-7.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+no-format-args-capture-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+no-format-args-capture-devel}"
SRC_URI[x86_64_v2_rust-miette+no-format-args-capture-devel.sha256sum] = "d433338f0dfc2c2fda444729c35d007884c5815b11032976185e1f516570cde0"

URI_x86_64_v2_rust-miette+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette+serde-devel-7.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette+serde-devel}"
SRC_URI[x86_64_v2_rust-miette+serde-devel.sha256sum] = "ba6e2aa29f25de681e13ea3d53d796be6f908eb32c15e60ef26fdada65521c46"

URI_x86_64_v2_rust-miette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miette-devel-7.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miette-devel}"
SRC_URI[x86_64_v2_rust-miette-devel.sha256sum] = "0ca6eaf39af47f5402f288c9e9416e19436f2b3eeab58fb7e8c3a012fab4db47"

URI_aarch64_rust-miette+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+default-devel-7.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-miette+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+default-devel}"
SRC_URI[aarch64_rust-miette+default-devel.sha256sum] = "6640a4ecde5e9d133cd8e5ba921a4618aa61ce7c3d318bd871652a5b88bfca38"

URI_aarch64_rust-miette+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+derive-devel-7.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-miette+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+derive-devel}"
SRC_URI[aarch64_rust-miette+derive-devel.sha256sum] = "8b5687019713724650080e06c4bba96f413bed9e92fe3e6071fa707385b5a9b6"

URI_aarch64_rust-miette+fancy-base-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-base-devel-7.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-miette+fancy-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-base-devel}"
SRC_URI[aarch64_rust-miette+fancy-base-devel.sha256sum] = "ee9e76fda3c60127f387915d39e4eb1a5014811e0f007ed7b3c0fdb4726154b0"

URI_aarch64_rust-miette+fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-devel-7.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-miette+fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-devel}"
SRC_URI[aarch64_rust-miette+fancy-devel.sha256sum] = "166f210304c56a53cc1c55b354243e33ec86a563695e48ec1bf5748852d3a1bd"

URI_aarch64_rust-miette+fancy-no-backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-no-backtrace-devel-7.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-miette+fancy-no-backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-no-backtrace-devel}"
SRC_URI[aarch64_rust-miette+fancy-no-backtrace-devel.sha256sum] = "495c44057f55944ab2bdf26c8f69095f7f143ac927b22ca1612b08f5dd383d21"

URI_aarch64_rust-miette+fancy-no-syscall-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+fancy-no-syscall-devel-7.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-miette+fancy-no-syscall-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+fancy-no-syscall-devel}"
SRC_URI[aarch64_rust-miette+fancy-no-syscall-devel.sha256sum] = "b842244eb72295e04cc328750783ebd8217a06c8ef9c9d5a7d69c6c07d0e7292"

URI_aarch64_rust-miette+no-format-args-capture-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+no-format-args-capture-devel-7.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-miette+no-format-args-capture-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+no-format-args-capture-devel}"
SRC_URI[aarch64_rust-miette+no-format-args-capture-devel.sha256sum] = "f8d37b6c1eeba9fe45bc7a81f43147489c2666a43f7513ebe018275f5528be69"

URI_aarch64_rust-miette+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette+serde-devel-7.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-miette+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette+serde-devel}"
SRC_URI[aarch64_rust-miette+serde-devel.sha256sum] = "51d518a9f17b7c5f54c7de1441536ca04e74ff7077a26252e04539c64f82c61d"

URI_aarch64_rust-miette-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miette-devel-7.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-miette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miette-devel}"
SRC_URI[aarch64_rust-miette-devel.sha256sum] = "9783e0e6388973a251f363bc3f9fcfa0c168e7ed0d13b6a6a2ba09e729421f0e"

RDEPENDS:rust-miette+default-devel = " \
 cargo \
 rust-miette+derive-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+derive-devel = " \
 cargo \
 rust-miette-derive+default-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+fancy-base-devel = " \
 cargo \
 rust-miette-devel \
 rust-owo-colors+default-devel \
 rust-textwrap+unicode-linebreak-devel \
 rust-textwrap+unicode-width-devel \
 rust-textwrap-devel \
 "
RDEPENDS:rust-miette+fancy-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-backtrace-ext+default-devel \
 rust-miette+fancy-no-backtrace-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+fancy-no-backtrace-devel = " \
 cargo \
 rust-miette+fancy-base-devel \
 rust-miette-devel \
 rust-supports-color+default-devel \
 rust-supports-hyperlinks+default-devel \
 rust-supports-unicode+default-devel \
 rust-terminal_size+default-devel \
 "
RDEPENDS:rust-miette+fancy-no-syscall-devel = " \
 cargo \
 rust-miette+fancy-base-devel \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+no-format-args-capture-devel = " \
 cargo \
 rust-miette-devel \
 "
RDEPENDS:rust-miette+serde-devel = " \
 cargo \
 rust-miette-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-miette-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-unicode-width0.1+default-devel \
 "
