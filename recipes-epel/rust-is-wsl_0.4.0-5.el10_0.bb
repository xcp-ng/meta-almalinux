# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is-wsl"
PV = "0.4.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-is-wsl+default-devel \
 rust-is-wsl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is-wsl-0.4.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa8109edc27af85622c8c3003f478e9a7ba9972b2aa9f3ee36d062953f54f081"

URI_x86_64_v2_rust-is-wsl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-wsl+default-devel-0.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-wsl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-wsl+default-devel}"
SRC_URI[x86_64_v2_rust-is-wsl+default-devel.sha256sum] = "a4abda314c7cfd21a7345aff4732b0ae6bd6aa7ccdb1010d8a9e093a9424655e"

URI_x86_64_v2_rust-is-wsl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-wsl-devel-0.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-wsl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-wsl-devel}"
SRC_URI[x86_64_v2_rust-is-wsl-devel.sha256sum] = "d5681426e82b66daa556a3fb96bb452f1eb8cdaa86a1bc72202120a9ae29c72b"

URI_aarch64_rust-is-wsl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-wsl+default-devel-0.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-is-wsl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-wsl+default-devel}"
SRC_URI[aarch64_rust-is-wsl+default-devel.sha256sum] = "daefa74781ab1b79d23c1f9cd392ca1b59fce731d784fe59d3ac3a3e40eafc7d"

URI_aarch64_rust-is-wsl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-wsl-devel-0.4.0-5.el10_0.noarch.rpm;name=aarch64_rust-is-wsl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-wsl-devel}"
SRC_URI[aarch64_rust-is-wsl-devel.sha256sum] = "2aad2e43db0cb60b0f2ee478e2e44b32628a9417b064d0545effcda04eaf416c"

RDEPENDS:rust-is-wsl+default-devel = " \
 cargo \
 rust-is-wsl-devel \
 "
RDEPENDS:rust-is-wsl-devel = " \
 cargo \
 rust-is-docker+default-devel \
 rust-once_cell+default-devel \
 "
