# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktrip"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ktrip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktrip-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de46dad39ff0e67ac34c65a2391d832e6554471b3a3011a5ceeb71f357493bac"

URI_x86_64_v2_ktrip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktrip-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktrip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktrip}"
SRC_URI[x86_64_v2_ktrip.sha256sum] = "c0bd23fd685ccd05255ebb58ed5a0da29a164efc0bb6d9aaf1b9062f925dac2e"

URI_aarch64_ktrip = "${EPEL_MIRROR}/aarch64/Packages/k/ktrip-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ktrip;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktrip}"
SRC_URI[aarch64_ktrip.sha256sum] = "d3ac3bbb62466d855af6f38d0b37c8b8f3cd8e6bc4d7c79b2fef7554695045fc"

RDEPENDS:ktrip = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
