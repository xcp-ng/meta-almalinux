# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtkmm4.0"
PV = "4.13.2"
PR = "5.el10"
PACKAGES = " \
 gtkmm4.0 \
 gtkmm4.0-devel \
 gtkmm4.0-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gtkmm4.0-4.13.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e642d0e34e284b8410df02f07d0c30e559ad6a792c58e7c50eadde8726916541"

URI_x86_64_v2_gtkmm4.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtkmm4.0-4.13.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtkmm4.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkmm4.0}"
SRC_URI[x86_64_v2_gtkmm4.0.sha256sum] = "765f53b5c32d26f0ceb7297de16d57f6534d52aa17929bd958b00b4667caf6dc"

URI_x86_64_v2_gtkmm4.0-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtkmm4.0-devel-4.13.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_gtkmm4.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkmm4.0-devel}"
SRC_URI[x86_64_v2_gtkmm4.0-devel.sha256sum] = "7c9f8b57a15060d6759f9e45e1e7c0dcd34fb26b2e9e23776e28c0986922ac8a"

URI_x86_64_v2_gtkmm4.0-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtkmm4.0-doc-4.13.2-5.el10.noarch.rpm;name=x86_64_v2_gtkmm4.0-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkmm4.0-doc}"
SRC_URI[x86_64_v2_gtkmm4.0-doc.sha256sum] = "72642e2997c1f8a2c02581c6495f5cb5cf662a40d8f9827763d6fa5c0846d989"

URI_aarch64_gtkmm4.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtkmm4.0-4.13.2-5.el10.aarch64.rpm;name=aarch64_gtkmm4.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkmm4.0}"
SRC_URI[aarch64_gtkmm4.0.sha256sum] = "7cef64c2bdf42f697f1e9ba89704c4e56856e9dcd93fe008e984a52e2d0ff288"

URI_aarch64_gtkmm4.0-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtkmm4.0-devel-4.13.2-5.el10.aarch64.rpm;name=aarch64_gtkmm4.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkmm4.0-devel}"
SRC_URI[aarch64_gtkmm4.0-devel.sha256sum] = "d8b9d514fa58721551552a6973a79ffcbea839a5dbb51ed236224a3eec2ab266"

URI_aarch64_gtkmm4.0-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtkmm4.0-doc-4.13.2-5.el10.noarch.rpm;name=aarch64_gtkmm4.0-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkmm4.0-doc}"
SRC_URI[aarch64_gtkmm4.0-doc.sha256sum] = "72642e2997c1f8a2c02581c6495f5cb5cf662a40d8f9827763d6fa5c0846d989"

RDEPENDS:gtkmm4.0 = " \
 cairo-gobject \
 cairomm1.16 \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 glibmm2.68 \
 graphene \
 gtk4 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 pangomm2.48 \
 "
RDEPENDS:gtkmm4.0-devel = " \
 cairomm1.16-devel \
 gdk-pixbuf2-devel \
 glibmm2.68-devel \
 gtk4-devel \
 gtkmm4.0 \
 pangomm2.48-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gtkmm4.0-doc = " \
 glibmm2.68-doc \
 gtkmm4.0 \
 "
