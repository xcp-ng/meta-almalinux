# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plantuml"
PE = "1"
PV = "1.2026.1"
PR = "1.el10_2"
PACKAGES = " \
 plantuml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plantuml-1.2026.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "225125a8516340e9647bcc8e0aba8806ebdf565c6a401ba92ac294de28876196"

URI_x86_64_v2_plantuml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plantuml-1.2026.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_plantuml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plantuml}"
SRC_URI[x86_64_v2_plantuml.sha256sum] = "ccb1bcab916943f8dd48eb4a711b02afe4ad2f866b87163e6bbbae0f479beea8"

URI_aarch64_plantuml = "${EPEL_MIRROR}/aarch64/Packages/p/plantuml-1.2026.1-1.el10_2.noarch.rpm;name=aarch64_plantuml;unpack=0"
SRC_URI:append = " ${URI_aarch64_plantuml}"
SRC_URI[aarch64_plantuml.sha256sum] = "03f8775d683e99da5f3069898e7e52d78f1208a36fbf9233dc58d762a2604237"

RDEPENDS:plantuml = " \
 bash \
 graphviz \
 java-21-openjdk \
 javapackages-filesystem \
 javapackages-tools \
 "
