# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tungstenite"
PV = "0.28.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+data-encoding-devel \
 rust-tungstenite+default-devel \
 rust-tungstenite+handshake-devel \
 rust-tungstenite+http-devel \
 rust-tungstenite+httparse-devel \
 rust-tungstenite+native-tls-crate-devel \
 rust-tungstenite+native-tls-devel \
 rust-tungstenite+rustls-devel \
 rust-tungstenite+rustls-native-certs-devel \
 rust-tungstenite+rustls-pki-types-devel \
 rust-tungstenite+rustls-tls-native-roots-devel \
 rust-tungstenite+rustls-tls-webpki-roots-devel \
 rust-tungstenite+sha1-devel \
 rust-tungstenite+url-devel \
 rust-tungstenite+webpki-roots-devel \
 rust-tungstenite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tungstenite-0.28.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db0b8ac385d92f6a56f506cc589dfff67762add9829d919a60cf78f79bd31fc3"

URI_x86_64_v2_rust-tungstenite+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+__rustls-tls-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+__rustls-tls-devel.sha256sum] = "336f4bde26fdf3b268bad9c696ba93a5a20ed110b2f40df695895360467078a0"

URI_x86_64_v2_rust-tungstenite+data-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+data-encoding-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+data-encoding-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+data-encoding-devel.sha256sum] = "33e3334f274a83d08953e1d605befb48cb50fe5cf322d397f713986661381458"

URI_x86_64_v2_rust-tungstenite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+default-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+default-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+default-devel.sha256sum] = "71b834e19341c82732899ea7272384c25c9e5d60beb107b59f371c136da5b6de"

URI_x86_64_v2_rust-tungstenite+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+handshake-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+handshake-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+handshake-devel.sha256sum] = "cc0aade41abcd2ca2430113fc703f829a72488e77c3e72e72cb001eb6f243cd1"

URI_x86_64_v2_rust-tungstenite+http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+http-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+http-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+http-devel.sha256sum] = "2eb61c4b48d0f85f65b8259a36590bf6a88b42e0243fa3bc2b5d23de448cb97f"

URI_x86_64_v2_rust-tungstenite+httparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+httparse-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+httparse-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+httparse-devel.sha256sum] = "945a92f1aa0b20c135467f1097060e0c41f757db81ec58159d0f2decb97446c3"

URI_x86_64_v2_rust-tungstenite+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+native-tls-crate-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+native-tls-crate-devel.sha256sum] = "ff0ed136952263c5b9ed4f33899323de9d1c9dd0fde516f886bf366e3cce9010"

URI_x86_64_v2_rust-tungstenite+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+native-tls-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+native-tls-devel.sha256sum] = "e8a542c42f95c15196dcd2452458dbfc2e87d807de595408b75f030118c8d5f8"

URI_x86_64_v2_rust-tungstenite+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-devel.sha256sum] = "844eba06192c5ae2bc872fd49086e5aab1c2a9660589f2e78bba25669a64b535"

URI_x86_64_v2_rust-tungstenite+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-native-certs-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-native-certs-devel.sha256sum] = "7c5e9a313b04d49051b6ce66fdd218d04d6cf05ff55231394fa4d000ef800def"

URI_x86_64_v2_rust-tungstenite+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-pki-types-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-pki-types-devel.sha256sum] = "f484a0247d370e2c1dd2ba7d52ae8b5b161dd47814e9b5269d30175f34088576"

URI_x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-tls-native-roots-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "7a4e4313043a311835489300ac06731b9cf7e3f2c628c61f69d0ba6871ffe7aa"

URI_x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-tls-webpki-roots-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "371248bb39c9afd120dfaf894cfbdcf77ca3c70c48d101acaae9630de2765d47"

URI_x86_64_v2_rust-tungstenite+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+sha1-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+sha1-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+sha1-devel.sha256sum] = "6f9947c57920505b34c4935b1e2ed44a11622709ae962cd87d21c0698715271e"

URI_x86_64_v2_rust-tungstenite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+url-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+url-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+url-devel.sha256sum] = "32a27006f3ac76128082e1252076df7ed164138b1e7375b78c1e1b1e660fd9f6"

URI_x86_64_v2_rust-tungstenite+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+webpki-roots-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+webpki-roots-devel.sha256sum] = "c421b79c93b512b6bd9a120969a1550411b8edfac130a17807b4e559b0e85817"

URI_x86_64_v2_rust-tungstenite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite-devel-0.28.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite-devel}"
SRC_URI[x86_64_v2_rust-tungstenite-devel.sha256sum] = "21aed8dc774c50f1cd9e4195418b5d80f684af88bbe44742f768bd7ef6085254"

URI_aarch64_rust-tungstenite+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+__rustls-tls-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tungstenite+__rustls-tls-devel.sha256sum] = "2367a962026f4603d0fa67a1d6ab8e8199c535069612fb97a8d5d9a974c80705"

URI_aarch64_rust-tungstenite+data-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+data-encoding-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+data-encoding-devel}"
SRC_URI[aarch64_rust-tungstenite+data-encoding-devel.sha256sum] = "cf0e9188f8775231a4a203bcf6a118bf2a9720ae2287f46bfa83dbc26013aada"

URI_aarch64_rust-tungstenite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+default-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+default-devel}"
SRC_URI[aarch64_rust-tungstenite+default-devel.sha256sum] = "209fa3b0b65d55ced74578278bee8fc7e699c7fe76aeacccec6100c6f054ad77"

URI_aarch64_rust-tungstenite+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+handshake-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+handshake-devel}"
SRC_URI[aarch64_rust-tungstenite+handshake-devel.sha256sum] = "03cf7a6c594fe7d2c48f7ef3e2c216602e17132f69cb6450a76578392f55d4f9"

URI_aarch64_rust-tungstenite+http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+http-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+http-devel}"
SRC_URI[aarch64_rust-tungstenite+http-devel.sha256sum] = "1349c3ead53e72268aa87ef5233e0c86c1c72cdf3008983789f10dfc3bfd5e90"

URI_aarch64_rust-tungstenite+httparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+httparse-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+httparse-devel}"
SRC_URI[aarch64_rust-tungstenite+httparse-devel.sha256sum] = "aececea6c3e6879b7a1b37294a652d1cacc8ac8f3fccf265ab2ae555bf812d78"

URI_aarch64_rust-tungstenite+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+native-tls-crate-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tungstenite+native-tls-crate-devel.sha256sum] = "adf8835c5a36e2f1c70b2de62d2a9ec1b6f36fab813256190366994158438e0c"

URI_aarch64_rust-tungstenite+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+native-tls-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+native-tls-devel}"
SRC_URI[aarch64_rust-tungstenite+native-tls-devel.sha256sum] = "08312ed7333d8d00e3472e0521b2e9807b5e4b853f94212fdb3ace11bb639da9"

URI_aarch64_rust-tungstenite+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-devel.sha256sum] = "d698665b81db0433ba9c37124c649274c89df6954a6856a25ef8d0f885c4043a"

URI_aarch64_rust-tungstenite+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-native-certs-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-native-certs-devel.sha256sum] = "2dca5ecfd66de7e0b3839450d76d20084db256142e0e57831324bbc98a53cc33"

URI_aarch64_rust-tungstenite+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-pki-types-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-pki-types-devel.sha256sum] = "9892ede02d0f78928cdd82fac7c535c26a65ae43284db3db6bf00455a13dadab"

URI_aarch64_rust-tungstenite+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-tls-native-roots-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "ee52775dfb4c7d92f5cb729a33bd1af79dec7c037e530c8e4a6b1e01abcaaf42"

URI_aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-tls-webpki-roots-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "45be16b5918006b8b6a21c6cde94c569da9db17069d7288a15ecb982144a2e62"

URI_aarch64_rust-tungstenite+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+sha1-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+sha1-devel}"
SRC_URI[aarch64_rust-tungstenite+sha1-devel.sha256sum] = "cf0021f33b828dd654541cdb1c87c20cd93a8b0d77bf46b19d44a1b762fee56c"

URI_aarch64_rust-tungstenite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+url-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+url-devel}"
SRC_URI[aarch64_rust-tungstenite+url-devel.sha256sum] = "2cccb18e0877bb29d8ea10aeabeaa3b5695d9e7b18a3f46a13336ed8d0e65460"

URI_aarch64_rust-tungstenite+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+webpki-roots-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+webpki-roots-devel.sha256sum] = "0fc6e223aceeb29d77bfd03046004e731dbf65316f6d69b567b002b7699c51b4"

URI_aarch64_rust-tungstenite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite-devel-0.28.0-1.el10_2.noarch.rpm;name=aarch64_rust-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite-devel}"
SRC_URI[aarch64_rust-tungstenite-devel.sha256sum] = "bf93112c34afd9fdcf4d7a28db795023bcbbe165c1a797866bac330249e62537"

RDEPENDS:rust-tungstenite+__rustls-tls-devel = " \
 cargo \
 rust-tungstenite+rustls-devel \
 rust-tungstenite+rustls-pki-types-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+data-encoding-devel = " \
 cargo \
 rust-data-encoding+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+default-devel = " \
 cargo \
 rust-tungstenite+handshake-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+handshake-devel = " \
 cargo \
 rust-tungstenite+data-encoding-devel \
 rust-tungstenite+http-devel \
 rust-tungstenite+httparse-devel \
 rust-tungstenite+sha1-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+http-devel = " \
 cargo \
 rust-http+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+httparse-devel = " \
 cargo \
 rust-httparse+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+native-tls-devel = " \
 cargo \
 rust-tungstenite+native-tls-crate-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-devel = " \
 cargo \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+rustls-native-certs-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+webpki-roots-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+sha1-devel = " \
 cargo \
 rust-sha1+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+url-devel = " \
 cargo \
 rust-tungstenite-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-tungstenite+webpki-roots-devel = " \
 cargo \
 rust-tungstenite-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-tungstenite-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-log+default-devel \
 rust-rand0.9+default-devel \
 rust-thiserror+default-devel \
 rust-utf-8+default-devel \
 "
