# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-epoch"
PV = "0.9.21"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch+default-devel \
 rust-crossbeam-epoch+nightly-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-epoch-0.9.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7748cb4e2d1e77207222227cbc7f186c460d421fdc01676d8bc0395962f02eb4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+alloc-devel-0.9.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+alloc-devel.sha256sum] = "0c346b9bedfe0b4b62852be9e4c5e0364227bb7035f68ab76cbf593ea368f7aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+default-devel-0.9.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+default-devel.sha256sum] = "eaa018763b15cae28620c6ad9f8647d39510e39e73464083075f8cf9608d1693"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+nightly-devel-0.9.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+nightly-devel.sha256sum] = "390ee3a70875ac3a0ef77d51feb587d985614af4d19ee98dd7add0ef2a00d769"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch+std-devel-0.9.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch+std-devel.sha256sum] = "3ec9903c662b057f08527f8edcd2a8a32316fcb84094ea346d9c8e811589c1bf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-epoch-devel-0.9.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-epoch-devel.sha256sum] = "050b7131514bb1c4649c11dee992a58db1f305e5e620fb64e38262b293f4d297"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+alloc-devel-0.9.21-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch+alloc-devel.sha256sum] = "0d3867dfb761f4ea49ff2ec942b2f7ae2fbffa0781689cf3b9659d323d038eeb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+default-devel-0.9.21-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch+default-devel.sha256sum] = "15cfd0e062b2c3835ddf2195426e04f77b32810f4b61200c1a8e698d6e10068b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+nightly-devel-0.9.21-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch+nightly-devel.sha256sum] = "22237009d87bc2cdb9c9c78fc02ed7d559160131d036389bb61a4987b227438d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch+std-devel-0.9.21-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch+std-devel.sha256sum] = "fe0226fe9fbdb6bd48494501b3790a1e8770c02237d80e9084f81fc4021e942c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-epoch-devel-0.9.21-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-epoch-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-epoch-devel.sha256sum] = "0dbb930231845a2de7405a60612513ab54d60bc223bcfa8c338a799049b6a658"

RDEPENDS:rust-crossbeam-epoch+alloc-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+default-devel = " \
 cargo \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-epoch-devel \
 "
RDEPENDS:rust-crossbeam-epoch+nightly-devel = " \
 cargo \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-epoch+std-devel = " \
 cargo \
 rust-crossbeam-epoch+alloc-devel \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-epoch-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
