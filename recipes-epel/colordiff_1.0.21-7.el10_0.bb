# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colordiff"
PV = "1.0.21"
PR = "7.el10_0"
PACKAGES = " \
 colordiff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/colordiff-1.0.21-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d18e3b924331b064b743bb6a5e40fb3156271cc1d146e88034ecd49e31eeb8b9"

URI_x86_64_v2_colordiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/colordiff-1.0.21-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_colordiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colordiff}"
SRC_URI[x86_64_v2_colordiff.sha256sum] = "9514853e07258d3e03602885dd3f315b84ae41b3f816124a2c6b7d1210e7e2e9"

URI_aarch64_colordiff = "${EPEL_MIRROR}/aarch64/Packages/c/colordiff-1.0.21-7.el10_0.noarch.rpm;name=aarch64_colordiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_colordiff}"
SRC_URI[aarch64_colordiff.sha256sum] = "8f16c988c101af0113f8ce8884ffef842a3cee8a2805302f473ebaf01d346bc6"

RDEPENDS:colordiff = " \
 bash \
 diffutils \
 less \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
