# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shellexpand"
PV = "3.1.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+bstr-devel \
 rust-shellexpand+default-devel \
 rust-shellexpand+dirs-devel \
 rust-shellexpand+full-devel \
 rust-shellexpand+full-msrv-1-31-devel \
 rust-shellexpand+full-msrv-1-51-devel \
 rust-shellexpand+os_str_bytes-devel \
 rust-shellexpand+path-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-shellexpand-3.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "420092015a46e2227d8e406bf68b6d9e57aa032eacfd1c4780e839f8ee50e82d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+base-0-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+base-0-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+base-0-devel.sha256sum] = "79c97860eb0c65559e41e687f073450775909c5bbe29f65de10c7ab3b9e6cd8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+bstr-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+bstr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+bstr-devel.sha256sum] = "dc91e27471bbfc31abd76e2b9549fbf5ffe9b7e00ecba73855689bcb1bb97a61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+default-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+default-devel.sha256sum] = "6c390ef83e7857a1ebfe6359b4fbfaf40ddc8b07ebb1f608a5da8597269c02a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+dirs-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+dirs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+dirs-devel.sha256sum] = "3332b164552123de28c59663bf50f38dd721dc56c5d0ce23304ea1c22b7279a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+full-devel.sha256sum] = "8155ddcbfbf814350e5a8f893f9972187f70e550360f24b104d3f8e69a082130"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-msrv-1-31-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-msrv-1-31-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+full-msrv-1-31-devel.sha256sum] = "df1ff1abe1abfeef9300df938a769cced324423486f057026615c9f701ad3f2f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+full-msrv-1-51-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+full-msrv-1-51-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+full-msrv-1-51-devel.sha256sum] = "e07e18021d4521fd4390e48a395c6514201d97eb03ed96e7e0fa39089793e95d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+os_str_bytes-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+os_str_bytes-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+os_str_bytes-devel.sha256sum] = "196d7e272d2636a13a34352ed8ffbef5d2cc8c93c96c5712890a61b652d1f9d8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+path-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+path-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+path-devel.sha256sum] = "00637543c8b69e492745461a745d478524d3378aaa27355eb26be9309e0c2c16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand+tilde-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand+tilde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand+tilde-devel.sha256sum] = "3558dcd954a0a67603d5f0eb9d8b9708e0592d2b969e26f17ee346a43450f63a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shellexpand-devel-3.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shellexpand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-shellexpand-devel.sha256sum] = "ed78c6fd4c61f57cfc9eee1a0741d70e94f39c9b8ea3b5f3145cfa0ab7527e76"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+base-0-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+base-0-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+base-0-devel.sha256sum] = "56afbd08acadfa7bb2555ca2deb11fa2a1554ccc306de238c2ef754835ff096b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+bstr-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+bstr-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+bstr-devel.sha256sum] = "138eef57e75a141806ab6ce9997365d95930acf12b3e8ea6a26893ed2b88d0ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+default-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+default-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+default-devel.sha256sum] = "2698b4587f5b92660f6f09a30b375e105d96036b46a2d0976519dce7f4ec3e76"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+dirs-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+dirs-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+dirs-devel.sha256sum] = "7be8297aef83b5d57dacf2ded65fd00dd0056c189144d9902ebb6e73fe21be7e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+full-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+full-devel.sha256sum] = "d1797faf3dd11beb2e7b27b9a147b8fe316a67e6cced2bfdc25bbe4a66295d09"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-msrv-1-31-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+full-msrv-1-31-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+full-msrv-1-31-devel.sha256sum] = "28aa5fa5c3bc5ec96e97a3a4831f924d4362d9f8430f4cb7c74795b68dd49499"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+full-msrv-1-51-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+full-msrv-1-51-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+full-msrv-1-51-devel.sha256sum] = "9043a1e26438a795a9f892697f8da7870aa9a9ae76b3e86861478c8bbb718bb1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+os_str_bytes-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+os_str_bytes-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+os_str_bytes-devel.sha256sum] = "fb34a8b0cfe82431a6785c1512a69e2876d6f1e3b4d1baf334bf2341274e5661"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+path-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+path-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+path-devel.sha256sum] = "47c289995a847bdc696182872abfcb49f8ed7e7ffa1acf0a820827736217fc35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand+tilde-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand+tilde-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand+tilde-devel.sha256sum] = "acca48a770982a2f6b396fd2e5fa267f852edd0cf78c2dea7218e12d10768e7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-shellexpand-devel-3.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-shellexpand-devel;unpack=0"
SRC_URI[aarch64_rust-shellexpand-devel.sha256sum] = "3cd74f68242e1784a0790179e7d852fec55dd2e257408d538cc346b768968b37"

RDEPENDS:rust-shellexpand+base-0-devel = " \
 cargo \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+bstr-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+default-devel = " \
 cargo \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+dirs-devel = " \
 cargo \
 rust-dirs+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-devel = " \
 cargo \
 rust-shellexpand+full-msrv-1-51-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-msrv-1-31-devel = " \
 cargo \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+full-msrv-1-51-devel = " \
 cargo \
 rust-shellexpand+full-msrv-1-31-devel \
 rust-shellexpand+path-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+os_str_bytes-devel = " \
 cargo \
 rust-os_str_bytes6+default-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+path-devel = " \
 cargo \
 rust-shellexpand+bstr-devel \
 rust-shellexpand+os_str_bytes-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand+tilde-devel = " \
 cargo \
 rust-shellexpand+dirs-devel \
 rust-shellexpand-devel \
 "
RDEPENDS:rust-shellexpand-devel = " \
 bash \
 cargo \
 rust \
 "
