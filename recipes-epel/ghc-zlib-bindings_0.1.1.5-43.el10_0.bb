# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-zlib-bindings"
PV = "0.1.1.5"
PR = "43.el10_0"
PACKAGES = " \
 ghc-zlib-bindings \
 ghc-zlib-bindings-devel \
 ghc-zlib-bindings-doc \
 ghc-zlib-bindings-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-zlib-bindings-0.1.1.5-43.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9f704928e280a47bf6a69c4643cf070cd3969c19fb75325019b7a667fa918b5"

URI_x86_64_v2_ghc-zlib-bindings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zlib-bindings-0.1.1.5-43.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-zlib-bindings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zlib-bindings}"
SRC_URI[x86_64_v2_ghc-zlib-bindings.sha256sum] = "ae2784d223eac989478ce5e72fe38feb8d3c5f2c32212bbc9f8f81f4488975ea"

URI_x86_64_v2_ghc-zlib-bindings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zlib-bindings-devel-0.1.1.5-43.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-zlib-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zlib-bindings-devel}"
SRC_URI[x86_64_v2_ghc-zlib-bindings-devel.sha256sum] = "794574e264e8ab080a86b77ef0b365c3d7fa3d069e53aa338a928ff74ae07f95"

URI_x86_64_v2_ghc-zlib-bindings-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zlib-bindings-doc-0.1.1.5-43.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-zlib-bindings-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zlib-bindings-doc}"
SRC_URI[x86_64_v2_ghc-zlib-bindings-doc.sha256sum] = "096238ce88656debc52020c941d9b7a313265ee04078c97cd9068c168cba3e25"

URI_x86_64_v2_ghc-zlib-bindings-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-zlib-bindings-prof-0.1.1.5-43.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-zlib-bindings-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-zlib-bindings-prof}"
SRC_URI[x86_64_v2_ghc-zlib-bindings-prof.sha256sum] = "6400b14e62b091350ed7c2f5a755301ccae8e1248069296fb3db06191233b433"

URI_aarch64_ghc-zlib-bindings = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zlib-bindings-0.1.1.5-43.el10_0.aarch64.rpm;name=aarch64_ghc-zlib-bindings;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zlib-bindings}"
SRC_URI[aarch64_ghc-zlib-bindings.sha256sum] = "f06ae03007bfa73c398762748da8baa7b512dfa205e00b0fb54cd6d4c0c2fb70"

URI_aarch64_ghc-zlib-bindings-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zlib-bindings-devel-0.1.1.5-43.el10_0.aarch64.rpm;name=aarch64_ghc-zlib-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zlib-bindings-devel}"
SRC_URI[aarch64_ghc-zlib-bindings-devel.sha256sum] = "6692d895ca1f0d20aaedc647896934ea1630c825aec1762515c13fee2b0e5e22"

URI_aarch64_ghc-zlib-bindings-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zlib-bindings-doc-0.1.1.5-43.el10_0.noarch.rpm;name=aarch64_ghc-zlib-bindings-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zlib-bindings-doc}"
SRC_URI[aarch64_ghc-zlib-bindings-doc.sha256sum] = "ddf6bfe0ef2128ffbfe66bd27670b627e156d59819cca02259c1eec31437d45a"

URI_aarch64_ghc-zlib-bindings-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-zlib-bindings-prof-0.1.1.5-43.el10_0.aarch64.rpm;name=aarch64_ghc-zlib-bindings-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-zlib-bindings-prof}"
SRC_URI[aarch64_ghc-zlib-bindings-prof.sha256sum] = "00e15ed8015f04cdde0b36d39f9b5f935e5f4d80d4a83aee14e919fa9f7dec72"

RDEPENDS:ghc-zlib-bindings = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-zlib-bindings-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-zlib-bindings \
 ghc-zlib-devel \
 "
RDEPENDS:ghc-zlib-bindings-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-zlib-bindings-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-zlib-bindings-devel \
 ghc-zlib-prof \
 "
