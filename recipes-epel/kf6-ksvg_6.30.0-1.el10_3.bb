# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ksvg"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-ksvg \
 kf6-ksvg-devel \
 kf6-ksvg-doc \
 kf6-ksvg-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-ksvg-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "84b2f01bf90a5f9dd59a213ab3af435ec6ce06bf63f47db6c60860eec04b840e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg;unpack=0"
SRC_URI[x86_64_v2_kf6-ksvg.sha256sum] = "e887ee1b90c89fa4f8e273cc16c91555bea423e7f6e8446828395c75d64362a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ksvg-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-ksvg-devel.sha256sum] = "700a84a371e6297fb798912b46bca07af2e4a5365ca9b38a801ccf0d48728bc0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ksvg-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-ksvg-doc.sha256sum] = "8fcabb6ebdda86c8540b5706538dfe815e0ff69a1b05e5677cf84faa15078871"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ksvg-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ksvg-html;unpack=0"
SRC_URI[x86_64_v2_kf6-ksvg-html.sha256sum] = "f26f5b16502df26c07f737ec587d09ffd48106beb16ce2a22c1d54a1e0b58b26"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ksvg;unpack=0"
SRC_URI[aarch64_kf6-ksvg.sha256sum] = "09e4b91173caed081ed8270c9b415fc6cc013de390a1dd1f86fa4f85fe04ef2a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-ksvg-devel;unpack=0"
SRC_URI[aarch64_kf6-ksvg-devel.sha256sum] = "31c39149c7c489c8f497708cc55acef6feb5d31e10b85b820c50023290f28df3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ksvg-doc;unpack=0"
SRC_URI[aarch64_kf6-ksvg-doc.sha256sum] = "491cd947f02033c2f7e3b6bc7d23ad61f982b0100248a1a6863acd357dbe1e99"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ksvg-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-ksvg-html;unpack=0"
SRC_URI[aarch64_kf6-ksvg-html.sha256sum] = "0c3966bb573b8e6ff45a6d405dfbaa434773477d06c569b0cdd1adcfb9a7702d"

RDEPENDS:kf6-ksvg = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kirigami \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:kf6-ksvg-devel = " \
 cmake-filesystem \
 kf6-ksvg \
 "
RDEPENDS:kf6-ksvg-doc = " \
 "
RDEPENDS:kf6-ksvg-html = " \
 "
