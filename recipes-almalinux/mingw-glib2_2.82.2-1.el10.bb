# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-glib2"
PV = "2.82.2"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 mingw32-glib2 \
 mingw32-glib2-static \
 mingw64-glib2 \
 mingw64-glib2-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-glib2-2.82.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7fcf8531a6fb0fd272b08387c6dc0c60fafbce722ddb7cc5dce484ffca89754"

URI_x86_64_v2_mingw32-glib2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-glib2-2.82.2-1.el10.noarch.rpm;name=x86_64_v2_mingw32-glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-glib2}"
SRC_URI[x86_64_v2_mingw32-glib2.sha256sum] = "df93d9b6c0a74dc400e041e54e384f73e65ff1f03be4ab03e334ffb3eb39d2c7"

URI_x86_64_v2_mingw32-glib2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-glib2-static-2.82.2-1.el10.noarch.rpm;name=x86_64_v2_mingw32-glib2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-glib2-static}"
SRC_URI[x86_64_v2_mingw32-glib2-static.sha256sum] = "1a6ffa29a15bd09fc6d6210310babf23ceb649df996fcc8202dd1c88ce0cdf57"

URI_x86_64_v2_mingw64-glib2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-glib2-2.82.2-1.el10.noarch.rpm;name=x86_64_v2_mingw64-glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-glib2}"
SRC_URI[x86_64_v2_mingw64-glib2.sha256sum] = "e35635582f13ded7e9c3c1379b80600749adf8a8bf7aa950e0320180f78d8e9e"

URI_x86_64_v2_mingw64-glib2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-glib2-static-2.82.2-1.el10.noarch.rpm;name=x86_64_v2_mingw64-glib2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-glib2-static}"
SRC_URI[x86_64_v2_mingw64-glib2-static.sha256sum] = "599ce50c3a23030702f511b368699aa0b78ff7d2f48edce20d468d1d9e5cd57f"

RDEPENDS:mingw32-glib2 = " \
 bash \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-gettext \
 mingw32-libffi \
 mingw32-libgcc \
 mingw32-pcre2 \
 mingw32-zlib \
 python3 \
 "
RDEPENDS:mingw32-glib2-static = " \
 mingw32-gettext-static \
 mingw32-glib2 \
 "
RDEPENDS:mingw64-glib2 = " \
 bash \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-gettext \
 mingw64-libffi \
 mingw64-libgcc \
 mingw64-pcre2 \
 mingw64-zlib \
 python3 \
 "
RDEPENDS:mingw64-glib2-static = " \
 mingw64-gettext-static \
 mingw64-glib2 \
 "
