# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-minspan"
PV = "0.1.5"
PR = "3.el10_3"
PACKAGES = " \
 rust-minspan+default-devel \
 rust-minspan-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-minspan-0.1.5-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5ce474c7457f802926a5680320d743f8790c74eba96432feb62d11c6e46efb0"

URI_x86_64_v2_rust-minspan+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minspan+default-devel-0.1.5-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minspan+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minspan+default-devel}"
SRC_URI[x86_64_v2_rust-minspan+default-devel.sha256sum] = "242186615c8b379b3e4739343f5788ebc2ffbd75f10b8c64a2683d7b3587af60"

URI_x86_64_v2_rust-minspan-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minspan-devel-0.1.5-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minspan-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minspan-devel}"
SRC_URI[x86_64_v2_rust-minspan-devel.sha256sum] = "68748af9266e0f7be7ad4ed622782d5ff014956110d3e44f3e446093fa10141f"

URI_aarch64_rust-minspan+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minspan+default-devel-0.1.5-3.el10_3.noarch.rpm;name=aarch64_rust-minspan+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minspan+default-devel}"
SRC_URI[aarch64_rust-minspan+default-devel.sha256sum] = "13dd1d5ddc8cb99dd359074ad242fc0e7f22c90be6580b4919cc5ae5cd6c057c"

URI_aarch64_rust-minspan-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minspan-devel-0.1.5-3.el10_3.noarch.rpm;name=aarch64_rust-minspan-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minspan-devel}"
SRC_URI[aarch64_rust-minspan-devel.sha256sum] = "ea67468628bdf3e34bd1f383b73f068a45ffdb8d7493ff82d0fd4b440aac4ccc"

RDEPENDS:rust-minspan+default-devel = " \
 cargo \
 rust-minspan-devel \
 "
RDEPENDS:rust-minspan-devel = " \
 cargo \
 "
