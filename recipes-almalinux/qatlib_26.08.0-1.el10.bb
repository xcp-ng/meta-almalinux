# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatlib"
PV = "26.08.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qatlib \
 qatlib-devel \
 qatlib-service \
 qatlib-tests \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatlib-26.08.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b9627daf3f0566f72b45a8f7676114d16524d6b80bc1da28f2d5f18349cbd3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatlib-26.08.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib;unpack=0"
SRC_URI[x86_64_v2_qatlib.sha256sum] = "0ad51682641f40773be892578c515e0d7640f91fcf8c9772e9ef19ec6eb59b5f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatlib-devel-26.08.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib-devel;unpack=0"
SRC_URI[x86_64_v2_qatlib-devel.sha256sum] = "3662899e179756aa5535aca3b75433561d6983253a520432c9da89e6f74292c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatlib-service-26.08.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib-service;unpack=0"
SRC_URI[x86_64_v2_qatlib-service.sha256sum] = "2783bbbe0455a71e1be829ceaae2ad67468f0b13798eb0faa57fb95e69e555fd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatlib-tests-26.08.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatlib-tests;unpack=0"
SRC_URI[x86_64_v2_qatlib-tests.sha256sum] = "80e5826ebe3c87029f1bef260be2e0f10ebd2eeb50b0eba6def870f655bcbcd5"

RDEPENDS:qatlib = " \
 glibc \
 numactl-libs \
 openssl-libs \
 selinux-policy \
 "
RDEPENDS:qatlib-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 qatlib \
 qatlib-devel \
 "
RDEPENDS:qatlib-service = " \
 bash \
 glibc \
 numactl-libs \
 pciutils \
 qatlib \
 systemd \
 "
RDEPENDS:qatlib-tests = " \
 glibc \
 openssl-libs \
 qatlib \
 zlib-ng-compat \
 "
