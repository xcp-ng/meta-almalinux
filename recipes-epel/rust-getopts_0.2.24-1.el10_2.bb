# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getopts"
PV = "0.2.24"
PR = "1.el10_2"
PACKAGES = " \
 rust-getopts+default-devel \
 rust-getopts+unicode-devel \
 rust-getopts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getopts-0.2.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f26c5192d63c27267cf6e8fb4a128398b996d957ff0b22b97e6affc9c174351"

URI_x86_64_v2_rust-getopts+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getopts+default-devel-0.2.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getopts+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getopts+default-devel}"
SRC_URI[x86_64_v2_rust-getopts+default-devel.sha256sum] = "7e06f1fdd8b88feb2b062dd31548620371154308addb5a77828c7d72db088ec5"

URI_x86_64_v2_rust-getopts+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getopts+unicode-devel-0.2.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getopts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getopts+unicode-devel}"
SRC_URI[x86_64_v2_rust-getopts+unicode-devel.sha256sum] = "6fd3679b71644b78d1e37073fd75d64b9ab81fb9180f21ad92951f6d2b68f943"

URI_x86_64_v2_rust-getopts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getopts-devel-0.2.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getopts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getopts-devel}"
SRC_URI[x86_64_v2_rust-getopts-devel.sha256sum] = "e8a69fe73aad296d16c3b0c4dd11d7334d481352c33ed6902deb404bae330e41"

URI_aarch64_rust-getopts+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getopts+default-devel-0.2.24-1.el10_2.noarch.rpm;name=aarch64_rust-getopts+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getopts+default-devel}"
SRC_URI[aarch64_rust-getopts+default-devel.sha256sum] = "c5171bc82246fc19f4525ba1ea6d09926e6074cfc195a34b7f4767127382a820"

URI_aarch64_rust-getopts+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getopts+unicode-devel-0.2.24-1.el10_2.noarch.rpm;name=aarch64_rust-getopts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getopts+unicode-devel}"
SRC_URI[aarch64_rust-getopts+unicode-devel.sha256sum] = "c3a605b020a7762ca7c8f1f101ab94a4fb0409a0ec03c12e59acc710c5c424e9"

URI_aarch64_rust-getopts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getopts-devel-0.2.24-1.el10_2.noarch.rpm;name=aarch64_rust-getopts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getopts-devel}"
SRC_URI[aarch64_rust-getopts-devel.sha256sum] = "ff292af7a48e674aa16b41c577bd1415c52e9a61a885b79d27635db7e76da804"

RDEPENDS:rust-getopts+default-devel = " \
 cargo \
 rust-getopts+unicode-devel \
 rust-getopts-devel \
 "
RDEPENDS:rust-getopts+unicode-devel = " \
 cargo \
 rust-getopts-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-getopts-devel = " \
 cargo \
 rust \
 "
