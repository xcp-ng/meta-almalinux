# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tracer"
PV = "1.4"
PR = "1.el10_2"
PACKAGES = " \
 python3-tracer \
 tracer-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tracer-1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bc91a4e5adf6467b4c054609b6e474fafb40ef56ca66c2ce7f299ff8cc06c7d"

URI_x86_64_v2_python3-tracer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tracer-1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tracer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tracer}"
SRC_URI[x86_64_v2_python3-tracer.sha256sum] = "3830f032dea89256ebd4f3ec704f75998e30185c5c27e9ee3ed9ee19ace45af1"

URI_x86_64_v2_tracer-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tracer-common-1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tracer-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tracer-common}"
SRC_URI[x86_64_v2_tracer-common.sha256sum] = "f4a18030025b854efbdef4c024dfdbc8abc19632e3066a548a1e8437c3374908"

URI_aarch64_python3-tracer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tracer-1.4-1.el10_2.noarch.rpm;name=aarch64_python3-tracer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tracer}"
SRC_URI[aarch64_python3-tracer.sha256sum] = "fc6331f5cc822912600128eea23e6192e9e38527f717a68fc16afe1859cc89fd"

URI_aarch64_tracer-common = "${EPEL_MIRROR}/aarch64/Packages/t/tracer-common-1.4-1.el10_2.noarch.rpm;name=aarch64_tracer-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_tracer-common}"
SRC_URI[aarch64_tracer-common.sha256sum] = "810367c651680a2c144465bcca1bf65f66a122849c322bd23d2ea25d9f05f756"

RDEPENDS:python3-tracer = " \
 python3 \
 python3-dbus \
 python3-distro \
 python3-psutil \
 python3-rpm \
 python3-six \
 tracer-common \
 "
RDEPENDS:tracer-common = " \
 "
