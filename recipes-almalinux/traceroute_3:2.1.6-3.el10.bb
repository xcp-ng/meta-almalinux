# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "traceroute"
PE = "3"
PV = "2.1.6"
PR = "3.el10"
PACKAGES = " \
 traceroute \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/traceroute-2.1.6-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "744eecdb6f47df5731213194decff03e1eb2f22a533ccde82432584a4d5f23eb"

URI_x86_64_v2_traceroute = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/traceroute-2.1.6-3.el10.x86_64_v2.rpm;name=x86_64_v2_traceroute;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_traceroute}"
SRC_URI[x86_64_v2_traceroute.sha256sum] = "5a8235941be33ac7dc1734bdcef4095ad5a6483d6e3eff91c5a532fda679b7e8"

URI_aarch64_traceroute = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/traceroute-2.1.6-3.el10.aarch64.rpm;name=aarch64_traceroute;unpack=0"
SRC_URI:append = " ${URI_aarch64_traceroute}"
SRC_URI[aarch64_traceroute.sha256sum] = "f19dd8ab482a974a4024786668500bb39df889727cbcb72b4b23baaedccc8203"

RDEPENDS:traceroute = " \
 bash \
 glibc \
 "
