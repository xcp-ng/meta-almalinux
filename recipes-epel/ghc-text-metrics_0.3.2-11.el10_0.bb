# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-text-metrics"
PV = "0.3.2"
PR = "11.el10_0"
PACKAGES = " \
 ghc-text-metrics \
 ghc-text-metrics-devel \
 ghc-text-metrics-doc \
 ghc-text-metrics-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-text-metrics-0.3.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fcd340acdf27abb1c245983e5a5b783d140570ee0b9e05aae622f1b5307ee5d"

URI_x86_64_v2_ghc-text-metrics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-metrics-0.3.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-metrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-metrics}"
SRC_URI[x86_64_v2_ghc-text-metrics.sha256sum] = "9f0b7ecb4b76cade2ae401f623112aa03ad885f3f17fec44bfd5772adcc2719a"

URI_x86_64_v2_ghc-text-metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-metrics-devel-0.3.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-metrics-devel}"
SRC_URI[x86_64_v2_ghc-text-metrics-devel.sha256sum] = "4d342eb840cdf7e134d17e383b3cba4431f15ecd2c5ad2a2072365796c4a8c01"

URI_x86_64_v2_ghc-text-metrics-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-metrics-doc-0.3.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-text-metrics-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-metrics-doc}"
SRC_URI[x86_64_v2_ghc-text-metrics-doc.sha256sum] = "1ad2001087442fefb47e2c875d811763392900a319a4c19663194e3632a51bbe"

URI_x86_64_v2_ghc-text-metrics-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-text-metrics-prof-0.3.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-text-metrics-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-text-metrics-prof}"
SRC_URI[x86_64_v2_ghc-text-metrics-prof.sha256sum] = "637873bcacb9190472b28818b472c9670baffcf63c7451f85359026de8e9ad66"

URI_aarch64_ghc-text-metrics = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-metrics-0.3.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-text-metrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-metrics}"
SRC_URI[aarch64_ghc-text-metrics.sha256sum] = "daa5f5a793afb9cfa85265c97b6791ce20dc49843aa1eb6da19c4e7d598d9c2d"

URI_aarch64_ghc-text-metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-metrics-devel-0.3.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-text-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-metrics-devel}"
SRC_URI[aarch64_ghc-text-metrics-devel.sha256sum] = "e8c4925164f66fdcc1025276e72a46ccfe43b2e79171817f01baccf90b2e4881"

URI_aarch64_ghc-text-metrics-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-metrics-doc-0.3.2-11.el10_0.noarch.rpm;name=aarch64_ghc-text-metrics-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-metrics-doc}"
SRC_URI[aarch64_ghc-text-metrics-doc.sha256sum] = "3395f9db5876cc3ba1eb74b79c9275a88199f088bff8ae2a1414779fa1e4cf97"

URI_aarch64_ghc-text-metrics-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-text-metrics-prof-0.3.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-text-metrics-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-text-metrics-prof}"
SRC_URI[aarch64_ghc-text-metrics-prof.sha256sum] = "0e25204211437e5e425a19d90868782732e5caa74c11cc4703339d9c1e47713b"

RDEPENDS:ghc-text-metrics = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-text-metrics-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-text-devel \
 ghc-text-metrics \
 ghc-vector-devel \
 "
RDEPENDS:ghc-text-metrics-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-text-metrics-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-text-metrics-devel \
 ghc-text-prof \
 ghc-vector-prof \
 "
