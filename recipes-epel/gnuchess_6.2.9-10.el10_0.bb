# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnuchess"
PV = "6.2.9"
PR = "10.el10_0"
PACKAGES = " \
 gnuchess \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnuchess-6.2.9-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fc12eb959e25a49fe52a52309f271f78e4bc966f974be6da18cedf707363a63"

URI_x86_64_v2_gnuchess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuchess-6.2.9-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuchess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnuchess}"
SRC_URI[x86_64_v2_gnuchess.sha256sum] = "3d303c2f7a9735b1cb4775e3a39df883fe2c84368657ebc6f01b7b0ddf893399"

URI_aarch64_gnuchess = "${EPEL_MIRROR}/aarch64/Packages/g/gnuchess-6.2.9-10.el10_0.aarch64.rpm;name=aarch64_gnuchess;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnuchess}"
SRC_URI[aarch64_gnuchess.sha256sum] = "4b7b2d202903b2d18fb9c4607ec3ebb54507eeae12d0e43d87f72e76fb516099"

RDEPENDS:gnuchess = " \
 glibc \
 "
