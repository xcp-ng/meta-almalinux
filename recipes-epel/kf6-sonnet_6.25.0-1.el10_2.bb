# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-sonnet"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-sonnet \
 kf6-sonnet-aspell \
 kf6-sonnet-devel \
 kf6-sonnet-doc \
 kf6-sonnet-hspell \
 kf6-sonnet-html \
 kf6-sonnet-hunspell \
 kf6-sonnet-voikko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-sonnet-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3dceddfc9531c690359639d62ef95d52aadc8bdfba918660107624403f2dbfb"

URI_x86_64_v2_kf6-sonnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet}"
SRC_URI[x86_64_v2_kf6-sonnet.sha256sum] = "4c396b6e5fdc69f5f65592adfb55044a88a77ad42095a702fb494c0f752f8552"

URI_x86_64_v2_kf6-sonnet-aspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-aspell-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-aspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-aspell}"
SRC_URI[x86_64_v2_kf6-sonnet-aspell.sha256sum] = "1d339bbb34aaf647a3290a9c3577e3981ac6312a5bd0449e23b17a3e9b3f5db9"

URI_x86_64_v2_kf6-sonnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-devel}"
SRC_URI[x86_64_v2_kf6-sonnet-devel.sha256sum] = "521c8f7d8cd87f61512333dab67c2d9cc726c201d6417bf25bc1b96a570cd1ce"

URI_x86_64_v2_kf6-sonnet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-sonnet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-doc}"
SRC_URI[x86_64_v2_kf6-sonnet-doc.sha256sum] = "18dcaace7a06795f4b92bdfb8e1f282db96b2f5bf8e0abc19e9075c5f304c7f0"

URI_x86_64_v2_kf6-sonnet-hspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hspell-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-hspell}"
SRC_URI[x86_64_v2_kf6-sonnet-hspell.sha256sum] = "085c487c74ccbc0ef64627200c1bec4d2b06f61d41b6ec9097ceb14fc0701f23"

URI_x86_64_v2_kf6-sonnet-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-sonnet-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-html}"
SRC_URI[x86_64_v2_kf6-sonnet-html.sha256sum] = "fe5d4cb7f21201ffdd38757fec53bd52de71a051f5b7647d60c93d6ad8da9b1b"

URI_x86_64_v2_kf6-sonnet-hunspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hunspell-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hunspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-hunspell}"
SRC_URI[x86_64_v2_kf6-sonnet-hunspell.sha256sum] = "531b6e9ae82f3e670cda71adf6da66ffdb20320b2aa3455a4bd9956207e7165c"

URI_x86_64_v2_kf6-sonnet-voikko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-voikko-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-voikko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-sonnet-voikko}"
SRC_URI[x86_64_v2_kf6-sonnet-voikko.sha256sum] = "da084a2a68b3b0720d4db6603fc23d9876a2aa588c855b03127389f372b720dd"

URI_aarch64_kf6-sonnet = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-sonnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet}"
SRC_URI[aarch64_kf6-sonnet.sha256sum] = "8c07beeef4bd7398083b5d851b536ad77103c29267b8ce013b41054ca6dc67fc"

URI_aarch64_kf6-sonnet-aspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-aspell-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-sonnet-aspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-aspell}"
SRC_URI[aarch64_kf6-sonnet-aspell.sha256sum] = "8a11e7ca24a0961c3d9a2b7a6e37f0abc1df49eda501fa1e3b10677e3595245f"

URI_aarch64_kf6-sonnet-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-sonnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-devel}"
SRC_URI[aarch64_kf6-sonnet-devel.sha256sum] = "4fb4919cfe811900eddf135eea6b5a8e60047a197aafc58ab639fe39b9d66e44"

URI_aarch64_kf6-sonnet-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-sonnet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-doc}"
SRC_URI[aarch64_kf6-sonnet-doc.sha256sum] = "908b74e2a1ebef8e0be22b347490ba71dbd6884ef6e9e290fa43ad74e48045bf"

URI_aarch64_kf6-sonnet-hspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hspell-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-sonnet-hspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-hspell}"
SRC_URI[aarch64_kf6-sonnet-hspell.sha256sum] = "78412977595cb43a25dc3956978f1ca35a947a57fc7bf3e706e6eb28f0f3f827"

URI_aarch64_kf6-sonnet-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-sonnet-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-html}"
SRC_URI[aarch64_kf6-sonnet-html.sha256sum] = "1c9b837b3c65430ba298fd068aacf9c888fc0de024a5876da8c018a20e3348a1"

URI_aarch64_kf6-sonnet-hunspell = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hunspell-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-sonnet-hunspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-hunspell}"
SRC_URI[aarch64_kf6-sonnet-hunspell.sha256sum] = "1912073f58fd8028c023d77f7868f9ea87b43af5f701862a4bd5c7d42896a938"

URI_aarch64_kf6-sonnet-voikko = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-voikko-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-sonnet-voikko;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-sonnet-voikko}"
SRC_URI[aarch64_kf6-sonnet-voikko.sha256sum] = "09f8e478a34afbb9b1484621f2764f98d131ec0640eb7b94c050b90687347309"

RDEPENDS:kf6-sonnet = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-sonnet-aspell = " \
 aspell \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-devel = " \
 cmake-filesystem \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-sonnet-doc = " \
 "
RDEPENDS:kf6-sonnet-hspell = " \
 glibc \
 hspell \
 hunspell-he \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-html = " \
 "
RDEPENDS:kf6-sonnet-hunspell = " \
 glibc \
 hunspell \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-voikko = " \
 glibc \
 kf6-sonnet \
 libstdc++ \
 libvoikko \
 qt6-qtbase \
 "
