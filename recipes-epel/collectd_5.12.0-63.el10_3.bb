# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "collectd"
PV = "5.12.0"
PR = "63.el10_3"
PACKAGES = " \
 collectd \
 collectd-amqp \
 collectd-amqp1 \
 collectd-apache \
 collectd-ascent \
 collectd-bind \
 collectd-chrony \
 collectd-curl \
 collectd-curl_xml \
 collectd-dbi \
 collectd-disk \
 collectd-dns \
 collectd-drbd \
 collectd-email \
 collectd-generic-jmx \
 collectd-gps \
 collectd-hugepages \
 collectd-infiniband \
 collectd-ipmi \
 collectd-ipvs \
 collectd-java \
 collectd-lua \
 collectd-mcelog \
 collectd-mdevents \
 collectd-memcachec \
 collectd-modbus \
 collectd-mysql \
 collectd-netlink \
 collectd-nginx \
 collectd-notify_desktop \
 collectd-notify_email \
 collectd-nut \
 collectd-openldap \
 collectd-pinba \
 collectd-ping \
 collectd-postgresql \
 collectd-python \
 collectd-redis \
 collectd-rrdcached \
 collectd-rrdtool \
 collectd-sensors \
 collectd-smart \
 collectd-snmp \
 collectd-snmp_agent \
 collectd-synproxy \
 collectd-utils \
 collectd-varnish \
 collectd-virt \
 collectd-web \
 collectd-write_http \
 collectd-write_kafka \
 collectd-write_prometheus \
 collectd-write_redis \
 collectd-write_riemann \
 collectd-write_sensu \
 collectd-write_syslog \
 collectd-write_tsdb \
 collectd-zookeeper \
 libcollectdclient \
 libcollectdclient-devel \
 perl-Collectd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/collectd-5.12.0-63.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40efd76abe9462f729993e2def88cf3d85275e6a002b55034196f30766bda155"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - collectd-nut: libupsclient.so.6()(64bit)

URI_x86_64_v2_collectd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd}"
SRC_URI[x86_64_v2_collectd.sha256sum] = "425fd0102749ea87248cb545c58b9442dbebc0fbea71c7bd4a771c18f4456c4d"

URI_x86_64_v2_collectd-amqp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-amqp-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-amqp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-amqp}"
SRC_URI[x86_64_v2_collectd-amqp.sha256sum] = "a46c2c811d9ee89ce4823ff0962798c7bc53e086bbfca9ba21fba5897aa8c482"

URI_x86_64_v2_collectd-amqp1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-amqp1-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-amqp1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-amqp1}"
SRC_URI[x86_64_v2_collectd-amqp1.sha256sum] = "8d860d1f05dd5f7b87968954fa7a0e44f9a1181f2b94b7608cca7ab3d243d4ca"

URI_x86_64_v2_collectd-apache = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-apache-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-apache}"
SRC_URI[x86_64_v2_collectd-apache.sha256sum] = "18bbdc47369dbca4fa84aa01c7a979b0d4b7e3a6c1a459310f05ec67dd8a4971"

URI_x86_64_v2_collectd-ascent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ascent-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ascent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ascent}"
SRC_URI[x86_64_v2_collectd-ascent.sha256sum] = "9f5ef287b84e5a28266442b352c580e6612a175333ed4db4c5a8208657c29ce9"

URI_x86_64_v2_collectd-bind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-bind-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-bind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-bind}"
SRC_URI[x86_64_v2_collectd-bind.sha256sum] = "164ca8c17ee271d20b09dc8f02fdbf3d87dd8c08535dcdb61341765f7bee8a0f"

URI_x86_64_v2_collectd-chrony = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-chrony-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-chrony;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-chrony}"
SRC_URI[x86_64_v2_collectd-chrony.sha256sum] = "4d0a86fe3e6d56ca57b2bbfd8357e867b347c1b8ea1c079a845a81b4ebab7340"

URI_x86_64_v2_collectd-curl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-curl-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-curl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-curl}"
SRC_URI[x86_64_v2_collectd-curl.sha256sum] = "5a35eccf779d3ef058720b236013d131fc9069c3d3ba7860a5a442ded4145b9d"

URI_x86_64_v2_collectd-curl_xml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-curl_xml-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-curl_xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-curl_xml}"
SRC_URI[x86_64_v2_collectd-curl_xml.sha256sum] = "20c902ebb48e7314d4fa2091cfa848661cbf7ca52b7e884c8b09ef337c831e4a"

URI_x86_64_v2_collectd-dbi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-dbi-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-dbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-dbi}"
SRC_URI[x86_64_v2_collectd-dbi.sha256sum] = "e735066c4cc03aff4b7b712dc9970e1f4c99ec92eacb8cf9f0b702c5e254c835"

URI_x86_64_v2_collectd-disk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-disk-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-disk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-disk}"
SRC_URI[x86_64_v2_collectd-disk.sha256sum] = "e421c3b564901a20140a3fc2c428baed76e8e9ee926abbf92a9084bb885c4e4f"

URI_x86_64_v2_collectd-dns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-dns-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-dns}"
SRC_URI[x86_64_v2_collectd-dns.sha256sum] = "8ce2fbada986380f59f54bdb0625d6c32e5fddafef2a647264a97d108040c68b"

URI_x86_64_v2_collectd-drbd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-drbd-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-drbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-drbd}"
SRC_URI[x86_64_v2_collectd-drbd.sha256sum] = "b5fd5090d298de81655627ffcdfd2eaaccb84c420811387cfc66e4848153de6f"

URI_x86_64_v2_collectd-email = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-email-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-email;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-email}"
SRC_URI[x86_64_v2_collectd-email.sha256sum] = "d4a6c92fb90708414dbf77236b9e15f99f0b7e5f3d78bcaebf9fb1570e837e76"

URI_x86_64_v2_collectd-generic-jmx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-generic-jmx-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-generic-jmx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-generic-jmx}"
SRC_URI[x86_64_v2_collectd-generic-jmx.sha256sum] = "d4c3f0d0f8098c5c8d8cde548d1f4d14fd2f29bb73352ffb3777fbca07a4e80f"

URI_x86_64_v2_collectd-gps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-gps-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-gps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-gps}"
SRC_URI[x86_64_v2_collectd-gps.sha256sum] = "d59456d1ca94b976feb7e2eb700068070cf83be0db91d5ca0704bc691b7911d9"

URI_x86_64_v2_collectd-hugepages = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-hugepages-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-hugepages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-hugepages}"
SRC_URI[x86_64_v2_collectd-hugepages.sha256sum] = "57e5b64f9d1aeeb959dbdf1abf79b49b4808cbd4ce94193c43a285a37b2a0b62"

URI_x86_64_v2_collectd-infiniband = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-infiniband-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-infiniband;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-infiniband}"
SRC_URI[x86_64_v2_collectd-infiniband.sha256sum] = "e3b5d4d0e4a16a3c68d65f2096d12b1a1ca51ba5fbea904e903839a9821ca67e"

URI_x86_64_v2_collectd-ipmi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ipmi-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ipmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ipmi}"
SRC_URI[x86_64_v2_collectd-ipmi.sha256sum] = "8ab02656ace345c7ca980c42af98548d53aaba9e959d4e5dd34e0338cb7117da"

URI_x86_64_v2_collectd-ipvs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ipvs-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ipvs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ipvs}"
SRC_URI[x86_64_v2_collectd-ipvs.sha256sum] = "f84cc2c163a14138b629e0b2d8b72ed4a625ecc04b719bc8774e692a53413be5"

URI_x86_64_v2_collectd-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-java-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-java}"
SRC_URI[x86_64_v2_collectd-java.sha256sum] = "df3757ed6a289b4f8bc08417bb41fb2f04a686e727f86b8a27f2daea6cde65f5"

URI_x86_64_v2_collectd-lua = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-lua-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-lua}"
SRC_URI[x86_64_v2_collectd-lua.sha256sum] = "58bbb939758e8c0e4676a062b78d9219385269a5ecb9c502c42e3f30661af0f3"

URI_x86_64_v2_collectd-mcelog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-mcelog-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-mcelog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-mcelog}"
SRC_URI[x86_64_v2_collectd-mcelog.sha256sum] = "83b30b0aa150f18b9a1050d6f6b78677fd943fefe45b4d06c09451999577fe33"

URI_x86_64_v2_collectd-mdevents = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-mdevents-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-mdevents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-mdevents}"
SRC_URI[x86_64_v2_collectd-mdevents.sha256sum] = "188ad3cd0cc03859795ca90d24295d6dc8c67707a574dd3f3557060f2d8f6d10"

URI_x86_64_v2_collectd-memcachec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-memcachec-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-memcachec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-memcachec}"
SRC_URI[x86_64_v2_collectd-memcachec.sha256sum] = "2fc08d1d78d1cefdebb13a6ab89f252f229327d423b2f873988bf15f8d32b78c"

URI_x86_64_v2_collectd-modbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-modbus-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-modbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-modbus}"
SRC_URI[x86_64_v2_collectd-modbus.sha256sum] = "615f120ab47e328367a818fe6588b950ec402aa1e189f7d5dabffa0a20b973b9"

URI_x86_64_v2_collectd-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-mysql-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-mysql}"
SRC_URI[x86_64_v2_collectd-mysql.sha256sum] = "ea32d4bc39575ac61ce11f31314d2ddf1c8907edc78c793d8f67b06d4afeaf81"

URI_x86_64_v2_collectd-netlink = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-netlink-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-netlink;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-netlink}"
SRC_URI[x86_64_v2_collectd-netlink.sha256sum] = "1015b4c7a6a642c5a403b905cb9f868defca086343464044143a26b62c979e50"

URI_x86_64_v2_collectd-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-nginx-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-nginx}"
SRC_URI[x86_64_v2_collectd-nginx.sha256sum] = "4baa087b640f628543d69727d274547212f4cf36a7624beb78fbcde4293a6e5d"

URI_x86_64_v2_collectd-notify_desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-notify_desktop-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-notify_desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-notify_desktop}"
SRC_URI[x86_64_v2_collectd-notify_desktop.sha256sum] = "0262af0c7cbc3d82846b8e0371c4a622450afe7aa1e87ab0eb580d39ceee82a1"

URI_x86_64_v2_collectd-notify_email = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-notify_email-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-notify_email;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-notify_email}"
SRC_URI[x86_64_v2_collectd-notify_email.sha256sum] = "df739c9c3457b1a66ee86c35ed75b18b3523b5d536c1c4e870ffb68a42a5188f"

URI_x86_64_v2_collectd-nut = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-nut-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-nut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-nut}"
SRC_URI[x86_64_v2_collectd-nut.sha256sum] = "50bc77fc71a06f2872d8681383ebfe1d5b9e8f84085f15938c17737fdd7dcb1b"

URI_x86_64_v2_collectd-openldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-openldap-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-openldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-openldap}"
SRC_URI[x86_64_v2_collectd-openldap.sha256sum] = "1603675339975ea9d237eb04aa1901e8f14c3e8b87f6d5bd33ecf6a65395ba59"

URI_x86_64_v2_collectd-pinba = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-pinba-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-pinba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-pinba}"
SRC_URI[x86_64_v2_collectd-pinba.sha256sum] = "61efb078a8d9c1e934e27ad5f4d9db00fc4f64094cd752aff3e67e55e88f22c9"

URI_x86_64_v2_collectd-ping = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-ping-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-ping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-ping}"
SRC_URI[x86_64_v2_collectd-ping.sha256sum] = "4caa17eca5e56e3dcc504139eb27892217792a32105799cb656cd756b1617df7"

URI_x86_64_v2_collectd-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-postgresql-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-postgresql}"
SRC_URI[x86_64_v2_collectd-postgresql.sha256sum] = "7cf4fd9ffb8314eefe85240f303d95ec9ec3183bc2e576bbc95492e992b9863f"

URI_x86_64_v2_collectd-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-python-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-python}"
SRC_URI[x86_64_v2_collectd-python.sha256sum] = "242e6e6c9df090f71d3e3ba324405ae8b57298baab561823962d9050bb518b54"

URI_x86_64_v2_collectd-redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-redis-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-redis}"
SRC_URI[x86_64_v2_collectd-redis.sha256sum] = "3896aeb049ebeb24616e65262c1f591de2b650d733dc842bc905d5b8574bd4ee"

URI_x86_64_v2_collectd-rrdcached = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-rrdcached-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-rrdcached;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-rrdcached}"
SRC_URI[x86_64_v2_collectd-rrdcached.sha256sum] = "1fa4ef8768c83b5cf855eb981e339471eeb7edd2508e2eac3412cdc9b15a9e28"

URI_x86_64_v2_collectd-rrdtool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-rrdtool-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-rrdtool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-rrdtool}"
SRC_URI[x86_64_v2_collectd-rrdtool.sha256sum] = "d1aa5a45ef42e4c7af0b74a2572ca4e0a0c57798c4155e40c1ffd8ebf0001bba"

URI_x86_64_v2_collectd-sensors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-sensors-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-sensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-sensors}"
SRC_URI[x86_64_v2_collectd-sensors.sha256sum] = "c88ded94a8d39fdcf69c825c952a4eb25a0e5fa40116604a905eed602d50b2ae"

URI_x86_64_v2_collectd-smart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-smart-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-smart}"
SRC_URI[x86_64_v2_collectd-smart.sha256sum] = "6e9426ba4db12c2beea6eb4a2d722aa65eb81832b81cf7ff8a625abb4bec5c9e"

URI_x86_64_v2_collectd-snmp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-snmp-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-snmp}"
SRC_URI[x86_64_v2_collectd-snmp.sha256sum] = "edf2055b004a3d4d9477452097b4408feccb7375b08a81f5b272445bce406205"

URI_x86_64_v2_collectd-snmp_agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-snmp_agent-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-snmp_agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-snmp_agent}"
SRC_URI[x86_64_v2_collectd-snmp_agent.sha256sum] = "6f663be0fcea876f6c2aeb5e95d517e15cf1ccdec8ab8096a5484f4a3b8b361f"

URI_x86_64_v2_collectd-synproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-synproxy-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-synproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-synproxy}"
SRC_URI[x86_64_v2_collectd-synproxy.sha256sum] = "0211d3c765de77073274a86de442de0805cbd88054d59e600a21600113993347"

URI_x86_64_v2_collectd-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-utils-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-utils}"
SRC_URI[x86_64_v2_collectd-utils.sha256sum] = "75a463fa0c99db026bfd0350b51f6dc996e7f3155064bf2a7618b6141ee1031b"

URI_x86_64_v2_collectd-varnish = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-varnish-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-varnish;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-varnish}"
SRC_URI[x86_64_v2_collectd-varnish.sha256sum] = "782ae1f43a634f436bdf26c0410049480d3f115537c1dcf4ced5101bf4c04d9e"

URI_x86_64_v2_collectd-virt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-virt-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-virt}"
SRC_URI[x86_64_v2_collectd-virt.sha256sum] = "39f33021a776a9f31af880d3c943c48380c4ef19824e02eff58cb795dcbdc90a"

URI_x86_64_v2_collectd-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-web-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-web}"
SRC_URI[x86_64_v2_collectd-web.sha256sum] = "cea23c7b2d2d3bf61c1aa3ab5330734bb5cacf51651a43b623b564d352e20e92"

URI_x86_64_v2_collectd-write_http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_http-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_http}"
SRC_URI[x86_64_v2_collectd-write_http.sha256sum] = "e8743b23198fb4ce2f53443f31f3f0865721e4b86879698f004c330692b2351e"

URI_x86_64_v2_collectd-write_kafka = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_kafka-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_kafka}"
SRC_URI[x86_64_v2_collectd-write_kafka.sha256sum] = "8be127d05199f15a85e4b38b6d90bbe6ca4238621d48a61c2a243b372408ca6f"

URI_x86_64_v2_collectd-write_prometheus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_prometheus-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_prometheus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_prometheus}"
SRC_URI[x86_64_v2_collectd-write_prometheus.sha256sum] = "a37a5ec92ac8910cb8ffc54001c4118f793f56fb9d525e2b73e0eeda32397208"

URI_x86_64_v2_collectd-write_redis = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_redis-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_redis}"
SRC_URI[x86_64_v2_collectd-write_redis.sha256sum] = "6b139c0413715c2aa8d07df7cf1d6a5902e137e659ab61517848f5e29f178c29"

URI_x86_64_v2_collectd-write_riemann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_riemann-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_riemann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_riemann}"
SRC_URI[x86_64_v2_collectd-write_riemann.sha256sum] = "0150982b3c819fecc0a800b0e0efebe498d3ebf9837a7ce1acd24d8decf27809"

URI_x86_64_v2_collectd-write_sensu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_sensu-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_sensu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_sensu}"
SRC_URI[x86_64_v2_collectd-write_sensu.sha256sum] = "a44d4458fa5ac385a19977f71dc76b6fae7dc758f42858950cad951048b4573e"

URI_x86_64_v2_collectd-write_syslog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_syslog-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_syslog}"
SRC_URI[x86_64_v2_collectd-write_syslog.sha256sum] = "398011680ceea84ea6f7c047f3b5f8a6b9187895015dc11230195f5d8c5a92a4"

URI_x86_64_v2_collectd-write_tsdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-write_tsdb-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-write_tsdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-write_tsdb}"
SRC_URI[x86_64_v2_collectd-write_tsdb.sha256sum] = "9fe6f045ae07e214269eacb68907a0a7710f11f63603b7983fdc941a48f51ac4"

URI_x86_64_v2_collectd-zookeeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/collectd-zookeeper-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_collectd-zookeeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_collectd-zookeeper}"
SRC_URI[x86_64_v2_collectd-zookeeper.sha256sum] = "fc146fda48eccd40762bf015684395bf89c07a62c563d3a168674a9f70ab3832"

URI_x86_64_v2_libcollectdclient = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcollectdclient-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcollectdclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcollectdclient}"
SRC_URI[x86_64_v2_libcollectdclient.sha256sum] = "5bc40a001635e4c7f18884a650469c2813d7d78816371da54e2580480178111a"

URI_x86_64_v2_libcollectdclient-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcollectdclient-devel-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcollectdclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcollectdclient-devel}"
SRC_URI[x86_64_v2_libcollectdclient-devel.sha256sum] = "85ce068154452528f98b1733bb0ad19af93bcc86b6eb5e34bbd131bb1990b848"

URI_x86_64_v2_perl-Collectd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Collectd-5.12.0-63.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Collectd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Collectd}"
SRC_URI[x86_64_v2_perl-Collectd.sha256sum] = "8cca8e09ef9c18abc27528e503c4f71ca0f960052f19f8658ac11e86365864bf"

URI_aarch64_collectd = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd}"
SRC_URI[aarch64_collectd.sha256sum] = "d30f081b04071702a72589d7d8c5d7dbe076d26412111f2eb7e36fb47f629f95"

URI_aarch64_collectd-amqp = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-amqp-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-amqp;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-amqp}"
SRC_URI[aarch64_collectd-amqp.sha256sum] = "5b9eaa0f8e8a9bea72c502d8590da478c407f9b0b3faf259c34b57d6dfe119c8"

URI_aarch64_collectd-amqp1 = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-amqp1-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-amqp1;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-amqp1}"
SRC_URI[aarch64_collectd-amqp1.sha256sum] = "e3bae8286e592290b8e6600230ff1c62c2d0b1a911c545d53afe4b87de02976f"

URI_aarch64_collectd-apache = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-apache-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-apache}"
SRC_URI[aarch64_collectd-apache.sha256sum] = "892bec6ed8899c42b89a9ff83ebad709477752f5c1ca69c16b385cf866b6d3e1"

URI_aarch64_collectd-ascent = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ascent-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-ascent;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ascent}"
SRC_URI[aarch64_collectd-ascent.sha256sum] = "02862ec6ef944499b149df7e9189b00d32779e7a0bc42668a5d1bc832279b427"

URI_aarch64_collectd-bind = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-bind-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-bind;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-bind}"
SRC_URI[aarch64_collectd-bind.sha256sum] = "e911cbccf4d9d11cb5d687275465ba1ecf5a771baba2050277c2b419c28fb37c"

URI_aarch64_collectd-chrony = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-chrony-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-chrony;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-chrony}"
SRC_URI[aarch64_collectd-chrony.sha256sum] = "759cd35cb4da97ef6181c53d207daca90a83d78d1972640c06a940e37f156cca"

URI_aarch64_collectd-curl = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-curl-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-curl;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-curl}"
SRC_URI[aarch64_collectd-curl.sha256sum] = "a6acf0e488d935b9cab08ac03aef149edb1eeec0546d245d0e9072bf06a4deb8"

URI_aarch64_collectd-curl_xml = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-curl_xml-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-curl_xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-curl_xml}"
SRC_URI[aarch64_collectd-curl_xml.sha256sum] = "f686d4e37b2f5fc1cbd1c911763b38b4357a648b0f658cf34db06d1107e86ceb"

URI_aarch64_collectd-dbi = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-dbi-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-dbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-dbi}"
SRC_URI[aarch64_collectd-dbi.sha256sum] = "6775cf8153b4f15db052c9ef858b4c799c9ab3d7a60c3992f100326ff30b7a2c"

URI_aarch64_collectd-disk = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-disk-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-disk;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-disk}"
SRC_URI[aarch64_collectd-disk.sha256sum] = "920450850501ca8a7f7fcc122db39ddab9b352277e78d070501dee887e6efb0b"

URI_aarch64_collectd-dns = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-dns-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-dns}"
SRC_URI[aarch64_collectd-dns.sha256sum] = "867b7def6e4ccf06dfe20d8c3f68f4a258bab12c738d915f2e597f0760776fa5"

URI_aarch64_collectd-drbd = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-drbd-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-drbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-drbd}"
SRC_URI[aarch64_collectd-drbd.sha256sum] = "6092a7aa34636c184c7cfe4cb15e1ede516967134b7f04e76884a080206e672b"

URI_aarch64_collectd-email = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-email-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-email;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-email}"
SRC_URI[aarch64_collectd-email.sha256sum] = "6e13c8a54d70c2fec4fd2aba8e441bc2afe521d0c3ec337ad13c52a9b0e26f6c"

URI_aarch64_collectd-generic-jmx = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-generic-jmx-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-generic-jmx;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-generic-jmx}"
SRC_URI[aarch64_collectd-generic-jmx.sha256sum] = "b9b58fbb616a8b64a870fdc0babea1f2bc39353d6a92eee56038fbff792dce63"

URI_aarch64_collectd-gps = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-gps-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-gps;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-gps}"
SRC_URI[aarch64_collectd-gps.sha256sum] = "d4a6158a97a56e8da5aa6c3c42e3069da3f172e7730b441215c3348241158bf3"

URI_aarch64_collectd-hugepages = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-hugepages-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-hugepages;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-hugepages}"
SRC_URI[aarch64_collectd-hugepages.sha256sum] = "379cfc1d579e59cf23b3b3c22d448df64c416edfaad36343fce1e6ca31fb8f22"

URI_aarch64_collectd-infiniband = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-infiniband-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-infiniband;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-infiniband}"
SRC_URI[aarch64_collectd-infiniband.sha256sum] = "2b120c0e9f8bcaebb932b4862e6a5e1187ec671f1867ddd3c75e6653f3860cca"

URI_aarch64_collectd-ipmi = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ipmi-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-ipmi;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ipmi}"
SRC_URI[aarch64_collectd-ipmi.sha256sum] = "5c49d47e4aa055ec3fc3f671f46b2fbdfb3a2ce1f0669eba295656584fe5c46d"

URI_aarch64_collectd-ipvs = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ipvs-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-ipvs;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ipvs}"
SRC_URI[aarch64_collectd-ipvs.sha256sum] = "ab767ebfb40b4808e64984f2925a31cc3b970cd2abbb2d0eb9ab74349249d90e"

URI_aarch64_collectd-java = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-java-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-java}"
SRC_URI[aarch64_collectd-java.sha256sum] = "81cdfe3ffbd254f64c495a994c5c5d39648a6a67ebdfd53eacf163ed7c69a94c"

URI_aarch64_collectd-lua = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-lua-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-lua}"
SRC_URI[aarch64_collectd-lua.sha256sum] = "334882fbcc0487759dbbced165bc7f21f62534a908df1813cbd3d4828a637048"

URI_aarch64_collectd-mcelog = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-mcelog-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-mcelog;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-mcelog}"
SRC_URI[aarch64_collectd-mcelog.sha256sum] = "2ebe342f6c476adf0d5e927553d76191ffe747d11a0e98b1f6dd1570d6a4abaf"

URI_aarch64_collectd-mdevents = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-mdevents-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-mdevents;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-mdevents}"
SRC_URI[aarch64_collectd-mdevents.sha256sum] = "e126d98a63f9399303b739944b2723ea30abdbe3802151a7e0499e9656474899"

URI_aarch64_collectd-memcachec = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-memcachec-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-memcachec;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-memcachec}"
SRC_URI[aarch64_collectd-memcachec.sha256sum] = "b0a2bf0782502594c4da2d5fd4cfa43e604b8c60b7b7aab74ded52880b2a2b2d"

URI_aarch64_collectd-modbus = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-modbus-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-modbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-modbus}"
SRC_URI[aarch64_collectd-modbus.sha256sum] = "fb0b52684b9f347536c4235def198f1f7a335fc9c15a28766caf15580c91693f"

URI_aarch64_collectd-mysql = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-mysql-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-mysql}"
SRC_URI[aarch64_collectd-mysql.sha256sum] = "bcbcb2146cd34defd69c95ffb00bbb48af7ed3f132ce37bb1172891be44c04b0"

URI_aarch64_collectd-netlink = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-netlink-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-netlink;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-netlink}"
SRC_URI[aarch64_collectd-netlink.sha256sum] = "2171ef3f5c5312d56222644ea5fe2899f98dcefbf43bc998836366fb8cb0a0ae"

URI_aarch64_collectd-nginx = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-nginx-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-nginx}"
SRC_URI[aarch64_collectd-nginx.sha256sum] = "705a59abc515f9ed8c3a76f6e688970edc7e8e6edd56cf86da0cd14ada08712d"

URI_aarch64_collectd-notify_desktop = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-notify_desktop-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-notify_desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-notify_desktop}"
SRC_URI[aarch64_collectd-notify_desktop.sha256sum] = "5fd579efdaf554886b27c72e6791727f38bb008c5ea7bd71ad764596b9a4c2fb"

URI_aarch64_collectd-notify_email = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-notify_email-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-notify_email;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-notify_email}"
SRC_URI[aarch64_collectd-notify_email.sha256sum] = "7ea6bfbc273aeaf054b0393d5efcdbbe2d729ed4682badd7907366373efb0b5c"

URI_aarch64_collectd-nut = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-nut-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-nut;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-nut}"
SRC_URI[aarch64_collectd-nut.sha256sum] = "2544778b575baad2a554c82f072653242b0040592ac9b8670edf2828cb1bae78"

URI_aarch64_collectd-openldap = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-openldap-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-openldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-openldap}"
SRC_URI[aarch64_collectd-openldap.sha256sum] = "8ac9d84dda0e73d2c09998e712c07d5b09bad7addcb771115bf8d42719b65bcd"

URI_aarch64_collectd-pinba = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-pinba-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-pinba;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-pinba}"
SRC_URI[aarch64_collectd-pinba.sha256sum] = "0add19434180440055e6aa3f5664534b364ce2bb91e914b47d049b23b85b3ff3"

URI_aarch64_collectd-ping = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-ping-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-ping;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-ping}"
SRC_URI[aarch64_collectd-ping.sha256sum] = "fedbd9759d800271099de91dfdff8ece5adbd863adcc7ab0dc849eb23cdf9d0f"

URI_aarch64_collectd-postgresql = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-postgresql-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-postgresql}"
SRC_URI[aarch64_collectd-postgresql.sha256sum] = "c9a3a080e220c05f1cb1cde064013cce6f4cb73e3484c00dc5c22022c70a708b"

URI_aarch64_collectd-python = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-python-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-python}"
SRC_URI[aarch64_collectd-python.sha256sum] = "a58b1a0b521d6a934b9a784e6b75221f539e0e70f728ec7af4ff83872b8c2d28"

URI_aarch64_collectd-redis = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-redis-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-redis}"
SRC_URI[aarch64_collectd-redis.sha256sum] = "a24a7962031b127a67bd00938541d1c57f1c068497d83fa0699cd9acfd545be2"

URI_aarch64_collectd-rrdcached = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-rrdcached-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-rrdcached;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-rrdcached}"
SRC_URI[aarch64_collectd-rrdcached.sha256sum] = "4333efaa576dd35ac1b95f422f1fa299176f38d028b2c8b1c4ec234c56a0c4a8"

URI_aarch64_collectd-rrdtool = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-rrdtool-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-rrdtool;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-rrdtool}"
SRC_URI[aarch64_collectd-rrdtool.sha256sum] = "6f3b39d50bfca3c5f92b8f639981990f95b9564f1ac333f0fd9fa30e188d9a9c"

URI_aarch64_collectd-sensors = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-sensors-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-sensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-sensors}"
SRC_URI[aarch64_collectd-sensors.sha256sum] = "68479bc8393f507bde2fa546b309558105f65507dc7dc748a1468cc0eb51a668"

URI_aarch64_collectd-smart = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-smart-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-smart}"
SRC_URI[aarch64_collectd-smart.sha256sum] = "dcfbb7328729ab06db1c5419338c90f0843d9c4224b87a542ab87848f4eb83e3"

URI_aarch64_collectd-snmp = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-snmp-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-snmp}"
SRC_URI[aarch64_collectd-snmp.sha256sum] = "e82e51f31c7f9bead509cf033f9bf2768c10e9c12d9d650a4ff97f6b594947c8"

URI_aarch64_collectd-snmp_agent = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-snmp_agent-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-snmp_agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-snmp_agent}"
SRC_URI[aarch64_collectd-snmp_agent.sha256sum] = "108bca2e57d63ca03d6668b5170e0e5560818c8fa0f3e79aa041ac7c245ab120"

URI_aarch64_collectd-synproxy = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-synproxy-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-synproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-synproxy}"
SRC_URI[aarch64_collectd-synproxy.sha256sum] = "f8a35d766675b5459329a0f66d5bff1d1d9225ad93a09e439656c50e80421e63"

URI_aarch64_collectd-utils = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-utils-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-utils}"
SRC_URI[aarch64_collectd-utils.sha256sum] = "e28a4251eceab90a629e8fd67d92b306cc7e4a45f496e4bc44401d21cd3dbee4"

URI_aarch64_collectd-varnish = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-varnish-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-varnish;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-varnish}"
SRC_URI[aarch64_collectd-varnish.sha256sum] = "19231d9bdef62d161c22764071acbcdcb580588a8034a009b62ab3598e8072d4"

URI_aarch64_collectd-virt = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-virt-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-virt}"
SRC_URI[aarch64_collectd-virt.sha256sum] = "d95674b899e23dc77ff5b18fe8729638a90922bc9c88147c6e55500508377d1a"

URI_aarch64_collectd-web = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-web-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-web}"
SRC_URI[aarch64_collectd-web.sha256sum] = "1efb9af615e3fa7e6372e385ce07d86f7a3189a35f390480bf67e6ff61fe8dba"

URI_aarch64_collectd-write_http = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_http-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-write_http;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_http}"
SRC_URI[aarch64_collectd-write_http.sha256sum] = "7216c99cf9be6549bf5c05d9fb82dbc2094fb680fb79e3a3307c7e9dc3161d9b"

URI_aarch64_collectd-write_kafka = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_kafka-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-write_kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_kafka}"
SRC_URI[aarch64_collectd-write_kafka.sha256sum] = "390bb7dba267d3d793691008efec14e2ee2d54bc73a0067680acbe249a61d275"

URI_aarch64_collectd-write_prometheus = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_prometheus-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-write_prometheus;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_prometheus}"
SRC_URI[aarch64_collectd-write_prometheus.sha256sum] = "ce4528a207d8b9842a1803671ac14fde075c2f87a26d548f40d9d5e4bb0195ff"

URI_aarch64_collectd-write_redis = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_redis-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-write_redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_redis}"
SRC_URI[aarch64_collectd-write_redis.sha256sum] = "0e0fc423df3fee90265284c47ddb843c04e6fa60fbc4f5c88b6b031bc2374cec"

URI_aarch64_collectd-write_riemann = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_riemann-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-write_riemann;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_riemann}"
SRC_URI[aarch64_collectd-write_riemann.sha256sum] = "faaeff01f74f9452f48b74bdbfa3747ad729931e814566ebb7b00b7fc12be3da"

URI_aarch64_collectd-write_sensu = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_sensu-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-write_sensu;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_sensu}"
SRC_URI[aarch64_collectd-write_sensu.sha256sum] = "8b9e3d8955907c78a3f5808a4bdf0503292a76d583a13e2a9bf8a53f3d636599"

URI_aarch64_collectd-write_syslog = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_syslog-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-write_syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_syslog}"
SRC_URI[aarch64_collectd-write_syslog.sha256sum] = "8b355b10a458d60009268e0a3a941f2b9b96f93d99535e732e03524147f80a0a"

URI_aarch64_collectd-write_tsdb = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-write_tsdb-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-write_tsdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-write_tsdb}"
SRC_URI[aarch64_collectd-write_tsdb.sha256sum] = "f1d9faef84414a9e96f3a8092fd69efe0bf6873c1fcdcfbb420ef9a5d0dfa77d"

URI_aarch64_collectd-zookeeper = "${EPEL_MIRROR}/aarch64/Packages/c/collectd-zookeeper-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_collectd-zookeeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_collectd-zookeeper}"
SRC_URI[aarch64_collectd-zookeeper.sha256sum] = "845ba408ab106043231f03142383d4a7091f874db2f26822ed49e59c1393299e"

URI_aarch64_libcollectdclient = "${EPEL_MIRROR}/aarch64/Packages/l/libcollectdclient-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_libcollectdclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcollectdclient}"
SRC_URI[aarch64_libcollectdclient.sha256sum] = "174089c329ee0875a53870739955e0b7a5a5159d7b84963c4d244967639e42a5"

URI_aarch64_libcollectdclient-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcollectdclient-devel-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_libcollectdclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcollectdclient-devel}"
SRC_URI[aarch64_libcollectdclient-devel.sha256sum] = "aab8eb753c62235eb79fe66abe0f8383cfbc83f7e7344454cfc8b535977c1f30"

URI_aarch64_perl-Collectd = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Collectd-5.12.0-63.el10_3.aarch64.rpm;name=aarch64_perl-Collectd;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Collectd}"
SRC_URI[aarch64_perl-Collectd.sha256sum] = "1ee0d2a3fec2b5769278094bea9d39a7f52a7acc51f7a98530911e7872a5bee9"

RDEPENDS:collectd = " \
 bash \
 glibc \
 libgcrypt \
 libgpg-error \
 libmnl \
 systemd \
 "
RDEPENDS:collectd-amqp = " \
 collectd \
 glibc \
 librabbitmq \
 "
RDEPENDS:collectd-amqp1 = " \
 collectd \
 glibc \
 qpid-proton-c \
 "
RDEPENDS:collectd-apache = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-ascent = " \
 collectd \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-bind = " \
 collectd \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-chrony = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-curl = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-curl_xml = " \
 collectd \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-dbi = " \
 collectd \
 glibc \
 libdbi \
 "
RDEPENDS:collectd-disk = " \
 collectd \
 glibc \
 systemd-libs \
 "
RDEPENDS:collectd-dns = " \
 collectd \
 glibc \
 libpcap \
 "
RDEPENDS:collectd-drbd = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-email = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-generic-jmx = " \
 collectd \
 "
RDEPENDS:collectd-gps = " \
 collectd \
 glibc \
 gpsd-libs \
 "
RDEPENDS:collectd-hugepages = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-infiniband = " \
 glibc \
 "
RDEPENDS:collectd-ipmi = " \
 OpenIPMI-libs \
 collectd \
 glibc \
 "
RDEPENDS:collectd-ipvs = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-java = " \
 collectd \
 glibc \
 java-21-openjdk-headless \
 "
RDEPENDS:collectd-lua = " \
 collectd \
 glibc \
 lua-libs \
 "
RDEPENDS:collectd-mcelog = " \
 collectd \
 glibc \
 libgcc \
 "
RDEPENDS:collectd-mdevents = " \
 glibc \
 "
RDEPENDS:collectd-memcachec = " \
 collectd \
 glibc \
 libmemcached-awesome \
 "
RDEPENDS:collectd-modbus = " \
 collectd \
 glibc \
 libmodbus \
 "
RDEPENDS:collectd-mysql = " \
 collectd \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:collectd-netlink = " \
 collectd \
 glibc \
 libmnl \
 "
RDEPENDS:collectd-nginx = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-notify_desktop = " \
 collectd \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libnotify \
 "
RDEPENDS:collectd-notify_email = " \
 collectd \
 glibc \
 libesmtp \
 "
RDEPENDS:collectd-nut:x86_64_v2 = " \
 collectd \
 glibc \
 openssl-libs \
"
RDEPENDS:collectd-nut:aarch64 = " \
 collectd \
 glibc \
 nut-client \
 openssl-libs \
"
RDEPENDS:collectd-openldap = " \
 collectd \
 glibc \
 openldap \
 "
RDEPENDS:collectd-pinba = " \
 collectd \
 glibc \
 protobuf-c \
 "
RDEPENDS:collectd-ping = " \
 collectd \
 glibc \
 liboping \
 "
RDEPENDS:collectd-postgresql = " \
 collectd \
 glibc \
 libpq \
 "
RDEPENDS:collectd-python = " \
 collectd \
 glibc \
 python3-libs \
 "
RDEPENDS:collectd-redis = " \
 collectd \
 glibc \
 hiredis \
 "
RDEPENDS:collectd-rrdcached = " \
 collectd \
 glibc \
 rrdtool \
 "
RDEPENDS:collectd-rrdtool = " \
 collectd \
 glibc \
 rrdtool \
 "
RDEPENDS:collectd-sensors = " \
 collectd \
 glibc \
 lm_sensors-libs \
 "
RDEPENDS:collectd-smart = " \
 collectd \
 glibc \
 libatasmart \
 systemd-libs \
 "
RDEPENDS:collectd-snmp = " \
 collectd \
 glibc \
 net-snmp-libs \
 "
RDEPENDS:collectd-snmp_agent = " \
 collectd \
 glibc \
 net-snmp-agent-libs \
 "
RDEPENDS:collectd-synproxy = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-utils = " \
 collectd \
 glibc \
 libcollectdclient \
 "
RDEPENDS:collectd-varnish = " \
 collectd \
 glibc \
 varnish \
 "
RDEPENDS:collectd-virt = " \
 collectd \
 glibc \
 libvirt-libs \
 libxml2 \
 "
RDEPENDS:collectd-web = " \
 collectd \
 collectd-rrdtool \
 httpd \
 perl-CGI \
 perl-Carp \
 perl-Collectd \
 perl-Config-General \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Temp \
 perl-FindBin \
 perl-HTML-Parser \
 perl-JSON \
 perl-Regexp-Common \
 perl-URI \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 rrdtool-perl \
 "
RDEPENDS:collectd-write_http = " \
 collectd \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:collectd-write_kafka = " \
 collectd \
 glibc \
 librdkafka \
 "
RDEPENDS:collectd-write_prometheus = " \
 collectd \
 glibc \
 libmicrohttpd \
 protobuf-c \
 "
RDEPENDS:collectd-write_redis = " \
 collectd \
 glibc \
 hiredis \
 "
RDEPENDS:collectd-write_riemann = " \
 collectd \
 glibc \
 riemann-c-client \
 "
RDEPENDS:collectd-write_sensu = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-write_syslog = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-write_tsdb = " \
 collectd \
 glibc \
 "
RDEPENDS:collectd-zookeeper = " \
 collectd \
 glibc \
 "
RDEPENDS:libcollectdclient = " \
 glibc \
 libgcrypt \
 libgpg-error \
 "
RDEPENDS:libcollectdclient-devel = " \
 libcollectdclient \
 pkgconf-pkg-config \
 "
RDEPENDS:perl-Collectd = " \
 collectd \
 glibc \
 libxcrypt \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
