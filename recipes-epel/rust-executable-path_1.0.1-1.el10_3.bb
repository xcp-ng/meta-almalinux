# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-executable-path"
PV = "1.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-executable-path+default-devel \
 rust-executable-path-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-executable-path-1.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7aba00f0f13c247ee2c7b13e6821a3c8b952477cc962fd725ba4e64be470a7f"

URI_x86_64_v2_rust-executable-path+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-executable-path+default-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-executable-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-executable-path+default-devel}"
SRC_URI[x86_64_v2_rust-executable-path+default-devel.sha256sum] = "da30c4b8d78f61c2f871a714fb6628ed1dcc2b88b564596fa8b2e099893a130f"

URI_x86_64_v2_rust-executable-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-executable-path-devel-1.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-executable-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-executable-path-devel}"
SRC_URI[x86_64_v2_rust-executable-path-devel.sha256sum] = "d96a190f6064a3d6728484c7d47209bea6600e1559be878bb461d3b7bb54a13b"

URI_aarch64_rust-executable-path+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-executable-path+default-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-executable-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-executable-path+default-devel}"
SRC_URI[aarch64_rust-executable-path+default-devel.sha256sum] = "afabb538d8d523eba4013922353146702abe149ee793cf4b3747aa37d07294e9"

URI_aarch64_rust-executable-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-executable-path-devel-1.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-executable-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-executable-path-devel}"
SRC_URI[aarch64_rust-executable-path-devel.sha256sum] = "9c3fa85c44f1f7d4eb89321413d6ca58e145a634dd152cf59c60b6e5d05f03ec"

RDEPENDS:rust-executable-path+default-devel = " \
 cargo \
 rust-executable-path-devel \
 "
RDEPENDS:rust-executable-path-devel = " \
 cargo \
 "
