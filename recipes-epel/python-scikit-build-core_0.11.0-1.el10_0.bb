# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-scikit-build-core"
PV = "0.11.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-scikit-build-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-scikit-build-core-0.11.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4cc47276c3f6dfeecb8862ab28000542ca67b0f1b051227d8c8d56c4d94aaec"

URI_x86_64_v2_python3-scikit-build-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scikit-build-core-0.11.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scikit-build-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scikit-build-core}"
SRC_URI[x86_64_v2_python3-scikit-build-core.sha256sum] = "e3ba72d9f0e430d066ba587efaf0c998559de082049938adfbe8f0ebf977c1e0"

URI_aarch64_python3-scikit-build-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scikit-build-core-0.11.0-1.el10_0.noarch.rpm;name=aarch64_python3-scikit-build-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scikit-build-core}"
SRC_URI[aarch64_python3-scikit-build-core.sha256sum] = "7aac96ae4161e690cdaa1f4a0b05dfbc876542b0056d0a5a9ad4eef1e8401ceb"

RDEPENDS:python3-scikit-build-core = " \
 cmake \
 ninja-build \
 python3 \
 python3-packaging \
 python3-pathspec \
 "
