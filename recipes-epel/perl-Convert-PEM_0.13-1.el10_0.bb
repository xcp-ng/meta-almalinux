# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Convert-PEM"
PV = "0.13"
PR = "1.el10_0"
PACKAGES = " \
 perl-Convert-PEM \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Convert-PEM-0.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f8014d48161c3ae71ab2d65fc36d3806d6ac6d43c0fc17bbebfe98f3ccb92c9"

URI_x86_64_v2_perl-Convert-PEM = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Convert-PEM-0.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Convert-PEM;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Convert-PEM}"
SRC_URI[x86_64_v2_perl-Convert-PEM.sha256sum] = "d8ce6cfd342da3407822ae9cb1be95b9ce8ed5421a84b5acf370672222796cdf"

URI_aarch64_perl-Convert-PEM = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Convert-PEM-0.13-1.el10_0.noarch.rpm;name=aarch64_perl-Convert-PEM;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Convert-PEM}"
SRC_URI[aarch64_perl-Convert-PEM.sha256sum] = "694e21b0e53265c4819e543cd0b0a482cbb5d3d446afeebb4d634c2e43786f15"

RDEPENDS:perl-Convert-PEM = " \
 perl-Carp \
 perl-Class-ErrorHandler \
 perl-Convert-ASN1 \
 perl-Convert-PEM \
 perl-Crypt-DES_EDE3 \
 perl-CryptX \
 perl-Digest-MD5 \
 perl-MIME-Base64 \
 perl-base \
 perl-libs \
 perl-vars \
 "
