# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tornado"
PV = "6.5.8"
PR = "0.el10_2.1"
PACKAGES = " \
 python3-tornado \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-tornado-6.5.8-0.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a1c4661fabb3d218a00b5a3bc014c4189f119250a950efe3f90b2921c4e56ee6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tornado-6.5.8-0.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-tornado;unpack=0"
SRC_URI[x86_64_v2_python3-tornado.sha256sum] = "9a15dd045d74c47feddceb0f5bbe7f9a52cc12b376c3dbcb4379040edc1e3045"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tornado-6.5.8-0.el10_2.1.aarch64.rpm;name=aarch64_python3-tornado;unpack=0"
SRC_URI[aarch64_python3-tornado.sha256sum] = "7de3767eabe2c5bf48b0e113f5aa38a23fc874ed8bb96e39c74850f3a21dc291"

RDEPENDS:python3-tornado = " \
 glibc \
 python3 \
 "
