# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-addr2line"
PV = "0.25.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-addr2line+cargo-all-devel \
 rust-addr2line+cpp_demangle-devel \
 rust-addr2line+default-devel \
 rust-addr2line+fallible-iterator-devel \
 rust-addr2line+loader-devel \
 rust-addr2line+rustc-demangle-devel \
 rust-addr2line+smallvec-devel \
 rust-addr2line+std-devel \
 rust-addr2line-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-addr2line-0.25.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6bdc29e31fc598cb75790e3c505eda81b8bfaba7002fc0df5b2ff8910980f8b"

URI_x86_64_v2_rust-addr2line+cargo-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+cargo-all-devel-0.25.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+cargo-all-devel}"
SRC_URI[x86_64_v2_rust-addr2line+cargo-all-devel.sha256sum] = "42b2a9764059e2509cccc3500e9b6e3ca2f2e9ea05a75d063d7ef1ddbafdaa46"

URI_x86_64_v2_rust-addr2line+cpp_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+cpp_demangle-devel-0.25.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+cpp_demangle-devel}"
SRC_URI[x86_64_v2_rust-addr2line+cpp_demangle-devel.sha256sum] = "f28e6160254fdcdf6f60f8b0ef0d9610f7dce9f8ddd16fd63c3236b0cf08b4f0"

URI_x86_64_v2_rust-addr2line+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+default-devel-0.25.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+default-devel}"
SRC_URI[x86_64_v2_rust-addr2line+default-devel.sha256sum] = "256bb438da0e8699f56b31e5b314c9a8b1e1eb43e3ef0ac2a70c10c7a08ddeba"

URI_x86_64_v2_rust-addr2line+fallible-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+fallible-iterator-devel-0.25.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+fallible-iterator-devel}"
SRC_URI[x86_64_v2_rust-addr2line+fallible-iterator-devel.sha256sum] = "15af9f734c1b0870b6f70ffae913244f97b21447ac2c6e411f010a232ece7e77"

URI_x86_64_v2_rust-addr2line+loader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+loader-devel-0.25.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+loader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+loader-devel}"
SRC_URI[x86_64_v2_rust-addr2line+loader-devel.sha256sum] = "11d9ede150819429705adfab448c02b7876a30c8feb311fc2d91ff709cc25d1e"

URI_x86_64_v2_rust-addr2line+rustc-demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+rustc-demangle-devel-0.25.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+rustc-demangle-devel}"
SRC_URI[x86_64_v2_rust-addr2line+rustc-demangle-devel.sha256sum] = "84785e7f0b149778de6259e33495eb5d8a2c271b2283b0cfbe0adf4a70d6e619"

URI_x86_64_v2_rust-addr2line+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+smallvec-devel-0.25.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+smallvec-devel}"
SRC_URI[x86_64_v2_rust-addr2line+smallvec-devel.sha256sum] = "6dbf7c2f9e7dd03dc43987ea2f38bcf78dee3a00e312a878c32528648c432607"

URI_x86_64_v2_rust-addr2line+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line+std-devel-0.25.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line+std-devel}"
SRC_URI[x86_64_v2_rust-addr2line+std-devel.sha256sum] = "6d0c637dd0181dcde89cd2b6442658f3204d466e24dabbc3d8fd59836bbe66a9"

URI_x86_64_v2_rust-addr2line-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-addr2line-devel-0.25.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-addr2line-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-addr2line-devel}"
SRC_URI[x86_64_v2_rust-addr2line-devel.sha256sum] = "f5c72d171289a0341f4803aa338dd7683db81af217de1a6e4a7d50979deac423"

URI_aarch64_rust-addr2line+cargo-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+cargo-all-devel-0.25.1-1.el10_2.noarch.rpm;name=aarch64_rust-addr2line+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+cargo-all-devel}"
SRC_URI[aarch64_rust-addr2line+cargo-all-devel.sha256sum] = "eba3b4e518c705d59577426ca57512b4c27c910c8caeb6163f0982a68a70367a"

URI_aarch64_rust-addr2line+cpp_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+cpp_demangle-devel-0.25.1-1.el10_2.noarch.rpm;name=aarch64_rust-addr2line+cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+cpp_demangle-devel}"
SRC_URI[aarch64_rust-addr2line+cpp_demangle-devel.sha256sum] = "2e0dca7e3d03a9f5dd502cdf28d68e0c9934237da353c757ff67fc0f79390149"

URI_aarch64_rust-addr2line+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+default-devel-0.25.1-1.el10_2.noarch.rpm;name=aarch64_rust-addr2line+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+default-devel}"
SRC_URI[aarch64_rust-addr2line+default-devel.sha256sum] = "5d3fd5cafcc2c8bc2f4923e73001e88d080599f04dfe1d2168d42ed859d229eb"

URI_aarch64_rust-addr2line+fallible-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+fallible-iterator-devel-0.25.1-1.el10_2.noarch.rpm;name=aarch64_rust-addr2line+fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+fallible-iterator-devel}"
SRC_URI[aarch64_rust-addr2line+fallible-iterator-devel.sha256sum] = "efb6c04e626a5b2e61fc9c93d3f89e09b11351cb5fa0ccf0d7efe9285785c6e9"

URI_aarch64_rust-addr2line+loader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+loader-devel-0.25.1-1.el10_2.noarch.rpm;name=aarch64_rust-addr2line+loader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+loader-devel}"
SRC_URI[aarch64_rust-addr2line+loader-devel.sha256sum] = "3905b9a364270938b78d18cdb4760bb60c66128c8cd2d98b5426878e8cea25a4"

URI_aarch64_rust-addr2line+rustc-demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+rustc-demangle-devel-0.25.1-1.el10_2.noarch.rpm;name=aarch64_rust-addr2line+rustc-demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+rustc-demangle-devel}"
SRC_URI[aarch64_rust-addr2line+rustc-demangle-devel.sha256sum] = "4e1799467793678ba6610bc266010c284a7e1fdc7ced345c04d79851ab273531"

URI_aarch64_rust-addr2line+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+smallvec-devel-0.25.1-1.el10_2.noarch.rpm;name=aarch64_rust-addr2line+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+smallvec-devel}"
SRC_URI[aarch64_rust-addr2line+smallvec-devel.sha256sum] = "ffa64f59944ec9d14b47b2b35d9050fefae4a201f9bfa16da715e370990600ea"

URI_aarch64_rust-addr2line+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line+std-devel-0.25.1-1.el10_2.noarch.rpm;name=aarch64_rust-addr2line+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line+std-devel}"
SRC_URI[aarch64_rust-addr2line+std-devel.sha256sum] = "dd1009ac406ea7488c304d769bae97da602c9a8a80cdba97274ec551a5e673c6"

URI_aarch64_rust-addr2line-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-addr2line-devel-0.25.1-1.el10_2.noarch.rpm;name=aarch64_rust-addr2line-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-addr2line-devel}"
SRC_URI[aarch64_rust-addr2line-devel.sha256sum] = "3a0e8e8b72f6130ed333182ad58809e935d324abbde585e50b165f823bfde3fe"

RDEPENDS:rust-addr2line+cargo-all-devel = " \
 cargo \
 rust-addr2line-devel \
 "
RDEPENDS:rust-addr2line+cpp_demangle-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-addr2line+default-devel = " \
 cargo \
 rust-addr2line+cpp_demangle-devel \
 rust-addr2line+fallible-iterator-devel \
 rust-addr2line+loader-devel \
 rust-addr2line+rustc-demangle-devel \
 rust-addr2line+smallvec-devel \
 rust-addr2line-devel \
 "
RDEPENDS:rust-addr2line+fallible-iterator-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-fallible-iterator-devel \
 "
RDEPENDS:rust-addr2line+loader-devel = " \
 cargo \
 rust-addr2line+std-devel \
 rust-addr2line-devel \
 rust-memmap2+default-devel \
 rust-object0.37+compression-devel \
 rust-object0.37+read-devel \
 rust-object0.37-devel \
 rust-typed-arena+default-devel \
 "
RDEPENDS:rust-addr2line+rustc-demangle-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-rustc-demangle+default-devel \
 "
RDEPENDS:rust-addr2line+smallvec-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-addr2line+std-devel = " \
 cargo \
 rust-addr2line-devel \
 rust-gimli+std-devel \
 "
RDEPENDS:rust-addr2line-devel = " \
 cargo \
 rust \
 rust-gimli+read-devel \
 rust-gimli-devel \
 "
