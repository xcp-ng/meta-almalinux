# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kiconthemes"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kiconthemes \
 kf6-kiconthemes-devel \
 kf6-kiconthemes-doc \
 kf6-kiconthemes-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kiconthemes-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8da280782438e01516b525cd59c0a2c8092f347ba9e8103c2a2194afe69fcd6f"

URI_x86_64_v2_kf6-kiconthemes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes}"
SRC_URI[x86_64_v2_kf6-kiconthemes.sha256sum] = "2ac7636467230b3bddb73e703a4b3aadaf093cece1fc916d71b558c31af84352"

URI_x86_64_v2_kf6-kiconthemes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kiconthemes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-devel}"
SRC_URI[x86_64_v2_kf6-kiconthemes-devel.sha256sum] = "2dc72dcdddd517c6072c6b3d3faba868ed629001e8588becf090201182301190"

URI_x86_64_v2_kf6-kiconthemes-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kiconthemes-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-doc}"
SRC_URI[x86_64_v2_kf6-kiconthemes-doc.sha256sum] = "9848900d068329ca604e5fe03d3157790bf11b08ebb22561f34ee60a411b3a93"

URI_x86_64_v2_kf6-kiconthemes-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kiconthemes-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kiconthemes-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kiconthemes-html}"
SRC_URI[x86_64_v2_kf6-kiconthemes-html.sha256sum] = "292e0b7b7d825866ad104b8a345763a664d308af49b3cf2ee1aa27dcbc1353f7"

URI_aarch64_kf6-kiconthemes = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kiconthemes;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes}"
SRC_URI[aarch64_kf6-kiconthemes.sha256sum] = "5d8b7788e46c3dd3fffc8c725e5627ad9bdd8adfc98a691db84d63c2f55e65ff"

URI_aarch64_kf6-kiconthemes-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kiconthemes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-devel}"
SRC_URI[aarch64_kf6-kiconthemes-devel.sha256sum] = "a1554cd8747e70ca52516507b47edb77fcdc6a52e90ab38416c1028d9d7bd768"

URI_aarch64_kf6-kiconthemes-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kiconthemes-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-doc}"
SRC_URI[aarch64_kf6-kiconthemes-doc.sha256sum] = "56ae2a7428eaf241ba9e7c5473feb7a3b700bc5a7809f794eec2e8d247c52ec7"

URI_aarch64_kf6-kiconthemes-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kiconthemes-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kiconthemes-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kiconthemes-html}"
SRC_URI[aarch64_kf6-kiconthemes-html.sha256sum] = "6732dbc8e7281ba2b7e39599ee47e32213b96fab8d2327a333669158e6a07b95"

RDEPENDS:kf6-kiconthemes = " \
 glibc \
 hicolor-icon-theme \
 kf6-breeze-icons \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kiconthemes-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kiconthemes-doc = " \
 "
RDEPENDS:kf6-kiconthemes-html = " \
 "
