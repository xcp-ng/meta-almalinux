# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khelpcenter"
PE = "1"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 khelpcenter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khelpcenter-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9c56a8893ed3ac9b8a037716f03deb51ac12f2c97b608ccb43d45840a218210"

URI_x86_64_v2_khelpcenter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khelpcenter-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khelpcenter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khelpcenter}"
SRC_URI[x86_64_v2_khelpcenter.sha256sum] = "362e0251f31ab087b0e50db0c4b93f6154cbf27029a49be87a817b79b5c46ff2"

URI_aarch64_khelpcenter = "${EPEL_MIRROR}/aarch64/Packages/k/khelpcenter-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_khelpcenter;unpack=0"
SRC_URI:append = " ${URI_aarch64_khelpcenter}"
SRC_URI[aarch64_khelpcenter.sha256sum] = "ffbceb23748f2c1e16e9e2daf87940f17c3f1f8cd166c2c4897d395d42bd4732"

RDEPENDS:khelpcenter = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdoctools \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 libxml2 \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 xapian-core-libs \
 "
