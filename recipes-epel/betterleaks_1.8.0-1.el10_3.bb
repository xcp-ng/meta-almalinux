# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "betterleaks"
PV = "1.8.0"
PR = "1.el10_3"
PACKAGES = " \
 betterleaks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/betterleaks-1.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac22611d47ae2ac612799388c5213069cee79cb16d177a158dd1704efe156654"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/betterleaks-1.8.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_betterleaks;unpack=0"
SRC_URI[x86_64_v2_betterleaks.sha256sum] = "7ac9eeff795e01a8134f54ef766672bce722a162ccfb6bed9856e12fb646749f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/betterleaks-1.8.0-1.el10_3.aarch64.rpm;name=aarch64_betterleaks;unpack=0"
SRC_URI[aarch64_betterleaks.sha256sum] = "818891217e52c3aa72cc0fb914f429804d432fc8efd18be83949e4414035c6c8"

RDEPENDS:betterleaks = " \
 git-core \
 glibc \
 "
