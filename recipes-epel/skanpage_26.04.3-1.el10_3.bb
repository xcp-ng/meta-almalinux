# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skanpage"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 skanpage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skanpage-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79ad2eae6be78a22d3ad77a05f4de2d4331eda644b6e7ab24cd3d81b8ba72c03"

URI_x86_64_v2_skanpage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skanpage-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skanpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skanpage}"
SRC_URI[x86_64_v2_skanpage.sha256sum] = "653b64e846a1b95f2af2fd0347e9452131266780e7beee2a98852c7bdfd0c636"

URI_aarch64_skanpage = "${EPEL_MIRROR}/aarch64/Packages/s/skanpage-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_skanpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_skanpage}"
SRC_URI[aarch64_skanpage.sha256sum] = "65c42ef7fb165446b9d0b78cf65614d16c911a98d8283ceee289e6c6c0a56730"

RDEPENDS:skanpage = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kirigami \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kquickimageeditor-qt6 \
 ksanecore \
 leptonica \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 tesseract \
 "
