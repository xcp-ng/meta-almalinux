# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-jpeg"
PV = "0.5.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-zune-jpeg+default-devel \
 rust-zune-jpeg+log-devel \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+portable_simd-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-jpeg-0.5.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "404811d1e76cc10001c40e4eeedcc34bcae0861851b29fb205510f9ca3d285f8"

URI_x86_64_v2_rust-zune-jpeg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+default-devel-0.5.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+default-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+default-devel.sha256sum] = "67a27814e5492974b0fe5bcd11f5d0895865d1c0a8b4be62c63853ea30b7190c"

URI_x86_64_v2_rust-zune-jpeg+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+log-devel-0.5.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+log-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+log-devel.sha256sum] = "4a663658e3f034d3aeaebedb2129f34721676586863256316778c2f4cea3b4b2"

URI_x86_64_v2_rust-zune-jpeg+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+neon-devel-0.5.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+neon-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+neon-devel.sha256sum] = "db8457b7bc2884239cb7874b6606d8777a18188355627a01e7ae6a3057156a92"

URI_x86_64_v2_rust-zune-jpeg+portable_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+portable_simd-devel-0.5.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+portable_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+portable_simd-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+portable_simd-devel.sha256sum] = "e34d292e344ef658a432ff513c557de38437cc3e352b65a1377005b177484e0c"

URI_x86_64_v2_rust-zune-jpeg+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+std-devel-0.5.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+std-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+std-devel.sha256sum] = "d02909163b78daa52b01b8afb89937fa5f72b8a72dee67dc0e006db63f0e04a7"

URI_x86_64_v2_rust-zune-jpeg+x86-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+x86-devel-0.5.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+x86-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+x86-devel.sha256sum] = "a5265cb69c09c7f6e9b8777e5e448b500faaef0146223cceaf25618a00400a5f"

URI_x86_64_v2_rust-zune-jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg-devel-0.5.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg-devel.sha256sum] = "16456e5ddc782c9c94ab82923898cce77c76bb57b02b58aa494c02f500d481bd"

URI_aarch64_rust-zune-jpeg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+default-devel-0.5.13-1.el10_3.noarch.rpm;name=aarch64_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+default-devel}"
SRC_URI[aarch64_rust-zune-jpeg+default-devel.sha256sum] = "2d60027b7284647be1d9b7f1f74563413ea89cad55f7515168c7f296a852617c"

URI_aarch64_rust-zune-jpeg+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+log-devel-0.5.13-1.el10_3.noarch.rpm;name=aarch64_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+log-devel}"
SRC_URI[aarch64_rust-zune-jpeg+log-devel.sha256sum] = "1d48c9fce846c104b4e7927319b6e8eba0ac9872dbb7e8efc19d7d146486bc5b"

URI_aarch64_rust-zune-jpeg+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+neon-devel-0.5.13-1.el10_3.noarch.rpm;name=aarch64_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+neon-devel}"
SRC_URI[aarch64_rust-zune-jpeg+neon-devel.sha256sum] = "a6325ddcd61091ef7b59bf0a87ac02fc4f0b0dad59bc9d84b09b36a784c8f51b"

URI_aarch64_rust-zune-jpeg+portable_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+portable_simd-devel-0.5.13-1.el10_3.noarch.rpm;name=aarch64_rust-zune-jpeg+portable_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+portable_simd-devel}"
SRC_URI[aarch64_rust-zune-jpeg+portable_simd-devel.sha256sum] = "76b71df661882aa07eaeb7897e2af11323ef628cfac231d01a57d42869e2df4e"

URI_aarch64_rust-zune-jpeg+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+std-devel-0.5.13-1.el10_3.noarch.rpm;name=aarch64_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+std-devel}"
SRC_URI[aarch64_rust-zune-jpeg+std-devel.sha256sum] = "b79ededf286c1f2f9666bdafd677113d049c867eae96ff9fcb6dfacbc64923d8"

URI_aarch64_rust-zune-jpeg+x86-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+x86-devel-0.5.13-1.el10_3.noarch.rpm;name=aarch64_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+x86-devel}"
SRC_URI[aarch64_rust-zune-jpeg+x86-devel.sha256sum] = "f4d62f6aa413e2b2a40b2879b0a173ea54dbad1573681a498b70d0f035c45028"

URI_aarch64_rust-zune-jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg-devel-0.5.13-1.el10_3.noarch.rpm;name=aarch64_rust-zune-jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg-devel}"
SRC_URI[aarch64_rust-zune-jpeg-devel.sha256sum] = "d952a2df1b459bf6a639b8418cd3a1c159974059e399c951e2ceb922e9deac53"

RDEPENDS:rust-zune-jpeg+default-devel = " \
 cargo \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+log-devel = " \
 cargo \
 rust-zune-core+log-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+neon-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+portable_simd-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+std-devel = " \
 cargo \
 rust-zune-core+std-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+x86-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg-devel = " \
 cargo \
 rust \
 rust-zune-core+default-devel \
 "
