# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-libreswan"
PV = "1.2.29"
PR = "1.el10_1"
PACKAGES = " \
 NetworkManager-libreswan \
 NetworkManager-libreswan-gnome \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/NetworkManager-libreswan-1.2.29-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dfe9706eda4ba50ce84bc8f2bd96e2f6a61052619322452b2cb70e8aa92d7379"

URI_x86_64_v2_NetworkManager-libreswan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-1.2.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libreswan}"
SRC_URI[x86_64_v2_NetworkManager-libreswan.sha256sum] = "5954c470f0385c423218e85f9df02512e9e6515f3a12d9c905ac238d4236bc7d"

URI_x86_64_v2_NetworkManager-libreswan-gnome = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-gnome-1.2.29-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libreswan-gnome}"
SRC_URI[x86_64_v2_NetworkManager-libreswan-gnome.sha256sum] = "cfbd19747eee208f1e3ee1178d3328947f12d6a458cf9ffecfc4b971b1a611c5"

URI_aarch64_NetworkManager-libreswan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-1.2.29-1.el10_1.aarch64.rpm;name=aarch64_NetworkManager-libreswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libreswan}"
SRC_URI[aarch64_NetworkManager-libreswan.sha256sum] = "d7a75f8ee09610efa12b6e8cf71b8ffd870c1dbd78235b7e768da406093c9d0f"

URI_aarch64_NetworkManager-libreswan-gnome = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-gnome-1.2.29-1.el10_1.aarch64.rpm;name=aarch64_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libreswan-gnome}"
SRC_URI[aarch64_NetworkManager-libreswan-gnome.sha256sum] = "8332cbbd57b5ec411a3a699a407cce3b82ce90635e798d89daf8f65008a2f62b"

RDEPENDS:NetworkManager-libreswan = " \
 NetworkManager \
 NetworkManager-libnm \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 libnl3 \
 libreswan \
 "
RDEPENDS:NetworkManager-libreswan-gnome = " \
 NetworkManager-libnm \
 NetworkManager-libreswan \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 pango \
 shared-mime-info \
 vulkan-loader \
 "
