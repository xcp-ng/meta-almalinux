# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mandoc"
PV = "1.14.6"
PR = "11.el10_1"
PACKAGES = " \
 libmandoc-devel \
 mandoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mandoc-1.14.6-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dfe32b0fcf497344c38de069b1c015cfeb00ea529bb40a4b2b63da440169f8d"

URI_x86_64_v2_libmandoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmandoc-devel-1.14.6-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmandoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmandoc-devel}"
SRC_URI[x86_64_v2_libmandoc-devel.sha256sum] = "ecf0a0f724f6b3f69d8c95c159db83b5625164808920795087065c98ba98d1e9"

URI_x86_64_v2_mandoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mandoc-1.14.6-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mandoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mandoc}"
SRC_URI[x86_64_v2_mandoc.sha256sum] = "c206652e088c71f5f15ec67ff0bd02189df81ebbe5580dba56148cef8377630d"
RPROVIDES:mandoc:x86_64_v2 = "virtual//usr/bin/man"

URI_aarch64_libmandoc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmandoc-devel-1.14.6-11.el10_1.aarch64.rpm;name=aarch64_libmandoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmandoc-devel}"
SRC_URI[aarch64_libmandoc-devel.sha256sum] = "9be29cc510fabc6806148579eec9d7391e20ed88960e6042815df73d6279b8de"

URI_aarch64_mandoc = "${EPEL_MIRROR}/aarch64/Packages/m/mandoc-1.14.6-11.el10_1.aarch64.rpm;name=aarch64_mandoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mandoc}"
SRC_URI[aarch64_mandoc.sha256sum] = "1143acbf26aab49e24f0a2ea1dd7ffdd384b1afbb61c2e0642c487f1d46c5fb3"
RPROVIDES:mandoc:aarch64 = "virtual//usr/bin/man"

RDEPENDS:libmandoc-devel = " \
 "
RDEPENDS:mandoc = " \
 alternatives \
 bash \
 glibc \
 zlib-ng-compat \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/man"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/man"
