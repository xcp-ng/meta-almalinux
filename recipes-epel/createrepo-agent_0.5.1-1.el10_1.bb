# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "createrepo-agent"
PV = "0.5.1"
PR = "1.el10_1"
PACKAGES = " \
 createrepo-agent \
 python3-createrepo-agent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/createrepo-agent-0.5.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95191d6651413d15e2125095a8640ffdc394bf60ce7e28b676e065815f0545e1"

URI_x86_64_v2_createrepo-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/createrepo-agent-0.5.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_createrepo-agent}"
SRC_URI[x86_64_v2_createrepo-agent.sha256sum] = "d4d673ef8d2fdb452621a83aeeb7e4e7183589e8ec715494f63c6e04f35c0d0b"

URI_x86_64_v2_python3-createrepo-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-createrepo-agent-0.5.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-createrepo-agent}"
SRC_URI[x86_64_v2_python3-createrepo-agent.sha256sum] = "6fdbf0a99471ec4a2485b464acbc6a7d75c408adea8d5344164756fde1de266a"

URI_aarch64_createrepo-agent = "${EPEL_MIRROR}/aarch64/Packages/c/createrepo-agent-0.5.1-1.el10_1.aarch64.rpm;name=aarch64_createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_createrepo-agent}"
SRC_URI[aarch64_createrepo-agent.sha256sum] = "bd6d0b21678698479e7587c4027284464ef8db32bf31700259a93bea8a2ea03c"

URI_aarch64_python3-createrepo-agent = "${EPEL_MIRROR}/aarch64/Packages/p/python3-createrepo-agent-0.5.1-1.el10_1.aarch64.rpm;name=aarch64_python3-createrepo-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-createrepo-agent}"
SRC_URI[aarch64_python3-createrepo-agent.sha256sum] = "903a594f03646ddf2a0fde1bcc39650de839fac2ddd82c9304016104e9bb277d"

RDEPENDS:createrepo-agent = " \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme \
 libassuan \
 libgpg-error \
 "
RDEPENDS:python3-createrepo-agent = " \
 createrepo-agent \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme \
 libassuan \
 libgpg-error \
 python3 \
 "
