# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MooseX-AttributeHelpers"
PV = "0.25"
PR = "23.el10_0"
PACKAGES = " \
 perl-MooseX-AttributeHelpers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MooseX-AttributeHelpers-0.25-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "734b881c5e7da174ac2015d37db6d257ce0a692e8a6a329246e03c60ff47b5c5"

URI_x86_64_v2_perl-MooseX-AttributeHelpers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooseX-AttributeHelpers-0.25-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooseX-AttributeHelpers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MooseX-AttributeHelpers}"
SRC_URI[x86_64_v2_perl-MooseX-AttributeHelpers.sha256sum] = "50093a0733015c9062839194b99a5b7cf448161f518ee8c7b746b85fc2c8f2ca"

URI_aarch64_perl-MooseX-AttributeHelpers = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MooseX-AttributeHelpers-0.25-23.el10_0.noarch.rpm;name=aarch64_perl-MooseX-AttributeHelpers;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MooseX-AttributeHelpers}"
SRC_URI[aarch64_perl-MooseX-AttributeHelpers.sha256sum] = "4e969cddd99c09867f70a49f7f3e9b545fb352ca48771328c06571f6695e239f"

RDEPENDS:perl-MooseX-AttributeHelpers = " \
 perl-Moose \
 perl-MooseX-AttributeHelpers \
 perl-libs \
 "
