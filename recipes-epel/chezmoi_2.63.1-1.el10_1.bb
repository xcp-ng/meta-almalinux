# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chezmoi"
PV = "2.63.1"
PR = "1.el10_1"
PACKAGES = " \
 chezmoi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/chezmoi-2.63.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67d00b0645c78f7d69e2239f7b4829eaccfce722b7cc1468cb83393349bf6a42"

URI_x86_64_v2_chezmoi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/chezmoi-2.63.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_chezmoi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_chezmoi}"
SRC_URI[x86_64_v2_chezmoi.sha256sum] = "4cc77f1a561df1d74cfe67f44396e68620d51bacb7938c8f344af0c808c9e87f"

URI_aarch64_chezmoi = "${EPEL_MIRROR}/aarch64/Packages/c/chezmoi-2.63.1-1.el10_1.aarch64.rpm;name=aarch64_chezmoi;unpack=0"
SRC_URI:append = " ${URI_aarch64_chezmoi}"
SRC_URI[aarch64_chezmoi.sha256sum] = "43f4fd21f0205a3431f6289bc2afac28200218dd773f262959ca19858a34e484"

RDEPENDS:chezmoi = " \
 glibc \
 "
