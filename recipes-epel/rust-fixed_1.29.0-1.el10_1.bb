# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fixed"
PV = "1.29.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-fixed+arbitrary-devel \
 rust-fixed+az-devel \
 rust-fixed+default-devel \
 rust-fixed+f16-devel \
 rust-fixed+fail-on-warnings-devel \
 rust-fixed+num-traits-devel \
 rust-fixed+serde-devel \
 rust-fixed+serde-str-devel \
 rust-fixed+std-devel \
 rust-fixed-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fixed-1.29.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a40111153d74deba8e30ef6b8fd90932a917623b1a1be3e9670645168e1fe66d"

URI_x86_64_v2_rust-fixed+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed+arbitrary-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-fixed+arbitrary-devel.sha256sum] = "dbf390487e72de5933310103aca007859397a2da4abd327e3a4a6b748e95da94"

URI_x86_64_v2_rust-fixed+az-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed+az-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed+az-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed+az-devel}"
SRC_URI[x86_64_v2_rust-fixed+az-devel.sha256sum] = "32595dc375e860ba974c74aff78a68ec0ad894cbe5ecee39f37fd19acda15a46"

URI_x86_64_v2_rust-fixed+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed+default-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed+default-devel}"
SRC_URI[x86_64_v2_rust-fixed+default-devel.sha256sum] = "cebe592429532c4c39c424c7c095b58661afeef5f7c79a9efb209046b5e18631"

URI_x86_64_v2_rust-fixed+f16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed+f16-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed+f16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed+f16-devel}"
SRC_URI[x86_64_v2_rust-fixed+f16-devel.sha256sum] = "1a1ac5f7cb19990b0e9732aa9fe2709f5d07a163a3a0d5148cacaee48665b3ca"

URI_x86_64_v2_rust-fixed+fail-on-warnings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed+fail-on-warnings-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed+fail-on-warnings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed+fail-on-warnings-devel}"
SRC_URI[x86_64_v2_rust-fixed+fail-on-warnings-devel.sha256sum] = "06f7397c5ee63f26510715130231ea436b1cc81758432d3bd03033b6d0450c14"

URI_x86_64_v2_rust-fixed+num-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed+num-traits-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed+num-traits-devel}"
SRC_URI[x86_64_v2_rust-fixed+num-traits-devel.sha256sum] = "08a87078d5b125c38ce80dbc225e1bd90f429fe6dd743824e106d8d264a73b11"

URI_x86_64_v2_rust-fixed+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed+serde-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed+serde-devel}"
SRC_URI[x86_64_v2_rust-fixed+serde-devel.sha256sum] = "4260b543f00e37a00c46af207851bf52bb058d605d52feafc76304aab0727c2c"

URI_x86_64_v2_rust-fixed+serde-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed+serde-str-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed+serde-str-devel}"
SRC_URI[x86_64_v2_rust-fixed+serde-str-devel.sha256sum] = "f5f42af2b65bc8b9d885adc2bccd60ed4a83ae28daedeac0949249618e0a3584"

URI_x86_64_v2_rust-fixed+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed+std-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed+std-devel}"
SRC_URI[x86_64_v2_rust-fixed+std-devel.sha256sum] = "af398b4c157d090ceb9090cc287593f123af02238709a39046fe523e1de586bb"

URI_x86_64_v2_rust-fixed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixed-devel-1.29.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixed-devel}"
SRC_URI[x86_64_v2_rust-fixed-devel.sha256sum] = "27d560d2bc956ebf26bd7e761ebbc651b6e5849394e2ce2085bff60e9564f2b0"

URI_aarch64_rust-fixed+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed+arbitrary-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed+arbitrary-devel}"
SRC_URI[aarch64_rust-fixed+arbitrary-devel.sha256sum] = "bf484aadffe01280eb42ef5cc63de3afd38720805bc3e070ace97b1726ebc3f9"

URI_aarch64_rust-fixed+az-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed+az-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed+az-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed+az-devel}"
SRC_URI[aarch64_rust-fixed+az-devel.sha256sum] = "28a6a37d7b982dc1dae3126e87718aaa4a73236ef50307ed6990ad1dbebb9b4a"

URI_aarch64_rust-fixed+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed+default-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed+default-devel}"
SRC_URI[aarch64_rust-fixed+default-devel.sha256sum] = "94396e3b1eb80826b803e880618e8fe7696ed817e6aea38aa6b138e44610945b"

URI_aarch64_rust-fixed+f16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed+f16-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed+f16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed+f16-devel}"
SRC_URI[aarch64_rust-fixed+f16-devel.sha256sum] = "df0bd62cae331e119c6f0168825a93c9e4a670da18e00c3e83eeedfaaa59245b"

URI_aarch64_rust-fixed+fail-on-warnings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed+fail-on-warnings-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed+fail-on-warnings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed+fail-on-warnings-devel}"
SRC_URI[aarch64_rust-fixed+fail-on-warnings-devel.sha256sum] = "ec0a9c726e0315681a069f649ef243b2e912df19161643f3954fbdfeca382b91"

URI_aarch64_rust-fixed+num-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed+num-traits-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed+num-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed+num-traits-devel}"
SRC_URI[aarch64_rust-fixed+num-traits-devel.sha256sum] = "03cb49ad52ebf2762d5f6a711a0bb1f3e151ffd7634ca3b57bf50b16482e32c6"

URI_aarch64_rust-fixed+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed+serde-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed+serde-devel}"
SRC_URI[aarch64_rust-fixed+serde-devel.sha256sum] = "8e7d273fffe2652da2d3d43a87539d8696a476f604c4899765539836a49cdeab"

URI_aarch64_rust-fixed+serde-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed+serde-str-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed+serde-str-devel}"
SRC_URI[aarch64_rust-fixed+serde-str-devel.sha256sum] = "8a5ec5fd85b381b715ef4c5dcb589424aad74f9195221253473547fe8e2c05e7"

URI_aarch64_rust-fixed+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed+std-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed+std-devel}"
SRC_URI[aarch64_rust-fixed+std-devel.sha256sum] = "84c42267d37da11505a47e8a175133d0fe83b9089ff051863d3e2979053446c6"

URI_aarch64_rust-fixed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixed-devel-1.29.0-1.el10_1.noarch.rpm;name=aarch64_rust-fixed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixed-devel}"
SRC_URI[aarch64_rust-fixed-devel.sha256sum] = "6c0af77d2d6738eb4120b4932e466af515f11dfcc60d8619256d7c27df5a7e31"

RDEPENDS:rust-fixed+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-fixed-devel \
 "
RDEPENDS:rust-fixed+az-devel = " \
 cargo \
 rust-fixed-devel \
 "
RDEPENDS:rust-fixed+default-devel = " \
 cargo \
 rust-fixed-devel \
 "
RDEPENDS:rust-fixed+f16-devel = " \
 cargo \
 rust-fixed-devel \
 "
RDEPENDS:rust-fixed+fail-on-warnings-devel = " \
 cargo \
 rust-fixed-devel \
 "
RDEPENDS:rust-fixed+num-traits-devel = " \
 cargo \
 rust-fixed-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-fixed+serde-devel = " \
 cargo \
 rust-fixed-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-fixed+serde-str-devel = " \
 cargo \
 rust-fixed+serde-devel \
 rust-fixed+std-devel \
 rust-fixed-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-fixed+std-devel = " \
 cargo \
 rust-fixed-devel \
 "
RDEPENDS:rust-fixed-devel = " \
 cargo \
 rust \
 rust-az+default-devel \
 rust-bytemuck+default-devel \
 rust-typenum+default-devel \
 virtual/crate_half__ge_1.8.0_with_crate_half__lt_3.0.0~ \
 "
