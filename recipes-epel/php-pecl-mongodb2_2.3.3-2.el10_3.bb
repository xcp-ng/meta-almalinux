# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-mongodb2"
PV = "2.3.3"
PR = "2.el10_3"
PACKAGES = " \
 php-pecl-mongodb2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-mongodb2-2.3.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc31527a7a66e59be80f9682801d7dc178117b43135ae6fc7433ee13353f8deb"

URI_x86_64_v2_php-pecl-mongodb2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-mongodb2-2.3.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-mongodb2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-mongodb2}"
SRC_URI[x86_64_v2_php-pecl-mongodb2.sha256sum] = "8dc7840a58e59c3b40a6cd278eccc37f62beebc48c981d9b9fe776d5002346b2"

URI_aarch64_php-pecl-mongodb2 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-mongodb2-2.3.3-2.el10_3.aarch64.rpm;name=aarch64_php-pecl-mongodb2;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-mongodb2}"
SRC_URI[aarch64_php-pecl-mongodb2.sha256sum] = "29c6abb629bb2436e06f6de4075b8ecc96bdd1681169908ac2790ff8b42a0f5c"

RDEPENDS:php-pecl-mongodb2:x86_64_v2 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 virtual/php-json_x86-64_ \
"
RDEPENDS:php-pecl-mongodb2:aarch64 = " \
 glibc \
 libbson \
 libmongocrypt \
 mongo-c-driver-libs \
 php-common \
 virtual/php-json_aarch-64_ \
"
