# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pssh"
PV = "2.3.5"
PR = "8.el10_0"
PACKAGES = " \
 pssh \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pssh-2.3.5-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "be1081cf41223c2f603bac537467a596df92638b45986d7003dca7790bceea51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pssh-2.3.5-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pssh;unpack=0"
SRC_URI[x86_64_v2_pssh.sha256sum] = "ac990fe656c022b73d01081217715457fcea136326daf3fe39c410b099abd892"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pssh-2.3.5-8.el10_0.noarch.rpm;name=aarch64_pssh;unpack=0"
SRC_URI[aarch64_pssh.sha256sum] = "ab1e64247a6a1eac60b8dbc6e4f306d512dff6a9dd32064cd406dcd10c00e91f"

RDEPENDS:pssh = " \
 openssh-clients \
 python3 \
 "
