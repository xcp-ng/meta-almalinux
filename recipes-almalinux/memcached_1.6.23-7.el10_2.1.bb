# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "memcached"
PV = "1.6.23"
PR = "7.el10_2.1"
PACKAGES = " \
 memcached \
 memcached-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/memcached-1.6.23-7.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f6e8aba48263a26951988549992091e0f17b9bd008bc84b634b053dca6ef9368"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/memcached-1.6.23-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_memcached;unpack=0"
SRC_URI[x86_64_v2_memcached.sha256sum] = "7cfa85c9405fc603626263a4f2b1fb3472dbe09810d078d0f53859fece6f44c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/memcached-selinux-1.6.23-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_memcached-selinux;unpack=0"
SRC_URI[x86_64_v2_memcached-selinux.sha256sum] = "2cf04e65428287f153351788dbbaabecb82387f6a159c65a8bb36d78546eae9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/memcached-1.6.23-7.el10_2.1.aarch64.rpm;name=aarch64_memcached;unpack=0"
SRC_URI[aarch64_memcached.sha256sum] = "28602fac8a531bffff63e5d963707821ebde163f53c1d8095c8a6d647c7a17ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/memcached-selinux-1.6.23-7.el10_2.1.aarch64.rpm;name=aarch64_memcached-selinux;unpack=0"
SRC_URI[aarch64_memcached-selinux.sha256sum] = "c922c827213e6744c3310deb2a377bf39d3169b7f17be90a1934f6633799f3ff"

RDEPENDS:memcached = " \
 bash \
 cyrus-sasl-lib \
 glibc \
 libevent \
 memcached-selinux \
 openssl-libs \
 perl-IO \
 perl-interpreter \
 perl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:memcached-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
