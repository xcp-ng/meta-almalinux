# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-runtime-config"
PV = "40"
PR = "5.el10"
PACKAGES = " \
 flatpak-runtime-config \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/flatpak-runtime-config-40-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8313bfb3e18ea4f5fb5058ec886308256a94da22410f31351813237c8eafe65"

URI_x86_64_v2_flatpak-runtime-config = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flatpak-runtime-config-40-5.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-runtime-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-runtime-config}"
SRC_URI[x86_64_v2_flatpak-runtime-config.sha256sum] = "682423e3604c1b2b62ab41c68b12c2c414cc6ac4d693e9271b6dd04ccef0a47d"

URI_aarch64_flatpak-runtime-config = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flatpak-runtime-config-40-5.el10.aarch64.rpm;name=aarch64_flatpak-runtime-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-runtime-config}"
SRC_URI[aarch64_flatpak-runtime-config.sha256sum] = "a7d80cefbdb604ecb0ac514d7dd0f1412d48d25aa28c5c2b5570d55d1797918b"

RDEPENDS:flatpak-runtime-config = " \
 bash \
 findutils \
 fonts-filesystem \
 glibc \
 "
