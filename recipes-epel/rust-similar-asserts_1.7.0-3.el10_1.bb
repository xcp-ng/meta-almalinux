# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-similar-asserts"
PV = "1.7.0"
PR = "3.el10_1"
PACKAGES = " \
 rust-similar-asserts+default-devel \
 rust-similar-asserts+serde-devel \
 rust-similar-asserts+unicode-devel \
 rust-similar-asserts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-similar-asserts-1.7.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5407fa6331cae28c989df8acb146b5fc1c35acf26b209224e0fd86c5d5d37e38"

URI_x86_64_v2_rust-similar-asserts+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-asserts+default-devel-1.7.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-asserts+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-asserts+default-devel}"
SRC_URI[x86_64_v2_rust-similar-asserts+default-devel.sha256sum] = "32f1d1976d47ea9d3531a8ea6c534ceed006f4c4d4fb3bec6ff3050829d30059"

URI_x86_64_v2_rust-similar-asserts+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-asserts+serde-devel-1.7.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-asserts+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-asserts+serde-devel}"
SRC_URI[x86_64_v2_rust-similar-asserts+serde-devel.sha256sum] = "9d1ef71f1237b2fd8b0e0069473edb9ce8e69aed8f0a38ae8503e2d9e9cf2bf4"

URI_x86_64_v2_rust-similar-asserts+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-asserts+unicode-devel-1.7.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-asserts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-asserts+unicode-devel}"
SRC_URI[x86_64_v2_rust-similar-asserts+unicode-devel.sha256sum] = "d0e235abafa89e47891375ad0bfecb34714bf1fe59c6c3cc8e3c30edb8452633"

URI_x86_64_v2_rust-similar-asserts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-asserts-devel-1.7.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-asserts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-asserts-devel}"
SRC_URI[x86_64_v2_rust-similar-asserts-devel.sha256sum] = "325633a85202cb1e7268a956b826633cf805371b6d2285bed73e7617976e7050"

URI_aarch64_rust-similar-asserts+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-asserts+default-devel-1.7.0-3.el10_1.noarch.rpm;name=aarch64_rust-similar-asserts+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-asserts+default-devel}"
SRC_URI[aarch64_rust-similar-asserts+default-devel.sha256sum] = "9f857118fdbf4c40bac0ad799e78c029ff4188af175048dc9bc8178bf5d2fd96"

URI_aarch64_rust-similar-asserts+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-asserts+serde-devel-1.7.0-3.el10_1.noarch.rpm;name=aarch64_rust-similar-asserts+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-asserts+serde-devel}"
SRC_URI[aarch64_rust-similar-asserts+serde-devel.sha256sum] = "1a2db2fd71dff6b15b001cae694b44a9b54464349bc4e0a2a0aba75928975d59"

URI_aarch64_rust-similar-asserts+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-asserts+unicode-devel-1.7.0-3.el10_1.noarch.rpm;name=aarch64_rust-similar-asserts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-asserts+unicode-devel}"
SRC_URI[aarch64_rust-similar-asserts+unicode-devel.sha256sum] = "ff94498684802a50d3340aed3305492b85578c627a30d1ed088d3fc345070ef1"

URI_aarch64_rust-similar-asserts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-asserts-devel-1.7.0-3.el10_1.noarch.rpm;name=aarch64_rust-similar-asserts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-asserts-devel}"
SRC_URI[aarch64_rust-similar-asserts-devel.sha256sum] = "92bbeae99d6380ef80383157cf15d8373ae81be8eed5b733470927e00d53da30"

RDEPENDS:rust-similar-asserts+default-devel = " \
 cargo \
 rust-similar-asserts+unicode-devel \
 rust-similar-asserts-devel \
 "
RDEPENDS:rust-similar-asserts+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-similar-asserts-devel \
 "
RDEPENDS:rust-similar-asserts+unicode-devel = " \
 cargo \
 rust-similar+unicode-devel \
 rust-similar-asserts-devel \
 "
RDEPENDS:rust-similar-asserts-devel = " \
 cargo \
 rust \
 rust-console+std-devel \
 rust-console-devel \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 "
