# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fontforge"
PV = "20230101"
PR = "15.el10"
PACKAGES = " \
 fontforge \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/fontforge-20230101-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cf83425920280a96597ac208e72fe4d9365004fa612a2c624721bea0bc4fa9e"

URI_x86_64_v2_fontforge = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/fontforge-20230101-15.el10.x86_64_v2.rpm;name=x86_64_v2_fontforge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fontforge}"
SRC_URI[x86_64_v2_fontforge.sha256sum] = "03ff5ccbe4aabd1f99361107a99d5e50a977b03b7c0a1cf008fd55262147f2a6"

URI_aarch64_fontforge = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/fontforge-20230101-15.el10.aarch64.rpm;name=aarch64_fontforge;unpack=0"
SRC_URI:append = " ${URI_aarch64_fontforge}"
SRC_URI[aarch64_fontforge.sha256sum] = "c21e8e1655adc7cc8e0c3401620ec3cc9607ee53b983939e9d382cc390c98fc3"

RDEPENDS:fontforge = " \
 cairo \
 freetype \
 giflib \
 glib2 \
 glibc \
 gtk3 \
 hicolor-icon-theme \
 libgcc \
 libjpeg-turbo \
 libpng \
 libspiro \
 libstdc++ \
 libtiff \
 libxml2 \
 pango \
 potrace \
 python3 \
 python3-libs \
 readline \
 woff2 \
 xdg-utils \
 zlib-ng-compat \
 "
