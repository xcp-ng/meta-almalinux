# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-Format-Mail"
PE = "1"
PV = "0.403"
PR = "21.el10_0"
PACKAGES = " \
 perl-DateTime-Format-Mail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-Format-Mail-0.403-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50c37bc7709b8e8943a6c19643d35c1dc1d930724c633da0a8f4af7d1e884c59"

URI_x86_64_v2_perl-DateTime-Format-Mail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-Format-Mail-0.403-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-Format-Mail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-Format-Mail}"
SRC_URI[x86_64_v2_perl-DateTime-Format-Mail.sha256sum] = "fb893e1d1c21eda74c7fc63c6c73b3e323e91baafe3a2f586b0cf7b97c552d9b"

URI_aarch64_perl-DateTime-Format-Mail = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-Format-Mail-0.403-21.el10_0.noarch.rpm;name=aarch64_perl-DateTime-Format-Mail;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-Format-Mail}"
SRC_URI[aarch64_perl-DateTime-Format-Mail.sha256sum] = "17366f0af8eb40824fc676d7295bb694cca5ad11b2fd13b30d2c2ecf4a78c14b"

RDEPENDS:perl-DateTime-Format-Mail = " \
 perl-Carp \
 perl-DateTime \
 perl-Params-Validate \
 perl-libs \
 perl-vars \
 "
