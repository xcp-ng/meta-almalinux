# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httpbin"
PV = "0.10.2"
PR = "3.el10_0"
PACKAGES = " \
 python3-httpbin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httpbin-0.10.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db2fbb4f38ad3dd22d9d724084f064a4f700d82a6c6cdedba663c02a2b38d070"

URI_x86_64_v2_python3-httpbin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpbin-0.10.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpbin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpbin}"
SRC_URI[x86_64_v2_python3-httpbin.sha256sum] = "7c14182b7d220b8770bee3b17253c171eba8fa6864f2cb0877548bbecc40c4da"

URI_aarch64_python3-httpbin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpbin-0.10.2-3.el10_0.noarch.rpm;name=aarch64_python3-httpbin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpbin}"
SRC_URI[aarch64_python3-httpbin.sha256sum] = "5ce3b63d4203cbc8b36681d9d9f819c41afee7add6652005d691d14229d5f512"

RDEPENDS:python3-httpbin = " \
 python3 \
 python3-brotli \
 python3-decorator \
 python3-flask \
 python3-greenlet \
 python3-six \
 python3-werkzeug \
 "
