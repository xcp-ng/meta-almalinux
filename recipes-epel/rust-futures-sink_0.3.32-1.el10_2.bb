# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-sink"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-sink+alloc-devel \
 rust-futures-sink+default-devel \
 rust-futures-sink+std-devel \
 rust-futures-sink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-sink-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acf163d16d16b5e653121de6b4ed94e948de5ff805f58026339236563d8c35cd"

URI_x86_64_v2_rust-futures-sink+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+alloc-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-sink+alloc-devel.sha256sum] = "67dde4e6ee81b7a67a7054c09f47843e2ad1145685ff68141fdc3a3901810f81"

URI_x86_64_v2_rust-futures-sink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink+default-devel}"
SRC_URI[x86_64_v2_rust-futures-sink+default-devel.sha256sum] = "ab390d4168f6b224380384976172eb9c7e7cd7ceaed04971c40a24063253e0da"

URI_x86_64_v2_rust-futures-sink+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink+std-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink+std-devel}"
SRC_URI[x86_64_v2_rust-futures-sink+std-devel.sha256sum] = "09ca2f11a58985b5ecdd100f94c0c6539b564617df33cc43474a785faa95815a"

URI_x86_64_v2_rust-futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-sink-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-sink-devel}"
SRC_URI[x86_64_v2_rust-futures-sink-devel.sha256sum] = "49831100531276430d63f50c1926f6664fa4f1c8c4093d12f6012b171db14c4b"

URI_aarch64_rust-futures-sink+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+alloc-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-sink+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink+alloc-devel}"
SRC_URI[aarch64_rust-futures-sink+alloc-devel.sha256sum] = "bfecd263e7116e73c9115c58da5ad02f0bbda965b11b14eebecd5e890154daae"

URI_aarch64_rust-futures-sink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-sink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink+default-devel}"
SRC_URI[aarch64_rust-futures-sink+default-devel.sha256sum] = "8e7a5f3dec66d8fa525d14e20a6ff5a85ea769198208772fcb8c5ee67436dcf2"

URI_aarch64_rust-futures-sink+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink+std-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-sink+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink+std-devel}"
SRC_URI[aarch64_rust-futures-sink+std-devel.sha256sum] = "56ed70b7f7d386bad751a1decce4a8af337f2732a9cc33405c208c7fec8c506f"

URI_aarch64_rust-futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-sink-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-sink-devel}"
SRC_URI[aarch64_rust-futures-sink-devel.sha256sum] = "4b15efa6f947942bf2679ef698485351df291e6104d078ebdf3b0c519e5c31da"

RDEPENDS:rust-futures-sink+alloc-devel = " \
 cargo \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink+default-devel = " \
 cargo \
 rust-futures-sink+std-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink+std-devel = " \
 cargo \
 rust-futures-sink+alloc-devel \
 rust-futures-sink-devel \
 "
RDEPENDS:rust-futures-sink-devel = " \
 cargo \
 rust \
 "
