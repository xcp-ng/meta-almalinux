# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kigo"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kigo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kigo-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "356d4cabcfc3a37b1549d56f5b9eaeaebcd2ad11fd696c347d42970012ca3451"

URI_x86_64_v2_kigo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kigo-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kigo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kigo}"
SRC_URI[x86_64_v2_kigo.sha256sum] = "80015434a5e6b129a73d8a162735bae69213ac62eabb9ce730462acea212d4e4"

URI_aarch64_kigo = "${EPEL_MIRROR}/aarch64/Packages/k/kigo-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kigo;unpack=0"
SRC_URI:append = " ${URI_aarch64_kigo}"
SRC_URI[aarch64_kigo.sha256sum] = "82536ed3aae1b55ce5e8951f4da38b2c5fc825524fa3090fd958c0e0d2d0f241"

RDEPENDS:kigo = " \
 glibc \
 gnugo \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
