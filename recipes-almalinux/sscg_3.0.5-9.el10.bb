# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sscg"
PV = "3.0.5"
PR = "9.el10"
PACKAGES = " \
 sscg \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sscg-3.0.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76ac22c922fef10d3b1ee361f653ea6f324f42eb49892419139ad7cab8f6c6d2"

URI_x86_64_v2_sscg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sscg-3.0.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_sscg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sscg}"
SRC_URI[x86_64_v2_sscg.sha256sum] = "c4d131cbd40198c51fed1eee16fda0a3661647eab51c1b3b45121c91047bce9d"

URI_aarch64_sscg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sscg-3.0.5-9.el10.aarch64.rpm;name=aarch64_sscg;unpack=0"
SRC_URI:append = " ${URI_aarch64_sscg}"
SRC_URI[aarch64_sscg.sha256sum] = "be5ab285692516a1d7a3bef1335706f14510dab4f01a91d5cffab2fc14bdc349"

RDEPENDS:sscg = " \
 glibc \
 libpath_utils \
 libtalloc \
 openssl-libs \
 popt \
 "
