# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fb_procfs"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-fb_procfs+default-devel \
 rust-fb_procfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fb_procfs-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6216ba84f79e83ac0a3209a592f78db3f7d8207111a053e0962561a4e54370b"

URI_x86_64_v2_rust-fb_procfs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fb_procfs+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fb_procfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fb_procfs+default-devel}"
SRC_URI[x86_64_v2_rust-fb_procfs+default-devel.sha256sum] = "c8a61879f411bf792b31ddff0988c3fec41bd95c4a1d81dea863fd07357052d2"

URI_x86_64_v2_rust-fb_procfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fb_procfs-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fb_procfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fb_procfs-devel}"
SRC_URI[x86_64_v2_rust-fb_procfs-devel.sha256sum] = "092ddaff56d806f67dd5aa0321e2c607e0a5d4413f19dbcb25c129c8319bd844"

URI_aarch64_rust-fb_procfs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fb_procfs+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-fb_procfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fb_procfs+default-devel}"
SRC_URI[aarch64_rust-fb_procfs+default-devel.sha256sum] = "68c2887bad3a62b112621985e228200e40e421d4add83afb04d60bb73de2b0b3"

URI_aarch64_rust-fb_procfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fb_procfs-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-fb_procfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fb_procfs-devel}"
SRC_URI[aarch64_rust-fb_procfs-devel.sha256sum] = "e06de4da3df6d94fde12d51bd873c3de44f0b06888f4e286238612f14ffe4ae8"

RDEPENDS:rust-fb_procfs+default-devel = " \
 cargo \
 rust-fb_procfs-devel \
 "
RDEPENDS:rust-fb_procfs-devel = " \
 cargo \
 rust-below-common+default-devel \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 rust-nix0.29+default-devel \
 rust-nix0.29+dir-devel \
 rust-nix0.29+event-devel \
 rust-nix0.29+hostname-devel \
 rust-nix0.29+inotify-devel \
 rust-nix0.29+ioctl-devel \
 rust-nix0.29+mman-devel \
 rust-nix0.29+mount-devel \
 rust-nix0.29+net-devel \
 rust-nix0.29+poll-devel \
 rust-nix0.29+ptrace-devel \
 rust-nix0.29+reboot-devel \
 rust-nix0.29+resource-devel \
 rust-nix0.29+sched-devel \
 rust-nix0.29+signal-devel \
 rust-nix0.29+term-devel \
 rust-nix0.29+time-devel \
 rust-nix0.29+user-devel \
 rust-nix0.29+zerocopy-devel \
 rust-openat+default-devel \
 rust-parking_lot+default-devel \
 rust-parking_lot+send_guard-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 rust-thiserror+default-devel \
 rust-threadpool+default-devel \
 "
