# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is_executable"
PV = "1.0.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-is_executable+default-devel \
 rust-is_executable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is_executable-1.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6542c1a5e75f13b45ce945d75e80378ef759cce0b5b036538f704a3ec18aa11"

URI_x86_64_v2_rust-is_executable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_executable+default-devel-1.0.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_executable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_executable+default-devel}"
SRC_URI[x86_64_v2_rust-is_executable+default-devel.sha256sum] = "c668af17f1a26a74425cdfafd8ce5863318be76d91af985c1a52c95077983c2b"

URI_x86_64_v2_rust-is_executable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_executable-devel-1.0.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_executable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_executable-devel}"
SRC_URI[x86_64_v2_rust-is_executable-devel.sha256sum] = "c9987fcc10606c908801c3dd79312e88a223ab05fd5e216a65f6f0752d658557"

URI_aarch64_rust-is_executable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_executable+default-devel-1.0.5-1.el10_1.noarch.rpm;name=aarch64_rust-is_executable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_executable+default-devel}"
SRC_URI[aarch64_rust-is_executable+default-devel.sha256sum] = "fc9288aa7efa6e3ea5ccc2b00e1626fd0f57a27aa5ba466b83e689a62cf9fe27"

URI_aarch64_rust-is_executable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_executable-devel-1.0.5-1.el10_1.noarch.rpm;name=aarch64_rust-is_executable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_executable-devel}"
SRC_URI[aarch64_rust-is_executable-devel.sha256sum] = "c8984a06ffaa543c109e746f9f07dbe31f560ff696d2822286deca5d3486c97c"

RDEPENDS:rust-is_executable+default-devel = " \
 cargo \
 rust-is_executable-devel \
 "
RDEPENDS:rust-is_executable-devel = " \
 cargo \
 "
