# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Helpers"
PV = "0.027"
PR = "1.el10_0"
PACKAGES = " \
 perl-ExtUtils-Helpers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-Helpers-0.027-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8610656397255c32d6ca10c8f46d34243d88f8a8c36ebbcc72437bf0d0843675"

URI_x86_64_v2_perl-ExtUtils-Helpers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-Helpers-0.027-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Helpers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-Helpers}"
SRC_URI[x86_64_v2_perl-ExtUtils-Helpers.sha256sum] = "41d01d31676098063bd9c321d3efeedc0b10c62f70a2b818d74e72a43408e258"

URI_aarch64_perl-ExtUtils-Helpers = "${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-Helpers-0.027-1.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-Helpers;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-Helpers}"
SRC_URI[aarch64_perl-ExtUtils-Helpers.sha256sum] = "43bd31a932ce703676b8a5003edb01d762b19a17a803effe49f5b4d244a8f676"

RDEPENDS:perl-ExtUtils-Helpers = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-Text-ParseWords \
 perl-libs \
 "
