# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-logr-stdr"
PV = "1.2.2"
PR = "7.el10_0"
PACKAGES = " \
 golang-github-logr-stdr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-logr-stdr-1.2.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cea30d2d8b0ca33517e2426a220d29f5b181c84800dc220301dc02610ba1dc62"

URI_x86_64_v2_golang-github-logr-stdr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-logr-stdr-devel-1.2.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-logr-stdr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-logr-stdr-devel}"
SRC_URI[x86_64_v2_golang-github-logr-stdr-devel.sha256sum] = "e97d185b676bd334f18c10e37008517e3ff30de2dbdf3c8007cafbfc1634298b"

URI_aarch64_golang-github-logr-stdr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-logr-stdr-devel-1.2.2-7.el10_0.noarch.rpm;name=aarch64_golang-github-logr-stdr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-logr-stdr-devel}"
SRC_URI[aarch64_golang-github-logr-stdr-devel.sha256sum] = "0a6d2c0a936ba23d1cee7f643979ebbc0822e60a9a7265c25f5983a90bf81fca"

RDEPENDS:golang-github-logr-stdr-devel = " \
 go-filesystem \
 golang-github-logr-devel \
 "
