# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-twox-hash"
PV = "2.1.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-twox-hash+alloc-devel \
 rust-twox-hash+default-devel \
 rust-twox-hash+random-devel \
 rust-twox-hash+serialize-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-twox-hash-2.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4c843e0b3e905bb4f090ad120b55c1351f5d01af15efcc5efef5048207fcf6fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+alloc-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+alloc-devel.sha256sum] = "69c5cd374c4e4858c1bf67924ca500c08285022fc6f68b69ca391dbcff590332"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+default-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+default-devel.sha256sum] = "526e44f1e90b2425bd79433067cb286e88ba142aa3d209756b32051af24918d6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+random-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+random-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+random-devel.sha256sum] = "362dec8b24dab5e1566f855549f3cdedf6b86f4114abda9e8b6efa84246455d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+serialize-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+serialize-devel.sha256sum] = "623943b26ec283506cd91db275af9d4a7ecd3b9d4e53b6bd570ec1c44f019b04"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+std-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+std-devel.sha256sum] = "423375cb8063cfbfa8124ed94eb1bd1dcf5641d1d16da32e5489ccd2c9449d02"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash32-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash32-devel.sha256sum] = "37346270746a9ff4cc6ab840764271e0d37293c94d0b3662731ac9e9d09690c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_128-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_128-devel.sha256sum] = "3b0ad788b84f8113112aa7dc50b645a86f5dc3ff6b00221adcbbd19be916ace1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_64-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_64-devel.sha256sum] = "00776a0527e9e08ff85b7d92d035878c7afcb058d1d0480ff190f47392667366"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash64-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash64-devel.sha256sum] = "ae8617a008ba8ba1f0d8a66d68f5167297d4e81f4227a13aeec30f254f6fde10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash-devel-2.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash-devel.sha256sum] = "befa2dcbcac3bb7755c54f6d21f24f6f28d01904891f6b428690386239ffc6a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+alloc-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+alloc-devel.sha256sum] = "bbf5a54179e1569a8e260e0dcf07a44b74dfbba488230b7827faca2dffa89fb9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+default-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+default-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+default-devel.sha256sum] = "f2623690730729f1e7569c6bc64f4ce1589c9f62dbf58aa63e2e210f398ed75c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+random-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+random-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+random-devel.sha256sum] = "c6045234fda24bd6a8fdfbc59e80a13920fb552d933f182216ae935e9bc6cff2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+serialize-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+serialize-devel.sha256sum] = "2af5cdaab84f67a58f43248211c64d72f5017bd9be2f4f26f66d5a11aece1e44"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+std-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+std-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+std-devel.sha256sum] = "7536b2173302c5205dc1584815a9056c2a329c5c6f68578b9590131c4b0ce5f8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash32-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+xxhash32-devel.sha256sum] = "1d35c4710c34cb1c2541829b15e45c5fa47aa0d86b69e0a5a0172a8663a828e2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_128-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+xxhash3_128-devel.sha256sum] = "e3ed25a7fbef1f9ee9789015ad08cc5404c7487000074c756841275f675dbcf8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_64-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+xxhash3_64-devel.sha256sum] = "99a8c06e928f701bcfe02f19c223acf6abc838eea4fcd2d20936772625d5b7d2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash64-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+xxhash64-devel.sha256sum] = "2cc41602346b929f8c49352f7571a13400a961070d8b0c53a7542e851cb8ac9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash-devel-2.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-twox-hash-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash-devel.sha256sum] = "a3fbadc0972d1e1821c65858fc9d649ecfc06b2135b5731222160d67a728a076"

RDEPENDS:rust-twox-hash+alloc-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+default-devel = " \
 cargo \
 rust-twox-hash+random-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+random-devel = " \
 cargo \
 rust-twox-hash-devel \
 virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 \
 virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0 \
 "
RDEPENDS:rust-twox-hash+serialize-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+std-devel = " \
 cargo \
 rust-twox-hash+alloc-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash32-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_128-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash-devel = " \
 cargo \
 rust \
 "
