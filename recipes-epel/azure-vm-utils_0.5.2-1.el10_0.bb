# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "azure-vm-utils"
PV = "0.5.2"
PR = "1.el10_0"
PACKAGES = " \
 azure-vm-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/azure-vm-utils-0.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "991e160b3d5bbf78e268f96b26ce94c941fe78e07833277ff9dd412f17c69238"

URI_x86_64_v2_azure-vm-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/azure-vm-utils-0.5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_azure-vm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_azure-vm-utils}"
SRC_URI[x86_64_v2_azure-vm-utils.sha256sum] = "fce29580654776e1c6944d38c0723bb21a3cb89fd1001b566d57bec2ebc7ac07"

URI_aarch64_azure-vm-utils = "${EPEL_MIRROR}/aarch64/Packages/a/azure-vm-utils-0.5.2-1.el10_0.aarch64.rpm;name=aarch64_azure-vm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_azure-vm-utils}"
SRC_URI[aarch64_azure-vm-utils.sha256sum] = "3e501131dee145d9f832253895cbc106c6de486d481763ad843cb28faabf5a1c"

RDEPENDS:azure-vm-utils = " \
 bash \
 glibc \
 json-c \
 "
