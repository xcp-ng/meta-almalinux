# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-include_dir_macros"
PV = "0.7.4"
PR = "2.el10_2"
PACKAGES = " \
 rust-include_dir_macros+default-devel \
 rust-include_dir_macros+metadata-devel \
 rust-include_dir_macros+nightly-devel \
 rust-include_dir_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-include_dir_macros-0.7.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35e322fac29877f751ec780f0066db571460788b160a33cb1c062286c75a15fa"

URI_x86_64_v2_rust-include_dir_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-include_dir_macros+default-devel-0.7.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-include_dir_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-include_dir_macros+default-devel}"
SRC_URI[x86_64_v2_rust-include_dir_macros+default-devel.sha256sum] = "91cfeabb6a6258f8b8691d80ac8cb17534aeb37381b26567521bd924e92b8b53"

URI_x86_64_v2_rust-include_dir_macros+metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-include_dir_macros+metadata-devel-0.7.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-include_dir_macros+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-include_dir_macros+metadata-devel}"
SRC_URI[x86_64_v2_rust-include_dir_macros+metadata-devel.sha256sum] = "eea6b2b483f8488d518d8c464684e62f91d0fd5c33791dc34fb0e8c14d934b02"

URI_x86_64_v2_rust-include_dir_macros+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-include_dir_macros+nightly-devel-0.7.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-include_dir_macros+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-include_dir_macros+nightly-devel}"
SRC_URI[x86_64_v2_rust-include_dir_macros+nightly-devel.sha256sum] = "b52e17bf1bb238dda09f633ae4c8188dc2de68d0c2b7281254d8ae032fe265ac"

URI_x86_64_v2_rust-include_dir_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-include_dir_macros-devel-0.7.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-include_dir_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-include_dir_macros-devel}"
SRC_URI[x86_64_v2_rust-include_dir_macros-devel.sha256sum] = "41c9f08214be7d7341e71747bae3cffa0791f85adbfacb22344fb1372adc0a17"

URI_aarch64_rust-include_dir_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-include_dir_macros+default-devel-0.7.4-2.el10_2.noarch.rpm;name=aarch64_rust-include_dir_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-include_dir_macros+default-devel}"
SRC_URI[aarch64_rust-include_dir_macros+default-devel.sha256sum] = "49d9e3a3bb4eec4d56bd39433da108b68b377d9cd4bfdad283e6e7b59e5c798b"

URI_aarch64_rust-include_dir_macros+metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-include_dir_macros+metadata-devel-0.7.4-2.el10_2.noarch.rpm;name=aarch64_rust-include_dir_macros+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-include_dir_macros+metadata-devel}"
SRC_URI[aarch64_rust-include_dir_macros+metadata-devel.sha256sum] = "14d49b79a994c618250cdb8258576d482d9af9549b71117d7bfd07a55bca00e2"

URI_aarch64_rust-include_dir_macros+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-include_dir_macros+nightly-devel-0.7.4-2.el10_2.noarch.rpm;name=aarch64_rust-include_dir_macros+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-include_dir_macros+nightly-devel}"
SRC_URI[aarch64_rust-include_dir_macros+nightly-devel.sha256sum] = "f5d223f105273d052e4e9939192017f2cd548fc267535391b29f2729d98a671f"

URI_aarch64_rust-include_dir_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-include_dir_macros-devel-0.7.4-2.el10_2.noarch.rpm;name=aarch64_rust-include_dir_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-include_dir_macros-devel}"
SRC_URI[aarch64_rust-include_dir_macros-devel.sha256sum] = "7c0fb3060cdcf47387285951cac06336ebd6df6c18be3d68f1f0528b17407686"

RDEPENDS:rust-include_dir_macros+default-devel = " \
 cargo \
 rust-include_dir_macros-devel \
 "
RDEPENDS:rust-include_dir_macros+metadata-devel = " \
 cargo \
 rust-include_dir_macros-devel \
 "
RDEPENDS:rust-include_dir_macros+nightly-devel = " \
 cargo \
 rust-include_dir_macros-devel \
 "
RDEPENDS:rust-include_dir_macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
