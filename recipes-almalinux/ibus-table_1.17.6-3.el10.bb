# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-table"
PV = "1.17.6"
PR = "3.el10"
PACKAGES = " \
 ibus-table \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-table-1.17.6-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c39bad3160e123cc73d2ffb29936ca47dfeef48dd24c908d81948891d8db1fe"

URI_x86_64_v2_ibus-table = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-1.17.6-3.el10.noarch.rpm;name=x86_64_v2_ibus-table;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table}"
SRC_URI[x86_64_v2_ibus-table.sha256sum] = "0247dbc6d49010ccde332226b210c4257e2365216a482f088ab9ace05b771375"

URI_aarch64_ibus-table = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-1.17.6-3.el10.noarch.rpm;name=aarch64_ibus-table;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table}"
SRC_URI[aarch64_ibus-table.sha256sum] = "0247dbc6d49010ccde332226b210c4257e2365216a482f088ab9ace05b771375"

RDEPENDS:ibus-table = " \
 bash \
 ibus \
 python3 \
 "
