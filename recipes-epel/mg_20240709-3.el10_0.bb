# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mg"
PV = "20240709"
PR = "3.el10_0"
PACKAGES = " \
 mg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mg-20240709-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "575e66b0988582cbb39b5b2cd0291ae7f4483124e0175fbfcd9de51a5073c9a0"

URI_x86_64_v2_mg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mg-20240709-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mg}"
SRC_URI[x86_64_v2_mg.sha256sum] = "7eb67d3431e6b41f53908a08aaf524193ade93e620dbcb98baf1cd5c481e4e5b"

URI_aarch64_mg = "${EPEL_MIRROR}/aarch64/Packages/m/mg-20240709-3.el10_0.aarch64.rpm;name=aarch64_mg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mg}"
SRC_URI[aarch64_mg.sha256sum] = "2a1355296bded423defa6d6ed2dc25d60b3f5a4dea904f7ff2ecbc3aefb4b5c1"

RDEPENDS:mg = " \
 glibc \
 libbsd \
 ncurses-libs \
 "
