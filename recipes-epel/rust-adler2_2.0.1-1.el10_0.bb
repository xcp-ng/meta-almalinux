# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-adler2"
PV = "2.0.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-adler2+default-devel \
 rust-adler2+std-devel \
 rust-adler2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-adler2-2.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4da75ace8cfb03e42bb33ba94a05ad44aa627ba540704761a973e7868bd95a5c"

URI_x86_64_v2_rust-adler2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adler2+default-devel-2.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adler2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adler2+default-devel}"
SRC_URI[x86_64_v2_rust-adler2+default-devel.sha256sum] = "4e587bd4824f017ca29eac9157df7e3daf604ef3aa956e13220b28ff646a64b1"

URI_x86_64_v2_rust-adler2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adler2+std-devel-2.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adler2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adler2+std-devel}"
SRC_URI[x86_64_v2_rust-adler2+std-devel.sha256sum] = "0a140e16d0e7cd26bdd17cc7bd3bd51279ef7e73732e90a5886a89bfd67fcff8"

URI_x86_64_v2_rust-adler2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adler2-devel-2.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adler2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adler2-devel}"
SRC_URI[x86_64_v2_rust-adler2-devel.sha256sum] = "f585b314eacbf48acedc3048b4ffdeacb1da1b7468de0b25d42ebb83138a4f35"

URI_aarch64_rust-adler2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adler2+default-devel-2.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-adler2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adler2+default-devel}"
SRC_URI[aarch64_rust-adler2+default-devel.sha256sum] = "5715a68d3d74805cc84315480026eacff82d406d11dc3df41846d50e5c5565a7"

URI_aarch64_rust-adler2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adler2+std-devel-2.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-adler2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adler2+std-devel}"
SRC_URI[aarch64_rust-adler2+std-devel.sha256sum] = "4abcbf86639ab4477524549abe71eb53f2aa658b78347ec4cab126320c383bc5"

URI_aarch64_rust-adler2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adler2-devel-2.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-adler2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adler2-devel}"
SRC_URI[aarch64_rust-adler2-devel.sha256sum] = "e9522949cab930d007eb664dfd19d364176ba12336df7deac6267b73d37a5297"

RDEPENDS:rust-adler2+default-devel = " \
 cargo \
 rust-adler2+std-devel \
 rust-adler2-devel \
 "
RDEPENDS:rust-adler2+std-devel = " \
 cargo \
 rust-adler2-devel \
 "
RDEPENDS:rust-adler2-devel = " \
 cargo \
 "
