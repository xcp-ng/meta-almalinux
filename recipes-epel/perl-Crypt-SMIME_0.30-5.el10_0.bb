# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-SMIME"
PV = "0.30"
PR = "5.el10_0"
PACKAGES = " \
 perl-Crypt-SMIME \
 perl-Crypt-SMIME-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-SMIME-0.30-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22cc5a865eb258258baa634fd3236e1f9e6b517313187cc9cf388123e1463e13"

URI_x86_64_v2_perl-Crypt-SMIME = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SMIME-0.30-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-SMIME;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-SMIME}"
SRC_URI[x86_64_v2_perl-Crypt-SMIME.sha256sum] = "67e1fc138c8d52a4b9070f1d60700fd3547d65173fd4653e79cff5348ffc13c7"

URI_x86_64_v2_perl-Crypt-SMIME-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SMIME-tests-0.30-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-SMIME-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-SMIME-tests}"
SRC_URI[x86_64_v2_perl-Crypt-SMIME-tests.sha256sum] = "8d89394be3413cd7946dd6e2ffa81003efa77915be1d5b732d8bb6636dc20ea3"

URI_aarch64_perl-Crypt-SMIME = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SMIME-0.30-5.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-SMIME;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-SMIME}"
SRC_URI[aarch64_perl-Crypt-SMIME.sha256sum] = "64f56300c22eb16aee174b5230261f9c88b7a9e62dd083f101cf02eceeaca71f"

URI_aarch64_perl-Crypt-SMIME-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SMIME-tests-0.30-5.el10_0.aarch64.rpm;name=aarch64_perl-Crypt-SMIME-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-SMIME-tests}"
SRC_URI[aarch64_perl-Crypt-SMIME-tests.sha256sum] = "e0024f6a14d0d1604d9dcc897c06000b11dd928ef47981d9b1d89eaeee37facf"

RDEPENDS:perl-Crypt-SMIME = " \
 glibc \
 openssl-libs \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Crypt-SMIME-tests = " \
 perl-Crypt-SMIME \
 perl-Test-Harness \
 "
