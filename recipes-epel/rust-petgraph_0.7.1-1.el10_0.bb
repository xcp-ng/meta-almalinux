# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-petgraph"
PV = "0.7.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-petgraph+all-devel \
 rust-petgraph+default-devel \
 rust-petgraph+generate-devel \
 rust-petgraph+graphmap-devel \
 rust-petgraph+matrix_graph-devel \
 rust-petgraph+rayon-devel \
 rust-petgraph+serde-1-devel \
 rust-petgraph+serde-devel \
 rust-petgraph+serde_derive-devel \
 rust-petgraph+stable_graph-devel \
 rust-petgraph+unstable-devel \
 rust-petgraph-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-petgraph-0.7.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d511a21c68ed8edad8f24deefda3e98ad449dc434b357a5796ed338d4401e06"

URI_x86_64_v2_rust-petgraph+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+all-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+all-devel}"
SRC_URI[x86_64_v2_rust-petgraph+all-devel.sha256sum] = "a3df025cd674dce15c5a9f67d1b39dbd42445eb66890eab939d4764a9dda5475"

URI_x86_64_v2_rust-petgraph+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+default-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+default-devel}"
SRC_URI[x86_64_v2_rust-petgraph+default-devel.sha256sum] = "cf99c15496f02fc3e72bb9d52ee14e60d3f138d38d250c945af6e11f7d7a895d"

URI_x86_64_v2_rust-petgraph+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+generate-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+generate-devel}"
SRC_URI[x86_64_v2_rust-petgraph+generate-devel.sha256sum] = "3297d86f3d7154df4e4ea55d099f729f2c46893fa6a91bbc75b10d26c44b51a2"

URI_x86_64_v2_rust-petgraph+graphmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+graphmap-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+graphmap-devel}"
SRC_URI[x86_64_v2_rust-petgraph+graphmap-devel.sha256sum] = "73bb32913b3392af79fcb4f2d15ae4acb2f9945f8e2fbf59e792ead3c8bf66a0"

URI_x86_64_v2_rust-petgraph+matrix_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+matrix_graph-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+matrix_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph+matrix_graph-devel.sha256sum] = "663259465558a38b4b9581e0a7fcf632a156a59edf0a30f6e5427ed48bd10ece"

URI_x86_64_v2_rust-petgraph+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+rayon-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+rayon-devel}"
SRC_URI[x86_64_v2_rust-petgraph+rayon-devel.sha256sum] = "12bae7efdde7506454e8dd2b379dc4857bd8b297d091a59f3a78566c8bd09623"

URI_x86_64_v2_rust-petgraph+serde-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+serde-1-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+serde-1-devel}"
SRC_URI[x86_64_v2_rust-petgraph+serde-1-devel.sha256sum] = "9bb8b721eb3456cbec1b1121a86b0e3e4260f1022713d62a49c643af029ee9fd"

URI_x86_64_v2_rust-petgraph+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+serde-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+serde-devel}"
SRC_URI[x86_64_v2_rust-petgraph+serde-devel.sha256sum] = "438aa1db9262f3cc6dd4ff658201c3b0cab5a531172f5f6b6bfef14df1a6d526"

URI_x86_64_v2_rust-petgraph+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+serde_derive-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-petgraph+serde_derive-devel.sha256sum] = "f0f74af528586dcd986e4bd692420d74d8c1fe4dd783c27de926b101a1673f80"

URI_x86_64_v2_rust-petgraph+stable_graph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+stable_graph-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+stable_graph-devel}"
SRC_URI[x86_64_v2_rust-petgraph+stable_graph-devel.sha256sum] = "59ccc6bd010abcb43a249b3b87dd9a5db81c597cd098bf128994e612dfc505bb"

URI_x86_64_v2_rust-petgraph+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph+unstable-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph+unstable-devel}"
SRC_URI[x86_64_v2_rust-petgraph+unstable-devel.sha256sum] = "e7e4a2f9ee9c49dfd0a5a78de82fd181e733efdcfb01b97006d640cd2f755a0b"

URI_x86_64_v2_rust-petgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-petgraph-devel-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-petgraph-devel}"
SRC_URI[x86_64_v2_rust-petgraph-devel.sha256sum] = "f7d79e309cbf32f3c2d25065addf3ad83453563c04a6e01d3fa40b3be8b438c6"

URI_aarch64_rust-petgraph+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+all-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+all-devel}"
SRC_URI[aarch64_rust-petgraph+all-devel.sha256sum] = "abadc1f1ada0eded7075238e1760392d00dc688a6dc41e7bab01acdd668c14bf"

URI_aarch64_rust-petgraph+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+default-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+default-devel}"
SRC_URI[aarch64_rust-petgraph+default-devel.sha256sum] = "3dfdece6fbe5190720ddc7bc7f793b3eacd5426d12033dbd97afacb484b5a6f8"

URI_aarch64_rust-petgraph+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+generate-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+generate-devel}"
SRC_URI[aarch64_rust-petgraph+generate-devel.sha256sum] = "5fdc2a9beb9670febb68bcaed6a1d7313e118b421ff993f6fdd668379093faf0"

URI_aarch64_rust-petgraph+graphmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+graphmap-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+graphmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+graphmap-devel}"
SRC_URI[aarch64_rust-petgraph+graphmap-devel.sha256sum] = "ab20bad455be9d0a9078c83999bdfb11cc7585cf85a63c8dc9162f7e3df25167"

URI_aarch64_rust-petgraph+matrix_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+matrix_graph-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+matrix_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+matrix_graph-devel}"
SRC_URI[aarch64_rust-petgraph+matrix_graph-devel.sha256sum] = "771ec34e42bf5ea2087b1355172a801068ff2c3490d837fe0731b56653bfce16"

URI_aarch64_rust-petgraph+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+rayon-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+rayon-devel}"
SRC_URI[aarch64_rust-petgraph+rayon-devel.sha256sum] = "3ec496c203059844c757300d1e9315ef980399078429d56f120a3baf38d1ae2b"

URI_aarch64_rust-petgraph+serde-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+serde-1-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+serde-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+serde-1-devel}"
SRC_URI[aarch64_rust-petgraph+serde-1-devel.sha256sum] = "1f9e1c9f08ba614e04971d3a20b5b459a9bc312584b509e0eede43faa690c21d"

URI_aarch64_rust-petgraph+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+serde-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+serde-devel}"
SRC_URI[aarch64_rust-petgraph+serde-devel.sha256sum] = "a539f445f525e90213a977e5722efc3e1d34f02c16efe655a144def9cc9e1040"

URI_aarch64_rust-petgraph+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+serde_derive-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+serde_derive-devel}"
SRC_URI[aarch64_rust-petgraph+serde_derive-devel.sha256sum] = "1f7ea831b7115ef73545d7b49447fbf432fd9c04304fcac30e0df37ac8d795c5"

URI_aarch64_rust-petgraph+stable_graph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+stable_graph-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+stable_graph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+stable_graph-devel}"
SRC_URI[aarch64_rust-petgraph+stable_graph-devel.sha256sum] = "803b1d14afe0c0cb091ed9af2fd2255d81a5920d637ba1dd7d5c0e327eafd734"

URI_aarch64_rust-petgraph+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph+unstable-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph+unstable-devel}"
SRC_URI[aarch64_rust-petgraph+unstable-devel.sha256sum] = "9b6c17f1aa27a3c42d3ca1bab82a6544040e434bf083e5c5a7d79da38928b953"

URI_aarch64_rust-petgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-petgraph-devel-0.7.1-1.el10_0.noarch.rpm;name=aarch64_rust-petgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-petgraph-devel}"
SRC_URI[aarch64_rust-petgraph-devel.sha256sum] = "be41a562b3bd691af130b61e4569ec70f95dae2a37eebf721fbc29b3ef202ca1"

RDEPENDS:rust-petgraph+all-devel = " \
 cargo \
 rust-petgraph+graphmap-devel \
 rust-petgraph+matrix_graph-devel \
 rust-petgraph+rayon-devel \
 rust-petgraph+stable_graph-devel \
 rust-petgraph+unstable-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+default-devel = " \
 cargo \
 rust-petgraph+graphmap-devel \
 rust-petgraph+matrix_graph-devel \
 rust-petgraph+stable_graph-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+generate-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+graphmap-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+matrix_graph-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+rayon-devel = " \
 cargo \
 rust-indexmap+rayon-devel \
 rust-petgraph-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-petgraph+serde-1-devel = " \
 cargo \
 rust-petgraph+serde-devel \
 rust-petgraph+serde_derive-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+serde-devel = " \
 cargo \
 rust-petgraph-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-petgraph+serde_derive-devel = " \
 cargo \
 rust-petgraph-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-petgraph+stable_graph-devel = " \
 cargo \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph+unstable-devel = " \
 cargo \
 rust-petgraph+generate-devel \
 rust-petgraph-devel \
 "
RDEPENDS:rust-petgraph-devel = " \
 cargo \
 rust \
 rust-fixedbitset-devel \
 rust-indexmap+default-devel \
 "
