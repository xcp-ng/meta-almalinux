# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-setup"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-setup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-setup-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "507bb2d85cda86389040d4e8a78fad0e70f88f6d042edef084254d5934c4888d"

URI_x86_64_v2_plasma-setup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-setup-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-setup}"
SRC_URI[x86_64_v2_plasma-setup.sha256sum] = "490682ac5071b4ea36cb60f2d6f6c0cb6ce27b4a28b1e6ac9c280ea6545bb63c"

URI_aarch64_plasma-setup = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-setup-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-setup}"
SRC_URI[aarch64_plasma-setup.sha256sum] = "cd560bf9f610f0e18e7f7cf0e443de598919fcc31d0ccd6f6c908fa9cb43f83d"

RDEPENDS:plasma-setup = " \
 bash \
 dbus-common \
 glibc \
 kf6-filesystem \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libstdc++ \
 plasma-desktop \
 plasma-lookandfeel-fedora \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 virtual/system-backgrounds-kde \
 "
