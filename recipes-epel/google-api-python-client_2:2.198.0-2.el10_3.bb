# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-api-python-client"
PE = "2"
PV = "2.198.0"
PR = "2.el10_3"
PACKAGES = " \
 python3-google-api-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/google-api-python-client-2.198.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce5fa207f14ed173682ff58001751536de82b672d1e97df3bd9a923b2fecdd5f"

URI_x86_64_v2_python3-google-api-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-api-client-2.198.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-api-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-api-client}"
SRC_URI[x86_64_v2_python3-google-api-client.sha256sum] = "0d70727a982f1dd7a4a59029d569f3342a8d3891ce7874af1f0f747d5f7bc602"

URI_aarch64_python3-google-api-client = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-api-client-2.198.0-2.el10_3.noarch.rpm;name=aarch64_python3-google-api-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-api-client}"
SRC_URI[aarch64_python3-google-api-client.sha256sum] = "71386e8d6d8f31a46b5b88065551ed543c8f813608124e3fe3a147d26365a8e5"

RDEPENDS:python3-google-api-client = " \
 python3 \
 python3-google-api-core \
 python3-google-auth \
 python3-google-auth-httplib2 \
 python3-httplib2 \
 python3-uritemplate \
 "
