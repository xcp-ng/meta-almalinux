# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-body-util"
PV = "0.1.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-http-body-util+channel-devel \
 rust-http-body-util+default-devel \
 rust-http-body-util+full-devel \
 rust-http-body-util-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-http-body-util-0.1.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "682cb521c17853b2679855b6aa384b5ad628a53269d1a3e27196a8569a7b726a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+channel-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+channel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-body-util+channel-devel.sha256sum] = "c816b5dfc52b81bb7eadc8c07463733599a058d40f232aa90536894f5c0c778e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+default-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-body-util+default-devel.sha256sum] = "14de2a4942fd0cd70b3b0766a678d91166dd59fa0859a95791241b11ed2a0c11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util+full-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-body-util+full-devel.sha256sum] = "0ef49aa234155f7aa66b605443120536b41db83e4d534004831bd464a6eaec75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-body-util-devel-0.1.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-body-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-http-body-util-devel.sha256sum] = "93483d99ff9b63e32b9437df6caf8753443636ddb55e33eacd1c79231bac6bc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+channel-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-http-body-util+channel-devel;unpack=0"
SRC_URI[aarch64_rust-http-body-util+channel-devel.sha256sum] = "a0401b056313ed9dba590c555ab5014a020d97938db2ffd40415095cddada5cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+default-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-http-body-util+default-devel;unpack=0"
SRC_URI[aarch64_rust-http-body-util+default-devel.sha256sum] = "4e1c7afd3d54388f3ee7f33a2cf4de474b86f038a7a328f14167238b689b9b01"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util+full-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-http-body-util+full-devel;unpack=0"
SRC_URI[aarch64_rust-http-body-util+full-devel.sha256sum] = "056653e048d8f1db0979bf2a0b70e7d2eb6647c38b476b674efb4250362129f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-http-body-util-devel-0.1.5-1.el10_3.noarch.rpm;name=aarch64_rust-http-body-util-devel;unpack=0"
SRC_URI[aarch64_rust-http-body-util-devel.sha256sum] = "384fb4e69c197fd32cbc1de8780cbe47e1c84d0059ed99b40f9bc4f5237dc95f"

RDEPENDS:rust-http-body-util+channel-devel = " \
 cargo \
 rust-http-body-util-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-http-body-util+default-devel = " \
 cargo \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util+full-devel = " \
 cargo \
 rust-http-body-util+channel-devel \
 rust-http-body-util-devel \
 "
RDEPENDS:rust-http-body-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-pin-project-lite+default-devel \
 "
