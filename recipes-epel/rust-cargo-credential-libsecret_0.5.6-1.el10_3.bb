# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-credential-libsecret"
PV = "0.5.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-credential-libsecret-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-credential-libsecret-0.5.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9fff389ef517f4732da0a04b59120784871b1db7269407fefcb3bff6d398276"

URI_x86_64_v2_rust-cargo-credential-libsecret+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret+default-devel-0.5.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-libsecret+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret+default-devel.sha256sum] = "8ef2cda90ac5681ae98cbeb0a3e0bd758428977b927db7aa24d4ae3af346b6e7"

URI_x86_64_v2_rust-cargo-credential-libsecret-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret-devel-0.5.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-libsecret-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret-devel.sha256sum] = "6da81cc1e82ee986bc17791586de5d9533c1b006fa40f762470faf75ebcef30d"

URI_aarch64_rust-cargo-credential-libsecret+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret+default-devel-0.5.6-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-libsecret+default-devel}"
SRC_URI[aarch64_rust-cargo-credential-libsecret+default-devel.sha256sum] = "0e33e1aa7b196374aaf729f00a5759fceac1a6642c7669592306520bd33bc874"

URI_aarch64_rust-cargo-credential-libsecret-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret-devel-0.5.6-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-libsecret-devel}"
SRC_URI[aarch64_rust-cargo-credential-libsecret-devel.sha256sum] = "f42ab73bbb00cbef8de75b53eb90dc17f443c43a41825d6c59b5f3769f063a22"

RDEPENDS:rust-cargo-credential-libsecret+default-devel = " \
 cargo \
 rust-cargo-credential-libsecret-devel \
 "
RDEPENDS:rust-cargo-credential-libsecret-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-cargo-credential+default-devel \
 rust-libloading+default-devel \
 "
