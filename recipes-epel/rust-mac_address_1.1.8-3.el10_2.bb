# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mac_address"
PV = "1.1.8"
PR = "3.el10_2"
PACKAGES = " \
 rust-mac_address+default-devel \
 rust-mac_address+serde-devel \
 rust-mac_address-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mac_address-1.1.8-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac20e52117030c8fb159234709371457a4cc4d2f7b2b38586749c5d21ed7946f"

URI_x86_64_v2_rust-mac_address+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mac_address+default-devel-1.1.8-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mac_address+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mac_address+default-devel}"
SRC_URI[x86_64_v2_rust-mac_address+default-devel.sha256sum] = "2f6f6f78342bd9edb9e4dc8cb25c065aeef544bc9b83ba07a52033df823d63ba"

URI_x86_64_v2_rust-mac_address+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mac_address+serde-devel-1.1.8-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mac_address+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mac_address+serde-devel}"
SRC_URI[x86_64_v2_rust-mac_address+serde-devel.sha256sum] = "8c665bf77888a798e6885fff42eef59d0aa75e45098db1a07d1f316494fdf42f"

URI_x86_64_v2_rust-mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mac_address-devel-1.1.8-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mac_address-devel}"
SRC_URI[x86_64_v2_rust-mac_address-devel.sha256sum] = "24647d5ae24fe7adda903b7940b3d3becb9684b2d61d0cf0a498dc2a11fadb1b"

URI_aarch64_rust-mac_address+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mac_address+default-devel-1.1.8-3.el10_2.noarch.rpm;name=aarch64_rust-mac_address+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mac_address+default-devel}"
SRC_URI[aarch64_rust-mac_address+default-devel.sha256sum] = "07aed4eb32e07b678c9c53aff48361fd1533b42ac25286ce8e4394322cdebe1c"

URI_aarch64_rust-mac_address+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mac_address+serde-devel-1.1.8-3.el10_2.noarch.rpm;name=aarch64_rust-mac_address+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mac_address+serde-devel}"
SRC_URI[aarch64_rust-mac_address+serde-devel.sha256sum] = "fdc4d8553bf68327abb2b0544ddd226277a5a228a68eb16ba62a00088eda0f86"

URI_aarch64_rust-mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mac_address-devel-1.1.8-3.el10_2.noarch.rpm;name=aarch64_rust-mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mac_address-devel}"
SRC_URI[aarch64_rust-mac_address-devel.sha256sum] = "9ae41faaec14b3c4f20ffb5d776cb359102c020ed75e377bb7e751d3a0ae48f2"

RDEPENDS:rust-mac_address+default-devel = " \
 cargo \
 rust-mac_address-devel \
 "
RDEPENDS:rust-mac_address+serde-devel = " \
 cargo \
 rust-mac_address-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-mac_address-devel = " \
 cargo \
 rust-nix0.29+default-devel \
 rust-nix0.29+net-devel \
 "
