# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-validator-collection"
PV = "1.5.0"
PR = "3.el10_1"
PACKAGES = " \
 python3-validator-collection \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-validator-collection-1.5.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f063827595bbe3adf33bd36b4bfca97e32dd29d643a422b960408480992b970"

URI_x86_64_v2_python3-validator-collection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-validator-collection-1.5.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-validator-collection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-validator-collection}"
SRC_URI[x86_64_v2_python3-validator-collection.sha256sum] = "07b0594c6f59a33cb48dd8324a345a6c1a173605db592bb64b757baabdeac63c"

URI_aarch64_python3-validator-collection = "${EPEL_MIRROR}/aarch64/Packages/p/python3-validator-collection-1.5.0-3.el10_1.noarch.rpm;name=aarch64_python3-validator-collection;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-validator-collection}"
SRC_URI[aarch64_python3-validator-collection.sha256sum] = "e24df9852a6885f5673770d75dbd3605a67aff504dbed57c9eb88ea630addd63"

RDEPENDS:python3-validator-collection = " \
 python3 \
 python3-jsonschema \
 "
