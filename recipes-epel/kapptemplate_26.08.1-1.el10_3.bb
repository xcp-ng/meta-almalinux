# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kapptemplate"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kapptemplate \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kapptemplate-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9135cfff4a2026deb47072d925d155760e6146def1482687f590e6dbac8aca4e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kapptemplate-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kapptemplate;unpack=0"
SRC_URI[x86_64_v2_kapptemplate.sha256sum] = "25ba2b770f300c690341070f680af97c0379fff6966108d6f23e6031e1ff7917"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kapptemplate-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kapptemplate;unpack=0"
SRC_URI[aarch64_kapptemplate.sha256sum] = "e5e028fd77a881200584f6de4d82285ef74ff804604e2e7d55b6145a1ada83d2"

RDEPENDS:kapptemplate = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
