# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvr"
PV = "2.12.14"
PR = "2.el10_3"
PACKAGES = " \
 openvr-api \
 openvr-devel \
 openvr-doc \
 openvr-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openvr-2.12.14-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d99c9012171686113e1d722ca0d647a7f9f583b963115003d2bff1cfd167abc"

URI_x86_64_v2_openvr-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-api-2.12.14-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvr-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-api}"
SRC_URI[x86_64_v2_openvr-api.sha256sum] = "14117e83388f13b531d94c60bb9ba8c65edc2db79e6ba8c12e2a7334be6dcbe3"

URI_x86_64_v2_openvr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-devel-2.12.14-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-devel}"
SRC_URI[x86_64_v2_openvr-devel.sha256sum] = "86169b9a1be5d62ff2438b2a65b9eade28957bf8113bf920db377283bca98e58"

URI_x86_64_v2_openvr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-doc-2.12.14-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_openvr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-doc}"
SRC_URI[x86_64_v2_openvr-doc.sha256sum] = "e91da5675f5945d1e8ba6f6630cf92e447f82a7d784b436c9cc8f8c86f6175dd"

URI_x86_64_v2_openvr-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-samples-2.12.14-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvr-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-samples}"
SRC_URI[x86_64_v2_openvr-samples.sha256sum] = "29a1c0f0083e9709148597706d883e1860046c25416cb67da21e4ab59158b0e2"

URI_aarch64_openvr-api = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-api-2.12.14-2.el10_3.aarch64.rpm;name=aarch64_openvr-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-api}"
SRC_URI[aarch64_openvr-api.sha256sum] = "c49b5c6b5209f08887c8dfaa9b2d58f7877ca86588e112aae800d29e049a662c"

URI_aarch64_openvr-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-devel-2.12.14-2.el10_3.aarch64.rpm;name=aarch64_openvr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-devel}"
SRC_URI[aarch64_openvr-devel.sha256sum] = "25837637f2ece95c41bef4a61492045608f658f8d6acf6e7850ada3218a2beb3"

URI_aarch64_openvr-doc = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-doc-2.12.14-2.el10_3.noarch.rpm;name=aarch64_openvr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-doc}"
SRC_URI[aarch64_openvr-doc.sha256sum] = "71693d23af9b26c21f79aa0ada42461e070f34d20c6eb2744eeceeceafb1159b"

URI_aarch64_openvr-samples = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-samples-2.12.14-2.el10_3.aarch64.rpm;name=aarch64_openvr-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-samples}"
SRC_URI[aarch64_openvr-samples.sha256sum] = "134c3f9f07501172a9b675c53bd6150a32db214b4e351d25649f2841ca4b343e"

RDEPENDS:openvr-api = " \
 glibc \
 jsoncpp \
 libgcc \
 libstdc++ \
 "
RDEPENDS:openvr-devel = " \
 jsoncpp-devel \
 openvr-api \
 pkgconf-pkg-config \
 "
RDEPENDS:openvr-doc = " \
 "
RDEPENDS:openvr-samples = " \
 glibc \
 libGLEW \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 openvr-api \
 qt5-qtbase \
 qt5-qtbase-gui \
 virtual/libSDL2-2.0.so.0___64bit_ \
 vulkan-loader \
 "
