# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "3proxy"
PV = "1.0.0"
PR = "1.el10_3"
PACKAGES = " \
 3proxy \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/3/3proxy-1.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2a6b5773591caa5920df306157df37aef24801bb38ac99f9a688529b9ac2b964"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/3proxy-1.0.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_3proxy;unpack=0"
SRC_URI[x86_64_v2_3proxy.sha256sum] = "ce88a3ba9231f155b2409415e6bfee57bda1999e0c6fccfbdcf6cfbb9b002049"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/3/3proxy-1.0.0-1.el10_3.aarch64.rpm;name=aarch64_3proxy;unpack=0"
SRC_URI[aarch64_3proxy.sha256sum] = "b002a73a347bedeeaf82f78af88cb52716836750be9c9753f68b8fecf03395d8"

RDEPENDS:3proxy = " \
 bash \
 glibc \
 openssl-libs \
 pcre2 \
 "
