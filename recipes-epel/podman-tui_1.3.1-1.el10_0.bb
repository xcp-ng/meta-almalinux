# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman-tui"
PV = "1.3.1"
PR = "1.el10_0"
PACKAGES = " \
 podman-tui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/podman-tui-1.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50c9c672a1fd450a8278776157289d041214a388035f77a518773c11f3ca3ed8"

URI_x86_64_v2_podman-tui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/podman-tui-1.3.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_podman-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-tui}"
SRC_URI[x86_64_v2_podman-tui.sha256sum] = "737cb410cd3f3dec166476af0ca481c367cc8903cf63a99ea8391d4f02ea26f8"

URI_aarch64_podman-tui = "${EPEL_MIRROR}/aarch64/Packages/p/podman-tui-1.3.1-1.el10_0.aarch64.rpm;name=aarch64_podman-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-tui}"
SRC_URI[aarch64_podman-tui.sha256sum] = "069b0056e2af11fa802b962b10bcd354a3ac7817448f89793e8ab3c86d999200"

RDEPENDS:podman-tui = " \
 glibc \
 "
