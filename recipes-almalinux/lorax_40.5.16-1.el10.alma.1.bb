# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax"
PV = "40.5.16"
PR = "1.el10.alma.1"
PACKAGES = " \
 lorax \
 lorax-docs \
 lorax-lmc-novirt \
 lorax-lmc-virt \
 lorax-templates-generic \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-40.5.16-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db6af2f25fbbd97461db536355da2955fd7c89618baf19d03a1e1b64592ccbb3"

URI_x86_64_v2_lorax = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-40.5.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax}"
SRC_URI[x86_64_v2_lorax.sha256sum] = "b9891afcfba580d921c93cd6b9c4efbff3ba89c9080c6e8ff8c1cce4c9137e47"

URI_x86_64_v2_lorax-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-docs-40.5.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-docs}"
SRC_URI[x86_64_v2_lorax-docs.sha256sum] = "4e80fd421db8c125f5118921273a1575617350f3a6c036cb3f8a2b03af47568b"

URI_x86_64_v2_lorax-lmc-novirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-novirt-40.5.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-novirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-lmc-novirt}"
SRC_URI[x86_64_v2_lorax-lmc-novirt.sha256sum] = "fc3162384c4a7aec8c55b133c9b310f4d63e1587d0719f16e0692bfb32e4502e"

URI_x86_64_v2_lorax-lmc-virt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-virt-40.5.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-lmc-virt}"
SRC_URI[x86_64_v2_lorax-lmc-virt.sha256sum] = "408ca2164b169a13a1a2fa5be9cf6b6e9a9c5b0c022b0429d7caf9225b73ff12"

URI_x86_64_v2_lorax-templates-generic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-generic-40.5.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_lorax-templates-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-generic}"
SRC_URI[x86_64_v2_lorax-templates-generic.sha256sum] = "fb22a8ebf487f48e70bf834e06c857f59002dd9271db07a1cf5446e3d767318a"
RPROVIDES:lorax-templates-generic:x86_64_v2 = "virtual/lorax-templates"

URI_aarch64_lorax = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-40.5.16-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax}"
SRC_URI[aarch64_lorax.sha256sum] = "2a1d7553a6207cc611416bf582e855539cd6c453293fe877c5d9af7cc21f7b5a"

URI_aarch64_lorax-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-docs-40.5.16-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-docs}"
SRC_URI[aarch64_lorax-docs.sha256sum] = "2f30f16c641c21cf88c65ad939addc0b0b30e28fa0db948c1813c4a8c5827105"

URI_aarch64_lorax-lmc-novirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-novirt-40.5.16-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-lmc-novirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-lmc-novirt}"
SRC_URI[aarch64_lorax-lmc-novirt.sha256sum] = "c49ad7e3abcbd2f3bdd76a6f89b73c08c8aa4d588cbbf2df286ca1e2db28c2b3"

URI_aarch64_lorax-lmc-virt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-virt-40.5.16-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-lmc-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-lmc-virt}"
SRC_URI[aarch64_lorax-lmc-virt.sha256sum] = "f2e82459ded518edf7050b4833ba28781c1ef2f55b910534815814e5a8babea7"

URI_aarch64_lorax-templates-generic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-generic-40.5.16-1.el10.alma.1.aarch64.rpm;name=aarch64_lorax-templates-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-generic}"
SRC_URI[aarch64_lorax-templates-generic.sha256sum] = "cb6661857c76f46f26c688cd7e140fa39bdfb80bb3ec7e3b3a2b00b6b411b671"
RPROVIDES:lorax-templates-generic:aarch64 = "virtual/lorax-templates"

RDEPENDS:lorax:x86_64_v2 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 grub2-pc \
 grub2-tools \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax:aarch64 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax-docs = " \
 lorax \
 "
RDEPENDS:lorax-lmc-novirt = " \
 almalinux-logos \
 anaconda-core \
 anaconda-install-env-deps \
 anaconda-tui \
 lorax \
 python3-psutil \
 tar \
 "
RDEPENDS:lorax-lmc-virt:x86_64_v2 = " \
 edk2-ovmf \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-lmc-virt:aarch64 = " \
 edk2-aarch64 \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-templates-generic = " \
 lorax \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/lorax-templates"

PROVIDES:append:aarch64 = " rpm/virtual/lorax-templates"
