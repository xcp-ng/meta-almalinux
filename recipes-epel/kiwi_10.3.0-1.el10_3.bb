# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi"
PV = "10.3.0"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-pxeboot \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 python3-kiwi \
"
PACKAGES:aarch64 = " \
 dracut-kiwi-lib \
 dracut-kiwi-live \
 dracut-kiwi-oem-dump \
 dracut-kiwi-oem-repart \
 dracut-kiwi-overlay \
 dracut-kiwi-verity \
 kiwi-cli \
 kiwi-systemdeps \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-image-validation \
 kiwi-systemdeps-iso-media \
 python3-kiwi \
"

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiwi-10.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7e9ec865320dd6d391e12734de3a552fa14feffabedf843b37280fa02128efc"

URI_x86_64_v2_dracut-kiwi-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-lib-10.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-lib}"
SRC_URI[x86_64_v2_dracut-kiwi-lib.sha256sum] = "a6c67b40c9ff6a8069dea7f9e9a82b706087144cc7930d391a15b0dc01f5312f"

URI_x86_64_v2_dracut-kiwi-live = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-live-10.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-live;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-live}"
SRC_URI[x86_64_v2_dracut-kiwi-live.sha256sum] = "c83a74b26a33e93efc0b067c0c7da82c4981dd257bb0fb40d7596f3c587a12cd"

URI_x86_64_v2_dracut-kiwi-oem-dump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-dump-10.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-dump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-oem-dump}"
SRC_URI[x86_64_v2_dracut-kiwi-oem-dump.sha256sum] = "b9b2797242aabf997ccffd2b2dc3db9036904d126bde90ecd6636b1a0b5a53fe"

URI_x86_64_v2_dracut-kiwi-oem-repart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-oem-repart-10.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-oem-repart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-oem-repart}"
SRC_URI[x86_64_v2_dracut-kiwi-oem-repart.sha256sum] = "9aae0f0f04089d8b826a0fd3bdec9718a8e53129ca7d48d7a1bf125502df7bd8"

URI_x86_64_v2_dracut-kiwi-overlay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-overlay-10.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-kiwi-overlay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-overlay}"
SRC_URI[x86_64_v2_dracut-kiwi-overlay.sha256sum] = "f66b279d3de83571543d1758d1e054d25423d88f7201d7c9e8f92521fa0b3521"

URI_x86_64_v2_dracut-kiwi-verity = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-kiwi-verity-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dracut-kiwi-verity;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-kiwi-verity}"
SRC_URI[x86_64_v2_dracut-kiwi-verity.sha256sum] = "451339d09257bb2667112addfc434e4241062358f7e37fd3753bf5e5bd3fdd11"

URI_x86_64_v2_kiwi-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-cli-10.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-cli}"
SRC_URI[x86_64_v2_kiwi-cli.sha256sum] = "8fad3d89b399b22ebd693c2c78b419019298266080da61b80c5c4bfc917fa0af"

URI_x86_64_v2_kiwi-pxeboot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-pxeboot-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-pxeboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-pxeboot}"
SRC_URI[x86_64_v2_kiwi-pxeboot.sha256sum] = "96568f25e9f8d6b7aec58b749d996776be364458df3ccaa855b617392c954f83"

URI_x86_64_v2_kiwi-systemdeps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps}"
SRC_URI[x86_64_v2_kiwi-systemdeps.sha256sum] = "52d60fcbe98ad7d73229a14995e050b72e7e635a712ca27248776b6172c261d5"

URI_x86_64_v2_kiwi-systemdeps-bootloaders = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-bootloaders-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-bootloaders}"
SRC_URI[x86_64_v2_kiwi-systemdeps-bootloaders.sha256sum] = "c9e012a13ae0c7e114de897f60abb8c7da041e1859808d1b1a61bf9a49a30c7c"

URI_x86_64_v2_kiwi-systemdeps-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-containers-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-containers}"
SRC_URI[x86_64_v2_kiwi-systemdeps-containers.sha256sum] = "1e6531b71acc65ae98a86c343bc69e212c11c36adce94e5e6dd52274fda4267c"

URI_x86_64_v2_kiwi-systemdeps-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-core-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-core}"
SRC_URI[x86_64_v2_kiwi-systemdeps-core.sha256sum] = "13202ddcdd3a22fdac6a333e0e25af9abd1f1e46be09181e0af617c3e48a1f59"

URI_x86_64_v2_kiwi-systemdeps-disk-images = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-disk-images-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-disk-images}"
SRC_URI[x86_64_v2_kiwi-systemdeps-disk-images.sha256sum] = "dacce1eee87eb2843847d6f9ca9ab6bbe59a00619f86ab48e24d1fcc90e5414a"

URI_x86_64_v2_kiwi-systemdeps-filesystems = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-filesystems-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-filesystems}"
SRC_URI[x86_64_v2_kiwi-systemdeps-filesystems.sha256sum] = "8710c234258462774a267913abfa5887b3af62ebb18a5f9a95467471f3ad77f8"

URI_x86_64_v2_kiwi-systemdeps-image-validation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-image-validation-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-image-validation}"
SRC_URI[x86_64_v2_kiwi-systemdeps-image-validation.sha256sum] = "f2dda0439e802e8a47332a4b7b38376681426e8d49261756209736fa53194df6"

URI_x86_64_v2_kiwi-systemdeps-iso-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-systemdeps-iso-media-10.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiwi-systemdeps-iso-media}"
SRC_URI[x86_64_v2_kiwi-systemdeps-iso-media.sha256sum] = "edf947fbe32c37c3f17d22af007bfefff59c3857f1bd1cc8483995bac5181ea2"

URI_x86_64_v2_python3-kiwi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-10.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kiwi}"
SRC_URI[x86_64_v2_python3-kiwi.sha256sum] = "a0bde148020e7641621493bb838d9cd034144faded8a2a24f7443b19280e5ef1"

URI_aarch64_dracut-kiwi-lib = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-lib-10.3.0-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-lib}"
SRC_URI[aarch64_dracut-kiwi-lib.sha256sum] = "ce568e6ed2173aa2edaf0b3dc4fe316f1a134df1345b1a3b22cbef4baaad6bfb"

URI_aarch64_dracut-kiwi-live = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-live-10.3.0-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-live;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-live}"
SRC_URI[aarch64_dracut-kiwi-live.sha256sum] = "c39ffc26ae55874c6ccfe8cf5af01c32c5840c21268a824ef6103a405f1d8868"

URI_aarch64_dracut-kiwi-oem-dump = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-dump-10.3.0-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-oem-dump;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-oem-dump}"
SRC_URI[aarch64_dracut-kiwi-oem-dump.sha256sum] = "c78003e934b8ff95d246549631e25149eb176e436dbc64b3678ecd705ecb3a30"

URI_aarch64_dracut-kiwi-oem-repart = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-oem-repart-10.3.0-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-oem-repart;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-oem-repart}"
SRC_URI[aarch64_dracut-kiwi-oem-repart.sha256sum] = "36b4ccb336656411e9e4260bb4b09375a15b56ce05834a86741eb4231a8837a9"

URI_aarch64_dracut-kiwi-overlay = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-overlay-10.3.0-1.el10_3.noarch.rpm;name=aarch64_dracut-kiwi-overlay;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-overlay}"
SRC_URI[aarch64_dracut-kiwi-overlay.sha256sum] = "17e16a536921624cc6e80aac46a9cdf0c5d5a346fcd1ee35a5b499d087df3064"

URI_aarch64_dracut-kiwi-verity = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-kiwi-verity-10.3.0-1.el10_3.aarch64.rpm;name=aarch64_dracut-kiwi-verity;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-kiwi-verity}"
SRC_URI[aarch64_dracut-kiwi-verity.sha256sum] = "7d1e19f7531f2e074d29994d62c45bcf78a184e73371822df99c82c2d82e1cb0"

URI_aarch64_kiwi-cli = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-cli-10.3.0-1.el10_3.noarch.rpm;name=aarch64_kiwi-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-cli}"
SRC_URI[aarch64_kiwi-cli.sha256sum] = "8b2a372fe00c1bb46804e82c63558969b1fcb7317cf316d6fad54229da9ed600"

URI_aarch64_kiwi-systemdeps = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-10.3.0-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps}"
SRC_URI[aarch64_kiwi-systemdeps.sha256sum] = "7a8d008c4270e76aec630a80d3e214c833b66893f6ba1d9f0a1d3d963256d1ed"

URI_aarch64_kiwi-systemdeps-bootloaders = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-bootloaders-10.3.0-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-bootloaders;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-bootloaders}"
SRC_URI[aarch64_kiwi-systemdeps-bootloaders.sha256sum] = "8f95c06fdddffadf6ec8c6515e051e0c715e4a3bbed51f7c8ad751926dc41ddb"

URI_aarch64_kiwi-systemdeps-containers = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-containers-10.3.0-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-containers}"
SRC_URI[aarch64_kiwi-systemdeps-containers.sha256sum] = "f5ae8bcfea1041127d9678d3fc1cfa459b0501f7713cc4b274072b58a424a096"

URI_aarch64_kiwi-systemdeps-core = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-core-10.3.0-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-core}"
SRC_URI[aarch64_kiwi-systemdeps-core.sha256sum] = "fe680f95e64134e39e0c1c349c15be65471160b841388d124d8e3ec4620f5730"

URI_aarch64_kiwi-systemdeps-disk-images = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-disk-images-10.3.0-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-disk-images;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-disk-images}"
SRC_URI[aarch64_kiwi-systemdeps-disk-images.sha256sum] = "2faa608c4d10551ae3963249b56cc067dd94d7f397bb93284cb6d58fb7c3dc3d"

URI_aarch64_kiwi-systemdeps-filesystems = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-filesystems-10.3.0-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-filesystems;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-filesystems}"
SRC_URI[aarch64_kiwi-systemdeps-filesystems.sha256sum] = "a6527a35998e6d43f1f918bf86ab87de4299e41c691f8f3cf68150b852a35b4c"

URI_aarch64_kiwi-systemdeps-image-validation = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-image-validation-10.3.0-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-image-validation;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-image-validation}"
SRC_URI[aarch64_kiwi-systemdeps-image-validation.sha256sum] = "e00aaf531f375a4b6f424d2bc86611d7045aac6ffdea7e7151dd93b2073a8617"

URI_aarch64_kiwi-systemdeps-iso-media = "${EPEL_MIRROR}/aarch64/Packages/k/kiwi-systemdeps-iso-media-10.3.0-1.el10_3.aarch64.rpm;name=aarch64_kiwi-systemdeps-iso-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiwi-systemdeps-iso-media}"
SRC_URI[aarch64_kiwi-systemdeps-iso-media.sha256sum] = "988176d0930cddd4270b63430fe8bba313cbef587404068c646f7fbfa24072af"

URI_aarch64_python3-kiwi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-10.3.0-1.el10_3.noarch.rpm;name=aarch64_python3-kiwi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kiwi}"
SRC_URI[aarch64_python3-kiwi.sha256sum] = "6bb32fe9b82ec630451770b0e476733f31344e49ccb68de99b7bbbf8c9484853"

RDEPENDS:dracut-kiwi-lib = " \
 bash \
 bc \
 cryptsetup \
 curl \
 device-mapper \
 dialog \
 dracut \
 e2fsprogs \
 gdisk \
 grep \
 kpartx \
 lvm2 \
 mdadm \
 parted \
 pv \
 util-linux \
 virtual/coreutils \
 xfsprogs \
 xz \
 "
RDEPENDS:dracut-kiwi-live = " \
 bash \
 device-mapper \
 dialog \
 dracut \
 dracut-kiwi-lib \
 dracut-network \
 e2fsprogs \
 parted \
 util-linux \
 xfsprogs \
 "
RDEPENDS:dracut-kiwi-oem-dump = " \
 bash \
 dracut-kiwi-lib \
 gawk \
 kexec-tools \
 "
RDEPENDS:dracut-kiwi-oem-repart = " \
 bash \
 dracut-kiwi-lib \
 "
RDEPENDS:dracut-kiwi-overlay = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 util-linux \
 "
RDEPENDS:dracut-kiwi-verity = " \
 bash \
 dracut \
 dracut-kiwi-lib \
 glibc \
 "
RDEPENDS:kiwi-cli = " \
 bash \
 bash-completion \
 python3-kiwi \
 "
RDEPENDS:kiwi-pxeboot = " \
 syslinux \
 tftp-server \
 "
RDEPENDS:kiwi-systemdeps = " \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-containers \
 kiwi-systemdeps-core \
 kiwi-systemdeps-disk-images \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 "
RDEPENDS:kiwi-systemdeps-bootloaders:x86_64_v2 = " \
 grub2-efi-x64 \
 grub2-efi-x64-modules \
 grub2-pc \
 grub2-pc-modules \
 grub2-tools \
 grub2-tools-efi \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-bootloaders:aarch64 = " \
 grub2-efi-aa64-modules \
 grub2-tools \
 grub2-tools-extra \
 grub2-tools-minimal \
 kiwi-systemdeps-core \
"
RDEPENDS:kiwi-systemdeps-containers = " \
 appx-util \
 buildah \
 skopeo \
 "
RDEPENDS:kiwi-systemdeps-core = " \
 dnf \
 file \
 lsof \
 microdnf \
 mtools \
 openssl \
 python3-dnf \
 rsync \
 screen \
 sed \
 tar \
 xz \
 "
RDEPENDS:kiwi-systemdeps-disk-images = " \
 cryptsetup \
 gdisk \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-filesystems \
 kiwi-systemdeps-iso-media \
 kpartx \
 lvm2 \
 mdadm \
 open-vmdk \
 parted \
 util-linux \
 "
RDEPENDS:kiwi-systemdeps-filesystems = " \
 dosfstools \
 e2fsprogs \
 erofs-utils \
 kiwi-systemdeps-core \
 qemu-img \
 squashfs-tools \
 xfsprogs \
 "
RDEPENDS:kiwi-systemdeps-image-validation = " \
 python3-solv \
 "
RDEPENDS:kiwi-systemdeps-iso-media:x86_64_v2 = " \
 grub2-efi-x64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 syslinux \
 syslinux-nonlinux \
 xorriso \
"
RDEPENDS:kiwi-systemdeps-iso-media:aarch64 = " \
 grub2-efi-aa64-cdboot \
 isomd5sum \
 kiwi-systemdeps-bootloaders \
 kiwi-systemdeps-core \
 kiwi-systemdeps-filesystems \
 xorriso \
"
RDEPENDS:python3-kiwi = " \
 kiwi-systemdeps-core \
 python3 \
 python3-docopt-ng \
 python3-lxml \
 python3-pyyaml \
 python3-requests \
 python3-simplejson \
 "
