# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-json"
PV = "0.24.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-json+default-devel \
 rust-tree-sitter-json-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-json-0.24.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b73df456d5a152204d12ee1927dac361376114283118d7a8d3b8a936cdeffff"

URI_x86_64_v2_rust-tree-sitter-json+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-json+default-devel-0.24.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-json+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-json+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-json+default-devel.sha256sum] = "73d1cb05fdd545143fbee58d234e8960d3473ef5f5fa28713b02ced5ff2e2688"

URI_x86_64_v2_rust-tree-sitter-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-json-devel-0.24.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-json-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-json-devel.sha256sum] = "412bfc348f020d3700d18ab6be8e3865f33400efb48f561111e1fd3d3c23b12c"

URI_aarch64_rust-tree-sitter-json+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-json+default-devel-0.24.8-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-json+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-json+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-json+default-devel.sha256sum] = "ad1b1ebe77f4990a5d2d71bb2ffb8263bcfd3580a1443ed6a6df20989fae2661"

URI_aarch64_rust-tree-sitter-json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-json-devel-0.24.8-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-json-devel}"
SRC_URI[aarch64_rust-tree-sitter-json-devel.sha256sum] = "3c6347353be07c776678d19bee598503c746b88101bf01363a7b9a54cd584151"

RDEPENDS:rust-tree-sitter-json+default-devel = " \
 cargo \
 rust-tree-sitter-json-devel \
 "
RDEPENDS:rust-tree-sitter-json-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
