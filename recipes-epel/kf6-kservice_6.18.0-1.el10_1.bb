# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kservice"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kservice \
 kf6-kservice-devel \
 kf6-kservice-doc \
 kf6-kservice-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kservice-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c074591866c433b0b79374c62fbc9a09c99e3c45c02b193fb7f60ae3b724cae8"

URI_x86_64_v2_kf6-kservice = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice}"
SRC_URI[x86_64_v2_kf6-kservice.sha256sum] = "1b48c798ae045b20e1ca9cac5c9f1cd27552f335452f8355483e10f9f3f6c7c3"

URI_x86_64_v2_kf6-kservice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-devel}"
SRC_URI[x86_64_v2_kf6-kservice-devel.sha256sum] = "4f505b37aed8032f68b19f5946f8cdc89f3d9ab0d9878ac72323dd5fc8d80a5b"

URI_x86_64_v2_kf6-kservice-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kservice-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-doc}"
SRC_URI[x86_64_v2_kf6-kservice-doc.sha256sum] = "aac53ecd622e7176c758512d15014cc6a23424489017cfbe0f5d6b43b8a4061c"

URI_x86_64_v2_kf6-kservice-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kservice-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-html}"
SRC_URI[x86_64_v2_kf6-kservice-html.sha256sum] = "1b6b4df340452513f74fbf2893c1d56314277a17599d54060fdd11f4c401673e"

URI_aarch64_kf6-kservice = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kservice;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice}"
SRC_URI[aarch64_kf6-kservice.sha256sum] = "5357c7c248752fc3b85e2ef87363b1773143d9d5ac03ebadd1b7e984cc9031d9"

URI_aarch64_kf6-kservice-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kservice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-devel}"
SRC_URI[aarch64_kf6-kservice-devel.sha256sum] = "c67e4d0229d5046e637e27b9f3e81dc56fe5ae5ed0bacee81131626df646ed22"

URI_aarch64_kf6-kservice-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kservice-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-doc}"
SRC_URI[aarch64_kf6-kservice-doc.sha256sum] = "0182bcfa1bfcd4b3b3e8169839571db59b05f8f17f4fa65a30020c3cd51c4055"

URI_aarch64_kf6-kservice-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kservice-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-html}"
SRC_URI[aarch64_kf6-kservice-html.sha256sum] = "1126d7d316766d14ce40eb34c0c8113f9421e30e402d5955d94812a045724d17"

RDEPENDS:kf6-kservice = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kservice-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kservice \
 "
RDEPENDS:kf6-kservice-doc = " \
 "
RDEPENDS:kf6-kservice-html = " \
 "
