# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxsmm"
PV = "1.17"
PR = "7.el10_0"
PACKAGES:x86_64_v2 = " \
 libxsmm \
 libxsmm-devel \
 libxsmm-doc \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/l/libxsmm-1.17-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52cd51ade4324cc095ceb3d04ce29d848b6d882da7182812e8cd7410f6f2fa97"

URI_x86_64_v2_libxsmm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxsmm-1.17-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxsmm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxsmm}"
SRC_URI[x86_64_v2_libxsmm.sha256sum] = "218b4d62afa17d9065085e4ca136a6e32f7db82b6e29eed461334d7b96aa4b8b"

URI_x86_64_v2_libxsmm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxsmm-devel-1.17-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxsmm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxsmm-devel}"
SRC_URI[x86_64_v2_libxsmm-devel.sha256sum] = "946b8c4a238a064b7373ff7abf45411c599296c148cb7d71ae7cfd064db2d695"

URI_x86_64_v2_libxsmm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxsmm-doc-1.17-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libxsmm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxsmm-doc}"
SRC_URI[x86_64_v2_libxsmm-doc.sha256sum] = "d3e15b100d3b08e5ff721722aefa1f1df391cb8074af4d376a90d706d8f237cc"

RDEPENDS:libxsmm = " \
 glibc \
 libgcc \
 libgomp \
 "
RDEPENDS:libxsmm-devel = " \
 glibc \
 libxsmm \
 libxsmm-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libxsmm-doc = " \
 virtual//usr/bin/env \
 "
