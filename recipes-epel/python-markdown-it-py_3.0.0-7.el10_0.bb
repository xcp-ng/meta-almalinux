# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-markdown-it-py"
PV = "3.0.0"
PR = "7.el10_0"
PACKAGES = " \
 python3-markdown-it-py \
 python3-markdown-it-py+linkify \
 python3-markdown-it-py+plugins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-markdown-it-py-3.0.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27fd2c25633ec3b7f21fceefad1b5a80b547f11f50e39d661e40f125fd21e111"

URI_x86_64_v2_python3-markdown-it-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-markdown-it-py-3.0.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-markdown-it-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-markdown-it-py}"
SRC_URI[x86_64_v2_python3-markdown-it-py.sha256sum] = "9e39aa74b7cfca6a8dae4e23dfbbf4c3693327b6491448cf15bf4d5ca25dc7e4"

URI_x86_64_v2_python3-markdown-it-py+linkify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-markdown-it-py+linkify-3.0.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-markdown-it-py+linkify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-markdown-it-py+linkify}"
SRC_URI[x86_64_v2_python3-markdown-it-py+linkify.sha256sum] = "c5228e5d3ffcdababe969a73bf6d995127ab3b05bc24a682661c3a5af2a02fd8"

URI_x86_64_v2_python3-markdown-it-py+plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-markdown-it-py+plugins-3.0.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-markdown-it-py+plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-markdown-it-py+plugins}"
SRC_URI[x86_64_v2_python3-markdown-it-py+plugins.sha256sum] = "abd583842817b7d928363abb6b8e0d425603ff448f83fc0fd66a3dab1ee4c2e3"

URI_aarch64_python3-markdown-it-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-markdown-it-py-3.0.0-7.el10_0.noarch.rpm;name=aarch64_python3-markdown-it-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-markdown-it-py}"
SRC_URI[aarch64_python3-markdown-it-py.sha256sum] = "c00a88a2fa27a861f502c2e82946c738d38cfbea8b74a49bf3459a7f611961c8"

URI_aarch64_python3-markdown-it-py+linkify = "${EPEL_MIRROR}/aarch64/Packages/p/python3-markdown-it-py+linkify-3.0.0-7.el10_0.noarch.rpm;name=aarch64_python3-markdown-it-py+linkify;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-markdown-it-py+linkify}"
SRC_URI[aarch64_python3-markdown-it-py+linkify.sha256sum] = "c41dc4d29a1ef67bee440032aaa2faca1fdf502832cc6b517cccdcbb2d7a0150"

URI_aarch64_python3-markdown-it-py+plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-markdown-it-py+plugins-3.0.0-7.el10_0.noarch.rpm;name=aarch64_python3-markdown-it-py+plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-markdown-it-py+plugins}"
SRC_URI[aarch64_python3-markdown-it-py+plugins.sha256sum] = "48752cfaadb8b457379614b6105748d13790530b81e88a028354251b883a3276"

RDEPENDS:python3-markdown-it-py = " \
 python3 \
 python3-mdurl \
 "
RDEPENDS:python3-markdown-it-py+linkify = " \
 python3 \
 python3-linkify-it-py \
 python3-markdown-it-py \
 "
RDEPENDS:python3-markdown-it-py+plugins = " \
 python3 \
 python3-markdown-it-py \
 python3-mdit-py-plugins \
 "
