# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "greenboot-rs"
PV = "0.16.3"
PR = "0.el10_2"
PACKAGES = " \
 greenboot \
 greenboot-default-health-checks \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/greenboot-rs-0.16.3-0.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5167476f119a1411bb8e6c9cf9a7d6dc728c39979a7d0e0388c8367672498c8f"

URI_x86_64_v2_greenboot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-0.16.3-0.el10_2.x86_64_v2.rpm;name=x86_64_v2_greenboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_greenboot}"
SRC_URI[x86_64_v2_greenboot.sha256sum] = "4790bc07023cd7060de9ff779fc01e38fe8a9511fae94fffa5520ca52164da43"

URI_x86_64_v2_greenboot-default-health-checks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/greenboot-default-health-checks-0.16.3-0.el10_2.x86_64_v2.rpm;name=x86_64_v2_greenboot-default-health-checks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_greenboot-default-health-checks}"
SRC_URI[x86_64_v2_greenboot-default-health-checks.sha256sum] = "34621f6b6be49c98cd41317cff184d1b28ae7db2050cbb0ba092d78c0061f9a2"

URI_aarch64_greenboot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-0.16.3-0.el10_2.aarch64.rpm;name=aarch64_greenboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_greenboot}"
SRC_URI[aarch64_greenboot.sha256sum] = "0611d0d48a8d312b3e2b0344605629c3c205e7456e20fa89fbbc0ab8040af81e"

URI_aarch64_greenboot-default-health-checks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/greenboot-default-health-checks-0.16.3-0.el10_2.aarch64.rpm;name=aarch64_greenboot-default-health-checks;unpack=0"
SRC_URI:append = " ${URI_aarch64_greenboot-default-health-checks}"
SRC_URI[aarch64_greenboot-default-health-checks.sha256sum] = "b97509dbfda2de06a426ed5c9f3219720c447900c7da17c07354517c6a276c30"

RDEPENDS:greenboot = " \
 bash \
 glibc \
 libgcc \
 pam \
 rpm-ostree \
 systemd \
 "
RDEPENDS:greenboot-default-health-checks = " \
 bash \
 greenboot \
 jq \
 util-linux \
 "
