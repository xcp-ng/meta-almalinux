# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-data-encoding-macro"
PV = "0.1.19"
PR = "1.el10_3"
PACKAGES = " \
 rust-data-encoding-macro+default-devel \
 rust-data-encoding-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-data-encoding-macro-0.1.19-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cff2fd9d428998adf6d5d14dece0e82b1c6ea15bfc004e14bfe360eb7df990ad"

URI_x86_64_v2_rust-data-encoding-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-macro+default-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding-macro+default-devel}"
SRC_URI[x86_64_v2_rust-data-encoding-macro+default-devel.sha256sum] = "9f8560f502e83b76c559da39bbf8e4e2391b08a8507160f8df3ccf639144e9bf"

URI_x86_64_v2_rust-data-encoding-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-macro-devel-0.1.19-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding-macro-devel}"
SRC_URI[x86_64_v2_rust-data-encoding-macro-devel.sha256sum] = "df2838531cd2b6c839a0937537927117156f6096c9ea8326ce73aad8fa16f131"

URI_aarch64_rust-data-encoding-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-macro+default-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding-macro+default-devel}"
SRC_URI[aarch64_rust-data-encoding-macro+default-devel.sha256sum] = "989fecf69ded7ea3e65e75a7f4a35d7861d50117c7bab32dffc7d8386238d8e9"

URI_aarch64_rust-data-encoding-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-macro-devel-0.1.19-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding-macro-devel}"
SRC_URI[aarch64_rust-data-encoding-macro-devel.sha256sum] = "9e384dcecdfb4515234962a10c89e99543842cec7f45cb53da3ca649042deb97"

RDEPENDS:rust-data-encoding-macro+default-devel = " \
 cargo \
 rust-data-encoding-macro-devel \
 "
RDEPENDS:rust-data-encoding-macro-devel = " \
 cargo \
 rust \
 rust-data-encoding-devel \
 rust-data-encoding-macro-internal+default-devel \
 "
