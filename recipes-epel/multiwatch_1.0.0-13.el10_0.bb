# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "multiwatch"
PV = "1.0.0"
PR = "13.el10_0"
PACKAGES = " \
 multiwatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/multiwatch-1.0.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24d6250436e11041246b3831bec72a7790c28d00251d65a34ad4782ef2431381"

URI_x86_64_v2_multiwatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/multiwatch-1.0.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_multiwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_multiwatch}"
SRC_URI[x86_64_v2_multiwatch.sha256sum] = "24103eeeb802915673419f66c254d720442c06555b262a5bb5a98e3a79a450f6"

URI_aarch64_multiwatch = "${EPEL_MIRROR}/aarch64/Packages/m/multiwatch-1.0.0-13.el10_0.aarch64.rpm;name=aarch64_multiwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_multiwatch}"
SRC_URI[aarch64_multiwatch.sha256sum] = "0e6e29026d42a9b45eebe662d407fc6ffe4d12f71a0731d2e4613c048db1ac6a"

RDEPENDS:multiwatch = " \
 glib2 \
 glibc \
 libev \
 "
