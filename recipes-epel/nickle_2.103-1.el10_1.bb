# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nickle"
PV = "2.103"
PR = "1.el10_1"
PACKAGES = " \
 nickle \
 nickle-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nickle-2.103-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cec2d7e46f06a1f11aaf7f46d78fd32325f28ad98447dd8968ff212f7b15b005"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nickle-2.103-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nickle;unpack=0"
SRC_URI[x86_64_v2_nickle.sha256sum] = "a585c23a8b194160c2cbced50308d8a9e1f1ffaf98830b4ac7ee1ba21f43a533"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nickle-devel-2.103-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nickle-devel;unpack=0"
SRC_URI[x86_64_v2_nickle-devel.sha256sum] = "f06c1f767d6db5e0d349d3c5d14e068630e83733732c1c18d955436c7e808f63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nickle-2.103-1.el10_1.aarch64.rpm;name=aarch64_nickle;unpack=0"
SRC_URI[aarch64_nickle.sha256sum] = "c70ab9478322637ff6659d8709c5f18bc761c10c29a025cf0f28c81fc2b240a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nickle-devel-2.103-1.el10_1.aarch64.rpm;name=aarch64_nickle-devel;unpack=0"
SRC_URI[aarch64_nickle-devel.sha256sum] = "aef6c9dcd2c817f71eb02f99d141677fd27ffe10fed4e5cf1b208682077057a3"

RDEPENDS:nickle = " \
 bash \
 glibc \
 readline \
 "
RDEPENDS:nickle-devel = " \
 nickle \
 "
