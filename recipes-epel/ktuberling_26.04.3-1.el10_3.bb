# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktuberling"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ktuberling \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktuberling-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13f6fd607f3ac6ed6cc603e160ba7ce3af6d407cb6199fb3aaa5e56898304f54"

URI_x86_64_v2_ktuberling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktuberling-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktuberling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktuberling}"
SRC_URI[x86_64_v2_ktuberling.sha256sum] = "e10bbfbc94c630a898fdbce79d4e3d854c3e7ac6b4b90c2baac473699a1eb8f9"

URI_aarch64_ktuberling = "${EPEL_MIRROR}/aarch64/Packages/k/ktuberling-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ktuberling;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktuberling}"
SRC_URI[aarch64_ktuberling.sha256sum] = "ee3ee2dbe5649462f6c1e36103015e7da37451a5db59de4e4a8f02cab09f5ae9"

RDEPENDS:ktuberling = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
