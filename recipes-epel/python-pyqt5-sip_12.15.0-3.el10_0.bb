# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyqt5-sip"
PV = "12.15.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-pyqt5-sip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyqt5-sip-12.15.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc034d7307db1e19715bf48268aabfe81bba11c9a42d2598b02971182673ade2"

URI_x86_64_v2_python3-pyqt5-sip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyqt5-sip-12.15.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt5-sip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt5-sip}"
SRC_URI[x86_64_v2_python3-pyqt5-sip.sha256sum] = "9e1749f4c259ae26876d09b078de3014c2da52ecc4ea89f7d859f198d5c96346"

URI_aarch64_python3-pyqt5-sip = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyqt5-sip-12.15.0-3.el10_0.aarch64.rpm;name=aarch64_python3-pyqt5-sip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt5-sip}"
SRC_URI[aarch64_python3-pyqt5-sip.sha256sum] = "c991fee89da18dc04c64d42da32419a1163d72e377ff8d9f1ae2f3a32ed6b331"

RDEPENDS:python3-pyqt5-sip = " \
 glibc \
 python3 \
 "
