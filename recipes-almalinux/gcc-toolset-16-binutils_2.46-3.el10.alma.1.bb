# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-16-binutils"
PV = "2.46"
PR = "3.el10.alma.1"
PACKAGES = " \
 gcc-toolset-16-binutils \
 gcc-toolset-16-binutils-devel \
 gcc-toolset-16-binutils-gold \
 gcc-toolset-16-binutils-gprofng \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-16-binutils-2.46-3.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7670bb2eb40c440169b944ffdeed5d248442fbfba94bf5705c939128ad0fe90f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-binutils-2.46-3.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-binutils;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-binutils.sha256sum] = "11e89d8ad4ccd25cda6bdc452810bc06a17b5a510ec1f36e87afba129ed980d4"
RPROVIDES:gcc-toolset-16-binutils:append:x86_64_v2 = " virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-binutils-devel-2.46-3.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-binutils-devel;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-binutils-devel.sha256sum] = "79b4c9e25232620b9e84580f812b3cdc778cde3db5143292d7ddd80dbcf38857"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-binutils-gold-2.46-3.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-binutils-gold;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-binutils-gold.sha256sum] = "71edb404785669220f9e2b38037e2126b9ee2c1a9a2372d2111c3cadbfff50cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-16-binutils-gprofng-2.46-3.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-16-binutils-gprofng;unpack=0"
SRC_URI[x86_64_v2_gcc-toolset-16-binutils-gprofng.sha256sum] = "ab5ba4c4dcb1a919e6a331c43fe8c96ce2aa771c7cea885b75afe4c8320a531f"
RPROVIDES:gcc-toolset-16-binutils-gprofng:append:x86_64_v2 = " virtual/libgprofng.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-binutils-2.46-3.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-binutils;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-binutils.sha256sum] = "54c56755531209585476204dac83188c3c231f9a4423d03e89cfce8403fa06bc"
RPROVIDES:gcc-toolset-16-binutils:append:aarch64 = " virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-binutils-devel-2.46-3.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-binutils-devel;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-binutils-devel.sha256sum] = "97e3603fb7cc5314621f58e730fc2ab590742cc7293e3f2d6b8ede3b12a2ff91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-binutils-gold-2.46-3.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-binutils-gold;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-binutils-gold.sha256sum] = "f89e65be750e57ee7531e9c1fcb932489b3190ceb11b60ac431d3b892ef5c119"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-16-binutils-gprofng-2.46-3.el10.alma.1.aarch64.rpm;name=aarch64_gcc-toolset-16-binutils-gprofng;unpack=0"
SRC_URI[aarch64_gcc-toolset-16-binutils-gprofng.sha256sum] = "d0a2a862434891239b918d52cb4ba76098f314f0a1a30f658b6411297abd5bbe"
RPROVIDES:gcc-toolset-16-binutils-gprofng:append:aarch64 = " virtual/libgprofng.so.0___64bit_"

RDEPENDS:gcc-toolset-16-binutils = " \
 alternatives \
 bash \
 elfutils-debuginfod-client \
 gcc-toolset-16-runtime \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 libzstd \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-16-binutils-devel = " \
 bash \
 gcc-toolset-16-binutils \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
RDEPENDS:gcc-toolset-16-binutils-gold = " \
 bash \
 gcc-toolset-16-binutils \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 libzstd \
 zlib-ng-compat \
 "
RDEPENDS:gcc-toolset-16-binutils-gprofng = " \
 bash \
 gcc-toolset-16-binutils \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 virtual//usr/bin/env \
 zlib-ng-compat \
 "
