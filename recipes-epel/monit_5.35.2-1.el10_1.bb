# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "monit"
PV = "5.35.2"
PR = "1.el10_1"
PACKAGES = " \
 monit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/monit-5.35.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36d4a486a4ec168907a536f54dd0768c2021dd80a11bd87bfe96608763ad482a"

URI_x86_64_v2_monit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/monit-5.35.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_monit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_monit}"
SRC_URI[x86_64_v2_monit.sha256sum] = "deb562984cf70064a112a2fc8b0fc3e5469ac691243540875ffd20a81220d1ee"

URI_aarch64_monit = "${EPEL_MIRROR}/aarch64/Packages/m/monit-5.35.2-1.el10_1.aarch64.rpm;name=aarch64_monit;unpack=0"
SRC_URI:append = " ${URI_aarch64_monit}"
SRC_URI[aarch64_monit.sha256sum] = "08825306f35a67239c9f3786ff6c405bce1cae3a7c1e852801fdb9edeca1e206"

RDEPENDS:monit = " \
 bash \
 glibc \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd \
 zlib-ng-compat \
 "
