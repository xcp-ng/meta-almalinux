# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkexiv2"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkexiv2-qt6 \
 libkexiv2-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkexiv2-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df23559ea2d8a65e7565fa764c8e6191bcd46c4b5f0cca6b0b36b464a01c967e"

URI_x86_64_v2_libkexiv2-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkexiv2-qt6}"
SRC_URI[x86_64_v2_libkexiv2-qt6.sha256sum] = "2cb9a0013094dc9646a20ca62bce01167b0a6b7194e78f9a1fcfc39442d0a609"

URI_x86_64_v2_libkexiv2-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkexiv2-qt6-devel}"
SRC_URI[x86_64_v2_libkexiv2-qt6-devel.sha256sum] = "9921e34798fc77ecb06f0e44ac435bb281c82232d8193dec135351d40014d485"

URI_aarch64_libkexiv2-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkexiv2-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkexiv2-qt6}"
SRC_URI[aarch64_libkexiv2-qt6.sha256sum] = "8d204f8cbc7ab66b38a623e03f2039c92e9961aadc0d5493ebe8c5dd7483499a"

URI_aarch64_libkexiv2-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkexiv2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkexiv2-qt6-devel}"
SRC_URI[aarch64_libkexiv2-qt6-devel.sha256sum] = "f006df52dcaa3b53f7548fb0e0c4e6dd8c80df1e3ba2d9b44eceafe18320584c"

RDEPENDS:libkexiv2-qt6 = " \
 exiv2-libs \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkexiv2-qt6-devel = " \
 cmake-filesystem \
 libkexiv2-qt6 \
 qt6-qtbase-devel \
 "
