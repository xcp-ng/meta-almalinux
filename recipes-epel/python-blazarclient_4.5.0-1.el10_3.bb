# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-blazarclient"
PV = "4.5.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-blazarclient \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-blazarclient-4.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "234ec31a787af1247246cd0ccd6ef75064882a198524769d89dd72bb4a3e50c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-blazarclient-4.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-blazarclient;unpack=0"
SRC_URI[x86_64_v2_python3-blazarclient.sha256sum] = "073619d5f0f0f8fdf749f16f6400846941b03fe0085ecc77c38f7bda040cabea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-blazarclient-4.5.0-1.el10_3.noarch.rpm;name=aarch64_python3-blazarclient;unpack=0"
SRC_URI[aarch64_python3-blazarclient.sha256sum] = "d5047953ed5498fc88c7772c01dba0a10dc43ca5e1c8a798a79ba00732a2c085"

RDEPENDS:python3-blazarclient = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-osc-lib \
 python3-oslo-i18n \
 python3-oslo-log \
 python3-oslo-utils \
 python3-pbr \
 python3-prettytable \
 "
