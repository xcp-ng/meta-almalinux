# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quickcheck_macros"
PV = "1.1.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-quickcheck_macros+default-devel \
 rust-quickcheck_macros-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-quickcheck_macros-1.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "810bbb8933ae8df6ecc187ada45fd15c1b771d28c7f61f5816c4e115ae7f5962"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck_macros+default-devel-1.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck_macros+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quickcheck_macros+default-devel.sha256sum] = "7276d8572991671459499f505a3dfb93424dee9f3f7ce1032b55c23267d7133c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quickcheck_macros-devel-1.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quickcheck_macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-quickcheck_macros-devel.sha256sum] = "228db4bd3d9b94946f14e1d237bf8bf93e9f23f25bc33644a14756ed5885be0d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck_macros+default-devel-1.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-quickcheck_macros+default-devel;unpack=0"
SRC_URI[aarch64_rust-quickcheck_macros+default-devel.sha256sum] = "bff3b77c78689cc6a36f699ceb026cc0ba436c0defd1e2f089c97546b96c9ec8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-quickcheck_macros-devel-1.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-quickcheck_macros-devel;unpack=0"
SRC_URI[aarch64_rust-quickcheck_macros-devel.sha256sum] = "11dc1714404d1f0b5bb5c6834d0f075feb36c3ec3800dc4e1fb91dfe7129923c"

RDEPENDS:rust-quickcheck_macros+default-devel = " \
 cargo \
 rust-quickcheck_macros-devel \
 "
RDEPENDS:rust-quickcheck_macros-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
