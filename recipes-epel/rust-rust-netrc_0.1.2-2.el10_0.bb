# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-netrc"
PV = "0.1.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-rust-netrc+default-devel \
 rust-rust-netrc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-netrc-0.1.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10bd638323ac6bd909dac11de4b20bee77c2e90dbf8aaa18a3c4dafa13d3118a"

URI_x86_64_v2_rust-rust-netrc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-netrc+default-devel-0.1.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-netrc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-netrc+default-devel}"
SRC_URI[x86_64_v2_rust-rust-netrc+default-devel.sha256sum] = "053b97878b4c76c5b9aaa97e77db42aaa88831f6d3bc30bea8691a8fe81be544"

URI_x86_64_v2_rust-rust-netrc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-netrc-devel-0.1.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-netrc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-netrc-devel}"
SRC_URI[x86_64_v2_rust-rust-netrc-devel.sha256sum] = "ea4250d4a656db20d5732258ba33767d434de04903bc72249cbf01c8ce6ffd83"

URI_aarch64_rust-rust-netrc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-netrc+default-devel-0.1.2-2.el10_0.noarch.rpm;name=aarch64_rust-rust-netrc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-netrc+default-devel}"
SRC_URI[aarch64_rust-rust-netrc+default-devel.sha256sum] = "d65178236c67864fc4f960260971475bbe311a62b02856400423a7bf4b115c26"

URI_aarch64_rust-rust-netrc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-netrc-devel-0.1.2-2.el10_0.noarch.rpm;name=aarch64_rust-rust-netrc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-netrc-devel}"
SRC_URI[aarch64_rust-rust-netrc-devel.sha256sum] = "b43c453f64a47d5410145454917f69ce889454c1af59a5cf3fd133f5c7c6cb32"

RDEPENDS:rust-rust-netrc+default-devel = " \
 cargo \
 rust-rust-netrc-devel \
 "
RDEPENDS:rust-rust-netrc-devel = " \
 cargo \
 rust-shellexpand+base-0-devel \
 rust-shellexpand+path-devel \
 rust-shellexpand+tilde-devel \
 rust-shellexpand-devel \
 rust-thiserror1+default-devel \
 "
