# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cbc0.1"
PV = "0.1.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-cbc0.1+alloc-devel \
 rust-cbc0.1+block-padding-devel \
 rust-cbc0.1+default-devel \
 rust-cbc0.1+std-devel \
 rust-cbc0.1+zeroize-devel \
 rust-cbc0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cbc0.1-0.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dac36abc66f414c5bdbcb75a7c009631a01ebcc0a8d20360d6835cf573cb689"

URI_x86_64_v2_rust-cbc0.1+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc0.1+alloc-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc0.1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc0.1+alloc-devel}"
SRC_URI[x86_64_v2_rust-cbc0.1+alloc-devel.sha256sum] = "f2698210462f4b03cf407a7858c6c85a47fa2b0630979b3df4fa7ed780a0147c"

URI_x86_64_v2_rust-cbc0.1+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc0.1+block-padding-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc0.1+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc0.1+block-padding-devel}"
SRC_URI[x86_64_v2_rust-cbc0.1+block-padding-devel.sha256sum] = "016af07cc0c47a34d27c8d92c071077e9c8d49f6ec310b83151f778e5c5064e7"

URI_x86_64_v2_rust-cbc0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc0.1+default-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc0.1+default-devel}"
SRC_URI[x86_64_v2_rust-cbc0.1+default-devel.sha256sum] = "af2c6993f440a2a4e2aa15fc052bf18bd409bef072b26b744883f0bf4dcf9ca6"

URI_x86_64_v2_rust-cbc0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc0.1+std-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc0.1+std-devel}"
SRC_URI[x86_64_v2_rust-cbc0.1+std-devel.sha256sum] = "af7f7d77224910e9235764ef2f671fca4a529a89339c70fe77a963b8d4b394f3"

URI_x86_64_v2_rust-cbc0.1+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc0.1+zeroize-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc0.1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc0.1+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cbc0.1+zeroize-devel.sha256sum] = "ab38691b7fc924f847dc0bec81e1ad1bfbfca46d7dde2b1c8352502ac71de9a4"

URI_x86_64_v2_rust-cbc0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbc0.1-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbc0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbc0.1-devel}"
SRC_URI[x86_64_v2_rust-cbc0.1-devel.sha256sum] = "8b7f8aeff144b67dd6f9ee1d30a41d52c3ec57c855e60e81258d98aac850a727"

URI_aarch64_rust-cbc0.1+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc0.1+alloc-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-cbc0.1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc0.1+alloc-devel}"
SRC_URI[aarch64_rust-cbc0.1+alloc-devel.sha256sum] = "6dc08be0964ec4caae0e692b3267c723a231b9be89842739f28e936ad5a915b3"

URI_aarch64_rust-cbc0.1+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc0.1+block-padding-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-cbc0.1+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc0.1+block-padding-devel}"
SRC_URI[aarch64_rust-cbc0.1+block-padding-devel.sha256sum] = "7d1a82b8c042233f075931cee6cefb0d32a78bdb48bedc48c9123579b31966d6"

URI_aarch64_rust-cbc0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc0.1+default-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-cbc0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc0.1+default-devel}"
SRC_URI[aarch64_rust-cbc0.1+default-devel.sha256sum] = "5d5a7a3df7ccd5f2b61fd1ee695b94eb71e404ba088d5b3ef4069ec2bde8a42a"

URI_aarch64_rust-cbc0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc0.1+std-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-cbc0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc0.1+std-devel}"
SRC_URI[aarch64_rust-cbc0.1+std-devel.sha256sum] = "57923791826008f592ee70a56a729ea95f33201439e932d0375057ca36a6b957"

URI_aarch64_rust-cbc0.1+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc0.1+zeroize-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-cbc0.1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc0.1+zeroize-devel}"
SRC_URI[aarch64_rust-cbc0.1+zeroize-devel.sha256sum] = "0c4b292a563ac9f46ff0cbd73b5d60556146d8185933fe2dd3e4e9a6d381c6d9"

URI_aarch64_rust-cbc0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbc0.1-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-cbc0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbc0.1-devel}"
SRC_URI[aarch64_rust-cbc0.1-devel.sha256sum] = "6d36b4dbadddb9b01ade171827dcf68096847b58067dab006005ecd05e3f8777"

RDEPENDS:rust-cbc0.1+alloc-devel = " \
 cargo \
 rust-cbc0.1-devel \
 rust-cipher0.4+alloc-devel \
 "
RDEPENDS:rust-cbc0.1+block-padding-devel = " \
 cargo \
 rust-cbc0.1-devel \
 rust-cipher0.4+block-padding-devel \
 "
RDEPENDS:rust-cbc0.1+default-devel = " \
 cargo \
 rust-cbc0.1+block-padding-devel \
 rust-cbc0.1-devel \
 "
RDEPENDS:rust-cbc0.1+std-devel = " \
 cargo \
 rust-cbc0.1+alloc-devel \
 rust-cbc0.1-devel \
 rust-cipher0.4+std-devel \
 "
RDEPENDS:rust-cbc0.1+zeroize-devel = " \
 cargo \
 rust-cbc0.1-devel \
 rust-cipher0.4+zeroize-devel \
 "
RDEPENDS:rust-cbc0.1-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
