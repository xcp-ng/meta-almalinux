# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "extra-cmake-modules"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 extra-cmake-modules \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/extra-cmake-modules-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b06d21acb81019038eec86584ec356a8c586c5bd5ee15c9f4d99f2264c1df24e"

URI_x86_64_v2_extra-cmake-modules = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/extra-cmake-modules-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_extra-cmake-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_extra-cmake-modules}"
SRC_URI[x86_64_v2_extra-cmake-modules.sha256sum] = "b52dae365cc4d46c914976bc95dca16e795e29cfebe9b2331deb093cd30c7841"

URI_aarch64_extra-cmake-modules = "${EPEL_MIRROR}/aarch64/Packages/e/extra-cmake-modules-6.28.0-1.el10_3.noarch.rpm;name=aarch64_extra-cmake-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_extra-cmake-modules}"
SRC_URI[aarch64_extra-cmake-modules.sha256sum] = "2160c11649098307815850ad5766d49762d0c5c18e0615988c4dd5d0e1863144"

RDEPENDS:extra-cmake-modules = " \
 bash \
 kf6-rpm-macros \
 python3 \
 "
