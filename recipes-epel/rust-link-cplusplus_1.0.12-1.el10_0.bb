# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-link-cplusplus"
PV = "1.0.12"
PR = "1.el10_0"
PACKAGES = " \
 rust-link-cplusplus+default-devel \
 rust-link-cplusplus+libc++-devel \
 rust-link-cplusplus+libcxx-devel \
 rust-link-cplusplus+libstdc++-devel \
 rust-link-cplusplus+libstdcxx-devel \
 rust-link-cplusplus+nothing-devel \
 rust-link-cplusplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-link-cplusplus-1.0.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "650b9ac60a54f5ddf5fd79456b44e92840dc9c31c58b1817e349de797f629cd7"

URI_x86_64_v2_rust-link-cplusplus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+default-devel-1.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+default-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+default-devel.sha256sum] = "e33869fda948f0c1c8acfb74ca36e0a7d84ec0f3ac189e3861e23c24036a379e"

URI_x86_64_v2_rust-link-cplusplus+libc++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libc++-devel-1.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libc++-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libc++-devel.sha256sum] = "2375a3d923f7514a7b44f02b9186add61a1592e96bf1d637c42a87bac90deb48"

URI_x86_64_v2_rust-link-cplusplus+libcxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libcxx-devel-1.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libcxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libcxx-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libcxx-devel.sha256sum] = "e5d9eee89f129a07fb783b92b35190aaed738a5768aacd643f4e3fc15d23e6bf"

URI_x86_64_v2_rust-link-cplusplus+libstdc++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libstdc++-devel-1.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libstdc++-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libstdc++-devel.sha256sum] = "7c46bc8ce373ce2098fca4285c1fbb46fdef6e519d55a7b53f9928f9700d254a"

URI_x86_64_v2_rust-link-cplusplus+libstdcxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+libstdcxx-devel-1.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+libstdcxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+libstdcxx-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+libstdcxx-devel.sha256sum] = "4295cbad7191d80135a680bf7d179b089e7a1011998f2764081d70f8da4a103b"

URI_x86_64_v2_rust-link-cplusplus+nothing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus+nothing-devel-1.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus+nothing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus+nothing-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus+nothing-devel.sha256sum] = "833508ecb48371b067f36d36ae16e76e630adbc7daa692619cfc8044262f8f77"

URI_x86_64_v2_rust-link-cplusplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-cplusplus-devel-1.0.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-cplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-link-cplusplus-devel}"
SRC_URI[x86_64_v2_rust-link-cplusplus-devel.sha256sum] = "2a7c71c7135bfa898cae8f7a22cd3c2890f7c475c9163a7d684a61bee613c08d"

URI_aarch64_rust-link-cplusplus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+default-devel-1.0.12-1.el10_0.noarch.rpm;name=aarch64_rust-link-cplusplus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+default-devel}"
SRC_URI[aarch64_rust-link-cplusplus+default-devel.sha256sum] = "0ed168b0037774645350f645dc5d46017b18abba9205bf3bfc94582531de8e08"

URI_aarch64_rust-link-cplusplus+libc++-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libc++-devel-1.0.12-1.el10_0.noarch.rpm;name=aarch64_rust-link-cplusplus+libc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libc++-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libc++-devel.sha256sum] = "643a6f29d0f90c4a6f930685ce7c696792bb796d73b311bc6cecd783a10a09bc"

URI_aarch64_rust-link-cplusplus+libcxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libcxx-devel-1.0.12-1.el10_0.noarch.rpm;name=aarch64_rust-link-cplusplus+libcxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libcxx-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libcxx-devel.sha256sum] = "a4be053d406f5e8789553d704f1a3752b8262635f694d4d7323422414b5ac5fe"

URI_aarch64_rust-link-cplusplus+libstdc++-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libstdc++-devel-1.0.12-1.el10_0.noarch.rpm;name=aarch64_rust-link-cplusplus+libstdc++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libstdc++-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libstdc++-devel.sha256sum] = "7edbd65b14a07d87f87340e26a42bdb8aff79445599fe7bad104e206bd3ac940"

URI_aarch64_rust-link-cplusplus+libstdcxx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+libstdcxx-devel-1.0.12-1.el10_0.noarch.rpm;name=aarch64_rust-link-cplusplus+libstdcxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+libstdcxx-devel}"
SRC_URI[aarch64_rust-link-cplusplus+libstdcxx-devel.sha256sum] = "d14f27abdfa9f237f02c582301ace1199ef8860e64c5503b57a432d738af65b9"

URI_aarch64_rust-link-cplusplus+nothing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus+nothing-devel-1.0.12-1.el10_0.noarch.rpm;name=aarch64_rust-link-cplusplus+nothing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus+nothing-devel}"
SRC_URI[aarch64_rust-link-cplusplus+nothing-devel.sha256sum] = "0b9ded4d5369ee60d999590162762d53cf92f6046e04939a8cefab3577705b02"

URI_aarch64_rust-link-cplusplus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-link-cplusplus-devel-1.0.12-1.el10_0.noarch.rpm;name=aarch64_rust-link-cplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-link-cplusplus-devel}"
SRC_URI[aarch64_rust-link-cplusplus-devel.sha256sum] = "b11a171fcd7a32e522c24849d1c79bcbb5612406d11555e0c6c1d63882392815"

RDEPENDS:rust-link-cplusplus+default-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libc++-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libcxx-devel = " \
 cargo \
 rust-link-cplusplus+libc++-devel \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libstdc++-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+libstdcxx-devel = " \
 cargo \
 rust-link-cplusplus+libstdc++-devel \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus+nothing-devel = " \
 cargo \
 rust-link-cplusplus-devel \
 "
RDEPENDS:rust-link-cplusplus-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 "
