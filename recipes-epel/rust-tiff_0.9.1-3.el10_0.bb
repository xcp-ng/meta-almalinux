# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tiff"
PV = "0.9.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-tiff+default-devel \
 rust-tiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tiff-0.9.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbd5aca4e7a370343df28e9dc47ea59604e99765cebb981f0b04369691c04250"

URI_x86_64_v2_rust-tiff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff+default-devel-0.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff+default-devel}"
SRC_URI[x86_64_v2_rust-tiff+default-devel.sha256sum] = "2afa006428b981246de4f17aec131adff2b603ef2311f26895b9093cfebb39cf"

URI_x86_64_v2_rust-tiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tiff-devel-0.9.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tiff-devel}"
SRC_URI[x86_64_v2_rust-tiff-devel.sha256sum] = "318a19b47f3faf52e071fc8b6e8ff4a305d66718c89b98304c4c31b2679612e6"

URI_aarch64_rust-tiff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff+default-devel-0.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-tiff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff+default-devel}"
SRC_URI[aarch64_rust-tiff+default-devel.sha256sum] = "683021682f7ffede184be4e1c208972d972d3d9b036e57d2c9646f8cfcfef72b"

URI_aarch64_rust-tiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tiff-devel-0.9.1-3.el10_0.noarch.rpm;name=aarch64_rust-tiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tiff-devel}"
SRC_URI[aarch64_rust-tiff-devel.sha256sum] = "79478b7692a1e2708bc5d460ba5fe1d612059120b821c08c8983ac45acbc66b9"

RDEPENDS:rust-tiff+default-devel = " \
 cargo \
 rust-tiff-devel \
 "
RDEPENDS:rust-tiff-devel = " \
 cargo \
 rust \
 rust-flate2+default-devel \
 rust-jpeg-decoder-devel \
 rust-weezl+default-devel \
 "
