# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-modernc-fileutil"
PV = "1.3.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-modernc-fileutil-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-modernc-fileutil-1.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c008074f71347546fdc49ef0242ce6664846b2374898cb585f743b50ad75329"

URI_x86_64_v2_golang-modernc-fileutil-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-modernc-fileutil-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-modernc-fileutil-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-modernc-fileutil-devel}"
SRC_URI[x86_64_v2_golang-modernc-fileutil-devel.sha256sum] = "63464ac8a9bd3ca798807706748317f7c3ba17e76626300c0fc4cefdda3e6895"

URI_aarch64_golang-modernc-fileutil-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-modernc-fileutil-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_golang-modernc-fileutil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-modernc-fileutil-devel}"
SRC_URI[aarch64_golang-modernc-fileutil-devel.sha256sum] = "d2e652ca2ee6a552bca6030bca9997200f9ef0c6f003133f873f0d14b11502fe"

RDEPENDS:golang-modernc-fileutil-devel = " \
 go-filesystem \
 golang-modernc-mathutil-devel \
 "
