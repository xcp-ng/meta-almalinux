# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbackup"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbackup-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e26549bb9ee556e7b2fd7d43ebda936c816f02e6ecedbf6b1cbd5342bd3b814f"

URI_x86_64_v2_kbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbackup-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbackup}"
SRC_URI[x86_64_v2_kbackup.sha256sum] = "a849c6f9f10d63ffc2b568cd1a9e52e21d19c9aaaee19b3fe29ce10b5b5c4599"

URI_aarch64_kbackup = "${EPEL_MIRROR}/aarch64/Packages/k/kbackup-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbackup}"
SRC_URI[aarch64_kbackup.sha256sum] = "7316164c7d8808709a9a4dcc70ec9d13ff50fa6b4c1f7244de782c51a72b054d"

RDEPENDS:kbackup = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
