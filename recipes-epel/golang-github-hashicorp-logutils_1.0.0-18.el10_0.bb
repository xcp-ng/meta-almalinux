# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-logutils"
PV = "1.0.0"
PR = "18.el10_0"
PACKAGES = " \
 golang-github-hashicorp-logutils-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-logutils-1.0.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd457539a16cb32c11a7e16104bbe3d14945eab99314c11002b916e2aaaca120"

URI_x86_64_v2_golang-github-hashicorp-logutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-logutils-devel-1.0.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-logutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-logutils-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-logutils-devel.sha256sum] = "047c5d5f45b5ca0c40729d223a32088b81f515751a6e547e4dcb1da9528daad5"

URI_aarch64_golang-github-hashicorp-logutils-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-logutils-devel-1.0.0-18.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-logutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-logutils-devel}"
SRC_URI[aarch64_golang-github-hashicorp-logutils-devel.sha256sum] = "a3c521af2a3a80025039e551e1bd9f63a665fd8524a80ea948c68521d5f9f7ed"

RDEPENDS:golang-github-hashicorp-logutils-devel = " \
 go-filesystem \
 "
