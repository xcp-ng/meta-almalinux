# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liberation-narrow-fonts"
PE = "2"
PV = "1.07.6"
PR = "16.el10"
PACKAGES = " \
 liberation-narrow-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/liberation-narrow-fonts-1.07.6-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8352f09a9b349df9ace35224a5ca4f2594534544711d4bb6d294afaafef3e71"

URI_x86_64_v2_liberation-narrow-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liberation-narrow-fonts-1.07.6-16.el10.noarch.rpm;name=x86_64_v2_liberation-narrow-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liberation-narrow-fonts}"
SRC_URI[x86_64_v2_liberation-narrow-fonts.sha256sum] = "5293da75e16be7c3668b59d3417fe835867ddc7d58d4f58618690eeb3e5a184d"

URI_aarch64_liberation-narrow-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liberation-narrow-fonts-1.07.6-16.el10.noarch.rpm;name=aarch64_liberation-narrow-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_liberation-narrow-fonts}"
SRC_URI[aarch64_liberation-narrow-fonts.sha256sum] = "5293da75e16be7c3668b59d3417fe835867ddc7d58d4f58618690eeb3e5a184d"

RDEPENDS:liberation-narrow-fonts = " \
 fonts-filesystem \
 "
