# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scap-security-guide"
PV = "0.1.82"
PR = "2.el10_2.alma.1"
PACKAGES = " \
 scap-security-guide \
 scap-security-guide-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/scap-security-guide-0.1.82-2.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "31f1535dd3570b0a98b6b4234392c61d513451061bb99576cb250214d4d0880e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-0.1.82-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide;unpack=0"
SRC_URI[x86_64_v2_scap-security-guide.sha256sum] = "42d78de45aeff664023caa21d2542569a3b83e6ff1e01f352daeef5ad5bf6807"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/scap-security-guide-doc-0.1.82-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_scap-security-guide-doc;unpack=0"
SRC_URI[x86_64_v2_scap-security-guide-doc.sha256sum] = "4556bf642961fad933f0e05da5c8b435d05a536d65830c34d9e0ded492e40c78"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-0.1.82-2.el10_2.alma.1.noarch.rpm;name=aarch64_scap-security-guide;unpack=0"
SRC_URI[aarch64_scap-security-guide.sha256sum] = "42d78de45aeff664023caa21d2542569a3b83e6ff1e01f352daeef5ad5bf6807"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/scap-security-guide-doc-0.1.82-2.el10_2.alma.1.noarch.rpm;name=aarch64_scap-security-guide-doc;unpack=0"
SRC_URI[aarch64_scap-security-guide-doc.sha256sum] = "4556bf642961fad933f0e05da5c8b435d05a536d65830c34d9e0ded492e40c78"

RDEPENDS:scap-security-guide = " \
 openscap-scanner \
 xml-common \
 "
RDEPENDS:scap-security-guide-doc = " \
 scap-security-guide \
 "
