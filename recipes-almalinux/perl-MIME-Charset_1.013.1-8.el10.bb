# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MIME-Charset"
PV = "1.013.1"
PR = "8.el10"
PACKAGES = " \
 perl-MIME-Charset \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-MIME-Charset-1.013.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b87985000e06e0507f4beffc55acae7d3e29c689f98fe01099b52d93a0a05b9"

URI_x86_64_v2_perl-MIME-Charset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-MIME-Charset-1.013.1-8.el10.noarch.rpm;name=x86_64_v2_perl-MIME-Charset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MIME-Charset}"
SRC_URI[x86_64_v2_perl-MIME-Charset.sha256sum] = "a455fc8190c4fb739a0c71f291057acb8799bd5238fe84b8170609a29b7821de"

URI_aarch64_perl-MIME-Charset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-MIME-Charset-1.013.1-8.el10.noarch.rpm;name=aarch64_perl-MIME-Charset;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MIME-Charset}"
SRC_URI[aarch64_perl-MIME-Charset.sha256sum] = "a455fc8190c4fb739a0c71f291057acb8799bd5238fe84b8170609a29b7821de"

RDEPENDS:perl-MIME-Charset = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-vars \
 "
