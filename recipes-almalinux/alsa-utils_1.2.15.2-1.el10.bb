# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-utils"
PV = "1.2.15.2"
PR = "1.el10"
PACKAGES = " \
 alsa-ucm-utils \
 alsa-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-utils-1.2.15.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eaea9e27014f518e5624c4a2f46be26dd2d9fc3d632ab90d56bb3f4bcd34aa3"

URI_x86_64_v2_alsa-ucm-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-ucm-utils-1.2.15.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-ucm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-ucm-utils}"
SRC_URI[x86_64_v2_alsa-ucm-utils.sha256sum] = "1b1c0a479b667931b6b9620d2c1ed2bfacbcfdef38aef2fe4797f8f10eff19eb"

URI_x86_64_v2_alsa-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-utils-1.2.15.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_alsa-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alsa-utils}"
SRC_URI[x86_64_v2_alsa-utils.sha256sum] = "7484754b86adc17d1ab9cfd457f7b04fcfbe0e0c9a69f20fa3909742b06f8d98"

URI_aarch64_alsa-ucm-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-ucm-utils-1.2.15.2-1.el10.aarch64.rpm;name=aarch64_alsa-ucm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-ucm-utils}"
SRC_URI[aarch64_alsa-ucm-utils.sha256sum] = "082f748b5a88cb92df3e2d17973aca5a454cfd06864cf04fa562980b4890884e"

URI_aarch64_alsa-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-utils-1.2.15.2-1.el10.aarch64.rpm;name=aarch64_alsa-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_alsa-utils}"
SRC_URI[aarch64_alsa-utils.sha256sum] = "6f694163f6b0ffbf2e1c395feabe8a3f47ba68d5959f9f478fe4d74dcff60d93"

RDEPENDS:alsa-ucm-utils = " \
 alsa-lib \
 glibc \
 "
RDEPENDS:alsa-utils = " \
 alsa-lib \
 alsa-ucm \
 bash \
 glibc \
 libsamplerate \
 ncurses-libs \
 systemd \
 "
