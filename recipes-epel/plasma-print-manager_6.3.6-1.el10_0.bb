# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-print-manager"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-print-manager \
 plasma-print-manager-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-print-manager-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eee903e6b7075facce812105fea868390f89232b47772b75e3d49aaaaa5a6c45"

URI_x86_64_v2_plasma-print-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-print-manager-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-print-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-print-manager}"
SRC_URI[x86_64_v2_plasma-print-manager.sha256sum] = "3b0d77f0af5be4b3231ab0af946930ded86a93fa704b17a597468efbd5b94e72"

URI_x86_64_v2_plasma-print-manager-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-print-manager-libs-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-print-manager-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-print-manager-libs}"
SRC_URI[x86_64_v2_plasma-print-manager-libs.sha256sum] = "d73dffe4c8a5073c449de94109da42ebd941e3b59ed6027ea40440061652f963"

URI_aarch64_plasma-print-manager = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-print-manager-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-print-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-print-manager}"
SRC_URI[aarch64_plasma-print-manager.sha256sum] = "95a69e42e5d12d75e091a60b4523d225cdc5d0fe169c7f14130264b2e72db1d4"

URI_aarch64_plasma-print-manager-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-print-manager-libs-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-print-manager-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-print-manager-libs}"
SRC_URI[aarch64_plasma-print-manager-libs.sha256sum] = "434f02bce12650bbb3189b4fbd1b3d3bd6aae9fe0bc29de82ede173a143c9243"

RDEPENDS:plasma-print-manager = " \
 PackageKit-Qt6 \
 cups \
 cups-libs \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-print-manager-libs \
 plasma-workspace \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 system-config-printer-libs \
 "
RDEPENDS:plasma-print-manager-libs = " \
 cups-libs \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-print-manager \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
