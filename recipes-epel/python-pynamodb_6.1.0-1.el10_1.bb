# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pynamodb"
PV = "6.1.0"
PR = "1.el10_1"
PACKAGES = " \
 python-pynamodb-doc \
 python3-pynamodb \
 python3-pynamodb+signals \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pynamodb-6.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6788398df0f8185072ddb625da20c7ee01b55cd8e277accda727e38d5c4cfee0"

URI_x86_64_v2_python-pynamodb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pynamodb-doc-6.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-pynamodb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pynamodb-doc}"
SRC_URI[x86_64_v2_python-pynamodb-doc.sha256sum] = "3f786bc119744211ed97243ebd74056293b288fd31c5bf84652cc6e669359a80"

URI_x86_64_v2_python3-pynamodb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pynamodb-6.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pynamodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pynamodb}"
SRC_URI[x86_64_v2_python3-pynamodb.sha256sum] = "558c1bf33be62ac92653ec215f33fe7dc3ffdf14f95eec6f0a423affbc38a515"

URI_x86_64_v2_python3-pynamodb+signals = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pynamodb+signals-6.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pynamodb+signals;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pynamodb+signals}"
SRC_URI[x86_64_v2_python3-pynamodb+signals.sha256sum] = "a2bbb41cbe0e8a04435a42bbd5046218e3395bf9b752ec81a2ed9fcc0fb57c0f"

URI_aarch64_python-pynamodb-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pynamodb-doc-6.1.0-1.el10_1.noarch.rpm;name=aarch64_python-pynamodb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pynamodb-doc}"
SRC_URI[aarch64_python-pynamodb-doc.sha256sum] = "691e206f93b3b43c47afc54f1b27e0e5835c5c6b670146f2c247a3685abf4417"

URI_aarch64_python3-pynamodb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pynamodb-6.1.0-1.el10_1.noarch.rpm;name=aarch64_python3-pynamodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pynamodb}"
SRC_URI[aarch64_python3-pynamodb.sha256sum] = "286b43faea77419fd770f8116218393b81a59f9947ce80e7d853f9bd468d81de"

URI_aarch64_python3-pynamodb+signals = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pynamodb+signals-6.1.0-1.el10_1.noarch.rpm;name=aarch64_python3-pynamodb+signals;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pynamodb+signals}"
SRC_URI[aarch64_python3-pynamodb+signals.sha256sum] = "55dd8c728201a4b27d7cb594c5b5e089f6af2360a18a8c0f7e64a0000b38c10e"

RDEPENDS:python-pynamodb-doc = " \
 "
RDEPENDS:python3-pynamodb = " \
 python3 \
 python3-botocore \
 "
RDEPENDS:python3-pynamodb+signals = " \
 python3 \
 python3-blinker \
 python3-pynamodb \
 "
