# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mail-AuthenticationResults"
PV = "2.20231031"
PR = "4.el10_0"
PACKAGES = " \
 perl-Mail-AuthenticationResults \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mail-AuthenticationResults-2.20231031-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "132f09a903f698154aec5bce46586c9c93c8fc9c1417be839dd044b5782eaf47"

URI_x86_64_v2_perl-Mail-AuthenticationResults = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mail-AuthenticationResults-2.20231031-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mail-AuthenticationResults;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mail-AuthenticationResults}"
SRC_URI[x86_64_v2_perl-Mail-AuthenticationResults.sha256sum] = "293c023b5f76a26ac66fdcff39cf9857f5a70aaa9b2f149eeeecb375c6a25f63"

URI_aarch64_perl-Mail-AuthenticationResults = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mail-AuthenticationResults-2.20231031-4.el10_0.noarch.rpm;name=aarch64_perl-Mail-AuthenticationResults;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mail-AuthenticationResults}"
SRC_URI[aarch64_perl-Mail-AuthenticationResults.sha256sum] = "7d711e94ac8fd6ac7c3ed1da17f48b603b9f305962b5196c4ded7317a5e7417f"

RDEPENDS:perl-Mail-AuthenticationResults = " \
 perl-Carp \
 perl-Clone \
 perl-JSON \
 perl-Mail-AuthenticationResults \
 perl-Scalar-List-Utils \
 perl-base \
 perl-libs \
 "
