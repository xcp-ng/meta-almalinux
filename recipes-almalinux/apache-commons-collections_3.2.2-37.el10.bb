# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apache-commons-collections"
PV = "3.2.2"
PR = "37.el10"
PACKAGES = " \
 apache-commons-collections \
 apache-commons-collections-javadoc \
 apache-commons-collections-testframework \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/apache-commons-collections-3.2.2-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbe8d085b37cfa0a18af2580a619ff2ae75dd17890b96fb1fa23b6f004f7e7a4"

URI_x86_64_v2_apache-commons-collections = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-collections-3.2.2-37.el10.noarch.rpm;name=x86_64_v2_apache-commons-collections;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-collections}"
SRC_URI[x86_64_v2_apache-commons-collections.sha256sum] = "4cf4e3af6177a5de23a0d3390a82d4bc11e95dc9b7365aa8b1b87b7a65ef3d07"

URI_x86_64_v2_apache-commons-collections-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-collections-javadoc-3.2.2-37.el10.noarch.rpm;name=x86_64_v2_apache-commons-collections-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-collections-javadoc}"
SRC_URI[x86_64_v2_apache-commons-collections-javadoc.sha256sum] = "b267b62a07b154854525c16ed0292fad6eb0cf5f960d1e9b89398a36d9dd4618"

URI_x86_64_v2_apache-commons-collections-testframework = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/apache-commons-collections-testframework-3.2.2-37.el10.noarch.rpm;name=x86_64_v2_apache-commons-collections-testframework;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apache-commons-collections-testframework}"
SRC_URI[x86_64_v2_apache-commons-collections-testframework.sha256sum] = "cdcbe8bd5c811ffb6b1cb9899707497a78f568eefe92cbd6b2170855b2285d94"

URI_aarch64_apache-commons-collections = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-collections-3.2.2-37.el10.noarch.rpm;name=aarch64_apache-commons-collections;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-collections}"
SRC_URI[aarch64_apache-commons-collections.sha256sum] = "4cf4e3af6177a5de23a0d3390a82d4bc11e95dc9b7365aa8b1b87b7a65ef3d07"

URI_aarch64_apache-commons-collections-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-collections-javadoc-3.2.2-37.el10.noarch.rpm;name=aarch64_apache-commons-collections-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-collections-javadoc}"
SRC_URI[aarch64_apache-commons-collections-javadoc.sha256sum] = "b267b62a07b154854525c16ed0292fad6eb0cf5f960d1e9b89398a36d9dd4618"

URI_aarch64_apache-commons-collections-testframework = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/apache-commons-collections-testframework-3.2.2-37.el10.noarch.rpm;name=aarch64_apache-commons-collections-testframework;unpack=0"
SRC_URI:append = " ${URI_aarch64_apache-commons-collections-testframework}"
SRC_URI[aarch64_apache-commons-collections-testframework.sha256sum] = "cdcbe8bd5c811ffb6b1cb9899707497a78f568eefe92cbd6b2170855b2285d94"

RDEPENDS:apache-commons-collections = " \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-collections-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:apache-commons-collections-testframework = " \
 apache-commons-collections \
 javapackages-filesystem \
 "
