# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-sl"
PV = "0.20070127"
PR = "32.el10"
PACKAGES = " \
 hyphen-sl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-sl-0.20070127-32.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "48cee381dbedac2d7efcf2c616317914b7d633ad290a4109d1f2e584f166b6fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-sl-0.20070127-32.el10.noarch.rpm;name=x86_64_v2_hyphen-sl;unpack=0"
SRC_URI[x86_64_v2_hyphen-sl.sha256sum] = "14c8c358728ad1b5b4354eb2f70941c80947e775dee330a0645c8e0e6fdb48c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-sl-0.20070127-32.el10.noarch.rpm;name=aarch64_hyphen-sl;unpack=0"
SRC_URI[aarch64_hyphen-sl.sha256sum] = "14c8c358728ad1b5b4354eb2f70941c80947e775dee330a0645c8e0e6fdb48c6"

RDEPENDS:hyphen-sl = " \
 hyphen \
 "
