# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "archlinux-keyring"
PV = "20260612"
PR = "2.el10_2"
PACKAGES = " \
 archlinux-keyring \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/archlinux-keyring-20260612-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c5b19da2b5e3e5b2b9a9e6dc1cde0751cb507df0de8e6efe12fb2d3d169cf06"

URI_x86_64_v2_archlinux-keyring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/archlinux-keyring-20260612-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_archlinux-keyring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_archlinux-keyring}"
SRC_URI[x86_64_v2_archlinux-keyring.sha256sum] = "a415f8868fb577ada553940deac43e2c49f2c03b02344abcefb7bcceeb3a1754"

URI_aarch64_archlinux-keyring = "${EPEL_MIRROR}/aarch64/Packages/a/archlinux-keyring-20260612-2.el10_2.noarch.rpm;name=aarch64_archlinux-keyring;unpack=0"
SRC_URI:append = " ${URI_aarch64_archlinux-keyring}"
SRC_URI[aarch64_archlinux-keyring.sha256sum] = "431b2c04f0552418865397f7d0a5f4e974eb2e77caaeece10a7be6bbf8e17666"

RDEPENDS:archlinux-keyring = " \
 bash \
 keyrings-filesystem \
 pacman-filesystem \
 "
