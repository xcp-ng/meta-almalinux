# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prometheus"
PV = "3.15.0"
PR = "1.el10_2"
PACKAGES = " \
 prometheus \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/prometheus-3.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dad51fdac854993dc272dd4f2ae8fbf5a38f950adaf99f5c780b7317daa2a4a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prometheus-3.15.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prometheus;unpack=0"
SRC_URI[x86_64_v2_prometheus.sha256sum] = "702109dc45f0f3f61bbd7c516f057cb16194db2e3ed1aed7c503336fd296a886"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/prometheus-3.15.0-1.el10_2.aarch64.rpm;name=aarch64_prometheus;unpack=0"
SRC_URI[aarch64_prometheus.sha256sum] = "6f5467118f05bb9e97a1a00f86aa1711b7a1999a14463fd5c2b3f432063b7da3"

RDEPENDS:prometheus = " \
 bash \
 glibc \
 shadow-utils \
 "
