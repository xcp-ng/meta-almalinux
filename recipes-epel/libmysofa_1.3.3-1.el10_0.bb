# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmysofa"
PV = "1.3.3"
PR = "1.el10_0"
PACKAGES = " \
 libmysofa \
 libmysofa-devel \
 mysofa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmysofa-1.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "158dda7bb2c6630c1b5eea57c3edc8ba817843b1ee63caa9741baab60b1caf17"

URI_x86_64_v2_libmysofa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmysofa-1.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmysofa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmysofa}"
SRC_URI[x86_64_v2_libmysofa.sha256sum] = "0f0e337b95ba03c70b8036c2f283f040a833e6bae0b6067edcfc212b9f1b051f"

URI_x86_64_v2_libmysofa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmysofa-devel-1.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmysofa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmysofa-devel}"
SRC_URI[x86_64_v2_libmysofa-devel.sha256sum] = "3e2cb59342b3a9942a83d7d0a6e2d8caf5af00fde352549cea8a3f9741d9e397"

URI_x86_64_v2_mysofa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mysofa-1.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mysofa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mysofa}"
SRC_URI[x86_64_v2_mysofa.sha256sum] = "d8e3f48ab77e17d28ad4fbebb5e2acb26529866e5243d5fb24dae094f350e353"

URI_aarch64_libmysofa = "${EPEL_MIRROR}/aarch64/Packages/l/libmysofa-1.3.3-1.el10_0.aarch64.rpm;name=aarch64_libmysofa;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmysofa}"
SRC_URI[aarch64_libmysofa.sha256sum] = "f7c598df6925bdd4e2e0cea342296ef9421fee72659040a479277353fa0c1fe0"

URI_aarch64_libmysofa-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmysofa-devel-1.3.3-1.el10_0.aarch64.rpm;name=aarch64_libmysofa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmysofa-devel}"
SRC_URI[aarch64_libmysofa-devel.sha256sum] = "4e3d51dec33c1544b3a807f1f95dfa16693ea6b23fb1dced01ac2b02246eec2a"

URI_aarch64_mysofa = "${EPEL_MIRROR}/aarch64/Packages/m/mysofa-1.3.3-1.el10_0.aarch64.rpm;name=aarch64_mysofa;unpack=0"
SRC_URI:append = " ${URI_aarch64_mysofa}"
SRC_URI[aarch64_mysofa.sha256sum] = "037a0522c01c77a27779446d3855f1fd238c6bbf4d5137cbd8657c56e46cff37"

RDEPENDS:libmysofa = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libmysofa-devel = " \
 cmake-filesystem \
 libmysofa \
 pkgconf-pkg-config \
 "
RDEPENDS:mysofa = " \
 glibc \
 libmysofa \
 "
