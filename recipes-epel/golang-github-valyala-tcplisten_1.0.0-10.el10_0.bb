# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-valyala-tcplisten"
PV = "1.0.0"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-valyala-tcplisten-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-valyala-tcplisten-1.0.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e6dd16b78f7580e6432e22973bd567ce595fb10f5d622978871866572440238"

URI_x86_64_v2_golang-github-valyala-tcplisten-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-valyala-tcplisten-devel-1.0.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-valyala-tcplisten-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-valyala-tcplisten-devel}"
SRC_URI[x86_64_v2_golang-github-valyala-tcplisten-devel.sha256sum] = "f14f064014e575ebc506f6bf9888d4d44d4cc645810bec400ebbf2685828513e"

URI_aarch64_golang-github-valyala-tcplisten-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-valyala-tcplisten-devel-1.0.0-10.el10_0.noarch.rpm;name=aarch64_golang-github-valyala-tcplisten-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-valyala-tcplisten-devel}"
SRC_URI[aarch64_golang-github-valyala-tcplisten-devel.sha256sum] = "36d551feec0ff0d6fd58172a82a13d6919128c39cf5b2efa1f74f94b814ffaeb"

RDEPENDS:golang-github-valyala-tcplisten-devel = " \
 go-filesystem \
 "
