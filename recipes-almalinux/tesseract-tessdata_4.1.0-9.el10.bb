# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tesseract-tessdata"
PV = "4.1.0"
PR = "9.el10"
PACKAGES = " \
 tesseract-equ \
 tesseract-langpack-afr \
 tesseract-langpack-amh \
 tesseract-langpack-ara \
 tesseract-langpack-asm \
 tesseract-langpack-aze \
 tesseract-langpack-aze_cyrl \
 tesseract-langpack-bel \
 tesseract-langpack-ben \
 tesseract-langpack-bod \
 tesseract-langpack-bos \
 tesseract-langpack-bre \
 tesseract-langpack-bul \
 tesseract-langpack-cat \
 tesseract-langpack-ceb \
 tesseract-langpack-ces \
 tesseract-langpack-chi_sim \
 tesseract-langpack-chi_sim_vert \
 tesseract-langpack-chi_tra \
 tesseract-langpack-chi_tra_vert \
 tesseract-langpack-chr \
 tesseract-langpack-cos \
 tesseract-langpack-cym \
 tesseract-langpack-dan \
 tesseract-langpack-deu \
 tesseract-langpack-div \
 tesseract-langpack-dzo \
 tesseract-langpack-ell \
 tesseract-langpack-eng \
 tesseract-langpack-enm \
 tesseract-langpack-epo \
 tesseract-langpack-est \
 tesseract-langpack-eus \
 tesseract-langpack-fao \
 tesseract-langpack-fas \
 tesseract-langpack-fil \
 tesseract-langpack-fin \
 tesseract-langpack-fra \
 tesseract-langpack-frk \
 tesseract-langpack-frm \
 tesseract-langpack-fry \
 tesseract-langpack-gla \
 tesseract-langpack-gle \
 tesseract-langpack-glg \
 tesseract-langpack-grc \
 tesseract-langpack-guj \
 tesseract-langpack-hat \
 tesseract-langpack-heb \
 tesseract-langpack-hin \
 tesseract-langpack-hrv \
 tesseract-langpack-hun \
 tesseract-langpack-hye \
 tesseract-langpack-iku \
 tesseract-langpack-ind \
 tesseract-langpack-isl \
 tesseract-langpack-ita \
 tesseract-langpack-ita_old \
 tesseract-langpack-jav \
 tesseract-langpack-jpn \
 tesseract-langpack-jpn_vert \
 tesseract-langpack-kan \
 tesseract-langpack-kat \
 tesseract-langpack-kat_old \
 tesseract-langpack-kaz \
 tesseract-langpack-khm \
 tesseract-langpack-kir \
 tesseract-langpack-kmr \
 tesseract-langpack-kor \
 tesseract-langpack-kor_vert \
 tesseract-langpack-lao \
 tesseract-langpack-lat \
 tesseract-langpack-lav \
 tesseract-langpack-lit \
 tesseract-langpack-ltz \
 tesseract-langpack-mal \
 tesseract-langpack-mar \
 tesseract-langpack-mkd \
 tesseract-langpack-mlt \
 tesseract-langpack-mon \
 tesseract-langpack-mri \
 tesseract-langpack-msa \
 tesseract-langpack-mya \
 tesseract-langpack-nep \
 tesseract-langpack-nld \
 tesseract-langpack-nor \
 tesseract-langpack-oci \
 tesseract-langpack-ori \
 tesseract-langpack-pan \
 tesseract-langpack-pol \
 tesseract-langpack-por \
 tesseract-langpack-pus \
 tesseract-langpack-que \
 tesseract-langpack-ron \
 tesseract-langpack-rus \
 tesseract-langpack-san \
 tesseract-langpack-sin \
 tesseract-langpack-slk \
 tesseract-langpack-slv \
 tesseract-langpack-snd \
 tesseract-langpack-spa \
 tesseract-langpack-spa_old \
 tesseract-langpack-sqi \
 tesseract-langpack-srp \
 tesseract-langpack-srp_latn \
 tesseract-langpack-sun \
 tesseract-langpack-swa \
 tesseract-langpack-swe \
 tesseract-langpack-syr \
 tesseract-langpack-tam \
 tesseract-langpack-tat \
 tesseract-langpack-tel \
 tesseract-langpack-tgk \
 tesseract-langpack-tha \
 tesseract-langpack-tir \
 tesseract-langpack-ton \
 tesseract-langpack-tur \
 tesseract-langpack-uig \
 tesseract-langpack-ukr \
 tesseract-langpack-urd \
 tesseract-langpack-uzb \
 tesseract-langpack-uzb_cyrl \
 tesseract-langpack-vie \
 tesseract-langpack-yid \
 tesseract-langpack-yor \
 tesseract-osd \
 tesseract-tessdata-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tesseract-tessdata-4.1.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c7a964598b80c8b3ff0740dfbff7cde5b3d3b5cbf957bdea4c9594759cb4512b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-equ-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-equ;unpack=0"
SRC_URI[x86_64_v2_tesseract-equ.sha256sum] = "2db416741863566d16d552590015296c342081b23c6d61b816937f795bf00b4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-afr-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-afr;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-afr.sha256sum] = "2f975c82242d935894288c0d636f2b58834ce5fb2573225c6d6bd1e71496ba6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-amh-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-amh;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-amh.sha256sum] = "52b3c6c371e5f3570fd31ae55fabe267688c485c7f1780a82c376a3333f47959"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ara-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ara;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ara.sha256sum] = "3577d1dcdbe07d5f76fc2d7e0b3516ff19f901f49bffc44cfd61da861032df5d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-asm-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-asm;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-asm.sha256sum] = "13bcdd2fc8bda6231babaf880f781b1dad76570cc63456086fbac5b532e70102"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-aze-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-aze;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-aze.sha256sum] = "2909aa4cb9d3e31c4ec47f545d2f4b64f6ad0df62e1b3bd251049be5f87bc547"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-aze_cyrl-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-aze_cyrl;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-aze_cyrl.sha256sum] = "20d6a84d6bd1874b971e53aedaea1b21e793ad1c3b471d3485877787e20327b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-bel-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-bel;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-bel.sha256sum] = "edc7a068f0bbcf7d6c7f38341159cb760798bb79aab2c03a640a8ee578b6ea45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ben-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ben;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ben.sha256sum] = "1d6c4c765cf7aacff17be4c8521403dfe9234bcfc77d81359113fa1698581ea9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-bod-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-bod;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-bod.sha256sum] = "2ac2c2c73b19c26a961400cebb2f364f580f4351f23eb983898dd847d96b8b12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-bos-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-bos;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-bos.sha256sum] = "8a4833bb9ee14fb2492133c0859bcc0b05db654ecd169fb3dac6b4d092474c3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-bre-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-bre;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-bre.sha256sum] = "deece245ce22798c9c28557901921681ce3b4f757bce3205cfef7441c0df1a45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-bul-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-bul;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-bul.sha256sum] = "427675746615db6e567e03d7f7cb8793d192a9c60a5f9343abc96a1a1c62a14b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-cat-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-cat;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-cat.sha256sum] = "f300b389ac110e722de49b9961a403da5a7021c9c0c32191eeee28f06822ec8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ceb-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ceb;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ceb.sha256sum] = "22d2d0db985bc749c67d8e4663c8fe4ccf41175b4f38c5faf42ad40eeb44cf05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ces-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ces;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ces.sha256sum] = "d61b23c3b661fb2add5af14872bb06906768ba4484162dec6725cf9c4c28695b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-chi_sim-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-chi_sim;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-chi_sim.sha256sum] = "b913dd49f20b76e8bd96d69a0250e7f8ef24dee27a086ea80233210706ee600e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-chi_sim_vert-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-chi_sim_vert;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-chi_sim_vert.sha256sum] = "92327f28b777f036d6c2b4de848b04c228f006f1b7ad91e4cdfa2143edeace58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-chi_tra-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-chi_tra;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-chi_tra.sha256sum] = "75b728e1fdc0c78d9e42c0c2749276ae38d7e1d26567d814bd6ce81b9017131e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-chi_tra_vert-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-chi_tra_vert;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-chi_tra_vert.sha256sum] = "d2ae52f9f597ba4379925071a391135eeb2e384ec231b79c5e02b52c720b9e96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-chr-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-chr;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-chr.sha256sum] = "55dbb0b4932d2c64221ada47b6cfa44e6bf0f238216ac57e618057407587197e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-cos-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-cos;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-cos.sha256sum] = "a4045c367f909453e55b4abfd1649974a7a5e86177c9ced06ad603cfb87f56fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-cym-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-cym;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-cym.sha256sum] = "d9f5183431aa84623b1a1f3a76d172a6bab70ba62fe674589d29a555c8fd1d3a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-dan-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-dan;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-dan.sha256sum] = "14ff4ed8bad2a9b32caadca8661182a71476f21bb4b979764673706ae18549b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-deu-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-deu;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-deu.sha256sum] = "75d9839d97932ebb3015e4a134732ce111a64f26898da2ca8c55dbf6941dbaa0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-div-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-div;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-div.sha256sum] = "dfd8880c8dc15fb15df85d8add49b6bea2db59d10e176a9937454fc532f50b3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-dzo-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-dzo;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-dzo.sha256sum] = "c08a23688499f8699e047a8fb05180c864451536204de5d990f900fda39f8732"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ell-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ell;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ell.sha256sum] = "4d09a9ec7c89d52b617492d9dd71e30d3c98b0e4494d41e19495758fa911ca67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-eng-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-eng;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-eng.sha256sum] = "791748badec2f22b0d3214b5c884112f8aa7f055edc71141f7c628ac509bbe8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-enm-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-enm;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-enm.sha256sum] = "0e8a78891558798e98061bd84d2af615e03385f8cb316b060eed3048b619afef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-epo-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-epo;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-epo.sha256sum] = "a5ee74c08fd3a2a87ec3feeb86bfec06b7138f09e04071b9ff8cb3fa3662bf97"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-est-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-est;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-est.sha256sum] = "db3233471328f89538909c42ed618a32773415887920fee1441bf21c283c2e92"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-eus-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-eus;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-eus.sha256sum] = "051a55f45f45be60c599a5e0db2ab309148cd0309117fdc4dbf19eef8150bb3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-fao-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-fao;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-fao.sha256sum] = "5b7c7dc8a450b7544623963dd7620bc9fdb631bd8262069e03575051294b56df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-fas-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-fas;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-fas.sha256sum] = "34567b280f16b640467ec6b4981f3d7d1e641c1c35083b6f01df9e1dbf80b66c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-fil-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-fil;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-fil.sha256sum] = "4e5e5996eb39a79fcd9e3ac084b34b12996845c18cf9d41c797e0cd6aba22c27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-fin-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-fin;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-fin.sha256sum] = "0c66e07fbbf03d95e32022f96814226d28af67825853806f64529f877a4cfa67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-fra-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-fra;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-fra.sha256sum] = "58a7ba2691592b94c1d10f0f85bfea8fd3778b4d69b26f60cbb962f928664005"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-frk-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-frk;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-frk.sha256sum] = "09293e446ca8461d03eaee9ce8c305e85fe0b647e32bc9461d141294a5d02231"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-frm-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-frm;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-frm.sha256sum] = "5c2fe40c5d3dda405e156a132c37a1e342bc411ff26ed0ba49a9b322a38570e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-fry-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-fry;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-fry.sha256sum] = "598c2e16a3643a9bddb978321ac62839dd04ad90f9406356a0766bcf302c5658"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-gla-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-gla;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-gla.sha256sum] = "13febe469b2aa8ac50ddcb0410ab3f59faf32d00afd22eef3c0effe7dc8e6d4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-gle-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-gle;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-gle.sha256sum] = "d2676a9c5a90dc9f41769c7614529969d49eac47a158b821aac8184c44067f2b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-glg-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-glg;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-glg.sha256sum] = "3dac8397fea203af287031ed8a378921acd10e5dae9fbeffae941938545594fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-grc-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-grc;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-grc.sha256sum] = "7f21af866fe91ec185a42e5938f75fe88f4adbc40d78a6ec4fa7c65a97235dad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-guj-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-guj;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-guj.sha256sum] = "cc750493e2e617101cdc561d45ab3fa922c3ced7803c3e666d40b28302680ef8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-hat-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-hat;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-hat.sha256sum] = "b26ae4a7005e99c5750ecad9df95df62f4ac3d27b2d752918f12063412291f95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-heb-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-heb;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-heb.sha256sum] = "daf61e38e6585932b29c17ef9da91b8608805850cce1bd6c29fce72af5ff2797"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-hin-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-hin;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-hin.sha256sum] = "f796b38f145b1bd92c3d0e9e1cafe738e8934aa6c95f08705ea2a849237df3b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-hrv-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-hrv;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-hrv.sha256sum] = "d3f9fea37517b49f97b7468874fc148aa4db30c91c49c926953479c302832db2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-hun-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-hun;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-hun.sha256sum] = "6e26f18ae4720a8708de045a1cb19c02435ba99b26fb921ed4110b2786ae86b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-hye-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-hye;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-hye.sha256sum] = "e679d34ad8fc93c63d285804fcebe5706e6b28d84acd3f2eb74d988ee58463aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-iku-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-iku;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-iku.sha256sum] = "8491ed9581ad698498cebe9a1ff37f36707f3e678261b47ac1f855823b338df6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ind-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ind;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ind.sha256sum] = "a698404f393c39a0e14d952322afd460021ad2acceddf810a4266adc3bc16e37"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-isl-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-isl;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-isl.sha256sum] = "c8e006ab66326e3fe499b976deb5357f81bfeed456ad193d670f9e4b3f0295c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ita-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ita;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ita.sha256sum] = "ac50f2dd8accd8b32f45f2564b71053059b805d6ab949a9ebabdf2f0d3cbcae2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ita_old-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ita_old;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ita_old.sha256sum] = "7b7ede065b8c91e5b3176a1112de46721c1d2d5f468faf5666ccc2cb0d4393a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-jav-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-jav;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-jav.sha256sum] = "985919cb96e0d27fb8a4a294587e84068d21dcf08610702c681b95d17469387f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-jpn-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-jpn;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-jpn.sha256sum] = "9a8ed9c169a5e6cabd6a3141e4ae3d73e8f36f9d661d762a6ea975c9b16d288c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-jpn_vert-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-jpn_vert;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-jpn_vert.sha256sum] = "dab4cece28ad028df7ae655ed0853e2aa79766491864bc2cbbac1a7232f0fe29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-kan-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-kan;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-kan.sha256sum] = "269987ebe6077cc90ebb3f3f165adeda9ce2ded3cdb81f5ad5b7735e1112a9f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-kat-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-kat;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-kat.sha256sum] = "86776fe91e8a24dc884e2c21bbd9f698bdf6f0031bf5eeefd8b00813a8a73388"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-kat_old-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-kat_old;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-kat_old.sha256sum] = "f9033f415f1735070dd9f111588962e108b6233845ccd5c4ed21f04dd75c358f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-kaz-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-kaz;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-kaz.sha256sum] = "43d01f1d50440f3dc628c3cbee0b7be46589cb05b13e4af242321cc5990daf6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-khm-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-khm;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-khm.sha256sum] = "b882a791ecbc0caa4827e95badea1d72a4db244871993c86d0811f8bd606bc1f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-kir-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-kir;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-kir.sha256sum] = "fa5e29f69566d6365740659fc93bbd81897b641a0c3b6467ec59497e8c1f1000"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-kmr-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-kmr;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-kmr.sha256sum] = "560a8baf79c7c387955dfdc7ca4cf1b86bd260f4d30287930c5d06c9250b616a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-kor-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-kor;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-kor.sha256sum] = "888e58b2895a62385ee5c5cde618904c3947e61036f0dab8b36eda26ed734142"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-kor_vert-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-kor_vert;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-kor_vert.sha256sum] = "ff68ff22f6885fec0bf9382e87ca46cd3e4ae8f1f8eaa0eb8b923426fb4b73c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-lao-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-lao;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-lao.sha256sum] = "841a45dc8fa60449bea7811dce7a57768bf59ab57a7bd04f7c07b5a8007e9952"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-lat-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-lat;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-lat.sha256sum] = "79f3f2cc972deed49ee56b4831c0c4ce3160031793a8f6a99860b3262c825f52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-lav-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-lav;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-lav.sha256sum] = "436b9bd58e1bb65e514e59534c01cb895005ebc5707b2d824b3e6f1aa8d8c972"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-lit-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-lit;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-lit.sha256sum] = "08aa2c1cc9de9f986d59bbee270cbf9ac17ac606662064f159b282a53bdc7475"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ltz-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ltz;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ltz.sha256sum] = "c77f808daed1f5205551913981d41ef775f61cf8fce21e02f46649b7bd982efd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-mal-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-mal;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-mal.sha256sum] = "548596e82b17e8d17fa09aa41f3904655259051221fc382bc421ba57f3284883"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-mar-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-mar;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-mar.sha256sum] = "8c54926f680bb71099f9fcd87c6793913cfb17c720641b0ea3364903dce3f0db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-mkd-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-mkd;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-mkd.sha256sum] = "9ae37b61eb086640c4e0a0bb5b918a9ec4592b7b4d9f16c4439504de11419575"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-mlt-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-mlt;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-mlt.sha256sum] = "9964ca9dff895e136562cb8fecb4adcdbeafef830f4c6d4b73f586eccf9faf52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-mon-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-mon;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-mon.sha256sum] = "01a47f1fe61679bdc5a8a811c30a76320d5d56149179b6cf6df5c4b6e9740759"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-mri-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-mri;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-mri.sha256sum] = "bd477b44272c6d1b3153a2f1c42905b6f0c9fac4ea7d87bfac3c9b20849f120a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-msa-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-msa;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-msa.sha256sum] = "d8ddcf07b72d57482a7cf57d24c331221d5bfb7bfc487f398ffebde7fab877f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-mya-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-mya;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-mya.sha256sum] = "82b780f27d53be1649b9d44070acd2e12f294e5fc198d1d514da21828c5d2097"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-nep-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-nep;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-nep.sha256sum] = "961c9ab2c3970c3d6d0cdd2827655c563c259f4719ba854dd04ebff07dd36c18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-nld-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-nld;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-nld.sha256sum] = "c1d1863761cd21cf4697f5f1ba571a49ad0df89ceec342feedf2a0a35e7fa254"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-nor-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-nor;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-nor.sha256sum] = "33dd9c7d576fe06f39f2d8a0057b88825aa2317f99f962696abb81ac30a3360b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-oci-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-oci;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-oci.sha256sum] = "fa590426fdd10d508c5e9416dd083a320852ca406bc2f9b3b11dbd7e5c7c49df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ori-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ori;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ori.sha256sum] = "40da7174e39451e6899217ce32753ad607e1ae96112f036659298ac25684e7b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-pan-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-pan;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-pan.sha256sum] = "7a4d72059628a9afa4bc42dfb2c5b778bf4478aaab4e01f19d9992ff233963fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-pol-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-pol;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-pol.sha256sum] = "264120f21a34c95c91eb1a4e117ce2cabca62c91409feca15f9de12e4f6f8cfb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-por-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-por;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-por.sha256sum] = "e03fc81fb80bd8aadf27c17dd1c1e532b8a66f7ea489a73fd728f795394c2405"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-pus-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-pus;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-pus.sha256sum] = "b1fc8a27cb01997e016c247b34d56733b7bb0f74d01ac4a509f6f6773d264acf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-que-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-que;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-que.sha256sum] = "2cb148385772e2dde77134553787fdcde19a4f6b034fbb3b327c9d5cc9ba675d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ron-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ron;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ron.sha256sum] = "a7db7d4e76cef25dc79f74e0f2767a28a92ba8ac819c22e764b0111c14e3e905"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-rus-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-rus;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-rus.sha256sum] = "8c06ea2559589a177832d6bf330c448d29dc6e1e3d79a6f843dcc3c991a1c18e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-san-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-san;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-san.sha256sum] = "7638b3ac7892b3dcd1afa0476edc65c8822b64e85264ccc7d1ff3b135916a900"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-sin-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-sin;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-sin.sha256sum] = "575c88af139513db957018659ea39d37d72b680d1b9d8620e574ae9d093d3795"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-slk-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-slk;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-slk.sha256sum] = "97b1534ec5c708452ba8c4839f2743852f61795925cef2089880fdd736f2996f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-slv-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-slv;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-slv.sha256sum] = "78e8d301c4af35b361e32f62f453ae653b80e385a43f60cbe10762ef15e02849"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-snd-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-snd;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-snd.sha256sum] = "ddaa8a2a7c989aa9b2643af5f9c7e904fa05b2ca98ae1a84fcfd9a91860753f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-spa-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-spa;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-spa.sha256sum] = "a95447f01c34e674bb70945e855a6f5a0db3f3083203d7830cc3a9652b0a3881"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-spa_old-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-spa_old;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-spa_old.sha256sum] = "dcde66d7a83d216d0ea70b6973f8c3086be27453c20b1c300fe0f4b36f93f540"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-sqi-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-sqi;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-sqi.sha256sum] = "c820266e110bc5b08ed2c0d0233cca0253c94201f7f1abab6728219253d087aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-srp-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-srp;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-srp.sha256sum] = "19ec37aab3466bf7941a22cfd2dae5a4dd4ada85b6e845f8069f878fb1d80457"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-srp_latn-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-srp_latn;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-srp_latn.sha256sum] = "f343ed1116f3bd693b6f23d9fa884bc41706f67c4f5dd7a0f44361a811d16cf9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-sun-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-sun;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-sun.sha256sum] = "46ec7c3e8829cb3f539c4007608e236a02569cd076efb0d7ceb6a688cc4d40c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-swa-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-swa;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-swa.sha256sum] = "be52898a7d28e72b1374cec4ef4d8427e70a220f4425efcf0f261ea66c6d2953"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-swe-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-swe;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-swe.sha256sum] = "b25032c93b5a6f63ef5c74b64e22438b7898ca681b34d59c437cc9ff87d16742"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-syr-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-syr;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-syr.sha256sum] = "42e7dfbf3fd0d44183814235866241f2d3453504d33079829445bfec94316476"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-tam-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-tam;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-tam.sha256sum] = "3d51e73913d6bcad748bcb3262650b9950e2e0f3313e3a391e2417dccf09affd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-tat-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-tat;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-tat.sha256sum] = "df1ea7d881e2b4de9ad4aa2b3d90aa98e63d027567dc4ab9f6d2336476a71ef6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-tel-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-tel;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-tel.sha256sum] = "6e4e442999a1acd535729e249e277f3c7f4fa65f1d5ab91b40f6b6cce2d682d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-tgk-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-tgk;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-tgk.sha256sum] = "6aaf4de419b6cdc4b3f6cdebde2ad8d69d2c05f65fc5b3f284c75f161a83953b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-tha-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-tha;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-tha.sha256sum] = "fab886ef2b5a04c0d91c98f21efcf541b45235fad634d8e379d9fa6bf2f5d6ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-tir-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-tir;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-tir.sha256sum] = "dce636082484b92fe3bfa4f12b02be9eca91278f94a4c5ce836486069769e6d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ton-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ton;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ton.sha256sum] = "0c019009c2b8116c14d1588333ed409e9f77a4a2a01d9388ad808fd04c5708ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-tur-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-tur;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-tur.sha256sum] = "a7355bf845252dbd00f62e43ab1de026731be66f9f83db2cf087a08098689789"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-uig-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-uig;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-uig.sha256sum] = "ac20d0cb4525efe6ded0161b37a383a57e7a93ddde3049b7dd54b4143a766f58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-ukr-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-ukr;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-ukr.sha256sum] = "fd1943a535e71922157771394428178ce42284890c2f10ea88ecfe5c81444c0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-urd-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-urd;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-urd.sha256sum] = "d53389b1b7fb1d3e0ea83b57ab7fcef19a3f08331ddfdea5b392964189e7f287"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-uzb-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-uzb;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-uzb.sha256sum] = "483036501d54345792ed9b5e741daf3b52122e45d6de1e601ff661e37685d8f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-uzb_cyrl-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-uzb_cyrl;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-uzb_cyrl.sha256sum] = "b0ff20ea987792661e34c1c73ba5bace53109075784f628954586c0246796335"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-vie-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-vie;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-vie.sha256sum] = "df1c2b64fc8d7db1bd57d87f9cc761abb79770219ec4bddad24f7a0af1d6dd55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-yid-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-yid;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-yid.sha256sum] = "8fa81c68541c7890139e8229063c3bc728c721109b2d93c145b5b9d169dbb0f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-langpack-yor-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-langpack-yor;unpack=0"
SRC_URI[x86_64_v2_tesseract-langpack-yor.sha256sum] = "cf0410afff986b543a43747cc430dd0ef130ceba839e9128535f7781556c448a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-osd-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-osd;unpack=0"
SRC_URI[x86_64_v2_tesseract-osd.sha256sum] = "50cb21ec1dbd14003fe6885eb33a1f86a3405dae38eda51306c315eacbdee989"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tesseract-tessdata-doc-4.1.0-9.el10.noarch.rpm;name=x86_64_v2_tesseract-tessdata-doc;unpack=0"
SRC_URI[x86_64_v2_tesseract-tessdata-doc.sha256sum] = "1b95c5e1e125bf1b825a4e95caa3f98b1cd7b1d447fdee922cb861c0ea6bae73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-equ-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-equ;unpack=0"
SRC_URI[aarch64_tesseract-equ.sha256sum] = "2db416741863566d16d552590015296c342081b23c6d61b816937f795bf00b4e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-afr-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-afr;unpack=0"
SRC_URI[aarch64_tesseract-langpack-afr.sha256sum] = "2f975c82242d935894288c0d636f2b58834ce5fb2573225c6d6bd1e71496ba6d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-amh-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-amh;unpack=0"
SRC_URI[aarch64_tesseract-langpack-amh.sha256sum] = "52b3c6c371e5f3570fd31ae55fabe267688c485c7f1780a82c376a3333f47959"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ara-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ara;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ara.sha256sum] = "3577d1dcdbe07d5f76fc2d7e0b3516ff19f901f49bffc44cfd61da861032df5d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-asm-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-asm;unpack=0"
SRC_URI[aarch64_tesseract-langpack-asm.sha256sum] = "13bcdd2fc8bda6231babaf880f781b1dad76570cc63456086fbac5b532e70102"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-aze-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-aze;unpack=0"
SRC_URI[aarch64_tesseract-langpack-aze.sha256sum] = "2909aa4cb9d3e31c4ec47f545d2f4b64f6ad0df62e1b3bd251049be5f87bc547"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-aze_cyrl-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-aze_cyrl;unpack=0"
SRC_URI[aarch64_tesseract-langpack-aze_cyrl.sha256sum] = "20d6a84d6bd1874b971e53aedaea1b21e793ad1c3b471d3485877787e20327b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-bel-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-bel;unpack=0"
SRC_URI[aarch64_tesseract-langpack-bel.sha256sum] = "edc7a068f0bbcf7d6c7f38341159cb760798bb79aab2c03a640a8ee578b6ea45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ben-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ben;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ben.sha256sum] = "1d6c4c765cf7aacff17be4c8521403dfe9234bcfc77d81359113fa1698581ea9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-bod-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-bod;unpack=0"
SRC_URI[aarch64_tesseract-langpack-bod.sha256sum] = "2ac2c2c73b19c26a961400cebb2f364f580f4351f23eb983898dd847d96b8b12"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-bos-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-bos;unpack=0"
SRC_URI[aarch64_tesseract-langpack-bos.sha256sum] = "8a4833bb9ee14fb2492133c0859bcc0b05db654ecd169fb3dac6b4d092474c3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-bre-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-bre;unpack=0"
SRC_URI[aarch64_tesseract-langpack-bre.sha256sum] = "deece245ce22798c9c28557901921681ce3b4f757bce3205cfef7441c0df1a45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-bul-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-bul;unpack=0"
SRC_URI[aarch64_tesseract-langpack-bul.sha256sum] = "427675746615db6e567e03d7f7cb8793d192a9c60a5f9343abc96a1a1c62a14b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-cat-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-cat;unpack=0"
SRC_URI[aarch64_tesseract-langpack-cat.sha256sum] = "f300b389ac110e722de49b9961a403da5a7021c9c0c32191eeee28f06822ec8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ceb-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ceb;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ceb.sha256sum] = "22d2d0db985bc749c67d8e4663c8fe4ccf41175b4f38c5faf42ad40eeb44cf05"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ces-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ces;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ces.sha256sum] = "d61b23c3b661fb2add5af14872bb06906768ba4484162dec6725cf9c4c28695b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-chi_sim-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-chi_sim;unpack=0"
SRC_URI[aarch64_tesseract-langpack-chi_sim.sha256sum] = "b913dd49f20b76e8bd96d69a0250e7f8ef24dee27a086ea80233210706ee600e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-chi_sim_vert-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-chi_sim_vert;unpack=0"
SRC_URI[aarch64_tesseract-langpack-chi_sim_vert.sha256sum] = "92327f28b777f036d6c2b4de848b04c228f006f1b7ad91e4cdfa2143edeace58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-chi_tra-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-chi_tra;unpack=0"
SRC_URI[aarch64_tesseract-langpack-chi_tra.sha256sum] = "75b728e1fdc0c78d9e42c0c2749276ae38d7e1d26567d814bd6ce81b9017131e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-chi_tra_vert-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-chi_tra_vert;unpack=0"
SRC_URI[aarch64_tesseract-langpack-chi_tra_vert.sha256sum] = "d2ae52f9f597ba4379925071a391135eeb2e384ec231b79c5e02b52c720b9e96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-chr-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-chr;unpack=0"
SRC_URI[aarch64_tesseract-langpack-chr.sha256sum] = "55dbb0b4932d2c64221ada47b6cfa44e6bf0f238216ac57e618057407587197e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-cos-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-cos;unpack=0"
SRC_URI[aarch64_tesseract-langpack-cos.sha256sum] = "a4045c367f909453e55b4abfd1649974a7a5e86177c9ced06ad603cfb87f56fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-cym-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-cym;unpack=0"
SRC_URI[aarch64_tesseract-langpack-cym.sha256sum] = "d9f5183431aa84623b1a1f3a76d172a6bab70ba62fe674589d29a555c8fd1d3a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-dan-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-dan;unpack=0"
SRC_URI[aarch64_tesseract-langpack-dan.sha256sum] = "14ff4ed8bad2a9b32caadca8661182a71476f21bb4b979764673706ae18549b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-deu-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-deu;unpack=0"
SRC_URI[aarch64_tesseract-langpack-deu.sha256sum] = "75d9839d97932ebb3015e4a134732ce111a64f26898da2ca8c55dbf6941dbaa0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-div-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-div;unpack=0"
SRC_URI[aarch64_tesseract-langpack-div.sha256sum] = "dfd8880c8dc15fb15df85d8add49b6bea2db59d10e176a9937454fc532f50b3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-dzo-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-dzo;unpack=0"
SRC_URI[aarch64_tesseract-langpack-dzo.sha256sum] = "c08a23688499f8699e047a8fb05180c864451536204de5d990f900fda39f8732"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ell-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ell;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ell.sha256sum] = "4d09a9ec7c89d52b617492d9dd71e30d3c98b0e4494d41e19495758fa911ca67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-eng-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-eng;unpack=0"
SRC_URI[aarch64_tesseract-langpack-eng.sha256sum] = "791748badec2f22b0d3214b5c884112f8aa7f055edc71141f7c628ac509bbe8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-enm-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-enm;unpack=0"
SRC_URI[aarch64_tesseract-langpack-enm.sha256sum] = "0e8a78891558798e98061bd84d2af615e03385f8cb316b060eed3048b619afef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-epo-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-epo;unpack=0"
SRC_URI[aarch64_tesseract-langpack-epo.sha256sum] = "a5ee74c08fd3a2a87ec3feeb86bfec06b7138f09e04071b9ff8cb3fa3662bf97"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-est-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-est;unpack=0"
SRC_URI[aarch64_tesseract-langpack-est.sha256sum] = "db3233471328f89538909c42ed618a32773415887920fee1441bf21c283c2e92"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-eus-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-eus;unpack=0"
SRC_URI[aarch64_tesseract-langpack-eus.sha256sum] = "051a55f45f45be60c599a5e0db2ab309148cd0309117fdc4dbf19eef8150bb3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-fao-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-fao;unpack=0"
SRC_URI[aarch64_tesseract-langpack-fao.sha256sum] = "5b7c7dc8a450b7544623963dd7620bc9fdb631bd8262069e03575051294b56df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-fas-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-fas;unpack=0"
SRC_URI[aarch64_tesseract-langpack-fas.sha256sum] = "34567b280f16b640467ec6b4981f3d7d1e641c1c35083b6f01df9e1dbf80b66c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-fil-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-fil;unpack=0"
SRC_URI[aarch64_tesseract-langpack-fil.sha256sum] = "4e5e5996eb39a79fcd9e3ac084b34b12996845c18cf9d41c797e0cd6aba22c27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-fin-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-fin;unpack=0"
SRC_URI[aarch64_tesseract-langpack-fin.sha256sum] = "0c66e07fbbf03d95e32022f96814226d28af67825853806f64529f877a4cfa67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-fra-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-fra;unpack=0"
SRC_URI[aarch64_tesseract-langpack-fra.sha256sum] = "58a7ba2691592b94c1d10f0f85bfea8fd3778b4d69b26f60cbb962f928664005"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-frk-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-frk;unpack=0"
SRC_URI[aarch64_tesseract-langpack-frk.sha256sum] = "09293e446ca8461d03eaee9ce8c305e85fe0b647e32bc9461d141294a5d02231"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-frm-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-frm;unpack=0"
SRC_URI[aarch64_tesseract-langpack-frm.sha256sum] = "5c2fe40c5d3dda405e156a132c37a1e342bc411ff26ed0ba49a9b322a38570e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-fry-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-fry;unpack=0"
SRC_URI[aarch64_tesseract-langpack-fry.sha256sum] = "598c2e16a3643a9bddb978321ac62839dd04ad90f9406356a0766bcf302c5658"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-gla-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-gla;unpack=0"
SRC_URI[aarch64_tesseract-langpack-gla.sha256sum] = "13febe469b2aa8ac50ddcb0410ab3f59faf32d00afd22eef3c0effe7dc8e6d4b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-gle-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-gle;unpack=0"
SRC_URI[aarch64_tesseract-langpack-gle.sha256sum] = "d2676a9c5a90dc9f41769c7614529969d49eac47a158b821aac8184c44067f2b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-glg-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-glg;unpack=0"
SRC_URI[aarch64_tesseract-langpack-glg.sha256sum] = "3dac8397fea203af287031ed8a378921acd10e5dae9fbeffae941938545594fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-grc-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-grc;unpack=0"
SRC_URI[aarch64_tesseract-langpack-grc.sha256sum] = "7f21af866fe91ec185a42e5938f75fe88f4adbc40d78a6ec4fa7c65a97235dad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-guj-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-guj;unpack=0"
SRC_URI[aarch64_tesseract-langpack-guj.sha256sum] = "cc750493e2e617101cdc561d45ab3fa922c3ced7803c3e666d40b28302680ef8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-hat-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-hat;unpack=0"
SRC_URI[aarch64_tesseract-langpack-hat.sha256sum] = "b26ae4a7005e99c5750ecad9df95df62f4ac3d27b2d752918f12063412291f95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-heb-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-heb;unpack=0"
SRC_URI[aarch64_tesseract-langpack-heb.sha256sum] = "daf61e38e6585932b29c17ef9da91b8608805850cce1bd6c29fce72af5ff2797"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-hin-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-hin;unpack=0"
SRC_URI[aarch64_tesseract-langpack-hin.sha256sum] = "f796b38f145b1bd92c3d0e9e1cafe738e8934aa6c95f08705ea2a849237df3b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-hrv-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-hrv;unpack=0"
SRC_URI[aarch64_tesseract-langpack-hrv.sha256sum] = "d3f9fea37517b49f97b7468874fc148aa4db30c91c49c926953479c302832db2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-hun-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-hun;unpack=0"
SRC_URI[aarch64_tesseract-langpack-hun.sha256sum] = "6e26f18ae4720a8708de045a1cb19c02435ba99b26fb921ed4110b2786ae86b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-hye-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-hye;unpack=0"
SRC_URI[aarch64_tesseract-langpack-hye.sha256sum] = "e679d34ad8fc93c63d285804fcebe5706e6b28d84acd3f2eb74d988ee58463aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-iku-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-iku;unpack=0"
SRC_URI[aarch64_tesseract-langpack-iku.sha256sum] = "8491ed9581ad698498cebe9a1ff37f36707f3e678261b47ac1f855823b338df6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ind-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ind;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ind.sha256sum] = "a698404f393c39a0e14d952322afd460021ad2acceddf810a4266adc3bc16e37"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-isl-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-isl;unpack=0"
SRC_URI[aarch64_tesseract-langpack-isl.sha256sum] = "c8e006ab66326e3fe499b976deb5357f81bfeed456ad193d670f9e4b3f0295c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ita-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ita;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ita.sha256sum] = "ac50f2dd8accd8b32f45f2564b71053059b805d6ab949a9ebabdf2f0d3cbcae2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ita_old-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ita_old;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ita_old.sha256sum] = "7b7ede065b8c91e5b3176a1112de46721c1d2d5f468faf5666ccc2cb0d4393a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-jav-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-jav;unpack=0"
SRC_URI[aarch64_tesseract-langpack-jav.sha256sum] = "985919cb96e0d27fb8a4a294587e84068d21dcf08610702c681b95d17469387f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-jpn-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-jpn;unpack=0"
SRC_URI[aarch64_tesseract-langpack-jpn.sha256sum] = "9a8ed9c169a5e6cabd6a3141e4ae3d73e8f36f9d661d762a6ea975c9b16d288c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-jpn_vert-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-jpn_vert;unpack=0"
SRC_URI[aarch64_tesseract-langpack-jpn_vert.sha256sum] = "dab4cece28ad028df7ae655ed0853e2aa79766491864bc2cbbac1a7232f0fe29"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-kan-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-kan;unpack=0"
SRC_URI[aarch64_tesseract-langpack-kan.sha256sum] = "269987ebe6077cc90ebb3f3f165adeda9ce2ded3cdb81f5ad5b7735e1112a9f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-kat-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-kat;unpack=0"
SRC_URI[aarch64_tesseract-langpack-kat.sha256sum] = "86776fe91e8a24dc884e2c21bbd9f698bdf6f0031bf5eeefd8b00813a8a73388"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-kat_old-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-kat_old;unpack=0"
SRC_URI[aarch64_tesseract-langpack-kat_old.sha256sum] = "f9033f415f1735070dd9f111588962e108b6233845ccd5c4ed21f04dd75c358f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-kaz-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-kaz;unpack=0"
SRC_URI[aarch64_tesseract-langpack-kaz.sha256sum] = "43d01f1d50440f3dc628c3cbee0b7be46589cb05b13e4af242321cc5990daf6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-khm-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-khm;unpack=0"
SRC_URI[aarch64_tesseract-langpack-khm.sha256sum] = "b882a791ecbc0caa4827e95badea1d72a4db244871993c86d0811f8bd606bc1f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-kir-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-kir;unpack=0"
SRC_URI[aarch64_tesseract-langpack-kir.sha256sum] = "fa5e29f69566d6365740659fc93bbd81897b641a0c3b6467ec59497e8c1f1000"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-kmr-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-kmr;unpack=0"
SRC_URI[aarch64_tesseract-langpack-kmr.sha256sum] = "560a8baf79c7c387955dfdc7ca4cf1b86bd260f4d30287930c5d06c9250b616a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-kor-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-kor;unpack=0"
SRC_URI[aarch64_tesseract-langpack-kor.sha256sum] = "888e58b2895a62385ee5c5cde618904c3947e61036f0dab8b36eda26ed734142"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-kor_vert-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-kor_vert;unpack=0"
SRC_URI[aarch64_tesseract-langpack-kor_vert.sha256sum] = "ff68ff22f6885fec0bf9382e87ca46cd3e4ae8f1f8eaa0eb8b923426fb4b73c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-lao-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-lao;unpack=0"
SRC_URI[aarch64_tesseract-langpack-lao.sha256sum] = "841a45dc8fa60449bea7811dce7a57768bf59ab57a7bd04f7c07b5a8007e9952"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-lat-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-lat;unpack=0"
SRC_URI[aarch64_tesseract-langpack-lat.sha256sum] = "79f3f2cc972deed49ee56b4831c0c4ce3160031793a8f6a99860b3262c825f52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-lav-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-lav;unpack=0"
SRC_URI[aarch64_tesseract-langpack-lav.sha256sum] = "436b9bd58e1bb65e514e59534c01cb895005ebc5707b2d824b3e6f1aa8d8c972"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-lit-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-lit;unpack=0"
SRC_URI[aarch64_tesseract-langpack-lit.sha256sum] = "08aa2c1cc9de9f986d59bbee270cbf9ac17ac606662064f159b282a53bdc7475"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ltz-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ltz;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ltz.sha256sum] = "c77f808daed1f5205551913981d41ef775f61cf8fce21e02f46649b7bd982efd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-mal-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-mal;unpack=0"
SRC_URI[aarch64_tesseract-langpack-mal.sha256sum] = "548596e82b17e8d17fa09aa41f3904655259051221fc382bc421ba57f3284883"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-mar-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-mar;unpack=0"
SRC_URI[aarch64_tesseract-langpack-mar.sha256sum] = "8c54926f680bb71099f9fcd87c6793913cfb17c720641b0ea3364903dce3f0db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-mkd-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-mkd;unpack=0"
SRC_URI[aarch64_tesseract-langpack-mkd.sha256sum] = "9ae37b61eb086640c4e0a0bb5b918a9ec4592b7b4d9f16c4439504de11419575"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-mlt-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-mlt;unpack=0"
SRC_URI[aarch64_tesseract-langpack-mlt.sha256sum] = "9964ca9dff895e136562cb8fecb4adcdbeafef830f4c6d4b73f586eccf9faf52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-mon-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-mon;unpack=0"
SRC_URI[aarch64_tesseract-langpack-mon.sha256sum] = "01a47f1fe61679bdc5a8a811c30a76320d5d56149179b6cf6df5c4b6e9740759"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-mri-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-mri;unpack=0"
SRC_URI[aarch64_tesseract-langpack-mri.sha256sum] = "bd477b44272c6d1b3153a2f1c42905b6f0c9fac4ea7d87bfac3c9b20849f120a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-msa-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-msa;unpack=0"
SRC_URI[aarch64_tesseract-langpack-msa.sha256sum] = "d8ddcf07b72d57482a7cf57d24c331221d5bfb7bfc487f398ffebde7fab877f4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-mya-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-mya;unpack=0"
SRC_URI[aarch64_tesseract-langpack-mya.sha256sum] = "82b780f27d53be1649b9d44070acd2e12f294e5fc198d1d514da21828c5d2097"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-nep-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-nep;unpack=0"
SRC_URI[aarch64_tesseract-langpack-nep.sha256sum] = "961c9ab2c3970c3d6d0cdd2827655c563c259f4719ba854dd04ebff07dd36c18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-nld-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-nld;unpack=0"
SRC_URI[aarch64_tesseract-langpack-nld.sha256sum] = "c1d1863761cd21cf4697f5f1ba571a49ad0df89ceec342feedf2a0a35e7fa254"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-nor-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-nor;unpack=0"
SRC_URI[aarch64_tesseract-langpack-nor.sha256sum] = "33dd9c7d576fe06f39f2d8a0057b88825aa2317f99f962696abb81ac30a3360b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-oci-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-oci;unpack=0"
SRC_URI[aarch64_tesseract-langpack-oci.sha256sum] = "fa590426fdd10d508c5e9416dd083a320852ca406bc2f9b3b11dbd7e5c7c49df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ori-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ori;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ori.sha256sum] = "40da7174e39451e6899217ce32753ad607e1ae96112f036659298ac25684e7b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-pan-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-pan;unpack=0"
SRC_URI[aarch64_tesseract-langpack-pan.sha256sum] = "7a4d72059628a9afa4bc42dfb2c5b778bf4478aaab4e01f19d9992ff233963fc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-pol-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-pol;unpack=0"
SRC_URI[aarch64_tesseract-langpack-pol.sha256sum] = "264120f21a34c95c91eb1a4e117ce2cabca62c91409feca15f9de12e4f6f8cfb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-por-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-por;unpack=0"
SRC_URI[aarch64_tesseract-langpack-por.sha256sum] = "e03fc81fb80bd8aadf27c17dd1c1e532b8a66f7ea489a73fd728f795394c2405"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-pus-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-pus;unpack=0"
SRC_URI[aarch64_tesseract-langpack-pus.sha256sum] = "b1fc8a27cb01997e016c247b34d56733b7bb0f74d01ac4a509f6f6773d264acf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-que-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-que;unpack=0"
SRC_URI[aarch64_tesseract-langpack-que.sha256sum] = "2cb148385772e2dde77134553787fdcde19a4f6b034fbb3b327c9d5cc9ba675d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ron-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ron;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ron.sha256sum] = "a7db7d4e76cef25dc79f74e0f2767a28a92ba8ac819c22e764b0111c14e3e905"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-rus-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-rus;unpack=0"
SRC_URI[aarch64_tesseract-langpack-rus.sha256sum] = "8c06ea2559589a177832d6bf330c448d29dc6e1e3d79a6f843dcc3c991a1c18e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-san-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-san;unpack=0"
SRC_URI[aarch64_tesseract-langpack-san.sha256sum] = "7638b3ac7892b3dcd1afa0476edc65c8822b64e85264ccc7d1ff3b135916a900"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-sin-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-sin;unpack=0"
SRC_URI[aarch64_tesseract-langpack-sin.sha256sum] = "575c88af139513db957018659ea39d37d72b680d1b9d8620e574ae9d093d3795"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-slk-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-slk;unpack=0"
SRC_URI[aarch64_tesseract-langpack-slk.sha256sum] = "97b1534ec5c708452ba8c4839f2743852f61795925cef2089880fdd736f2996f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-slv-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-slv;unpack=0"
SRC_URI[aarch64_tesseract-langpack-slv.sha256sum] = "78e8d301c4af35b361e32f62f453ae653b80e385a43f60cbe10762ef15e02849"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-snd-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-snd;unpack=0"
SRC_URI[aarch64_tesseract-langpack-snd.sha256sum] = "ddaa8a2a7c989aa9b2643af5f9c7e904fa05b2ca98ae1a84fcfd9a91860753f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-spa-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-spa;unpack=0"
SRC_URI[aarch64_tesseract-langpack-spa.sha256sum] = "a95447f01c34e674bb70945e855a6f5a0db3f3083203d7830cc3a9652b0a3881"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-spa_old-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-spa_old;unpack=0"
SRC_URI[aarch64_tesseract-langpack-spa_old.sha256sum] = "dcde66d7a83d216d0ea70b6973f8c3086be27453c20b1c300fe0f4b36f93f540"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-sqi-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-sqi;unpack=0"
SRC_URI[aarch64_tesseract-langpack-sqi.sha256sum] = "c820266e110bc5b08ed2c0d0233cca0253c94201f7f1abab6728219253d087aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-srp-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-srp;unpack=0"
SRC_URI[aarch64_tesseract-langpack-srp.sha256sum] = "19ec37aab3466bf7941a22cfd2dae5a4dd4ada85b6e845f8069f878fb1d80457"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-srp_latn-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-srp_latn;unpack=0"
SRC_URI[aarch64_tesseract-langpack-srp_latn.sha256sum] = "f343ed1116f3bd693b6f23d9fa884bc41706f67c4f5dd7a0f44361a811d16cf9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-sun-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-sun;unpack=0"
SRC_URI[aarch64_tesseract-langpack-sun.sha256sum] = "46ec7c3e8829cb3f539c4007608e236a02569cd076efb0d7ceb6a688cc4d40c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-swa-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-swa;unpack=0"
SRC_URI[aarch64_tesseract-langpack-swa.sha256sum] = "be52898a7d28e72b1374cec4ef4d8427e70a220f4425efcf0f261ea66c6d2953"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-swe-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-swe;unpack=0"
SRC_URI[aarch64_tesseract-langpack-swe.sha256sum] = "b25032c93b5a6f63ef5c74b64e22438b7898ca681b34d59c437cc9ff87d16742"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-syr-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-syr;unpack=0"
SRC_URI[aarch64_tesseract-langpack-syr.sha256sum] = "42e7dfbf3fd0d44183814235866241f2d3453504d33079829445bfec94316476"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-tam-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-tam;unpack=0"
SRC_URI[aarch64_tesseract-langpack-tam.sha256sum] = "3d51e73913d6bcad748bcb3262650b9950e2e0f3313e3a391e2417dccf09affd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-tat-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-tat;unpack=0"
SRC_URI[aarch64_tesseract-langpack-tat.sha256sum] = "df1ea7d881e2b4de9ad4aa2b3d90aa98e63d027567dc4ab9f6d2336476a71ef6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-tel-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-tel;unpack=0"
SRC_URI[aarch64_tesseract-langpack-tel.sha256sum] = "6e4e442999a1acd535729e249e277f3c7f4fa65f1d5ab91b40f6b6cce2d682d3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-tgk-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-tgk;unpack=0"
SRC_URI[aarch64_tesseract-langpack-tgk.sha256sum] = "6aaf4de419b6cdc4b3f6cdebde2ad8d69d2c05f65fc5b3f284c75f161a83953b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-tha-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-tha;unpack=0"
SRC_URI[aarch64_tesseract-langpack-tha.sha256sum] = "fab886ef2b5a04c0d91c98f21efcf541b45235fad634d8e379d9fa6bf2f5d6ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-tir-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-tir;unpack=0"
SRC_URI[aarch64_tesseract-langpack-tir.sha256sum] = "dce636082484b92fe3bfa4f12b02be9eca91278f94a4c5ce836486069769e6d5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ton-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ton;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ton.sha256sum] = "0c019009c2b8116c14d1588333ed409e9f77a4a2a01d9388ad808fd04c5708ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-tur-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-tur;unpack=0"
SRC_URI[aarch64_tesseract-langpack-tur.sha256sum] = "a7355bf845252dbd00f62e43ab1de026731be66f9f83db2cf087a08098689789"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-uig-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-uig;unpack=0"
SRC_URI[aarch64_tesseract-langpack-uig.sha256sum] = "ac20d0cb4525efe6ded0161b37a383a57e7a93ddde3049b7dd54b4143a766f58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-ukr-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-ukr;unpack=0"
SRC_URI[aarch64_tesseract-langpack-ukr.sha256sum] = "fd1943a535e71922157771394428178ce42284890c2f10ea88ecfe5c81444c0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-urd-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-urd;unpack=0"
SRC_URI[aarch64_tesseract-langpack-urd.sha256sum] = "d53389b1b7fb1d3e0ea83b57ab7fcef19a3f08331ddfdea5b392964189e7f287"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-uzb-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-uzb;unpack=0"
SRC_URI[aarch64_tesseract-langpack-uzb.sha256sum] = "483036501d54345792ed9b5e741daf3b52122e45d6de1e601ff661e37685d8f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-uzb_cyrl-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-uzb_cyrl;unpack=0"
SRC_URI[aarch64_tesseract-langpack-uzb_cyrl.sha256sum] = "b0ff20ea987792661e34c1c73ba5bace53109075784f628954586c0246796335"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-vie-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-vie;unpack=0"
SRC_URI[aarch64_tesseract-langpack-vie.sha256sum] = "df1c2b64fc8d7db1bd57d87f9cc761abb79770219ec4bddad24f7a0af1d6dd55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-yid-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-yid;unpack=0"
SRC_URI[aarch64_tesseract-langpack-yid.sha256sum] = "8fa81c68541c7890139e8229063c3bc728c721109b2d93c145b5b9d169dbb0f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-langpack-yor-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-langpack-yor;unpack=0"
SRC_URI[aarch64_tesseract-langpack-yor.sha256sum] = "cf0410afff986b543a43747cc430dd0ef130ceba839e9128535f7781556c448a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-osd-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-osd;unpack=0"
SRC_URI[aarch64_tesseract-osd.sha256sum] = "50cb21ec1dbd14003fe6885eb33a1f86a3405dae38eda51306c315eacbdee989"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tesseract-tessdata-doc-4.1.0-9.el10.noarch.rpm;name=aarch64_tesseract-tessdata-doc;unpack=0"
SRC_URI[aarch64_tesseract-tessdata-doc.sha256sum] = "1b95c5e1e125bf1b825a4e95caa3f98b1cd7b1d447fdee922cb861c0ea6bae73"

RDEPENDS:tesseract-equ = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-afr = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-amh = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ara = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-asm = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-aze = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-aze_cyrl = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-bel = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ben = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-bod = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-bos = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-bre = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-bul = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-cat = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ceb = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ces = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-chi_sim = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-chi_sim_vert = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-chi_tra = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-chi_tra_vert = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-chr = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-cos = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-cym = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-dan = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-deu = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-div = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-dzo = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ell = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-eng = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-enm = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-epo = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-est = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-eus = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-fao = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-fas = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-fil = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-fin = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-fra = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-frk = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-frm = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-fry = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-gla = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-gle = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-glg = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-grc = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-guj = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-hat = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-heb = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-hin = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-hrv = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-hun = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-hye = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-iku = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ind = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-isl = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ita = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ita_old = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-jav = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-jpn = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-jpn_vert = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-kan = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-kat = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-kat_old = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-kaz = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-khm = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-kir = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-kmr = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-kor = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-kor_vert = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-lao = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-lat = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-lav = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-lit = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ltz = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-mal = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-mar = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-mkd = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-mlt = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-mon = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-mri = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-msa = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-mya = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-nep = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-nld = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-nor = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-oci = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ori = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-pan = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-pol = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-por = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-pus = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-que = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ron = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-rus = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-san = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-sin = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-slk = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-slv = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-snd = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-spa = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-spa_old = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-sqi = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-srp = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-srp_latn = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-sun = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-swa = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-swe = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-syr = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-tam = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-tat = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-tel = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-tgk = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-tha = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-tir = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ton = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-tur = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-uig = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-ukr = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-urd = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-uzb = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-uzb_cyrl = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-vie = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-yid = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-langpack-yor = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-osd = " \
 tesseract \
 tesseract-tessdata-doc \
 "
RDEPENDS:tesseract-tessdata-doc = " \
 "
