# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "almalinux-logos"
PV = "100.4"
PR = "1.el10_2"
PACKAGES = " \
 almalinux-backgrounds \
 almalinux-logos \
 almalinux-logos-httpd \
 almalinux-logos-ipa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/almalinux-logos-100.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36b503edc70d96891fd592ed4d0f2f0a0884c5a86d436ed778c2f84b472c55d6"

URI_x86_64_v2_almalinux-backgrounds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-backgrounds-100.4-1.el10_2.noarch.rpm;name=x86_64_v2_almalinux-backgrounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-backgrounds}"
SRC_URI[x86_64_v2_almalinux-backgrounds.sha256sum] = "174c6eaf05b436c3802f38f47bd2d96842e30ba275b42b05ee2c96f43ba5b4f9"
RPROVIDES:almalinux-backgrounds:x86_64_v2 = "virtual/desktop-backgrounds-compat virtual/system-backgrounds-kde"

URI_x86_64_v2_almalinux-logos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-logos-100.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_almalinux-logos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-logos}"
SRC_URI[x86_64_v2_almalinux-logos.sha256sum] = "a6a2c2e828cfc3aaa6e8ae9ba1fb25684f9e7786594e32b58eef7cc964e69bce"

URI_x86_64_v2_almalinux-logos-httpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-logos-httpd-100.4-1.el10_2.noarch.rpm;name=x86_64_v2_almalinux-logos-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-logos-httpd}"
SRC_URI[x86_64_v2_almalinux-logos-httpd.sha256sum] = "0d57f34c52e55fd302d00593245ff547c10f17e23b23d5e5ded7fa6de2b1ad67"

URI_x86_64_v2_almalinux-logos-ipa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/almalinux-logos-ipa-100.4-1.el10_2.noarch.rpm;name=x86_64_v2_almalinux-logos-ipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-logos-ipa}"
SRC_URI[x86_64_v2_almalinux-logos-ipa.sha256sum] = "ff40fc5757175a66042cf6b39c5a14c2baad9caf634d3b404598cc177e2e2cd1"

URI_aarch64_almalinux-backgrounds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-backgrounds-100.4-1.el10_2.noarch.rpm;name=aarch64_almalinux-backgrounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-backgrounds}"
SRC_URI[aarch64_almalinux-backgrounds.sha256sum] = "174c6eaf05b436c3802f38f47bd2d96842e30ba275b42b05ee2c96f43ba5b4f9"
RPROVIDES:almalinux-backgrounds:aarch64 = "virtual/desktop-backgrounds-compat virtual/system-backgrounds-kde"

URI_aarch64_almalinux-logos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-logos-100.4-1.el10_2.aarch64.rpm;name=aarch64_almalinux-logos;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-logos}"
SRC_URI[aarch64_almalinux-logos.sha256sum] = "3599168011ae5177b32623ddd89c7740168fa54b05111654ee37f8355d48aab5"

URI_aarch64_almalinux-logos-httpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-logos-httpd-100.4-1.el10_2.noarch.rpm;name=aarch64_almalinux-logos-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-logos-httpd}"
SRC_URI[aarch64_almalinux-logos-httpd.sha256sum] = "0d57f34c52e55fd302d00593245ff547c10f17e23b23d5e5ded7fa6de2b1ad67"

URI_aarch64_almalinux-logos-ipa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/almalinux-logos-ipa-100.4-1.el10_2.noarch.rpm;name=aarch64_almalinux-logos-ipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-logos-ipa}"
SRC_URI[aarch64_almalinux-logos-ipa.sha256sum] = "ff40fc5757175a66042cf6b39c5a14c2baad9caf634d3b404598cc177e2e2cd1"

RDEPENDS:almalinux-backgrounds = " \
 almalinux-logos \
 "
RDEPENDS:almalinux-logos = " \
 bash \
 virtual/coreutils \
 "
RDEPENDS:almalinux-logos-httpd = " \
 "
RDEPENDS:almalinux-logos-ipa = " \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/desktop-backgrounds-compat rpm/virtual/system-backgrounds-kde"

PROVIDES:append:aarch64 = " rpm/virtual/desktop-backgrounds-compat rpm/virtual/system-backgrounds-kde"
