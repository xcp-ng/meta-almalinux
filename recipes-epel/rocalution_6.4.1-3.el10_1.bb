# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocalution"
PV = "6.4.1"
PR = "3.el10_1"
PACKAGES:x86_64_v2 = " \
 rocalution \
 rocalution-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocalution-6.4.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2364187c9f83592476d2cb11a2f4421c0e8115a19da2b96be686a8091ee78cd"

URI_x86_64_v2_rocalution = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocalution-6.4.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocalution;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocalution}"
SRC_URI[x86_64_v2_rocalution.sha256sum] = "bea9405668c9de31e2725045187d9c58fbe8897621cc0aaa47c51c25dd7e392d"

URI_x86_64_v2_rocalution-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocalution-devel-6.4.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocalution-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocalution-devel}"
SRC_URI[x86_64_v2_rocalution-devel.sha256sum] = "ad6d580f3bd65ae31705d67b43fb3f54e8575ee3ef2b27a2c3a9a5564e0576aa"

RDEPENDS:rocalution = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocm-hip \
 rocrand \
 rocsparse \
 "
RDEPENDS:rocalution-devel = " \
 cmake-filesystem \
 rocalution \
 "
