# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setup"
PV = "2.14.5"
PR = "4.el10"
PACKAGES = " \
 setup \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/setup-2.14.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1854539039934f8b1a4d634531a5ea5f1afe3845a7aa9ef556ab40e0c9e82a5a"

URI_x86_64_v2_setup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/setup-2.14.5-4.el10.noarch.rpm;name=x86_64_v2_setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setup}"
SRC_URI[x86_64_v2_setup.sha256sum] = "ac6b578f6644f0e80ee0f3b38c7be810f3fe8e8474fc01427c3a35d1626686e3"

URI_aarch64_setup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/setup-2.14.5-4.el10.noarch.rpm;name=aarch64_setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_setup}"
SRC_URI[aarch64_setup.sha256sum] = "ac6b578f6644f0e80ee0f3b38c7be810f3fe8e8474fc01427c3a35d1626686e3"

RDEPENDS:setup = " \
 almalinux-release \
 "
