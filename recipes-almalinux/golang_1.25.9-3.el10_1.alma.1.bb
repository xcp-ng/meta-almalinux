# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang"
PV = "1.25.9"
PR = "3.el10_1.alma.1"
PACKAGES = " \
 go-toolset \
 golang \
 golang-bin \
 golang-docs \
 golang-misc \
 golang-race \
 golang-src \
 golang-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-1.25.9-3.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bde703e3b6dd715f2ff20cb2268c7e9aeb68c4d0db4a0b24ad7480d37e170e53"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-toolset-1.25.9-3.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_go-toolset;unpack=0"
SRC_URI[x86_64_v2_go-toolset.sha256sum] = "b88d1c685d5b727de89248c1ebd25493a4e07ea97e2d02ffe42394e0131ab7a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-1.25.9-3.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang;unpack=0"
SRC_URI[x86_64_v2_golang.sha256sum] = "30458c1be091c25281d29e2f47e2f6de0e2e2fed5db3a84ee20e974f65062668"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-bin-1.25.9-3.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-bin;unpack=0"
SRC_URI[x86_64_v2_golang-bin.sha256sum] = "bb0d0c57b1c9731a250af520186a4b1897896937177ee49825701763e743121d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-docs-1.25.9-3.el10_1.alma.1.noarch.rpm;name=x86_64_v2_golang-docs;unpack=0"
SRC_URI[x86_64_v2_golang-docs.sha256sum] = "de07ac1ccba557b72d716728f654475ef556ae4b189138f2a4f00e08aec2094c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-misc-1.25.9-3.el10_1.alma.1.noarch.rpm;name=x86_64_v2_golang-misc;unpack=0"
SRC_URI[x86_64_v2_golang-misc.sha256sum] = "8eaa33130ec0a0a1c5d0c7b06afbb2299e232d345844c2a1cb4280f88c4ed9bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-race-1.25.9-3.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-race;unpack=0"
SRC_URI[x86_64_v2_golang-race.sha256sum] = "728e5fa6e72f6830ca68fb2cdd36171fbd2f86ee2b1994f8da41e2d2bfecd70d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-src-1.25.9-3.el10_1.alma.1.noarch.rpm;name=x86_64_v2_golang-src;unpack=0"
SRC_URI[x86_64_v2_golang-src.sha256sum] = "4a77c44fdc29a841743d7cabb21367676ea4b5bf4a90494bad2d0b07220e73d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-tests-1.25.9-3.el10_1.alma.1.noarch.rpm;name=x86_64_v2_golang-tests;unpack=0"
SRC_URI[x86_64_v2_golang-tests.sha256sum] = "d4c3eac56d1508fa6aeeac85e1523da2412eb809ddd2e93943dca41f7bc0d8e6"
RPROVIDES:golang-tests:append:x86_64_v2 = " virtual/libtiffxx.so.6___64bit_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-toolset-1.25.9-3.el10_1.alma.1.aarch64.rpm;name=aarch64_go-toolset;unpack=0"
SRC_URI[aarch64_go-toolset.sha256sum] = "5f01be8a80b231e43db7456f1f03c7774c1a98c96240a2f7d30710efc77fca5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-1.25.9-3.el10_1.alma.1.aarch64.rpm;name=aarch64_golang;unpack=0"
SRC_URI[aarch64_golang.sha256sum] = "c1b0d8bd4c8319192cdaa575e992e7e85e1713e03915daf66ac088f21b9c598d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-bin-1.25.9-3.el10_1.alma.1.aarch64.rpm;name=aarch64_golang-bin;unpack=0"
SRC_URI[aarch64_golang-bin.sha256sum] = "b495da52d906d182c3f998ccaf6535852b7f3978e09ef1105c9e7a4ca7835a6e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-docs-1.25.9-3.el10_1.alma.1.noarch.rpm;name=aarch64_golang-docs;unpack=0"
SRC_URI[aarch64_golang-docs.sha256sum] = "de07ac1ccba557b72d716728f654475ef556ae4b189138f2a4f00e08aec2094c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-misc-1.25.9-3.el10_1.alma.1.noarch.rpm;name=aarch64_golang-misc;unpack=0"
SRC_URI[aarch64_golang-misc.sha256sum] = "8eaa33130ec0a0a1c5d0c7b06afbb2299e232d345844c2a1cb4280f88c4ed9bc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-race-1.25.9-3.el10_1.alma.1.aarch64.rpm;name=aarch64_golang-race;unpack=0"
SRC_URI[aarch64_golang-race.sha256sum] = "9e759e46e2f18b858f0e8411c16906697e8db8dd2770081bfe008b229b5ad876"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-src-1.25.9-3.el10_1.alma.1.noarch.rpm;name=aarch64_golang-src;unpack=0"
SRC_URI[aarch64_golang-src.sha256sum] = "4a77c44fdc29a841743d7cabb21367676ea4b5bf4a90494bad2d0b07220e73d9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-tests-1.25.9-3.el10_1.alma.1.noarch.rpm;name=aarch64_golang-tests;unpack=0"
SRC_URI[aarch64_golang-tests.sha256sum] = "d4c3eac56d1508fa6aeeac85e1523da2412eb809ddd2e93943dca41f7bc0d8e6"
RPROVIDES:golang-tests:append:aarch64 = " virtual/libtiffxx.so.6___64bit_"

RDEPENDS:go-toolset = " \
 delve \
 golang \
 "
RDEPENDS:golang = " \
 golang-bin \
 golang-race \
 golang-src \
 openssl-devel \
 "
RDEPENDS:golang-bin = " \
 alternatives \
 bash \
 gcc \
 glibc \
 golang \
 "
RDEPENDS:golang-docs = " \
 golang \
 "
RDEPENDS:golang-misc = " \
 golang \
 "
RDEPENDS:golang-race = " \
 golang \
 "
RDEPENDS:golang-src = " \
 "
RDEPENDS:golang-tests = " \
 golang \
 "
