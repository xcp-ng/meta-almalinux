# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shaderc"
PV = "2025.2"
PR = "1.el10"
PACKAGES = " \
 glslc \
 libshaderc \
 libshaderc-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/shaderc-2025.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bcb91ce3769a108bd8f5bbbdd2a1f0f34e64fb560718cff89868cd4874317e7"

URI_x86_64_v2_glslc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glslc-2025.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_glslc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glslc}"
SRC_URI[x86_64_v2_glslc.sha256sum] = "e3f37faa79e3d8fff3c75e90fda1d3d347879af1d462a5f792776c1f9a97b094"

URI_x86_64_v2_libshaderc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libshaderc-2025.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libshaderc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshaderc}"
SRC_URI[x86_64_v2_libshaderc.sha256sum] = "b824178b8076131c1204695009d75bb4ef2279958e93445f82649536df562cc5"

URI_x86_64_v2_libshaderc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libshaderc-devel-2025.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_libshaderc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libshaderc-devel}"
SRC_URI[x86_64_v2_libshaderc-devel.sha256sum] = "cc1fb547d499cb798110d4c6259a89809bfb9938f35646c5d94a2b2f59404f39"

URI_aarch64_glslc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glslc-2025.2-1.el10.aarch64.rpm;name=aarch64_glslc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glslc}"
SRC_URI[aarch64_glslc.sha256sum] = "fd21909b1d00818fa69a2573668070955bf2a9ef7cb6ac3beb58017914a22f94"

URI_aarch64_libshaderc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libshaderc-2025.2-1.el10.aarch64.rpm;name=aarch64_libshaderc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshaderc}"
SRC_URI[aarch64_libshaderc.sha256sum] = "5e13d89adbbfc7282b734c2cb36a00f98c1e24a829a8581919fb2fc8f04ccc61"

URI_aarch64_libshaderc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libshaderc-devel-2025.2-1.el10.aarch64.rpm;name=aarch64_libshaderc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libshaderc-devel}"
SRC_URI[aarch64_libshaderc-devel.sha256sum] = "df57a9b558b563018dfcfa57ae7fe62c294754cab123f886ecd2fe4764fb1a17"

RDEPENDS:glslc = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:libshaderc = " \
 glibc \
 libgcc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:libshaderc-devel = " \
 libshaderc \
 pkgconf-pkg-config \
 "
