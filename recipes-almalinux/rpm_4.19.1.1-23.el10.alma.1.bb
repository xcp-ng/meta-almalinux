# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm"
PV = "4.19.1.1"
PR = "23.el10.alma.1"
PACKAGES = " \
 python3-rpm \
 rpm \
 rpm-apidocs \
 rpm-build \
 rpm-build-libs \
 rpm-cron \
 rpm-devel \
 rpm-libs \
 rpm-plugin-audit \
 rpm-plugin-dbus-announce \
 rpm-plugin-fapolicyd \
 rpm-plugin-ima \
 rpm-plugin-selinux \
 rpm-plugin-syslog \
 rpm-plugin-systemd-inhibit \
 rpm-sign \
 rpm-sign-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rpm-4.19.1.1-23.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f97b7e98fcd3ba1604f4b6179e784bc5d71937da7caa2b28a556a98d75bb33c4"

URI_x86_64_v2_python3-rpm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-rpm-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpm}"
SRC_URI[x86_64_v2_python3-rpm.sha256sum] = "495b979bbd91a36239867c202a797ce971b993f05fcb405d5f31de9144e76849"

URI_x86_64_v2_rpm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm}"
SRC_URI[x86_64_v2_rpm.sha256sum] = "ff5a667c88e7f5c9bb47b0d9e800c378ea5bb57c916b1db6211a1190ae235153"

URI_x86_64_v2_rpm-apidocs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-apidocs-4.19.1.1-23.el10.alma.1.noarch.rpm;name=x86_64_v2_rpm-apidocs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-apidocs}"
SRC_URI[x86_64_v2_rpm-apidocs.sha256sum] = "4ef10edaa72276e471987a07315e128b2efe98dc4c7d686c613997fd8529225e"

URI_x86_64_v2_rpm-build = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-build-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-build}"
SRC_URI[x86_64_v2_rpm-build.sha256sum] = "8743914cda1e169865792fbfa115f04d9523115bed86613255e6b8ed2479814e"

URI_x86_64_v2_rpm-build-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-build-libs-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-build-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-build-libs}"
SRC_URI[x86_64_v2_rpm-build-libs.sha256sum] = "0dd6c3ff95ce85eaab0c35befb67209ba4c44c8ef1fa26976a3a6a5ad4b68ffc"

URI_x86_64_v2_rpm-cron = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-cron-4.19.1.1-23.el10.alma.1.noarch.rpm;name=x86_64_v2_rpm-cron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-cron}"
SRC_URI[x86_64_v2_rpm-cron.sha256sum] = "fc33a6cb752e38b43972c87d103c6d1f26232cd13ce67a0d33bfa265140ce74d"

URI_x86_64_v2_rpm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-devel-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-devel}"
SRC_URI[x86_64_v2_rpm-devel.sha256sum] = "5cabd6e2dad36e85ff1ae298094c3b6846a97da515b3e32833dc47956da89977"

URI_x86_64_v2_rpm-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-libs-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-libs}"
SRC_URI[x86_64_v2_rpm-libs.sha256sum] = "14bcdd1e669f341d98011269b8b72d840e4167c710c85828f53c2240c4aad15c"

URI_x86_64_v2_rpm-plugin-audit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-plugin-audit-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-audit}"
SRC_URI[x86_64_v2_rpm-plugin-audit.sha256sum] = "3db6811d827901731eb5e84088d6d3bb2f7404a00871b444c5976129f056e0fb"

URI_x86_64_v2_rpm-plugin-dbus-announce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-dbus-announce-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-dbus-announce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-dbus-announce}"
SRC_URI[x86_64_v2_rpm-plugin-dbus-announce.sha256sum] = "0dacc69e34253467f2d5ed14e0ff154c0b99ff0052819e35870b92410d0d243c"

URI_x86_64_v2_rpm-plugin-fapolicyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-fapolicyd-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-fapolicyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-fapolicyd}"
SRC_URI[x86_64_v2_rpm-plugin-fapolicyd.sha256sum] = "f5f4c41032f8d5b30aa533456d949e5b57c349eb228ef779ccfdd524796b5a87"

URI_x86_64_v2_rpm-plugin-ima = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-ima-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-ima;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-ima}"
SRC_URI[x86_64_v2_rpm-plugin-ima.sha256sum] = "51d6f2c3d0446fd4c36efbeaa30bcb15546329d1ab9133c911ad45f0646b9347"

URI_x86_64_v2_rpm-plugin-selinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-plugin-selinux-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-selinux}"
SRC_URI[x86_64_v2_rpm-plugin-selinux.sha256sum] = "e4323e8de14a655181c33340f11fdc2b19ed56b22c38780c84b9b59228171d5a"

URI_x86_64_v2_rpm-plugin-syslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-syslog-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-syslog}"
SRC_URI[x86_64_v2_rpm-plugin-syslog.sha256sum] = "d0baf8ba449ef3145a1bbcd4d2a223bafd6f755d16877a23cf5ad5a95c5e0feb"

URI_x86_64_v2_rpm-plugin-systemd-inhibit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-systemd-inhibit-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-systemd-inhibit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-systemd-inhibit}"
SRC_URI[x86_64_v2_rpm-plugin-systemd-inhibit.sha256sum] = "5afd3adb64828d5fd81d344c9e1975520b00db43aaf7ea7f4df79f43a22485a1"

URI_x86_64_v2_rpm-sign = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sign-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-sign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sign}"
SRC_URI[x86_64_v2_rpm-sign.sha256sum] = "70056d07408d1936e5b9ea3c1963730f96354c3c6110ecaee32a20dc77f8af1f"

URI_x86_64_v2_rpm-sign-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sign-libs-4.19.1.1-23.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-sign-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sign-libs}"
SRC_URI[x86_64_v2_rpm-sign-libs.sha256sum] = "88e6de7d53b83a854d2b999c0bfb7c52ed2ca707d1947f49d0b223219c8d8edc"

URI_aarch64_python3-rpm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-rpm-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_python3-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpm}"
SRC_URI[aarch64_python3-rpm.sha256sum] = "e36848d10314400a7f9e1293e479aaefdd4fcae7884f52fdb5d9e8e455d2833d"

URI_aarch64_rpm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm}"
SRC_URI[aarch64_rpm.sha256sum] = "4bf5bc6286dffecd825e9ba0a8dcce0d54439da03a3c7c5703e46d13eae5fdab"

URI_aarch64_rpm-apidocs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-apidocs-4.19.1.1-23.el10.alma.1.noarch.rpm;name=aarch64_rpm-apidocs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-apidocs}"
SRC_URI[aarch64_rpm-apidocs.sha256sum] = "4ef10edaa72276e471987a07315e128b2efe98dc4c7d686c613997fd8529225e"

URI_aarch64_rpm-build = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-build-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-build}"
SRC_URI[aarch64_rpm-build.sha256sum] = "aaccb6a75045304e3d09bc3566c08462c39d30cf8ea3281dc2a8c62c1e64f809"

URI_aarch64_rpm-build-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-build-libs-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-build-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-build-libs}"
SRC_URI[aarch64_rpm-build-libs.sha256sum] = "38f5575408e098669b773ca1670cc38997f02819e7e1ff388f62710d891b53a5"

URI_aarch64_rpm-cron = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-cron-4.19.1.1-23.el10.alma.1.noarch.rpm;name=aarch64_rpm-cron;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-cron}"
SRC_URI[aarch64_rpm-cron.sha256sum] = "fc33a6cb752e38b43972c87d103c6d1f26232cd13ce67a0d33bfa265140ce74d"

URI_aarch64_rpm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-devel-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-devel}"
SRC_URI[aarch64_rpm-devel.sha256sum] = "0fbfab5f4ade9458840edf08d713822a4f053d30a2dc0a4bef1570044c3b1021"

URI_aarch64_rpm-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-libs-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-libs}"
SRC_URI[aarch64_rpm-libs.sha256sum] = "1f61b2dce8db0fab8c3e0032606fefa62c8c5d546dc9eba10cea29a15debbfc8"

URI_aarch64_rpm-plugin-audit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-plugin-audit-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-audit}"
SRC_URI[aarch64_rpm-plugin-audit.sha256sum] = "2abde42b6f5cb1f41447460c07e8e27187bfd06171c1a5b269f74b706ff9087d"

URI_aarch64_rpm-plugin-dbus-announce = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-dbus-announce-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-dbus-announce;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-dbus-announce}"
SRC_URI[aarch64_rpm-plugin-dbus-announce.sha256sum] = "469637996114d25b75945fc4ff020f19a321456ba165319f82b1d4fec96ebd2b"

URI_aarch64_rpm-plugin-fapolicyd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-fapolicyd-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-fapolicyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-fapolicyd}"
SRC_URI[aarch64_rpm-plugin-fapolicyd.sha256sum] = "dff522110c2b28cc087d69f9af7de68c9b70c162cfc90ab571fd5b32dc126472"

URI_aarch64_rpm-plugin-ima = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-ima-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-ima;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-ima}"
SRC_URI[aarch64_rpm-plugin-ima.sha256sum] = "abc44b811496a8b46ed989b65892917509658164800aa619d3cc6c1bb2b4c41a"

URI_aarch64_rpm-plugin-selinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-plugin-selinux-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-selinux}"
SRC_URI[aarch64_rpm-plugin-selinux.sha256sum] = "d3e83c186e38a66a5378c4b5cf933ad5a313f109af3c67bd56575a6a52237e8c"

URI_aarch64_rpm-plugin-syslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-syslog-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-syslog}"
SRC_URI[aarch64_rpm-plugin-syslog.sha256sum] = "ae4060f1283ed2ddee5e0d4d44c132c923ecea724203f114554f737a9e8960be"

URI_aarch64_rpm-plugin-systemd-inhibit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-systemd-inhibit-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-systemd-inhibit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-systemd-inhibit}"
SRC_URI[aarch64_rpm-plugin-systemd-inhibit.sha256sum] = "fafd346aa4cf433a5db6b86f3f455f78ca32a24f16814283556547ac86828744"

URI_aarch64_rpm-sign = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sign-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-sign;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sign}"
SRC_URI[aarch64_rpm-sign.sha256sum] = "09f84af19b5404b051a54e9b60638d66fc131dd7799cb7456789f29662a67a16"

URI_aarch64_rpm-sign-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sign-libs-4.19.1.1-23.el10.alma.1.aarch64.rpm;name=aarch64_rpm-sign-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sign-libs}"
SRC_URI[aarch64_rpm-sign-libs.sha256sum] = "ffe43846199296c5a036f10a8d153dd5182b05a62880929e2cd5d6ac95752ce2"

RDEPENDS:python3-rpm = " \
 glibc \
 python3 \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm = " \
 bash \
 curl \
 findutils \
 glibc \
 libarchive \
 popt \
 rpm-libs \
 sed \
 virtual/coreutils \
 "
RDEPENDS:rpm-apidocs = " \
 "
RDEPENDS:rpm-build = " \
 bash \
 binutils \
 bzip2 \
 cpio \
 debugedit \
 diffutils \
 elfutils \
 elfutils-libelf \
 file \
 findutils \
 gawk \
 glibc \
 grep \
 gzip \
 patch \
 pkgconf-pkg-config \
 popt \
 readline \
 redhat-rpm-config \
 rpm \
 rpm-build-libs \
 rpm-libs \
 sed \
 tar \
 unzip \
 virtual//usr/bin/gdb-add-index \
 xz \
 zstd \
 "
RDEPENDS:rpm-build-libs = " \
 elfutils-libelf \
 elfutils-libs \
 file-libs \
 glibc \
 libcap \
 libgcc \
 libgomp \
 lua-libs \
 popt \
 rpm-libs \
 "
RDEPENDS:rpm-cron = " \
 bash \
 crontabs \
 logrotate \
 rpm \
 "
RDEPENDS:rpm-devel = " \
 cmake-filesystem \
 glibc \
 pkgconf-pkg-config \
 popt \
 popt-devel \
 rpm \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm-libs = " \
 bzip2-libs \
 glibc \
 libacl \
 libcap \
 libzstd \
 lua-libs \
 popt \
 rpm \
 rpm-sequoia \
 sqlite-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:rpm-plugin-audit = " \
 audit-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-dbus-announce = " \
 dbus-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-fapolicyd = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-ima = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-selinux = " \
 glibc \
 libselinux \
 rpm-libs \
 selinux-policy \
 "
RDEPENDS:rpm-plugin-syslog = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-systemd-inhibit = " \
 dbus-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-sign = " \
 glibc \
 popt \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm-sign-libs = " \
 glibc \
 ima-evm-utils \
 popt \
 rpm-libs \
 "
