# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgedit-gfls"
PV = "0.2.1"
PR = "1.el10_1"
PACKAGES = " \
 libgedit-gfls \
 libgedit-gfls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgedit-gfls-0.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8594663d5703316b3074749b19141296f6c2e47328fb994c4ba609c8b3ca86e"

URI_x86_64_v2_libgedit-gfls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-gfls-0.2.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-gfls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-gfls}"
SRC_URI[x86_64_v2_libgedit-gfls.sha256sum] = "e6c3b06efefa8713317d1cf082e4915d49a0c46a46456d4b4884ccc0aa2799aa"

URI_x86_64_v2_libgedit-gfls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-gfls-devel-0.2.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-gfls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-gfls-devel}"
SRC_URI[x86_64_v2_libgedit-gfls-devel.sha256sum] = "f55afa0c77532f46f965e3d3d818d227f16b6676786a4a9e0852edbc407065af"

URI_aarch64_libgedit-gfls = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-gfls-0.2.1-1.el10_1.aarch64.rpm;name=aarch64_libgedit-gfls;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-gfls}"
SRC_URI[aarch64_libgedit-gfls.sha256sum] = "552428c3997b46842dc72c098af89724567db56961855ce984ce1cdf6c22a14b"

URI_aarch64_libgedit-gfls-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-gfls-devel-0.2.1-1.el10_1.aarch64.rpm;name=aarch64_libgedit-gfls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-gfls-devel}"
SRC_URI[aarch64_libgedit-gfls-devel.sha256sum] = "1e6c245a06a06d0584ab8c3edb16a784e623ad7779d55f175c5e1c7984e18788"

RDEPENDS:libgedit-gfls = " \
 glib2 \
 glibc \
 "
RDEPENDS:libgedit-gfls-devel = " \
 glib2-devel \
 libgedit-gfls \
 pkgconf-pkg-config \
 "
