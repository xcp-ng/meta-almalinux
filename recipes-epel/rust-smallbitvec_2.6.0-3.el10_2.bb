# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smallbitvec"
PV = "2.6.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-smallbitvec+default-devel \
 rust-smallbitvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smallbitvec-2.6.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8848326c478e50c6bb3773021129793e68f221d0bd2e0b5d03debfb5385e6a45"

URI_x86_64_v2_rust-smallbitvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallbitvec+default-devel-2.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallbitvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallbitvec+default-devel}"
SRC_URI[x86_64_v2_rust-smallbitvec+default-devel.sha256sum] = "baa9f6e4e0ab58ac80148b39003c0463b19ca068fd3a19ccebc048c5575ac28c"

URI_x86_64_v2_rust-smallbitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smallbitvec-devel-2.6.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smallbitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smallbitvec-devel}"
SRC_URI[x86_64_v2_rust-smallbitvec-devel.sha256sum] = "44c20baa2fea2e576a9bf494adefd62d04d076a12ce22bef1a385cfa5f14b387"

URI_aarch64_rust-smallbitvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallbitvec+default-devel-2.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-smallbitvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallbitvec+default-devel}"
SRC_URI[aarch64_rust-smallbitvec+default-devel.sha256sum] = "757ebb6e45aa60d34455aeb5707051b76b0bc3aea25d93c1a660da91cca93450"

URI_aarch64_rust-smallbitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smallbitvec-devel-2.6.0-3.el10_2.noarch.rpm;name=aarch64_rust-smallbitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smallbitvec-devel}"
SRC_URI[aarch64_rust-smallbitvec-devel.sha256sum] = "703065566dc128248f0d3ccaddcb5c0c102598e7ca7971b8345ed76d58385d63"

RDEPENDS:rust-smallbitvec+default-devel = " \
 cargo \
 rust-smallbitvec-devel \
 "
RDEPENDS:rust-smallbitvec-devel = " \
 cargo \
 rust \
 "
