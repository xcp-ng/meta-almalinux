# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-npu-driver"
PV = "1.32.0"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 intel-npu-driver \
 intel-npu-driver-test \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-npu-driver-1.32.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "982db920ccd1af88e3674881669f431692b3cd7f3a2269ba055efe9c1a0350b3"

URI_x86_64_v2_intel-npu-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-npu-driver-1.32.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-npu-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-npu-driver}"
SRC_URI[x86_64_v2_intel-npu-driver.sha256sum] = "fe04c2287ffe47bb9f960dde815977045d00e547707addf9e7e052df9b658806"

URI_x86_64_v2_intel-npu-driver-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-npu-driver-test-1.32.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-npu-driver-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-npu-driver-test}"
SRC_URI[x86_64_v2_intel-npu-driver-test.sha256sum] = "f95d09d2bd50258817317327d10c210953e74dca8802e5266752b2f5b27b13c2"

RDEPENDS:intel-npu-driver = " \
 glibc \
 libgcc \
 libstdc++ \
 oneapi-level-zero \
 "
RDEPENDS:intel-npu-driver-test = " \
 glibc \
 gmock \
 gtest \
 intel-npu-driver \
 libgcc \
 libstdc++ \
 oneapi-level-zero \
 yaml-cpp \
 "
