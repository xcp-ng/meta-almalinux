# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numactl"
PV = "2.0.19"
PR = "3.el10"
PACKAGES = " \
 numactl \
 numactl-devel \
 numactl-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/numactl-2.0.19-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "706a42a4da79dd43b417f600a473a79eed8b19f572b25cdb726376157297c55b"

URI_x86_64_v2_numactl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numactl-2.0.19-3.el10.x86_64_v2.rpm;name=x86_64_v2_numactl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numactl}"
SRC_URI[x86_64_v2_numactl.sha256sum] = "403ffa010c28ada29a17476f4e5fd5c1524ad52b188d075aba07700399a62a65"

URI_x86_64_v2_numactl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/numactl-devel-2.0.19-3.el10.x86_64_v2.rpm;name=x86_64_v2_numactl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numactl-devel}"
SRC_URI[x86_64_v2_numactl-devel.sha256sum] = "1b2f1994bd804d28a97c7f2d3ded833d6f55d1793f36ff69dd73b6f8a336fe7a"

URI_x86_64_v2_numactl-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numactl-libs-2.0.19-3.el10.x86_64_v2.rpm;name=x86_64_v2_numactl-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numactl-libs}"
SRC_URI[x86_64_v2_numactl-libs.sha256sum] = "63d47a068bbbba6afaa291816b52a01e0b05c376d20da4c712db365514182235"

URI_aarch64_numactl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/numactl-2.0.19-3.el10.aarch64.rpm;name=aarch64_numactl;unpack=0"
SRC_URI:append = " ${URI_aarch64_numactl}"
SRC_URI[aarch64_numactl.sha256sum] = "e0514fc88927b59e83fdf23454ea38cd206765e58f37cade7d2b2deeb6031a05"

URI_aarch64_numactl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/numactl-devel-2.0.19-3.el10.aarch64.rpm;name=aarch64_numactl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_numactl-devel}"
SRC_URI[aarch64_numactl-devel.sha256sum] = "fa3f41bc367058596251a924e6f757edca8fb02ff25a52a8d878a23e5d6f3569"

URI_aarch64_numactl-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/numactl-libs-2.0.19-3.el10.aarch64.rpm;name=aarch64_numactl-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_numactl-libs}"
SRC_URI[aarch64_numactl-libs.sha256sum] = "8960d2b6ab8f03b383d435bd83448797ea03d9c9d24a83142a165e2c3f9fa804"

RDEPENDS:numactl = " \
 glibc \
 numactl-libs \
 "
RDEPENDS:numactl-devel = " \
 numactl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:numactl-libs:x86_64_v2 = " \
 glibc \
"
RDEPENDS:numactl-libs:aarch64 = " \
 glibc \
 libatomic \
"
