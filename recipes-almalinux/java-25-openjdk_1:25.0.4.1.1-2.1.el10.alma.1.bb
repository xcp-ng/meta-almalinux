# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-25-openjdk"
PE = "1"
PV = "25.0.4.1.1"
PR = "2.1.el10.alma.1"
PACKAGES = " \
 java-25-openjdk \
 java-25-openjdk-crypto-adapter \
 java-25-openjdk-crypto-adapter-fastdebug \
 java-25-openjdk-crypto-adapter-slowdebug \
 java-25-openjdk-demo \
 java-25-openjdk-demo-fastdebug \
 java-25-openjdk-demo-slowdebug \
 java-25-openjdk-devel \
 java-25-openjdk-devel-fastdebug \
 java-25-openjdk-devel-slowdebug \
 java-25-openjdk-fastdebug \
 java-25-openjdk-headless \
 java-25-openjdk-headless-fastdebug \
 java-25-openjdk-headless-slowdebug \
 java-25-openjdk-javadoc \
 java-25-openjdk-javadoc-zip \
 java-25-openjdk-jmods \
 java-25-openjdk-jmods-fastdebug \
 java-25-openjdk-jmods-slowdebug \
 java-25-openjdk-slowdebug \
 java-25-openjdk-src \
 java-25-openjdk-src-fastdebug \
 java-25-openjdk-src-slowdebug \
 java-25-openjdk-static-libs \
 java-25-openjdk-static-libs-fastdebug \
 java-25-openjdk-static-libs-slowdebug \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/java-25-openjdk-25.0.4.1.1-2.1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e8afee4dbe05ba5cbade1116ead983af6649121831fa57d35205a234074d1ee0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk.sha256sum] = "75c3a29cbfbde932eddfb3892c92f1606a2ae4a55f588b01732b89830eb86b1f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter.sha256sum] = "391aa4623f41b3565faca59626d71c62a3c079d61be24a9a1fa608119d528b76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-fastdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter-fastdebug.sha256sum] = "44998a4f1da3ba3b636a97b28056066c9be102ce054d204b5933724dfbc2966c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-crypto-adapter-slowdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-crypto-adapter-slowdebug.sha256sum] = "77d8fdee43adf8f95561659b411e41f6c9469efa3f6b3212f4ac4756b7ee9e81"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-demo-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-demo.sha256sum] = "0db3217e938c298074495f4d116598be2d195237c4d207c609d9651e56bf8c2a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-demo-fastdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-demo-fastdebug.sha256sum] = "658208665c1c957f754b9cef490ef47aa4c47532475ccea45bbf2f20da0651ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-demo-slowdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-demo-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-demo-slowdebug.sha256sum] = "377959e36993c79fedfb202527b8e6da50afb1d4e06ba6e8a59eb5f79b8e001f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-devel-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-devel.sha256sum] = "85f2f7bbae820da05ad934f544c6ad094a7022d7c2ea1fa0c02cbe43314f2e7d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-devel-fastdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-devel-fastdebug.sha256sum] = "9a544509be47ef73c47f47c5c09941e133921373b0a447ec2ed8a02d8f318921"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-devel-slowdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-devel-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-devel-slowdebug.sha256sum] = "3a27af3e50522d51434c9ac81470e25f5865cf45ce66e5540c56bb8783dfd8a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-fastdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-fastdebug.sha256sum] = "f72168b397fcbbff0dd894a3230c47eaa2ebcee852e9ca490e8f17840765ea24"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-headless-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-headless.sha256sum] = "34aab2369d728098f0d15f0f7de8c6bb5f9864b5e0d75072f920b6b3aeeeddb9"
RPROVIDES:java-25-openjdk-headless:append:x86_64_v2 = " virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-headless-fastdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-headless-fastdebug.sha256sum] = "392102e42976a8fd7c57542b3d09ae84280ba2525bbc735e33b36a044894a9b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-headless-slowdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-headless-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-headless-slowdebug.sha256sum] = "3efa8030ba5c647ccfa06a3a9277a68f1c2c60474e2b9328b4538a513c9cf6ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-javadoc-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-javadoc;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-javadoc.sha256sum] = "6d8666ea5288f6ac36dda1c94e0b9a47af1c486c4bd52e1ca77faff121f5d7db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-javadoc-zip-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-javadoc-zip;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-javadoc-zip.sha256sum] = "5340f1ebeab3d2ae5f05011f52587237fecf2a5e9478e63b3dd213746eb923d0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-jmods-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-jmods.sha256sum] = "207fb6edf35b2185ae1d3946dc1171c8675a35065cc98f0c0722973422a10756"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-jmods-fastdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-jmods-fastdebug.sha256sum] = "00f19e8d0820ca7ca8f821d228f08c4bd2c0ba1c7761f28ae36bf1aa20290ec3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-jmods-slowdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-jmods-slowdebug.sha256sum] = "33f992265203bb6727781d2aa5ffa3cbc8b5420e08a1ec289772b2d4c545cc39"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-slowdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-slowdebug.sha256sum] = "a3144b35abb46c41dad97817da36eada0f0896cfca9f0c2ce49248e0b0132f25"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-src-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-src.sha256sum] = "541ae807037e5319289aeac1bdaee2eea9aebe4c88cc4754fdb30574c7cb739c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-src-fastdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-src-fastdebug.sha256sum] = "18d364ccb2f62927114e8f6b0b63eac62c28dad1a2698e4323d5532a315dfbc5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-src-slowdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-src-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-src-slowdebug.sha256sum] = "5c161e508138f3839b0ffc3c345e48c353cb71f6e558cd70c4d6e172de35f0bd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-25-openjdk-static-libs-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs.sha256sum] = "de0bcb4d915b7b533c40080cf33df89b2f554c8ffbe2626d07a5538551805a52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-static-libs-fastdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs-fastdebug.sha256sum] = "99e2eb3a7a394d5434d2d3041145df5916369235c4fd84bee6b5c4343052e292"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-25-openjdk-static-libs-slowdebug-25.0.4.1.1-2.1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_java-25-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-25-openjdk-static-libs-slowdebug.sha256sum] = "8a58bec59b3480f69f79a43201b20a991549ad6b37b41a9668cc334a15a9a8f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk;unpack=0"
SRC_URI[aarch64_java-25-openjdk.sha256sum] = "88c480099302afda2013bec3ed2f779a2208bc83d48183b4b819d8e5639fa612"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-crypto-adapter-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter;unpack=0"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter.sha256sum] = "a4906835dbaa10d0b5217b8222a47528334f4ab0cd0bdbf8a6e001e4cfcd1651"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-crypto-adapter-fastdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter-fastdebug.sha256sum] = "404495f85e052b8ae046649fcaa0167fe593a13f8c3b1987af2f54de5ac86997"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-crypto-adapter-slowdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-crypto-adapter-slowdebug.sha256sum] = "e7f9c2fc0db39cfdbf30d4b694a8f7d89c863a086ad5067c7accc955c78f21cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-demo-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-demo;unpack=0"
SRC_URI[aarch64_java-25-openjdk-demo.sha256sum] = "937d57d938b3ed71680e9df237d5807dc729a2876ca9792887d7536b826fbb66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-demo-fastdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-demo-fastdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-demo-fastdebug.sha256sum] = "e98f35443b0eba3bc1f16a0591c42602d1848170f2bffa7fd39b579f79b3eedb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-demo-slowdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-demo-slowdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-demo-slowdebug.sha256sum] = "45c0ca2a2d7c0ec1e1dbd918bcdcdd1c68ce592f3f5ef3a78f915e2a490b0481"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-devel-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-devel;unpack=0"
SRC_URI[aarch64_java-25-openjdk-devel.sha256sum] = "ce60fcfea847677522b8e4486dd5c30682b786187ff0715e3cc5e9eca3be2823"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-devel-fastdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-devel-fastdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-devel-fastdebug.sha256sum] = "94bbfa7c8702a602d609f33d5ca3d95141267a503a6377f1915c58ac4327d5e3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-devel-slowdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-devel-slowdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-devel-slowdebug.sha256sum] = "c916c1cf5814bf6fc42f1db4be5548b5df46d9f8962fb39081ac2154574e2912"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-fastdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-fastdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-fastdebug.sha256sum] = "268cc01d4b554c9bc6b6c55a11f0e31a6c9e377640cfd7437ed02f52f62a6a71"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-headless-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-headless;unpack=0"
SRC_URI[aarch64_java-25-openjdk-headless.sha256sum] = "726fe084a72754c54bacd34f9a8c26e427c8dde7618e9206a4dbf5b36e1a3a33"
RPROVIDES:java-25-openjdk-headless:append:aarch64 = " virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-headless-fastdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-headless-fastdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-headless-fastdebug.sha256sum] = "6725a518d163533c42b4898ecb98c55706c61a03b691a8ffed8a71e0cad9e030"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-headless-slowdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-headless-slowdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-headless-slowdebug.sha256sum] = "b4d3f43237d2c706a94eb0f31e61fc24e88db55a80706caa3548b603551a5fcc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-javadoc-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-javadoc;unpack=0"
SRC_URI[aarch64_java-25-openjdk-javadoc.sha256sum] = "495f954223866281447aaa2dce42f792738ed991899f01896901221b3cc2b6dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-javadoc-zip-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-javadoc-zip;unpack=0"
SRC_URI[aarch64_java-25-openjdk-javadoc-zip.sha256sum] = "160139605127f880e533bfffce1c51f66e61af59718287b6c4cbb1e36508c006"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-jmods-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-jmods;unpack=0"
SRC_URI[aarch64_java-25-openjdk-jmods.sha256sum] = "faa4080184408b054b93fc2d18e2dfd7efea8601c30f9892986b665b8a82501c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-jmods-fastdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-jmods-fastdebug.sha256sum] = "d73c6338e9b74c7e1d9840c1e96cb63af211bf2a424f689ab46de6b145514c0c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-jmods-slowdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-jmods-slowdebug.sha256sum] = "550e77401f134c76a4e8bb83afa2aee1574cddb10da141fb22c5a15040ee4f8b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-slowdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-slowdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-slowdebug.sha256sum] = "d9ffca6aba35a485b553c174808d1e0bfbcabb2ef940bd1d810ae288a6392da5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-src-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-src;unpack=0"
SRC_URI[aarch64_java-25-openjdk-src.sha256sum] = "47733f8bc9f973cc58f2146c22c5b9e739ead97194e83b96266566d1dd38f5c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-src-fastdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-src-fastdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-src-fastdebug.sha256sum] = "55450b359f6fcf94d6c9d7674bb6a90479d16dbb75a3fc6ca43d33699363220a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-src-slowdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-src-slowdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-src-slowdebug.sha256sum] = "41a3c0f4e472337dee9c9a8de07544317d8bde0d032266ab35ee578594020999"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-25-openjdk-static-libs-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs;unpack=0"
SRC_URI[aarch64_java-25-openjdk-static-libs.sha256sum] = "f9a7f754948e2df2026eac4aaae36a85356b5b3066a3557a967c221d42ff8e65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-static-libs-fastdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-static-libs-fastdebug.sha256sum] = "97ed277662fa91f5fb94e7082b3e7cabc0c9f3f3bd934621cc8b7ec519d7c1f5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-25-openjdk-static-libs-slowdebug-25.0.4.1.1-2.1.el10.alma.1.aarch64.rpm;name=aarch64_java-25-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[aarch64_java-25-openjdk-static-libs-slowdebug.sha256sum] = "c8d40e93196e983580045f52622a2da1a7a1397c640ae653f46cfbfc6538d858"

RDEPENDS:java-25-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-crypto-adapter = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-crypto-adapter-fastdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-crypto-adapter-slowdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-25-openjdk-demo = " \
 java-25-openjdk \
 "
RDEPENDS:java-25-openjdk-demo-fastdebug = " \
 java-25-openjdk-fastdebug \
 "
RDEPENDS:java-25-openjdk-demo-slowdebug = " \
 java-25-openjdk-slowdebug \
 "
RDEPENDS:java-25-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk \
 "
RDEPENDS:java-25-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk-fastdebug \
 "
RDEPENDS:java-25-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-25-openjdk-slowdebug \
 "
RDEPENDS:java-25-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter-fastdebug \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-25-openjdk-crypto-adapter-slowdebug \
 javapackages-filesystem \
 lksctp-tools \
 tzdata-java \
 "
RDEPENDS:java-25-openjdk-javadoc = " \
 alternatives \
 bash \
 java-25-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-25-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 java-25-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-25-openjdk-jmods = " \
 java-25-openjdk-devel \
 "
RDEPENDS:java-25-openjdk-jmods-fastdebug = " \
 java-25-openjdk-devel-fastdebug \
 "
RDEPENDS:java-25-openjdk-jmods-slowdebug = " \
 java-25-openjdk-devel-slowdebug \
 "
RDEPENDS:java-25-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-25-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-25-openjdk-src = " \
 java-25-openjdk-headless \
 "
RDEPENDS:java-25-openjdk-src-fastdebug = " \
 java-25-openjdk-headless-fastdebug \
 "
RDEPENDS:java-25-openjdk-src-slowdebug = " \
 java-25-openjdk-headless-slowdebug \
 "
RDEPENDS:java-25-openjdk-static-libs = " \
 java-25-openjdk-devel \
 "
RDEPENDS:java-25-openjdk-static-libs-fastdebug = " \
 java-25-openjdk-devel-fastdebug \
 "
RDEPENDS:java-25-openjdk-static-libs-slowdebug = " \
 java-25-openjdk-devel-slowdebug \
 "
