# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flann"
PV = "1.9.2"
PR = "15.el10_3"
PACKAGES = " \
 flann \
 flann-devel \
 flann-static \
 python3-flann \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/flann-1.9.2-15.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4526203118dc64849e2c43e5d08449d551528f090b7692ab377ab91ea3f7aec7"

URI_x86_64_v2_flann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flann-1.9.2-15.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flann}"
SRC_URI[x86_64_v2_flann.sha256sum] = "229c512c0590bbe222d0b285dc597858372efb60b6f8226b94918e6738d74e8b"

URI_x86_64_v2_flann-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flann-devel-1.9.2-15.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flann-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flann-devel}"
SRC_URI[x86_64_v2_flann-devel.sha256sum] = "3166808091de04b57b27d5f555df89d61f87bc84a27970967443b9a3f45fc3b7"

URI_x86_64_v2_flann-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/flann-static-1.9.2-15.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_flann-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flann-static}"
SRC_URI[x86_64_v2_flann-static.sha256sum] = "8710630148d09c6fcf9e644a1824bc9d39019de36796c2b087a8b94c5495b10e"

URI_x86_64_v2_python3-flann = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flann-1.9.2-15.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-flann;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flann}"
SRC_URI[x86_64_v2_python3-flann.sha256sum] = "402e45e2bc08d3b516de288aa335e6dcef7da28ccd5bd56f1624485ee03d1ba3"

URI_aarch64_flann = "${EPEL_MIRROR}/aarch64/Packages/f/flann-1.9.2-15.el10_3.aarch64.rpm;name=aarch64_flann;unpack=0"
SRC_URI:append = " ${URI_aarch64_flann}"
SRC_URI[aarch64_flann.sha256sum] = "9f838960db84b74eaf9216a9a22c6139985dc09826f7eae5749a59a9b7890551"

URI_aarch64_flann-devel = "${EPEL_MIRROR}/aarch64/Packages/f/flann-devel-1.9.2-15.el10_3.aarch64.rpm;name=aarch64_flann-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_flann-devel}"
SRC_URI[aarch64_flann-devel.sha256sum] = "7da460b9d58d8666b59c023264c1f0bcb650496adedf6d81d376139cf01aec46"

URI_aarch64_flann-static = "${EPEL_MIRROR}/aarch64/Packages/f/flann-static-1.9.2-15.el10_3.aarch64.rpm;name=aarch64_flann-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_flann-static}"
SRC_URI[aarch64_flann-static.sha256sum] = "590d80e1b240019591cea5173b3de7a2a37b94ce9e62707c9c5a293b971faa6b"

URI_aarch64_python3-flann = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flann-1.9.2-15.el10_3.aarch64.rpm;name=aarch64_python3-flann;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flann}"
SRC_URI[aarch64_python3-flann.sha256sum] = "851a2a31f7662b7b4dddb16e20b6f7255ad9821d199e697f6969e35f8f389cb5"

RDEPENDS:flann = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 lz4-libs \
 "
RDEPENDS:flann-devel = " \
 boost-devel \
 cmake-filesystem \
 flann \
 flann-static \
 lz4-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:flann-static = " \
 flann-devel \
 "
RDEPENDS:python3-flann = " \
 flann \
 python3 \
 python3-numpy \
 "
