# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgravatar"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libgravatar \
 libgravatar-devel \
 libgravatar-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgravatar-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19ee211d33dd8cddfd243459f2347ef6aa577ea4a1715eb866ff12361c0d1e3a"

URI_x86_64_v2_libgravatar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar}"
SRC_URI[x86_64_v2_libgravatar.sha256sum] = "f1bb0074bd2a7b16b67aa0b36896fbc095ec55e0c22369d37ed16cffc8920ddc"

URI_x86_64_v2_libgravatar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar-devel}"
SRC_URI[x86_64_v2_libgravatar-devel.sha256sum] = "901228e6baa2d176e805acb354f74c6ff2023e856d39c4dd14cf2dd88d6b1a6b"

URI_x86_64_v2_libgravatar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_libgravatar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar-doc}"
SRC_URI[x86_64_v2_libgravatar-doc.sha256sum] = "014bc89b2749c79fed7b6bc8547b534e1605b0edf56cb46b9e206b5d48ca5061"

URI_aarch64_libgravatar = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libgravatar;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar}"
SRC_URI[aarch64_libgravatar.sha256sum] = "747fcd6548975bd1951ab04af5c6d58f19c93fe30a9184b2fb6ad07505d66892"

URI_aarch64_libgravatar-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libgravatar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar-devel}"
SRC_URI[aarch64_libgravatar-devel.sha256sum] = "4bf325f00b3482d1770f3f768755d1e84c111bcc41f1138c4319d34408b8e718"

URI_aarch64_libgravatar-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_libgravatar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar-doc}"
SRC_URI[aarch64_libgravatar-doc.sha256sum] = "7e73fe2a856a43f465a6ecb538f6544c667f46093578a032aa45dba21fd38bb6"

RDEPENDS:libgravatar = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libgravatar-devel = " \
 cmake-filesystem \
 libgravatar \
 "
RDEPENDS:libgravatar-doc = " \
 "
