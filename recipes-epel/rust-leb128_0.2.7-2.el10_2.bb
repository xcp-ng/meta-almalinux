# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-leb128"
PV = "0.2.7"
PR = "2.el10_2"
PACKAGES = " \
 leb128 \
 rust-leb128+default-devel \
 rust-leb128+nightly-devel \
 rust-leb128-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-leb128-0.2.7-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee0ee23a128392f772dc4e7593f25117db25ed0c7dbee09389d7da8bad80d18f"

URI_x86_64_v2_leb128 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/leb128-0.2.7-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_leb128;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_leb128}"
SRC_URI[x86_64_v2_leb128.sha256sum] = "fe1bf4ab65708a4742519363817bd81998dcc8f2b4917988408d413f6ff49bbf"

URI_x86_64_v2_rust-leb128+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-leb128+default-devel-0.2.7-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-leb128+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-leb128+default-devel}"
SRC_URI[x86_64_v2_rust-leb128+default-devel.sha256sum] = "b08661f44fd64eeda2729c6fc07e2f67dd11995e31c44a9c9db6079454e89b9a"

URI_x86_64_v2_rust-leb128+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-leb128+nightly-devel-0.2.7-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-leb128+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-leb128+nightly-devel}"
SRC_URI[x86_64_v2_rust-leb128+nightly-devel.sha256sum] = "09843a0237baf73ee6c034ba63f54c1c51234de194945f969652f12f64994cf6"

URI_x86_64_v2_rust-leb128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-leb128-devel-0.2.7-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-leb128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-leb128-devel}"
SRC_URI[x86_64_v2_rust-leb128-devel.sha256sum] = "7f015cad986311b07615b39f9aa54f4bc9752e02b38757b6ca3e17baab6bbe36"

URI_aarch64_leb128 = "${EPEL_MIRROR}/aarch64/Packages/l/leb128-0.2.7-2.el10_2.aarch64.rpm;name=aarch64_leb128;unpack=0"
SRC_URI:append = " ${URI_aarch64_leb128}"
SRC_URI[aarch64_leb128.sha256sum] = "2aa96bdeb01f3d86281cd6c1f374c45a8bc91f147069e6cc42f7318717e43866"

URI_aarch64_rust-leb128+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-leb128+default-devel-0.2.7-2.el10_2.noarch.rpm;name=aarch64_rust-leb128+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-leb128+default-devel}"
SRC_URI[aarch64_rust-leb128+default-devel.sha256sum] = "a69728e2168d3949181f6de94e9b4cdf355d20f8531ea6ae61198122e94b9442"

URI_aarch64_rust-leb128+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-leb128+nightly-devel-0.2.7-2.el10_2.noarch.rpm;name=aarch64_rust-leb128+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-leb128+nightly-devel}"
SRC_URI[aarch64_rust-leb128+nightly-devel.sha256sum] = "72e0b0156db4afbe94a0c0a5025855fd7d573f27ff9414ab0fccc1bc506adbfe"

URI_aarch64_rust-leb128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-leb128-devel-0.2.7-2.el10_2.noarch.rpm;name=aarch64_rust-leb128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-leb128-devel}"
SRC_URI[aarch64_rust-leb128-devel.sha256sum] = "aa953c52dc05d1014870812eb742ca972ad302864dd89af12a5d00bb0dc392af"

RDEPENDS:leb128 = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-leb128+default-devel = " \
 cargo \
 rust-leb128-devel \
 "
RDEPENDS:rust-leb128+nightly-devel = " \
 cargo \
 rust-leb128-devel \
 "
RDEPENDS:rust-leb128-devel = " \
 cargo \
 "
