# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fasteners"
PV = "0.19"
PR = "9.el10_0"
PACKAGES = " \
 python3-fasteners \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fasteners-0.19-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b72d56dc41b4944a524c06b4d54bfe53bb98e90c2ea3fbf1a678f6085acd7cd"

URI_x86_64_v2_python3-fasteners = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fasteners-0.19-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fasteners;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fasteners}"
SRC_URI[x86_64_v2_python3-fasteners.sha256sum] = "aa3dcaecd790aba6eaf533953a072a42098889dfdbdcfcad5b2c3ffee2eba0c2"

URI_aarch64_python3-fasteners = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fasteners-0.19-9.el10_0.noarch.rpm;name=aarch64_python3-fasteners;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fasteners}"
SRC_URI[aarch64_python3-fasteners.sha256sum] = "7fb5592416eb62bdda49b3ff0333078d72dd538048c9ee752e7c98a63a5d4e88"

RDEPENDS:python3-fasteners = " \
 python3 \
 "
