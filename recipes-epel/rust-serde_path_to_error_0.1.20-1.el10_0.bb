# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_path_to_error"
PV = "0.1.20"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_path_to_error+default-devel \
 rust-serde_path_to_error-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_path_to_error-0.1.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c19238fe0d05ce3e5622db58d7a2662f5295989ea35975d1263c3e22458f48d5"

URI_x86_64_v2_rust-serde_path_to_error+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_path_to_error+default-devel-0.1.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_path_to_error+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_path_to_error+default-devel}"
SRC_URI[x86_64_v2_rust-serde_path_to_error+default-devel.sha256sum] = "790e2f1c7f35a369599bb3b72ac59afad1eef8101f6c4f8de56f68b181b37e2e"

URI_x86_64_v2_rust-serde_path_to_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_path_to_error-devel-0.1.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_path_to_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_path_to_error-devel}"
SRC_URI[x86_64_v2_rust-serde_path_to_error-devel.sha256sum] = "20783cf8d3aa7fa7823254db558a6c7f2525df3a0feae2574ef48feb6916f0a4"

URI_aarch64_rust-serde_path_to_error+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_path_to_error+default-devel-0.1.20-1.el10_0.noarch.rpm;name=aarch64_rust-serde_path_to_error+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_path_to_error+default-devel}"
SRC_URI[aarch64_rust-serde_path_to_error+default-devel.sha256sum] = "edcb701531c5af5a06bedfaa9396a3534bea8b674fcade47cfe43f05e7d5d86d"

URI_aarch64_rust-serde_path_to_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_path_to_error-devel-0.1.20-1.el10_0.noarch.rpm;name=aarch64_rust-serde_path_to_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_path_to_error-devel}"
SRC_URI[aarch64_rust-serde_path_to_error-devel.sha256sum] = "b8c6fc23b38a45fdc256b5f75af275df02c49596fdb015093ec7fac6a8778e01"

RDEPENDS:rust-serde_path_to_error+default-devel = " \
 cargo \
 rust-serde_path_to_error-devel \
 "
RDEPENDS:rust-serde_path_to_error-devel = " \
 cargo \
 rust \
 rust-itoa+default-devel \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
