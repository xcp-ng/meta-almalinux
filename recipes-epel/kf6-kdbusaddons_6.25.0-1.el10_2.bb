# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdbusaddons"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kdbusaddons \
 kf6-kdbusaddons-devel \
 kf6-kdbusaddons-doc \
 kf6-kdbusaddons-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdbusaddons-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74886d67803ca8de6ef474a0863b810a7e7338cf8d1ac2fe8922c00dfd968dd3"

URI_x86_64_v2_kf6-kdbusaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons}"
SRC_URI[x86_64_v2_kf6-kdbusaddons.sha256sum] = "d677fba47dd20c55f160d1eecdcbb1f02a38864f602dc29651ca660c928082f7"

URI_x86_64_v2_kf6-kdbusaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdbusaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-devel}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-devel.sha256sum] = "9c8bb4a65b1ff26f3588b4e3297349b6dbe909591b64ca2abccbebf46e804048"

URI_x86_64_v2_kf6-kdbusaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdbusaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-doc}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-doc.sha256sum] = "1dc7741739fd41c59ee15dcea8b4fbf35a928133b8a0c039aca931b3701db4a4"

URI_x86_64_v2_kf6-kdbusaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdbusaddons-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdbusaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdbusaddons-html}"
SRC_URI[x86_64_v2_kf6-kdbusaddons-html.sha256sum] = "451e378ead0f30787b85df0f33126dab02634833477c55ef80dd5ec600fefb21"

URI_aarch64_kf6-kdbusaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdbusaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons}"
SRC_URI[aarch64_kf6-kdbusaddons.sha256sum] = "cce5e18062f5b80645596811b870294d986356a30595be15500b8c83d7e63f28"

URI_aarch64_kf6-kdbusaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdbusaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-devel}"
SRC_URI[aarch64_kf6-kdbusaddons-devel.sha256sum] = "ddf25e202d0e8dd206a127552b5d25158473ce9af1d61ccda26333fdc30f4e76"

URI_aarch64_kf6-kdbusaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdbusaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-doc}"
SRC_URI[aarch64_kf6-kdbusaddons-doc.sha256sum] = "d4b8ec5cb432378ce3428a8c215c53098757929297c749b9781fef2ff8d85122"

URI_aarch64_kf6-kdbusaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdbusaddons-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdbusaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdbusaddons-html}"
SRC_URI[aarch64_kf6-kdbusaddons-html.sha256sum] = "e31dd5bb478e7eeee0d925245dfc38a5031972afb5f4577694a0b377862f226d"

RDEPENDS:kf6-kdbusaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdbusaddons-devel = " \
 cmake-filesystem \
 kf6-kdbusaddons \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdbusaddons-doc = " \
 "
RDEPENDS:kf6-kdbusaddons-html = " \
 "
