# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-split"
PV = "0.2.5"
PR = "1.el10_0"
PACKAGES = " \
 ghc-split \
 ghc-split-devel \
 ghc-split-doc \
 ghc-split-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-split-0.2.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2626d0247073a009ac2bde7e20fba35a8d4852fce668e3462037286ce5c50c8"

URI_x86_64_v2_ghc-split = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-split-0.2.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-split;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-split}"
SRC_URI[x86_64_v2_ghc-split.sha256sum] = "9a27f9e26c61a58c51bf13b82b4e293dce7e150f209c7d7e3e5977eaf193508b"

URI_x86_64_v2_ghc-split-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-split-devel-0.2.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-split-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-split-devel}"
SRC_URI[x86_64_v2_ghc-split-devel.sha256sum] = "2bfbe2ecd37503107abed4b2dfa41688cf756c9428f4633bc41486bb343b51e7"

URI_x86_64_v2_ghc-split-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-split-doc-0.2.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-split-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-split-doc}"
SRC_URI[x86_64_v2_ghc-split-doc.sha256sum] = "4b2db927006a34833b050457849b077119d4825ff5c543664ed782c5c138153b"

URI_x86_64_v2_ghc-split-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-split-prof-0.2.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-split-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-split-prof}"
SRC_URI[x86_64_v2_ghc-split-prof.sha256sum] = "7ce044447b82542bbafcf3155689634fb213e1f7504804f43872a3879f0d24b1"

URI_aarch64_ghc-split = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-split-0.2.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-split;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-split}"
SRC_URI[aarch64_ghc-split.sha256sum] = "5731285161cef52db3f605e59d50c8c22f7c981696cc63453e9eb1180843e9d9"

URI_aarch64_ghc-split-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-split-devel-0.2.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-split-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-split-devel}"
SRC_URI[aarch64_ghc-split-devel.sha256sum] = "91cc0b05a695243d790b6cdcf38d74487e8a7005bb6783939311d11210c84994"

URI_aarch64_ghc-split-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-split-doc-0.2.5-1.el10_0.noarch.rpm;name=aarch64_ghc-split-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-split-doc}"
SRC_URI[aarch64_ghc-split-doc.sha256sum] = "ab7433d86c545c4496791a84a7419122b89f0c167a99a1775e44cfcf6ff75cac"

URI_aarch64_ghc-split-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-split-prof-0.2.5-1.el10_0.aarch64.rpm;name=aarch64_ghc-split-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-split-prof}"
SRC_URI[aarch64_ghc-split-prof.sha256sum] = "0c4b41f6200426f2e95f21af8ace6f9113ac54ed4f4ba6e9bda8166877b6f42f"

RDEPENDS:ghc-split = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-split-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-split \
 "
RDEPENDS:ghc-split-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-split-prof = " \
 ghc-base-prof \
 ghc-split-devel \
 "
