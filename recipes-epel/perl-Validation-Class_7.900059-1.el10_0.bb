# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Validation-Class"
PV = "7.900059"
PR = "1.el10_0"
PACKAGES = " \
 perl-Validation-Class \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Validation-Class-7.900059-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4161a5487f17a83d54ba34fed2ee109bead5b3ed4fa2849c333e44d580354d48"

URI_x86_64_v2_perl-Validation-Class = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Validation-Class-7.900059-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Validation-Class;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Validation-Class}"
SRC_URI[x86_64_v2_perl-Validation-Class.sha256sum] = "bfb6e3e6f273851686ff4471eca7fad04e641bc8b4d06eeccc5fdd2fc347df1b"

URI_aarch64_perl-Validation-Class = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Validation-Class-7.900059-1.el10_0.noarch.rpm;name=aarch64_perl-Validation-Class;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Validation-Class}"
SRC_URI[aarch64_perl-Validation-Class.sha256sum] = "db028f8574663a2290f5fe1f0e8b48e849bc5329f6cb1c50c842abd5157b0be3"

RDEPENDS:perl-Validation-Class = " \
 perl-Carp \
 perl-Clone \
 perl-Exporter \
 perl-Hash-Flatten \
 perl-Hash-Merge \
 perl-List-MoreUtils \
 perl-Module-Find \
 perl-Module-Runtime \
 perl-Scalar-List-Utils \
 perl-Validation-Class \
 perl-base \
 perl-libs \
 perl-overload \
 "
