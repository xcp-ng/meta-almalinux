# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cryptonite-conduit"
PV = "0.2.2"
PR = "32.el10_0"
PACKAGES = " \
 ghc-cryptonite-conduit \
 ghc-cryptonite-conduit-devel \
 ghc-cryptonite-conduit-doc \
 ghc-cryptonite-conduit-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cryptonite-conduit-0.2.2-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a8f9e8b7b18523e52b0aae07f974839e8a1731547072d8795232451ea0391a7"

URI_x86_64_v2_ghc-cryptonite-conduit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptonite-conduit-0.2.2-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptonite-conduit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptonite-conduit}"
SRC_URI[x86_64_v2_ghc-cryptonite-conduit.sha256sum] = "4986fe841e45cf592411e044aebb3cd128d6beacb024923217c263d104eb1e2c"

URI_x86_64_v2_ghc-cryptonite-conduit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptonite-conduit-devel-0.2.2-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptonite-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptonite-conduit-devel}"
SRC_URI[x86_64_v2_ghc-cryptonite-conduit-devel.sha256sum] = "2a04ca53e58565429cb8df11bac59565af2d333e21e2f48a51414b3a36468608"

URI_x86_64_v2_ghc-cryptonite-conduit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptonite-conduit-doc-0.2.2-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cryptonite-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptonite-conduit-doc}"
SRC_URI[x86_64_v2_ghc-cryptonite-conduit-doc.sha256sum] = "5314940ca84475824ac31e0737d7f9674026944adc56dce36329065a8edff9ca"

URI_x86_64_v2_ghc-cryptonite-conduit-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptonite-conduit-prof-0.2.2-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptonite-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptonite-conduit-prof}"
SRC_URI[x86_64_v2_ghc-cryptonite-conduit-prof.sha256sum] = "4779e8840906356a6e4c474a56dba3c20fe0a22d53edaecf3368571b6ad88775"

URI_aarch64_ghc-cryptonite-conduit = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptonite-conduit-0.2.2-32.el10_0.aarch64.rpm;name=aarch64_ghc-cryptonite-conduit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptonite-conduit}"
SRC_URI[aarch64_ghc-cryptonite-conduit.sha256sum] = "061c9eb84fcdbded0d8beec6c97f3b0a8f1b41e8c4126027e0aefa3d1c2549ac"

URI_aarch64_ghc-cryptonite-conduit-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptonite-conduit-devel-0.2.2-32.el10_0.aarch64.rpm;name=aarch64_ghc-cryptonite-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptonite-conduit-devel}"
SRC_URI[aarch64_ghc-cryptonite-conduit-devel.sha256sum] = "3e46330306fb0cdc6ecdb81f36cc8a5613605ee28f77c95439622928930809ef"

URI_aarch64_ghc-cryptonite-conduit-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptonite-conduit-doc-0.2.2-32.el10_0.noarch.rpm;name=aarch64_ghc-cryptonite-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptonite-conduit-doc}"
SRC_URI[aarch64_ghc-cryptonite-conduit-doc.sha256sum] = "bf51e4a74e1cfd9d475fa49bb7a7070525c28fba15499ebd672b7940f0b0dab9"

URI_aarch64_ghc-cryptonite-conduit-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptonite-conduit-prof-0.2.2-32.el10_0.aarch64.rpm;name=aarch64_ghc-cryptonite-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptonite-conduit-prof}"
SRC_URI[aarch64_ghc-cryptonite-conduit-prof.sha256sum] = "71af4233e71c0848a3e869f8bf5e92c93a19a408e2118603adba5754450ae59c"

RDEPENDS:ghc-cryptonite-conduit = " \
 ghc-array \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-basement \
 ghc-binary \
 ghc-bitvec \
 ghc-bytestring \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-cryptonite \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-memory \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-cryptonite-conduit-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-conduit-extra-devel \
 ghc-cryptonite-conduit \
 ghc-cryptonite-devel \
 ghc-exceptions-devel \
 ghc-memory-devel \
 ghc-resourcet-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-cryptonite-conduit-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cryptonite-conduit-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-conduit-extra-prof \
 ghc-conduit-prof \
 ghc-cryptonite-conduit-devel \
 ghc-cryptonite-prof \
 ghc-exceptions-prof \
 ghc-memory-prof \
 ghc-resourcet-prof \
 ghc-transformers-prof \
 "
