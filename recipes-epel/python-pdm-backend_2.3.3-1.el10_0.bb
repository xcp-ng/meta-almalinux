# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pdm-backend"
PV = "2.3.3"
PR = "1.el10_0"
PACKAGES = " \
 python3-pdm-backend \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pdm-backend-2.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad20c58d447326fd588e2e81060768bcc9e5ca68611550ea5629f3990cfe6ff4"

URI_x86_64_v2_python3-pdm-backend = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pdm-backend-2.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pdm-backend;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pdm-backend}"
SRC_URI[x86_64_v2_python3-pdm-backend.sha256sum] = "909a730b6a8bad9b850c4f8b9b1f841be6fcfe77703879a4543e7f44d82c6050"

URI_aarch64_python3-pdm-backend = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pdm-backend-2.3.3-1.el10_0.noarch.rpm;name=aarch64_python3-pdm-backend;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pdm-backend}"
SRC_URI[aarch64_python3-pdm-backend.sha256sum] = "f2276af7bbd07f68bfbb96045681cc35f221fb71261e20fa5300289f613ccf4f"

RDEPENDS:python3-pdm-backend = " \
 python3 \
 python3-editables \
 python3-packaging \
 python3-pyproject-metadata \
 python3-tomli-w \
 "
