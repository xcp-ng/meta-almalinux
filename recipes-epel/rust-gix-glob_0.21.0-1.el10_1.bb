# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-glob"
PV = "0.21.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-glob+default-devel \
 rust-gix-glob+document-features-devel \
 rust-gix-glob+serde-devel \
 rust-gix-glob-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-glob-0.21.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d33372c8a7960d7a042f0498d097995f69b2ff16916f3a6c447e556fd9cc6a93"

URI_x86_64_v2_rust-gix-glob+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+default-devel-0.21.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob+default-devel}"
SRC_URI[x86_64_v2_rust-gix-glob+default-devel.sha256sum] = "538244f1a9c25cd9766985c269625425e55a5099e2372120e33a46515f49c018"

URI_x86_64_v2_rust-gix-glob+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+document-features-devel-0.21.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-glob+document-features-devel.sha256sum] = "3bb8d0125b903d72303f200d98509d1b1aba56db5382a5509ee3d0440be0b7de"

URI_x86_64_v2_rust-gix-glob+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob+serde-devel-0.21.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-glob+serde-devel.sha256sum] = "b0888844a20574c8f790914ce6aeda81b7acb9cca8f30f65f73f45748322387c"

URI_x86_64_v2_rust-gix-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-glob-devel-0.21.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-glob-devel}"
SRC_URI[x86_64_v2_rust-gix-glob-devel.sha256sum] = "a9e2e87269e4bf1303a0bfce4bb7f622fe2c2a62b31d7270568604aab24e5118"

URI_aarch64_rust-gix-glob+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+default-devel-0.21.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob+default-devel}"
SRC_URI[aarch64_rust-gix-glob+default-devel.sha256sum] = "22543f72d410f5db3e74803cdc903abcfb8c33b9677b03c298e0b1ed74593a12"

URI_aarch64_rust-gix-glob+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+document-features-devel-0.21.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-glob+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob+document-features-devel}"
SRC_URI[aarch64_rust-gix-glob+document-features-devel.sha256sum] = "7907bc4f36c330a923d8fad286fe00f7cf6213702361df074de82d2eaa7d2814"

URI_aarch64_rust-gix-glob+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob+serde-devel-0.21.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-glob+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob+serde-devel}"
SRC_URI[aarch64_rust-gix-glob+serde-devel.sha256sum] = "6c98c500c5286692ae1ef28d4ed6812164e73e497b1fab962fe8528d106e987d"

URI_aarch64_rust-gix-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-glob-devel-0.21.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-glob-devel}"
SRC_URI[aarch64_rust-gix-glob-devel.sha256sum] = "3acb6ef49978d341781ca7606687ebe5ee0a883b107da5523be96ee3fe8d0b3d"

RDEPENDS:rust-gix-glob+default-devel = " \
 cargo \
 rust-gix-glob-devel \
 "
RDEPENDS:rust-gix-glob+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-glob-devel \
 "
RDEPENDS:rust-gix-glob+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-bstr+serde-devel \
 rust-gix-glob-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-glob-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-path+default-devel \
 "
