# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "usermode"
PV = "1.114"
PR = "12.el10"
PACKAGES = " \
 usermode \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/usermode-1.114-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d768b636bf852d61e2de98966abf68a80f2d3ccbade37318a0daaec3dcb73db"

URI_x86_64_v2_usermode = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/usermode-1.114-12.el10.x86_64_v2.rpm;name=x86_64_v2_usermode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_usermode}"
SRC_URI[x86_64_v2_usermode.sha256sum] = "7ed48a9080a48cccfc0bc20d0d1c60a2a4c73060f10dd68fb5e2a4929e0b8629"

URI_aarch64_usermode = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/usermode-1.114-12.el10.aarch64.rpm;name=aarch64_usermode;unpack=0"
SRC_URI:append = " ${URI_aarch64_usermode}"
SRC_URI[aarch64_usermode.sha256sum] = "6215637e19d4aa288446f12538c60144c61681fc2a907a10ca5df1a28cadd3dc"

RDEPENDS:usermode = " \
 glib2 \
 glibc \
 libselinux \
 libuser \
 pam \
 pam-libs \
 shadow-utils \
 util-linux \
 "
