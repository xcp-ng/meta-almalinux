# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zile"
PV = "2.6.4"
PR = "1.el10_2"
PACKAGES = " \
 zile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zile-2.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a183dfc9b15126433704405221ace0edf2feb759975477baaa0a3d9e62eedff5"

URI_x86_64_v2_zile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zile-2.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zile}"
SRC_URI[x86_64_v2_zile.sha256sum] = "adb76963c739639ae9bcc1c6e0fbd88d4cae8707429ccd16c75ea34d3b88dcdc"

URI_aarch64_zile = "${EPEL_MIRROR}/aarch64/Packages/z/zile-2.6.4-1.el10_2.aarch64.rpm;name=aarch64_zile;unpack=0"
SRC_URI:append = " ${URI_aarch64_zile}"
SRC_URI[aarch64_zile.sha256sum] = "bd293552d44fc9e16fff2f2d2c332647fb4b54e069af09deb1efb1da89523b62"

RDEPENDS:zile = " \
 glib2 \
 glibc \
 libgee \
 ncurses-libs \
 "
