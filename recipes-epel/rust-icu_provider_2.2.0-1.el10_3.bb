# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_provider"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_provider+alloc-devel \
 rust-icu_provider+baked-devel \
 rust-icu_provider+default-devel \
 rust-icu_provider+deserialize_bincode_1-devel \
 rust-icu_provider+deserialize_json-devel \
 rust-icu_provider+deserialize_postcard_1-devel \
 rust-icu_provider+export-devel \
 rust-icu_provider+logging-devel \
 rust-icu_provider+serde-devel \
 rust-icu_provider+std-devel \
 rust-icu_provider+sync-devel \
 rust-icu_provider+zerotrie-devel \
 rust-icu_provider-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_provider-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0cfc40a7f2b72529c4e4acb7d3ef657c39b3469ddecdb1f60104aa08fa4233f"

URI_x86_64_v2_rust-icu_provider+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+alloc-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+alloc-devel.sha256sum] = "374796680fa3e44c395bf9e947513e8aa8ad3ca0368b73e4098af86ee0678ce8"

URI_x86_64_v2_rust-icu_provider+baked-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+baked-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+baked-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+baked-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+baked-devel.sha256sum] = "f4a500bc6454e5be20d011229cd9251de6bc8c00dc2f38261c3be12f4be08ec6"

URI_x86_64_v2_rust-icu_provider+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+default-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+default-devel.sha256sum] = "618801f11d996c180e3e10cba68e0c5ffca2490f7653f729816d33eb71792969"

URI_x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+deserialize_bincode_1-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+deserialize_bincode_1-devel.sha256sum] = "e1ad899d5ec74e1c4f9cc8858ac8c12e94a78deb922f77085df8a7efd35f8669"

URI_x86_64_v2_rust-icu_provider+deserialize_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+deserialize_json-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+deserialize_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+deserialize_json-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+deserialize_json-devel.sha256sum] = "e42e5b8c0d117cf708ff2eec88a28463e7f0fb2918b5c4ddacd3f8f655cedd65"

URI_x86_64_v2_rust-icu_provider+deserialize_postcard_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+deserialize_postcard_1-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+deserialize_postcard_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+deserialize_postcard_1-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+deserialize_postcard_1-devel.sha256sum] = "380b9a8c687ad141c6c489e84ac10fb073eba743503335f302a099785d3d1b9b"

URI_x86_64_v2_rust-icu_provider+export-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+export-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+export-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+export-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+export-devel.sha256sum] = "6c0e63378d091b31407db33ca1ceea346bcad3519b8c66232b658949537c3e6c"

URI_x86_64_v2_rust-icu_provider+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+logging-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+logging-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+logging-devel.sha256sum] = "d666e5a3f50f1bcbd5738aafadaca28c8a869314a57da9d8f4cc326f4b6a7e3a"

URI_x86_64_v2_rust-icu_provider+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+serde-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+serde-devel.sha256sum] = "eae1bc80ba7f366929f5f1db695c1e2923523089476b58919148ae8d7ac4fe20"

URI_x86_64_v2_rust-icu_provider+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+std-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+std-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+std-devel.sha256sum] = "25af4e1679e13b752391c994ede4def96439b861bec40e02146014ef9725d101"

URI_x86_64_v2_rust-icu_provider+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+sync-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+sync-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+sync-devel.sha256sum] = "3b49129e69535841cd339a65632b755344193089f58f2087caf5d0f765130bf0"

URI_x86_64_v2_rust-icu_provider+zerotrie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider+zerotrie-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider+zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider+zerotrie-devel}"
SRC_URI[x86_64_v2_rust-icu_provider+zerotrie-devel.sha256sum] = "8148c8df39bddd10f1dde0a4aa9c41e99459e715952447242b9b5b55daebd2c7"

URI_x86_64_v2_rust-icu_provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_provider-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_provider-devel}"
SRC_URI[x86_64_v2_rust-icu_provider-devel.sha256sum] = "3a81b92e73a8cd7d089ec9fb3962d74af591561e8ddfd180a9171777f1bb4eaa"

URI_aarch64_rust-icu_provider+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+alloc-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+alloc-devel}"
SRC_URI[aarch64_rust-icu_provider+alloc-devel.sha256sum] = "9647265e3911e31385118c58459766aee795fbac2e1afc61beeeb7768251ca2c"

URI_aarch64_rust-icu_provider+baked-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+baked-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+baked-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+baked-devel}"
SRC_URI[aarch64_rust-icu_provider+baked-devel.sha256sum] = "d568bee8d884ae43e3d07f052674e2352599dcc079185f33179429d8cfe3402d"

URI_aarch64_rust-icu_provider+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+default-devel}"
SRC_URI[aarch64_rust-icu_provider+default-devel.sha256sum] = "88023cf0b6105eaa920642605cf99e241e1a1bc8f2f36c502042dfe994d29cf6"

URI_aarch64_rust-icu_provider+deserialize_bincode_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+deserialize_bincode_1-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+deserialize_bincode_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+deserialize_bincode_1-devel}"
SRC_URI[aarch64_rust-icu_provider+deserialize_bincode_1-devel.sha256sum] = "76e02046d0bf271629e4b8cf7474bbfe9b4acc5b3cb42efdf7709dd785c11cc7"

URI_aarch64_rust-icu_provider+deserialize_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+deserialize_json-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+deserialize_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+deserialize_json-devel}"
SRC_URI[aarch64_rust-icu_provider+deserialize_json-devel.sha256sum] = "0fed2a03709b1c74df6aa0bef56ed2a9b1f0f1595d6f7e00b2fcedd20346031e"

URI_aarch64_rust-icu_provider+deserialize_postcard_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+deserialize_postcard_1-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+deserialize_postcard_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+deserialize_postcard_1-devel}"
SRC_URI[aarch64_rust-icu_provider+deserialize_postcard_1-devel.sha256sum] = "e7fe6cd872e75f2acffdccff1e93838ed23a644a4aec72869d99eaf1976ab0d8"

URI_aarch64_rust-icu_provider+export-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+export-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+export-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+export-devel}"
SRC_URI[aarch64_rust-icu_provider+export-devel.sha256sum] = "4f87c8f7dfadcd43b2b3cfa2a8adb5d1dd684439a9a781dc4a5607a7d3718844"

URI_aarch64_rust-icu_provider+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+logging-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+logging-devel}"
SRC_URI[aarch64_rust-icu_provider+logging-devel.sha256sum] = "f7c1efea2388d954cc50ee312513589cfbbc56b0e5ce942776133a4ec5016de8"

URI_aarch64_rust-icu_provider+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+serde-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+serde-devel}"
SRC_URI[aarch64_rust-icu_provider+serde-devel.sha256sum] = "4f0edab8fd2be42a9c1830ea88570e0c99b9441dbbbe35384b410dd4e7ae007b"

URI_aarch64_rust-icu_provider+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+std-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+std-devel}"
SRC_URI[aarch64_rust-icu_provider+std-devel.sha256sum] = "3e926c9af1e1f7df17e4a949ea1a270e97cc62237ad8fcc935debb1502c1d491"

URI_aarch64_rust-icu_provider+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+sync-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+sync-devel}"
SRC_URI[aarch64_rust-icu_provider+sync-devel.sha256sum] = "ff80a10fece87cd5ccd938231112a1606aa9e585a97ec3d9aad7027b709228c5"

URI_aarch64_rust-icu_provider+zerotrie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider+zerotrie-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider+zerotrie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider+zerotrie-devel}"
SRC_URI[aarch64_rust-icu_provider+zerotrie-devel.sha256sum] = "49919d17792ad14628a6f5170e889571adc07891352a38ec6f42efb7d6352bf6"

URI_aarch64_rust-icu_provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_provider-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_provider-devel}"
SRC_URI[aarch64_rust-icu_provider-devel.sha256sum] = "b053b7243be61d2c30d187f31fa090466961bb52a265696c2acac9f359037e40"

RDEPENDS:rust-icu_provider+alloc-devel = " \
 cargo \
 rust-icu_locale_core+alloc-devel \
 rust-icu_provider-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-stable_deref_trait-devel \
 rust-writeable-devel \
 rust-yoke+alloc-devel \
 rust-zerofrom+alloc-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_provider+baked-devel = " \
 cargo \
 rust-icu_provider-devel \
 rust-writeable-devel \
 rust-zerotrie-devel \
 "
RDEPENDS:rust-icu_provider+default-devel = " \
 cargo \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+deserialize_bincode_1-devel = " \
 cargo \
 rust-bincode1+default-devel \
 rust-icu_provider+serde-devel \
 rust-icu_provider+std-devel \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+deserialize_json-devel = " \
 cargo \
 rust-icu_provider+serde-devel \
 rust-icu_provider-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-icu_provider+deserialize_postcard_1-devel = " \
 cargo \
 rust-icu_provider+serde-devel \
 rust-icu_provider-devel \
 rust-postcard-devel \
 "
RDEPENDS:rust-icu_provider+export-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-erased-serde+default-devel \
 rust-icu_provider+serde-devel \
 rust-icu_provider+std-devel \
 rust-icu_provider+sync-devel \
 rust-icu_provider-devel \
 rust-postcard-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_provider+logging-devel = " \
 cargo \
 rust-icu_provider-devel \
 rust-log-devel \
 "
RDEPENDS:rust-icu_provider+serde-devel = " \
 cargo \
 rust-icu_provider-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-yoke+serde-devel \
 "
RDEPENDS:rust-icu_provider+std-devel = " \
 cargo \
 rust-icu_provider+alloc-devel \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+sync-devel = " \
 cargo \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider+zerotrie-devel = " \
 cargo \
 rust-icu_provider-devel \
 "
RDEPENDS:rust-icu_provider-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-icu_locale_core-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 rust-zerovec+derive-devel \
 rust-zerovec-devel \
 "
