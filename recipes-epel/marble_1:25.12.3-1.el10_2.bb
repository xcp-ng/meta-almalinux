# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "marble"
PE = "1"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 marble \
 marble-astro \
 marble-astro-devel \
 marble-common \
 marble-plasma \
 marble-qt \
 marble-widget-data \
 marble-widget-qt6 \
 marble-widget-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/marble-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c574fbd5e67b991e9b9cede46b079e404d78b237db98d63e599ff52a76bf4ad9"

URI_x86_64_v2_marble = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble}"
SRC_URI[x86_64_v2_marble.sha256sum] = "50590efaa6d4f2b6ab9380cfc178a882e68637543926ea907e6b5ea705a70b36"

URI_x86_64_v2_marble-astro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-astro}"
SRC_URI[x86_64_v2_marble-astro.sha256sum] = "c902aa42ffc64b64536c5d49ce4d43f8084420db4a25ab3363075b3f8501116b"

URI_x86_64_v2_marble-astro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-astro-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-astro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-astro-devel}"
SRC_URI[x86_64_v2_marble-astro-devel.sha256sum] = "87ab4a4a59355bd8105f913a31d48e588bd8fc00060a40acf265faf168f4f271"

URI_x86_64_v2_marble-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-common-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_marble-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-common}"
SRC_URI[x86_64_v2_marble-common.sha256sum] = "ca03c03d5bbc9df0cb69a50ca0517612e5dec46b28f338809a8237ec63c9ce82"

URI_x86_64_v2_marble-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-plasma-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-plasma}"
SRC_URI[x86_64_v2_marble-plasma.sha256sum] = "5acb93aa812bda82a8d537b27c19ffefd378481b8def3f9b419fe09022f27f30"

URI_x86_64_v2_marble-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-qt-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-qt}"
SRC_URI[x86_64_v2_marble-qt.sha256sum] = "6f99868f21a46b16b3ae6d618310e3b90c6e4ceb523589f116a63c78405164fd"

URI_x86_64_v2_marble-widget-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-data-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_marble-widget-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-data}"
SRC_URI[x86_64_v2_marble-widget-data.sha256sum] = "d38cd7950e9db8d71bd901089c51d2a63041bcf52cf75372cb5257c4b53911be"

URI_x86_64_v2_marble-widget-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-qt6}"
SRC_URI[x86_64_v2_marble-widget-qt6.sha256sum] = "2f185bbefdc044d9039cb63d56d07973f9ee4247d48d2c28695197472b06afce"

URI_x86_64_v2_marble-widget-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/marble-widget-qt6-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_marble-widget-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_marble-widget-qt6-devel}"
SRC_URI[x86_64_v2_marble-widget-qt6-devel.sha256sum] = "99afb0b149181f70d1d4ee37e8f446e5644af7b6dd57944915ddaefad4a93731"

URI_aarch64_marble = "${EPEL_MIRROR}/aarch64/Packages/m/marble-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_marble;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble}"
SRC_URI[aarch64_marble.sha256sum] = "5d9dcc73613b9076e462899a297af7c79e9b47b9d69c48a8dca6fa1f518bbfdb"

URI_aarch64_marble-astro = "${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_marble-astro;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-astro}"
SRC_URI[aarch64_marble-astro.sha256sum] = "b9afb6049805eb05f68e84543dd47d318ebd5e1c4b5775cf91e0c442355b26d5"

URI_aarch64_marble-astro-devel = "${EPEL_MIRROR}/aarch64/Packages/m/marble-astro-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_marble-astro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-astro-devel}"
SRC_URI[aarch64_marble-astro-devel.sha256sum] = "90cd90eaa60af232fb003ce6ee351e538a0d381a4320eb52f9203835a45db185"

URI_aarch64_marble-common = "${EPEL_MIRROR}/aarch64/Packages/m/marble-common-25.12.3-1.el10_2.noarch.rpm;name=aarch64_marble-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-common}"
SRC_URI[aarch64_marble-common.sha256sum] = "dba6216ecc4ace6876b26c5ac472f8d097395a3879f40575dba3615eae557bd3"

URI_aarch64_marble-plasma = "${EPEL_MIRROR}/aarch64/Packages/m/marble-plasma-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_marble-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-plasma}"
SRC_URI[aarch64_marble-plasma.sha256sum] = "21bcb18961bded9131dc72df96cbc83fafebce18d8ea11c79427ef52bd8923e3"

URI_aarch64_marble-qt = "${EPEL_MIRROR}/aarch64/Packages/m/marble-qt-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_marble-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-qt}"
SRC_URI[aarch64_marble-qt.sha256sum] = "935d78c6e91e4a892d3c792bcf45a723e95830f23ed9e9a1b6b916eb1ddee789"

URI_aarch64_marble-widget-data = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-data-25.12.3-1.el10_2.noarch.rpm;name=aarch64_marble-widget-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-data}"
SRC_URI[aarch64_marble-widget-data.sha256sum] = "733655c54aa3ccc50ecfb5958169dc9bb876142a3e13201103476b798806d8bf"

URI_aarch64_marble-widget-qt6 = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_marble-widget-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-qt6}"
SRC_URI[aarch64_marble-widget-qt6.sha256sum] = "8ec1bc9787ea006864cb0a757f1fedaf7baba3d65673ee9d247cdb5975015909"

URI_aarch64_marble-widget-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/m/marble-widget-qt6-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_marble-widget-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_marble-widget-qt6-devel}"
SRC_URI[aarch64_marble-widget-qt6-devel.sha256sum] = "b93d7c7f1648345c717eb86b3ae0ccea218cd3b6d14d92cb4212dbffc5d8aef1"

RDEPENDS:marble = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:marble-astro = " \
 glibc \
 libstdc++ \
 marble-common \
 "
RDEPENDS:marble-astro-devel = " \
 cmake-filesystem \
 marble-astro \
 "
RDEPENDS:marble-common = " \
 "
RDEPENDS:marble-plasma = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-krunner \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-qt = " \
 glibc \
 libstdc++ \
 marble-common \
 marble-widget-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:marble-widget-data = " \
 marble-common \
 "
RDEPENDS:marble-widget-qt6 = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 marble-astro \
 marble-widget-data \
 phonon-qt6 \
 protobuf \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtserialport \
 qt6-qtsvg \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 shapelib \
 zlib-ng-compat \
 "
RDEPENDS:marble-widget-qt6-devel = " \
 cmake-filesystem \
 marble-widget-qt6 \
 qt6-qt5compat-devel \
 qt6-qtbase-devel \
 qt6-qtwebengine-devel \
 "
