# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lazy-object-proxy"
PV = "1.11.0"
PR = "5.el10_1"
PACKAGES = " \
 python3-lazy-object-proxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-lazy-object-proxy-1.11.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76d5cd71611d7aad60ce53b86997b9cf80d679b0fa4e75805f72d898edfaf2bd"

URI_x86_64_v2_python3-lazy-object-proxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lazy-object-proxy-1.11.0-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lazy-object-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lazy-object-proxy}"
SRC_URI[x86_64_v2_python3-lazy-object-proxy.sha256sum] = "08811e3d367567420cfb65e5a8b760920c97d998ff3e2fbbe48d2627dee7e783"

URI_aarch64_python3-lazy-object-proxy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lazy-object-proxy-1.11.0-5.el10_1.aarch64.rpm;name=aarch64_python3-lazy-object-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lazy-object-proxy}"
SRC_URI[aarch64_python3-lazy-object-proxy.sha256sum] = "89bb144f98e5bdb50d06c99db7f792aa7367982ce9812b4c43aa3409c306b2e6"

RDEPENDS:python3-lazy-object-proxy = " \
 glibc \
 python3 \
 "
