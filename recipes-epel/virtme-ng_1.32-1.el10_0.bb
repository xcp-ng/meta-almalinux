# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "virtme-ng"
PV = "1.32"
PR = "1.el10_0"
PACKAGES = " \
 virtme-ng \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/virtme-ng-1.32-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1342518bbcd9544640550d8107984dd3ae85820cbe4f9a0d39b5501e6e3c8ab1"

URI_x86_64_v2_virtme-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/virtme-ng-1.32-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_virtme-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_virtme-ng}"
SRC_URI[x86_64_v2_virtme-ng.sha256sum] = "3552e9b7dd58194e9e199942c6fa1f48070a344fbfb01a21752310015188d7a1"

URI_aarch64_virtme-ng = "${EPEL_MIRROR}/aarch64/Packages/v/virtme-ng-1.32-1.el10_0.noarch.rpm;name=aarch64_virtme-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_virtme-ng}"
SRC_URI[aarch64_virtme-ng.sha256sum] = "de15a8acd755f7aee67561ab54053b224df50506c91e93a326b5b612b48a39f2"

RDEPENDS:virtme-ng = " \
 bash \
 python3 \
 python3-argcomplete \
 python3-requests \
 python3-setuptools \
 "
