# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matches"
PV = "0.1.10"
PR = "4.el10_0"
PACKAGES = " \
 rust-matches+default-devel \
 rust-matches-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matches-0.1.10-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65e4dff7e1f52048a681608049c66a1a62032f41061b4eb33d2663daaa583775"

URI_x86_64_v2_rust-matches+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matches+default-devel-0.1.10-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matches+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matches+default-devel}"
SRC_URI[x86_64_v2_rust-matches+default-devel.sha256sum] = "3838eebdad4c35604c965576483bd7b3800051e300c997aeca5a17e1c374d4b8"

URI_x86_64_v2_rust-matches-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matches-devel-0.1.10-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matches-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matches-devel}"
SRC_URI[x86_64_v2_rust-matches-devel.sha256sum] = "3e7bd25dcbbcf903ed5ca1bb86318aff3fbffc8be73bd286a8d63522cb162f86"

URI_aarch64_rust-matches+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matches+default-devel-0.1.10-4.el10_0.noarch.rpm;name=aarch64_rust-matches+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matches+default-devel}"
SRC_URI[aarch64_rust-matches+default-devel.sha256sum] = "f8284e7b1b19d93393121456019f30cc27ec25229942e0c6563f82929b9c832d"

URI_aarch64_rust-matches-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matches-devel-0.1.10-4.el10_0.noarch.rpm;name=aarch64_rust-matches-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matches-devel}"
SRC_URI[aarch64_rust-matches-devel.sha256sum] = "9e9911b5f0228dd68c6ad2e2e84c9aa563cf5e748659102486948d209b9287cd"

RDEPENDS:rust-matches+default-devel = " \
 cargo \
 rust-matches-devel \
 "
RDEPENDS:rust-matches-devel = " \
 cargo \
 "
