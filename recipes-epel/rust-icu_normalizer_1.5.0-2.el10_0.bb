# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_normalizer"
PV = "1.5.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_normalizer+datagen-devel \
 rust-icu_normalizer+default-devel \
 rust-icu_normalizer+experimental-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_normalizer+std-devel \
 rust-icu_normalizer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_normalizer-1.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f3f1a301a97163ab77354bb3af296bf14cc3a25f6d24614fd9c05ff909866df"

URI_x86_64_v2_rust-icu_normalizer+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+compiled_data-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+compiled_data-devel.sha256sum] = "0bc6eb4c0ede474a4ca4fbcd3798e6e35d323579b75a774cc5bfbe7ec6d774ce"

URI_x86_64_v2_rust-icu_normalizer+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+datagen-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+datagen-devel.sha256sum] = "10b0bb063f3c20dbf347f7363d6d06e61e388effdc80c757e636d40373f618d9"

URI_x86_64_v2_rust-icu_normalizer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+default-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+default-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+default-devel.sha256sum] = "1b5ccc1bca757161f04068f09be38f2bf84999b7342449bc646248ee8007d32c"

URI_x86_64_v2_rust-icu_normalizer+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+experimental-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+experimental-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+experimental-devel.sha256sum] = "e2f38a16177ffd2e5ec08502114ea6984b789c7652ceb7569557065469961406"

URI_x86_64_v2_rust-icu_normalizer+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+serde-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+serde-devel.sha256sum] = "053ba3c78f12843061b2a3103265e2c343dcc7e7482ae4c0935e47cb270250a3"

URI_x86_64_v2_rust-icu_normalizer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+std-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+std-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+std-devel.sha256sum] = "2ddb0d00303cf824c3e6077b8ae9b219afff4cfef7b99c808260f96e4ce1bf8e"

URI_x86_64_v2_rust-icu_normalizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer-devel-1.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer-devel.sha256sum] = "e4515e6bf95d531860bfd7f2808d034f2d413905b60d916b26a682afc6ea2989"

URI_aarch64_rust-icu_normalizer+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+compiled_data-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_normalizer+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_normalizer+compiled_data-devel.sha256sum] = "b8537672510a8e1d2ba6a4c457be6a5562f895aa6f51dbc16f369aa6595721ae"

URI_aarch64_rust-icu_normalizer+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+datagen-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_normalizer+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+datagen-devel}"
SRC_URI[aarch64_rust-icu_normalizer+datagen-devel.sha256sum] = "1357964fcb321566688b3ab5a73690257b6a72a916a2f6eaeee8b60d11a25f83"

URI_aarch64_rust-icu_normalizer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+default-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_normalizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+default-devel}"
SRC_URI[aarch64_rust-icu_normalizer+default-devel.sha256sum] = "4ae73e4cf5a1e5e6cfe6e43cfa7e280d726e2919d27e489682a7eee2b069ab8c"

URI_aarch64_rust-icu_normalizer+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+experimental-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_normalizer+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+experimental-devel}"
SRC_URI[aarch64_rust-icu_normalizer+experimental-devel.sha256sum] = "ce898dc1396b01a3540ec0ed04fa8cac41de0dd7f3e7d8a08b285658ece37c8f"

URI_aarch64_rust-icu_normalizer+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+serde-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_normalizer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+serde-devel}"
SRC_URI[aarch64_rust-icu_normalizer+serde-devel.sha256sum] = "6c6b040a3805fba2c0b656e0d05a0e5ece1f78ac6f868e5947c678fffbec06f0"

URI_aarch64_rust-icu_normalizer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+std-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_normalizer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+std-devel}"
SRC_URI[aarch64_rust-icu_normalizer+std-devel.sha256sum] = "58280f853b5b6e968e8dbba46a88523f3c7745a0c43da89dbd42523904d066fa"

URI_aarch64_rust-icu_normalizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer-devel-1.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-icu_normalizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer-devel}"
SRC_URI[aarch64_rust-icu_normalizer-devel.sha256sum] = "7ce3f08a230c3a81a753c7dda3b0b3d8b218efa7d61e97ae766e3a3edc893847"

RDEPENDS:rust-icu_normalizer+compiled_data-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-icu_normalizer_data-devel \
 rust-icu_properties+compiled_data-devel \
 "
RDEPENDS:rust-icu_normalizer+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties+datagen-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_normalizer+default-devel = " \
 cargo \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer+experimental-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_normalizer+std-devel = " \
 cargo \
 rust-icu_collections+std-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties+std-devel \
 rust-icu_provider+std-devel \
 "
RDEPENDS:rust-icu_normalizer-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-icu_collections-devel \
 rust-icu_properties-devel \
 rust-icu_provider+macros-devel \
 rust-icu_provider-devel \
 rust-smallvec-devel \
 rust-utf16_iter-devel \
 rust-utf8_iter-devel \
 rust-write16+alloc-devel \
 rust-write16-devel \
 rust-zerovec-devel \
 "
