# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dist-git"
PV = "1.19"
PR = "1.el10_2"
PACKAGES = " \
 dist-git \
 dist-git-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dist-git-1.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b5289cd04cd80f21e75dd28952add36c3282b4e663d718750eeb96c2c80373a"

URI_x86_64_v2_dist-git = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dist-git-1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dist-git;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dist-git}"
SRC_URI[x86_64_v2_dist-git.sha256sum] = "9c1030314c62105b0a0830f93f04477012a7a25a189521d37e408b93ca0f97de"

URI_x86_64_v2_dist-git-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dist-git-selinux-1.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dist-git-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dist-git-selinux}"
SRC_URI[x86_64_v2_dist-git-selinux.sha256sum] = "c57581683f09b04ba962c4094ac91e0957fb2a1ddee6030b16abea902d4348a3"

URI_aarch64_dist-git = "${EPEL_MIRROR}/aarch64/Packages/d/dist-git-1.19-1.el10_2.noarch.rpm;name=aarch64_dist-git;unpack=0"
SRC_URI:append = " ${URI_aarch64_dist-git}"
SRC_URI[aarch64_dist-git.sha256sum] = "3a6d26ef70e7ac72976bc21f25f7033d58f031d359986de2459161774d6ca6bb"

URI_aarch64_dist-git-selinux = "${EPEL_MIRROR}/aarch64/Packages/d/dist-git-selinux-1.19-1.el10_2.noarch.rpm;name=aarch64_dist-git-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_dist-git-selinux}"
SRC_URI[aarch64_dist-git-selinux.sha256sum] = "51e9d22ebd28027c7061e3ee1499582e228f3f6fc002c543f84fc7036e78f729"

RDEPENDS:dist-git = " \
 bash \
 crudini \
 dist-git-selinux \
 git \
 git-daemon \
 httpd \
 mod_ssl \
 perl-Sys-Syslog \
 python3 \
 python3-requests \
 "
RDEPENDS:dist-git-selinux = " \
 bash \
 dist-git \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
