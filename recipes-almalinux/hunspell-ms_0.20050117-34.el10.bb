# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ms"
PV = "0.20050117"
PR = "34.el10"
PACKAGES = " \
 hunspell-ms \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ms-0.20050117-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "648d401a4ace214e28a1372f88315a7106c503243ef27f45ec1add35709d5e5f"

URI_x86_64_v2_hunspell-ms = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ms-0.20050117-34.el10.noarch.rpm;name=x86_64_v2_hunspell-ms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ms}"
SRC_URI[x86_64_v2_hunspell-ms.sha256sum] = "ed7db964b18cac626d6db3b23730a8ccf700658a0993e895d22767374e941583"

URI_aarch64_hunspell-ms = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ms-0.20050117-34.el10.noarch.rpm;name=aarch64_hunspell-ms;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ms}"
SRC_URI[aarch64_hunspell-ms.sha256sum] = "ed7db964b18cac626d6db3b23730a8ccf700658a0993e895d22767374e941583"

RDEPENDS:hunspell-ms = " \
 hunspell-filesystem \
 "
