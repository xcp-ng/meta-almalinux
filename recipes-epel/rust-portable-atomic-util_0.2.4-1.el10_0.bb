# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portable-atomic-util"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 rust-portable-atomic-util+std-devel \
 rust-portable-atomic-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-portable-atomic-util-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3216bff90fa2aa66b35c75bbccf928199550922e9f885e4a622964a2e301460c"

URI_x86_64_v2_rust-portable-atomic-util+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+alloc-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+alloc-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+alloc-devel.sha256sum] = "687a10ce8763014568d339db4471ab103a65a969c16270a16433d675a4218f2d"

URI_x86_64_v2_rust-portable-atomic-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+default-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+default-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+default-devel.sha256sum] = "ed6f7c2e7d9a7d93a07b87aa4d0e116d84a4616a61dede242bbfb5613bda815b"

URI_x86_64_v2_rust-portable-atomic-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+std-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util+std-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util+std-devel.sha256sum] = "7e4d104b385f64f43941ece1f136520a432d08faf274ffb41add4822c5652b3a"

URI_x86_64_v2_rust-portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-util-devel.sha256sum] = "6ee429b2bb63a88c34f63f6d035583e89a6dbd18ef52e27e9e9b40650530a1be"

URI_aarch64_rust-portable-atomic-util+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+alloc-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+alloc-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+alloc-devel.sha256sum] = "26dfe6f6e43ad858b5807403df023717cca3f2d9ea1096d3bc35c32a3c9acf48"

URI_aarch64_rust-portable-atomic-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+default-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+default-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+default-devel.sha256sum] = "296582ff4403816e0d9d5b70950059a69056567a57f96327187ae625e798e931"

URI_aarch64_rust-portable-atomic-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+std-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util+std-devel}"
SRC_URI[aarch64_rust-portable-atomic-util+std-devel.sha256sum] = "689fc41d524f20979be8fdfd7294f29fe4ba4c8cf9d62c8ad798d648120ad663"

URI_aarch64_rust-portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-util-devel}"
SRC_URI[aarch64_rust-portable-atomic-util-devel.sha256sum] = "697ad5fff3786b1c69804eebe17cf8d296f1081b1656b30b87b85237b81562cc"

RDEPENDS:rust-portable-atomic-util+alloc-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+default-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+std-devel = " \
 cargo \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util-devel = " \
 cargo \
 rust \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
