# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-webpki"
PV = "0.103.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki+default-devel \
 rust-rustls-webpki+ring-devel \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-webpki-0.103.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06a0a63b4fc214d206e0375bb04c8f26d2deabf4e78c77791c95a575fd30fab9"

URI_x86_64_v2_rust-rustls-webpki+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+alloc-devel-0.103.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+alloc-devel.sha256sum] = "f7af70ed131f9bdddcc7ffe5eff5a3a10517d13e2b8e9fb2ddc1e4941a457ff7"

URI_x86_64_v2_rust-rustls-webpki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+default-devel-0.103.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+default-devel.sha256sum] = "e0453ff0f0f725093ff7df2aaaf0f7c20a500918b3cebe552f00a5e4d1904950"

URI_x86_64_v2_rust-rustls-webpki+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+ring-devel-0.103.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+ring-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+ring-devel.sha256sum] = "21a52f6e64d8e72febd57fa87beb7a9fd56ef04e5f8f64583051c9b77d74b764"

URI_x86_64_v2_rust-rustls-webpki+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+std-devel-0.103.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+std-devel.sha256sum] = "8603e72128189d21f43dcaf5fba587ded10a7263386a6609492beab3d916e297"

URI_x86_64_v2_rust-rustls-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki-devel-0.103.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki-devel.sha256sum] = "d8268cad5727bd93cd6e71dfa362293d03a1a86f4eb8ad87c5e199eb0865a184"

URI_aarch64_rust-rustls-webpki+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+alloc-devel-0.103.13-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+alloc-devel}"
SRC_URI[aarch64_rust-rustls-webpki+alloc-devel.sha256sum] = "1b2fcfcd4fe1851145316272b2b44d20e11434b4c7f00c6e1c759cb117206e27"

URI_aarch64_rust-rustls-webpki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+default-devel-0.103.13-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+default-devel}"
SRC_URI[aarch64_rust-rustls-webpki+default-devel.sha256sum] = "ae647d9c4dc74b647195a6db59cefd4d658df64dd25743c0d1def0ed4e2c2272"

URI_aarch64_rust-rustls-webpki+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+ring-devel-0.103.13-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+ring-devel}"
SRC_URI[aarch64_rust-rustls-webpki+ring-devel.sha256sum] = "e966aa60be0cf8315c03ff2d97d2c71911c6b12c0e7ca9f8ff5833bae7fdb10a"

URI_aarch64_rust-rustls-webpki+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+std-devel-0.103.13-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+std-devel}"
SRC_URI[aarch64_rust-rustls-webpki+std-devel.sha256sum] = "3549919dde1c96dd62762e35a29485e4d7b50e01073452fbeeb953a8740d1aad"

URI_aarch64_rust-rustls-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki-devel-0.103.13-1.el10_2.noarch.rpm;name=aarch64_rust-rustls-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki-devel}"
SRC_URI[aarch64_rust-rustls-webpki-devel.sha256sum] = "d4b45261e78907986d2d92c2dfe4e1437132b46399b17a8cfe3e84e32bb569fe"

RDEPENDS:rust-rustls-webpki+alloc-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+default-devel = " \
 cargo \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+ring-devel = " \
 cargo \
 rust-ring-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+std-devel = " \
 cargo \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 rust-untrusted+default-devel \
 "
