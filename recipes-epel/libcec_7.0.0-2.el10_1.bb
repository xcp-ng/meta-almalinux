# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcec"
PV = "7.0.0"
PR = "2.el10_1"
PACKAGES = " \
 libcec \
 libcec-devel \
 python3-libcec \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcec-7.0.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82517ae61864e8dce98d0c16f36aa31700806aabec77b171feb17b9de87410cd"

URI_x86_64_v2_libcec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcec-7.0.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcec}"
SRC_URI[x86_64_v2_libcec.sha256sum] = "20e92fde3c559e5d668a7c83b859126c6b736cedc491e6107aa909a516a64543"

URI_x86_64_v2_libcec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcec-devel-7.0.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcec-devel}"
SRC_URI[x86_64_v2_libcec-devel.sha256sum] = "48281fed8585418d336f8a5e8cc7d8dbf201a7c4655d84bdae40d0e51361fba5"

URI_x86_64_v2_python3-libcec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libcec-7.0.0-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libcec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libcec}"
SRC_URI[x86_64_v2_python3-libcec.sha256sum] = "460acdaf8edfb2c7c0202b8e4c52ca041d0d3b9ee2fde4826586f39f1d0897dd"

URI_aarch64_libcec = "${EPEL_MIRROR}/aarch64/Packages/l/libcec-7.0.0-2.el10_1.aarch64.rpm;name=aarch64_libcec;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcec}"
SRC_URI[aarch64_libcec.sha256sum] = "c7a78cea0e681b63951377dc50f4cd5a0ac0215265ac7028ada19d85dcf6d946"

URI_aarch64_libcec-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcec-devel-7.0.0-2.el10_1.aarch64.rpm;name=aarch64_libcec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcec-devel}"
SRC_URI[aarch64_libcec-devel.sha256sum] = "7fe101d4a49176a0d92219ada03c8cbe4e122e719a24f542f224e871b7e9cda9"

URI_aarch64_python3-libcec = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libcec-7.0.0-2.el10_1.aarch64.rpm;name=aarch64_python3-libcec;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libcec}"
SRC_URI[aarch64_python3-libcec.sha256sum] = "7eac90e912c2ab44e6003c0ec7af9d300638b45bc7491449562108a75e475cc6"

RDEPENDS:libcec = " \
 bash \
 glibc \
 libX11 \
 libXrandr \
 libgcc \
 libstdc++ \
 ncurses-libs \
 platform \
 systemd-libs \
 "
RDEPENDS:libcec-devel = " \
 libcec \
 pkgconf-pkg-config \
 platform-devel \
 "
RDEPENDS:python3-libcec = " \
 glibc \
 libcec \
 libgcc \
 libstdc++ \
 platform \
 python3 \
 python3-libs \
 "
