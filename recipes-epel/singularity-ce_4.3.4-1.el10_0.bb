# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "singularity-ce"
PV = "4.3.4"
PR = "1.el10_0"
PACKAGES = " \
 singularity-ce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/singularity-ce-4.3.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6bb7bab82a30fc5dde0c1897b59f72eefb71e4ec81c3635927f3e8ca2001b5a"

URI_x86_64_v2_singularity-ce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/singularity-ce-4.3.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_singularity-ce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_singularity-ce}"
SRC_URI[x86_64_v2_singularity-ce.sha256sum] = "e1f5e1f0c66f9bb59b464a0815abf23509a93f747e077343676204df6a5743c3"

URI_aarch64_singularity-ce = "${EPEL_MIRROR}/aarch64/Packages/s/singularity-ce-4.3.4-1.el10_0.aarch64.rpm;name=aarch64_singularity-ce;unpack=0"
SRC_URI:append = " ${URI_aarch64_singularity-ce}"
SRC_URI[aarch64_singularity-ce.sha256sum] = "b75089790cf4cf6e7a61701a05a302b51700985b8734e94a3dbe05beba3603c6"

RDEPENDS:singularity-ce = " \
 bash \
 conmon \
 crun \
 cryptsetup \
 fuse \
 fuse3 \
 glibc \
 libseccomp \
 shadow-utils \
 shadow-utils-subid \
 squashfs-tools \
 squashfuse \
 "
