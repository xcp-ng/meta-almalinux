# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates"
PV = "3.1.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-predicates+color-devel \
 rust-predicates+default-devel \
 rust-predicates+diff-devel \
 rust-predicates+float-cmp-devel \
 rust-predicates+normalize-line-endings-devel \
 rust-predicates+regex-devel \
 rust-predicates+unstable-devel \
 rust-predicates-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates-3.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cf09e6c4dcfd36509cb8baa7ea990d45eec3b4c0fe9853e336a51d7fe731908"

URI_x86_64_v2_rust-predicates+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+color-devel-3.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+color-devel}"
SRC_URI[x86_64_v2_rust-predicates+color-devel.sha256sum] = "2fb57e38f49e8fbef74e778f0129d82d16de97e8ea9b2bae9f23e03de173d810"

URI_x86_64_v2_rust-predicates+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+default-devel-3.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+default-devel}"
SRC_URI[x86_64_v2_rust-predicates+default-devel.sha256sum] = "1e76472a5034c2a9b94bec0f0aca9ad7441f949926e487c4fd67af0e88deeb50"

URI_x86_64_v2_rust-predicates+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+diff-devel-3.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+diff-devel}"
SRC_URI[x86_64_v2_rust-predicates+diff-devel.sha256sum] = "7fbd1c8fcf236508fbd65e51634d7b7c28039e5167cc013515d7499211a4453d"

URI_x86_64_v2_rust-predicates+float-cmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+float-cmp-devel-3.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+float-cmp-devel}"
SRC_URI[x86_64_v2_rust-predicates+float-cmp-devel.sha256sum] = "1cf8121de570f1cdbbc86bf5d30fd51e8e99f14b3817f6a43cb6cd4d186b682e"

URI_x86_64_v2_rust-predicates+normalize-line-endings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+normalize-line-endings-devel-3.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+normalize-line-endings-devel}"
SRC_URI[x86_64_v2_rust-predicates+normalize-line-endings-devel.sha256sum] = "36c9ba14dbb7e6bb5db307aff7924f64208c967699c934d90024c3e3b5253b59"

URI_x86_64_v2_rust-predicates+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+regex-devel-3.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+regex-devel}"
SRC_URI[x86_64_v2_rust-predicates+regex-devel.sha256sum] = "f6e6b669cac2ae375cc422501f7cd20b490e226c159acc508c5c6c8a4b3e9ae4"

URI_x86_64_v2_rust-predicates+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates+unstable-devel-3.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates+unstable-devel}"
SRC_URI[x86_64_v2_rust-predicates+unstable-devel.sha256sum] = "15539c82bb990360ed71213aaf7cfff42b3cfca8813b87006360555929d22ab7"

URI_x86_64_v2_rust-predicates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-devel-3.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-devel}"
SRC_URI[x86_64_v2_rust-predicates-devel.sha256sum] = "eafc9693ce96037bfc76598b5cf625ca68832ce8952d0640eb64b8a8696a2f00"

URI_aarch64_rust-predicates+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+color-devel-3.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-predicates+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+color-devel}"
SRC_URI[aarch64_rust-predicates+color-devel.sha256sum] = "983197f9695ff8857c8599b7119548b837aae63ee756bbd51b74080c59e28657"

URI_aarch64_rust-predicates+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+default-devel-3.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-predicates+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+default-devel}"
SRC_URI[aarch64_rust-predicates+default-devel.sha256sum] = "649df65dfcb65c0421c7ed8077757305be2e7784e2fef7d0dd82c66afbdb94e5"

URI_aarch64_rust-predicates+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+diff-devel-3.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-predicates+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+diff-devel}"
SRC_URI[aarch64_rust-predicates+diff-devel.sha256sum] = "1601ac1175aa803e651ff02043cadf092adade2a11264bc2fa87d00eaac50dfb"

URI_aarch64_rust-predicates+float-cmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+float-cmp-devel-3.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-predicates+float-cmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+float-cmp-devel}"
SRC_URI[aarch64_rust-predicates+float-cmp-devel.sha256sum] = "f82768bcb14b769920cf2c03308952779caa8d0b47d86d5c412b2a6788c140fb"

URI_aarch64_rust-predicates+normalize-line-endings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+normalize-line-endings-devel-3.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-predicates+normalize-line-endings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+normalize-line-endings-devel}"
SRC_URI[aarch64_rust-predicates+normalize-line-endings-devel.sha256sum] = "0fb8acef2a346f443a30aa71c42f3e93370fe47746b37dabbd7ecfc39fa27ceb"

URI_aarch64_rust-predicates+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+regex-devel-3.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-predicates+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+regex-devel}"
SRC_URI[aarch64_rust-predicates+regex-devel.sha256sum] = "180925bfcab3e97a80e46d324484f6f32290ba4378785ae147425a283eab4feb"

URI_aarch64_rust-predicates+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates+unstable-devel-3.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-predicates+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates+unstable-devel}"
SRC_URI[aarch64_rust-predicates+unstable-devel.sha256sum] = "57ee915fd1f51be2d72aac9117c059a8aa5769041ca82bf7f21ffd0cc7ac5898"

URI_aarch64_rust-predicates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-devel-3.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-predicates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-devel}"
SRC_URI[aarch64_rust-predicates-devel.sha256sum] = "5891c7a6221b76146268c93b3729ba4bc36882d7afd73d9b43609ed507a87a51"

RDEPENDS:rust-predicates+color-devel = " \
 cargo \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+default-devel = " \
 cargo \
 rust-predicates+color-devel \
 rust-predicates+diff-devel \
 rust-predicates+float-cmp-devel \
 rust-predicates+normalize-line-endings-devel \
 rust-predicates+regex-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+diff-devel = " \
 cargo \
 rust-difflib+default-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+float-cmp-devel = " \
 cargo \
 rust-float-cmp+default-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+normalize-line-endings-devel = " \
 cargo \
 rust-normalize-line-endings+default-devel \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates+regex-devel = " \
 cargo \
 rust-predicates-devel \
 rust-regex+default-devel \
 "
RDEPENDS:rust-predicates+unstable-devel = " \
 cargo \
 rust-predicates-devel \
 "
RDEPENDS:rust-predicates-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-predicates-core+default-devel \
 "
