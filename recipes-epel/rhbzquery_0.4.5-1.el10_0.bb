# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rhbzquery"
PV = "0.4.5"
PR = "1.el10_0"
PACKAGES = " \
 rhbzquery \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rhbzquery-0.4.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2b135d6c194ebafbfbeb26a4f4e8f90f1f64a3af1619982399f21698bf73b11b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rhbzquery-0.4.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rhbzquery;unpack=0"
SRC_URI[x86_64_v2_rhbzquery.sha256sum] = "3231869150adf539c07d9477241b4aeafe55b8fc2d65d37d648f573550beca9e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rhbzquery-0.4.5-1.el10_0.aarch64.rpm;name=aarch64_rhbzquery;unpack=0"
SRC_URI[aarch64_rhbzquery.sha256sum] = "36715f1d3b2021d4eeb30357bc936684b1afb149b4eca12eaaff6d4e044986c1"

RDEPENDS:rhbzquery = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 "
