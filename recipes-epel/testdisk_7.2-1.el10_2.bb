# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "testdisk"
PV = "7.2"
PR = "1.el10_2"
PACKAGES = " \
 qphotorec \
 testdisk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/testdisk-7.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05bf8a6553acda910ddcf9d461ffa467fc5f5bd36b5c19c846cf56664695d752"

URI_x86_64_v2_qphotorec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qphotorec-7.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qphotorec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qphotorec}"
SRC_URI[x86_64_v2_qphotorec.sha256sum] = "e8ce4070a49fc4bb32db9461fdf97d71fd5c867142cd5ae314b0e32e7ef88d91"

URI_x86_64_v2_testdisk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/testdisk-7.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_testdisk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_testdisk}"
SRC_URI[x86_64_v2_testdisk.sha256sum] = "a9255230e72f43edff79d294726fb2023b0d7281cb864f87af6a5f26f06e62b6"

URI_aarch64_qphotorec = "${EPEL_MIRROR}/aarch64/Packages/q/qphotorec-7.2-1.el10_2.aarch64.rpm;name=aarch64_qphotorec;unpack=0"
SRC_URI:append = " ${URI_aarch64_qphotorec}"
SRC_URI[aarch64_qphotorec.sha256sum] = "2d8c9e132a1206f5a071ca8305aa3e01eecc8f992b15315dae5e07cd111d8de3"

URI_aarch64_testdisk = "${EPEL_MIRROR}/aarch64/Packages/t/testdisk-7.2-1.el10_2.aarch64.rpm;name=aarch64_testdisk;unpack=0"
SRC_URI:append = " ${URI_aarch64_testdisk}"
SRC_URI[aarch64_testdisk.sha256sum] = "7674b5cf9dab45d2796c7742dc59c0f88df9e8a24a70190f42f98b01e87b66cf"

RDEPENDS:qphotorec = " \
 e2fsprogs-libs \
 glibc \
 libewf \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 ntfs-3g-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 zlib-ng-compat \
 "
RDEPENDS:testdisk = " \
 e2fsprogs-libs \
 glibc \
 libewf \
 libjpeg-turbo \
 ncurses-libs \
 ntfs-3g-libs \
 zlib-ng-compat \
 "
