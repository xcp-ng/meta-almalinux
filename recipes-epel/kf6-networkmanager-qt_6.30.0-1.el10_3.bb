# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-networkmanager-qt"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-networkmanager-qt \
 kf6-networkmanager-qt-devel \
 kf6-networkmanager-qt-doc \
 kf6-networkmanager-qt-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-networkmanager-qt-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "12c785060624e5d6b45af1ee7870a0d728dab34f14922fa0a545866e6b545db5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt;unpack=0"
SRC_URI[x86_64_v2_kf6-networkmanager-qt.sha256sum] = "a65d0ec1e645ceb3ff8dffee5ba5ded642dab6876c5f135a50326d28e1b00a56"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-devel.sha256sum] = "5ec29697039bd5ac3f0e1e9b8a00c96178488a3a756daf8e5b044cc3014f0fbb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-doc.sha256sum] = "4446bc82ff25b0428cedc9a1279e64478997091c1220d583b3565a403d574265"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-networkmanager-qt-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-networkmanager-qt-html;unpack=0"
SRC_URI[x86_64_v2_kf6-networkmanager-qt-html.sha256sum] = "fdde3b7aef1fb009d81ff2510b29b3aa4299b1c96caeb183b9b9f23368fe078c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-networkmanager-qt;unpack=0"
SRC_URI[aarch64_kf6-networkmanager-qt.sha256sum] = "4b77dfc324fc7f8b8dcef1f52ac5abbb75e22f8da4122f32464a24a97b49a69b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-networkmanager-qt-devel;unpack=0"
SRC_URI[aarch64_kf6-networkmanager-qt-devel.sha256sum] = "8c3030341f50e0e658819db52eaf2a7336344e8e165f622205e467a8bbd14476"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-networkmanager-qt-doc;unpack=0"
SRC_URI[aarch64_kf6-networkmanager-qt-doc.sha256sum] = "adf622a3a871b8e19367a0db237aae44b5adaf594b9ae8dbde240d1cf2dd7bd3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-networkmanager-qt-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-networkmanager-qt-html;unpack=0"
SRC_URI[aarch64_kf6-networkmanager-qt-html.sha256sum] = "eadad137a8fb94f0e3f1d64efc06c85048232e5456354c09a66a19b08f2fa9c3"

RDEPENDS:kf6-networkmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-networkmanager-qt-devel = " \
 NetworkManager-libnm-devel \
 cmake-filesystem \
 kf6-networkmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-networkmanager-qt-doc = " \
 "
RDEPENDS:kf6-networkmanager-qt-html = " \
 "
