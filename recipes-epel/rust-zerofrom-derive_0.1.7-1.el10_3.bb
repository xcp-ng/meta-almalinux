# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerofrom-derive"
PV = "0.1.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerofrom-derive+default-devel \
 rust-zerofrom-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerofrom-derive-0.1.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76975744816273dcd2ee03b88f80ed7c753297ed6a86dfad2487eb24c46272de"

URI_x86_64_v2_rust-zerofrom-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-derive+default-devel-0.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-derive+default-devel.sha256sum] = "80e0c543325fc1d15bec8d295d9064da7377e3d752c280612f292f7b617f8cfc"

URI_x86_64_v2_rust-zerofrom-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-derive-devel-0.1.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-derive-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-derive-devel.sha256sum] = "e4d8386601c0f005704d59950eb1baa842505639debfec1f701c2628b55d326d"

URI_aarch64_rust-zerofrom-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-derive+default-devel-0.1.7-1.el10_3.noarch.rpm;name=aarch64_rust-zerofrom-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-derive+default-devel}"
SRC_URI[aarch64_rust-zerofrom-derive+default-devel.sha256sum] = "1a8dfe7bced6db9433727187b3859cf042aa10683b38ea2d687ed43657c94408"

URI_aarch64_rust-zerofrom-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-derive-devel-0.1.7-1.el10_3.noarch.rpm;name=aarch64_rust-zerofrom-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-derive-devel}"
SRC_URI[aarch64_rust-zerofrom-derive-devel.sha256sum] = "06fb334733003443eea7e408bfbcc97dbf2927afc35981604582980c1b39ad09"

RDEPENDS:rust-zerofrom-derive+default-devel = " \
 cargo \
 rust-zerofrom-derive-devel \
 "
RDEPENDS:rust-zerofrom-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+fold-devel \
 rust-synstructure+default-devel \
 "
