# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baresip"
PV = "4.11.0"
PR = "1.el10_2"
PACKAGES = " \
 baresip \
 baresip-aac \
 baresip-alsa \
 baresip-av1 \
 baresip-avcodec \
 baresip-avfilter \
 baresip-avformat \
 baresip-codec2 \
 baresip-ctrl_dbus \
 baresip-devel \
 baresip-g722 \
 baresip-gst \
 baresip-gtk \
 baresip-jack \
 baresip-mqtt \
 baresip-opus \
 baresip-pipewire \
 baresip-plc \
 baresip-portaudio \
 baresip-pulse \
 baresip-sdl \
 baresip-snapshot \
 baresip-sndfile \
 baresip-swscale \
 baresip-tools \
 baresip-v4l2 \
 baresip-vp8 \
 baresip-vp9 \
 baresip-x11 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/baresip-4.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d24ba26886c9cbf2cb86be729baa6bea5d0fffe958d21a29af9141af76913920"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip;unpack=0"
SRC_URI[x86_64_v2_baresip.sha256sum] = "746ee267587f57e07f6fbc75775190983f8feb0454fed640f441a9eb57136cf7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-aac-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-aac;unpack=0"
SRC_URI[x86_64_v2_baresip-aac.sha256sum] = "a0478403bbd425bebf63ae78833692479a8a7c5a5dcbd7f5942e810d7b4e53db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-alsa-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-alsa;unpack=0"
SRC_URI[x86_64_v2_baresip-alsa.sha256sum] = "1e2e58017433c02a0468cd48c5ca60dc74d08f98f53b8c761219d8f5c97e0c40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-av1-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-av1;unpack=0"
SRC_URI[x86_64_v2_baresip-av1.sha256sum] = "e5e4f60516f332a0579e2ed17d4d54fad62f304a6451dc488ab503081dc87cf4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avcodec-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avcodec;unpack=0"
SRC_URI[x86_64_v2_baresip-avcodec.sha256sum] = "440366b72692cc2491d94be81ea498e670435c66e38f73dc32a9e18f47657dcf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avfilter-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avfilter;unpack=0"
SRC_URI[x86_64_v2_baresip-avfilter.sha256sum] = "6093e050cff52066dddfbdf69280a1a51c95309aac930d03e7caae4a7bc12a2e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avformat-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avformat;unpack=0"
SRC_URI[x86_64_v2_baresip-avformat.sha256sum] = "9ada7f1187d4de31abb0eca25b8fcedbed95e806322d975b15925ef4ca076fc2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-codec2-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-codec2;unpack=0"
SRC_URI[x86_64_v2_baresip-codec2.sha256sum] = "273a72306012016e9697ad2fd2c22419210d4dbfba524be6df9f4d2f2ba7e576"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-ctrl_dbus-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-ctrl_dbus;unpack=0"
SRC_URI[x86_64_v2_baresip-ctrl_dbus.sha256sum] = "83743f553dfe3ef651a44ffbbc8a1527574f933769ebdc43b5596342b12f7960"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-devel-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-devel;unpack=0"
SRC_URI[x86_64_v2_baresip-devel.sha256sum] = "c822dd466cf0c241a960c21e4cfc8086ccc5d5664d16c40e561180056d99c5d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-g722-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-g722;unpack=0"
SRC_URI[x86_64_v2_baresip-g722.sha256sum] = "d89f212efd0a3fd8b1e4a48a71745d920be5fbabe54bdc059d6afd676c69eff0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gst-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gst;unpack=0"
SRC_URI[x86_64_v2_baresip-gst.sha256sum] = "c17ddc6d7cdd41aad8d295d503a84c451c3e77d74bed84477e45a2500f484cc5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gtk-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gtk;unpack=0"
SRC_URI[x86_64_v2_baresip-gtk.sha256sum] = "eda73fd01f40b2bf7ae051b2a67870418120a0d60e3dea29cef740cea36e0799"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-jack-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-jack;unpack=0"
SRC_URI[x86_64_v2_baresip-jack.sha256sum] = "5a9d82c63b151e6ae54200fbf878c354d6ce6c8e66909a5cd14fba80c26b098f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-mqtt-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-mqtt;unpack=0"
SRC_URI[x86_64_v2_baresip-mqtt.sha256sum] = "f05ae19bd1bbe675e8f703501eeb405c943d2ae836cbe311dabab857731b0ec5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-opus-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-opus;unpack=0"
SRC_URI[x86_64_v2_baresip-opus.sha256sum] = "c510a905a9fa633c5696a7e30cc243f4fccc48d467402e747366aabded110c57"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pipewire-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pipewire;unpack=0"
SRC_URI[x86_64_v2_baresip-pipewire.sha256sum] = "1645a993625269c510324873667f86780934ed15b30fb036dba7b2f3a616bf8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-plc-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-plc;unpack=0"
SRC_URI[x86_64_v2_baresip-plc.sha256sum] = "1b0c86c06515824baae9fe2c8a42645a108756eb73234d5319700575abdadbcf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-portaudio-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-portaudio;unpack=0"
SRC_URI[x86_64_v2_baresip-portaudio.sha256sum] = "853dbcb24721602304a8742b21f5ed534e2b75ccf91bcb6775dfd5c02c5ba0c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pulse-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pulse;unpack=0"
SRC_URI[x86_64_v2_baresip-pulse.sha256sum] = "a0162fdef9db08a191703eabcb75ba20b2941527f404f50da9aa6afc8f491d08"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sdl-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sdl;unpack=0"
SRC_URI[x86_64_v2_baresip-sdl.sha256sum] = "79b0acd67bf4c6607158fa1256d4352c3acb83aea8c1dbb1eda0a1b65ceacd0b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-snapshot-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-snapshot;unpack=0"
SRC_URI[x86_64_v2_baresip-snapshot.sha256sum] = "35d0eebc3b2067991ec061fe0b332b27d445989461c6c610e2a21431d95c039d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sndfile-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sndfile;unpack=0"
SRC_URI[x86_64_v2_baresip-sndfile.sha256sum] = "40b48af0297450e12ac044569fd2263b11ed1fb3ccddfaf4db950b558df3805d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-swscale-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-swscale;unpack=0"
SRC_URI[x86_64_v2_baresip-swscale.sha256sum] = "ece20fc2f8ffdd4ebb9a1dcbd93154e32bd42c2db74e878b70d6716f08830cdc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-tools-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-tools;unpack=0"
SRC_URI[x86_64_v2_baresip-tools.sha256sum] = "093788611306a7483ccd097388da818e09ef67c14271805439d442c13be96787"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-v4l2-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-v4l2;unpack=0"
SRC_URI[x86_64_v2_baresip-v4l2.sha256sum] = "b110513b2aa130d29885767f361698c17ed3d6dd4713ec184ca518340b53299b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp8-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp8;unpack=0"
SRC_URI[x86_64_v2_baresip-vp8.sha256sum] = "5bcea2873e207bd4854ee3f9a0b06e6daf69cf54ee99101aae598e36a37b7a44"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp9-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp9;unpack=0"
SRC_URI[x86_64_v2_baresip-vp9.sha256sum] = "dd62909a7c264b807cec7b12990f8f82003b97312dd889c7b77509d8acae05d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-x11-4.11.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-x11;unpack=0"
SRC_URI[x86_64_v2_baresip-x11.sha256sum] = "35bc50ae68de586b93bf9d91eb3da71343a9c652b5e5ac172048650939d812e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip;unpack=0"
SRC_URI[aarch64_baresip.sha256sum] = "513afa4ae6ff12f12970489548a0845af51a8e991363d927ee0862b4e90adac5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-aac-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-aac;unpack=0"
SRC_URI[aarch64_baresip-aac.sha256sum] = "b8541f0c6d133317fb46dd42e320f7c4bb78939652f9e93336f5c4edaab556de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-alsa-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-alsa;unpack=0"
SRC_URI[aarch64_baresip-alsa.sha256sum] = "8ea11a549ccbf8fd121bbc8d79c1ed8a5f035285d262ee34ff86892a722e15f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-av1-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-av1;unpack=0"
SRC_URI[aarch64_baresip-av1.sha256sum] = "791a8361ee1db943c1c3f05e5f22b45aa82069f94790a566e04d691724170633"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-avcodec-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-avcodec;unpack=0"
SRC_URI[aarch64_baresip-avcodec.sha256sum] = "81a6d4d5def44a80d04ce8ff054c333c97a2ba0346fe587093155ccbffec3ecb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-avfilter-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-avfilter;unpack=0"
SRC_URI[aarch64_baresip-avfilter.sha256sum] = "7e060e2dfc82ddfbe75b5e71ffe0a874e63d8b89c0a112b6aa9f6e5fbd2a6631"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-avformat-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-avformat;unpack=0"
SRC_URI[aarch64_baresip-avformat.sha256sum] = "b693b236f9f39ca1c393678d68e412f2d56e3dc294f0c3e4ac483adebdd0d5a5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-codec2-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-codec2;unpack=0"
SRC_URI[aarch64_baresip-codec2.sha256sum] = "213fac218b1a3ba887137acfceaffa6157946570ef85b5ad4ffdc18a3699594c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-ctrl_dbus-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-ctrl_dbus;unpack=0"
SRC_URI[aarch64_baresip-ctrl_dbus.sha256sum] = "32d28f0b50454a3e516c32b02ca94d7318f2a06ad597058b9f87c77249a6edfa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-devel-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-devel;unpack=0"
SRC_URI[aarch64_baresip-devel.sha256sum] = "a29ec8d754372eb9be37dde2afe213516ffb20f4b55aa0dbfca3f2c287df5f0d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-g722-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-g722;unpack=0"
SRC_URI[aarch64_baresip-g722.sha256sum] = "33214717189ee1d1795108289d2cb69c53c8ce80a25896e0cfefcf1ea6237856"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-gst-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-gst;unpack=0"
SRC_URI[aarch64_baresip-gst.sha256sum] = "0d47032682d534a2713288d28925104e0447296969c9e28d3664de6dea159314"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-gtk-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-gtk;unpack=0"
SRC_URI[aarch64_baresip-gtk.sha256sum] = "b9a017585f54a7110df4dd835b694d5523a192f320e19bebfc35f0f97da4942a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-jack-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-jack;unpack=0"
SRC_URI[aarch64_baresip-jack.sha256sum] = "9e3b7314ebd077f3a2d30723988baee59a6517b8e40a410b1deec3566b06c0a8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-mqtt-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-mqtt;unpack=0"
SRC_URI[aarch64_baresip-mqtt.sha256sum] = "da71af1d3516b4053719e3d595a0775eaf2d0ae34a567e7992a59270f5a3a2d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-opus-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-opus;unpack=0"
SRC_URI[aarch64_baresip-opus.sha256sum] = "ebebfc2ae23a30c316a05f8e067831e2de44c25f55f92fcb3228816e34bb07a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-pipewire-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-pipewire;unpack=0"
SRC_URI[aarch64_baresip-pipewire.sha256sum] = "957f3b0eb3186ef7c407cb26e024be0f49d85aa9e59f98ea48c7f7f564c5dc29"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-plc-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-plc;unpack=0"
SRC_URI[aarch64_baresip-plc.sha256sum] = "08c404ec75774eb486787dad802007cc673200231a0fe97a1a6a614ee3d6b226"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-portaudio-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-portaudio;unpack=0"
SRC_URI[aarch64_baresip-portaudio.sha256sum] = "fb2c5792d5525fa403145c1a663c24fbbe7ad9b03e70814e97c64772582c15c5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-pulse-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-pulse;unpack=0"
SRC_URI[aarch64_baresip-pulse.sha256sum] = "bbf93daa6d2879d4ae2365fe6bf9dbcdbe1871afcb3e378dc2049a5a5de7f2ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-sdl-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-sdl;unpack=0"
SRC_URI[aarch64_baresip-sdl.sha256sum] = "51364e92cf9fef9eb7e483ff629de505fd39cbe1c3148c90b562ab1b6fa28c80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-snapshot-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-snapshot;unpack=0"
SRC_URI[aarch64_baresip-snapshot.sha256sum] = "9bc0fc3520a1631c31df2c38712af7955507416a236f38a960e5f2ea123d80ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-sndfile-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-sndfile;unpack=0"
SRC_URI[aarch64_baresip-sndfile.sha256sum] = "3beed9bd8e890b8d52b77676997efd39555172c6cacab2d3044251940d9a2e1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-swscale-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-swscale;unpack=0"
SRC_URI[aarch64_baresip-swscale.sha256sum] = "8389486cf13da9e0a00d4c008cc81943ab7863a9919bb00e15455df6805442a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-tools-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-tools;unpack=0"
SRC_URI[aarch64_baresip-tools.sha256sum] = "16e437a8e88f53c0520f14a8587503979c345b441c7b73734464f800bf6d61f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-v4l2-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-v4l2;unpack=0"
SRC_URI[aarch64_baresip-v4l2.sha256sum] = "6c6e0fbab6d0ffde6d91160ffe783b96100a6e39d6d1b44470967d94e620b827"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp8-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-vp8;unpack=0"
SRC_URI[aarch64_baresip-vp8.sha256sum] = "76d831e6e7953dc3a2b160308867b5997b6697d6bbede2c405118e30003aac50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp9-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-vp9;unpack=0"
SRC_URI[aarch64_baresip-vp9.sha256sum] = "f27367804c75deee573042f9df1c05ebdc74f743b364f22d7687a11aea05f06f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baresip-x11-4.11.0-1.el10_2.aarch64.rpm;name=aarch64_baresip-x11;unpack=0"
SRC_URI[aarch64_baresip-x11.sha256sum] = "ba33d9184099137944005269b8bdd3e2625381bcb2019e13d740b90a4d94ba22"

RDEPENDS:baresip = " \
 glibc \
 libre \
 "
RDEPENDS:baresip-aac = " \
 baresip \
 fdk-aac-free \
 glibc \
 "
RDEPENDS:baresip-alsa = " \
 alsa-lib \
 baresip \
 glibc \
 "
RDEPENDS:baresip-av1 = " \
 baresip \
 glibc \
 libaom \
 "
RDEPENDS:baresip-avcodec = " \
 baresip \
 glibc \
 libavcodec-free \
 libavutil-free \
 "
RDEPENDS:baresip-avfilter = " \
 baresip \
 glibc \
 libavfilter-free \
 libavutil-free \
 "
RDEPENDS:baresip-avformat = " \
 baresip \
 glibc \
 libavcodec-free \
 libavdevice-free \
 libavformat-free \
 libavutil-free \
 libswresample-free \
 "
RDEPENDS:baresip-codec2 = " \
 baresip \
 codec2 \
 glibc \
 "
RDEPENDS:baresip-ctrl_dbus = " \
 baresip \
 glib2 \
 glibc \
 "
RDEPENDS:baresip-devel = " \
 baresip \
 pkgconf-pkg-config \
 "
RDEPENDS:baresip-g722 = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-gst = " \
 baresip \
 glib2 \
 glibc \
 gstreamer1 \
 "
RDEPENDS:baresip-gtk = " \
 adwaita-icon-theme \
 baresip \
 glib2 \
 glibc \
 gnome-shell-extension-appindicator \
 gtk3 \
 "
RDEPENDS:baresip-jack = " \
 baresip \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:baresip-mqtt = " \
 baresip \
 glibc \
 mosquitto \
 "
RDEPENDS:baresip-opus = " \
 baresip \
 glibc \
 opus \
 "
RDEPENDS:baresip-pipewire = " \
 baresip \
 glibc \
 pipewire-libs \
 "
RDEPENDS:baresip-plc = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-portaudio = " \
 baresip \
 glibc \
 portaudio \
 "
RDEPENDS:baresip-pulse = " \
 baresip \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:baresip-sdl = " \
 baresip \
 glibc \
 sdl2-compat \
 "
RDEPENDS:baresip-snapshot = " \
 baresip \
 glibc \
 libpng \
 "
RDEPENDS:baresip-sndfile = " \
 baresip \
 glibc \
 libsndfile \
 "
RDEPENDS:baresip-swscale = " \
 baresip \
 glibc \
 libswscale-free \
 "
RDEPENDS:baresip-tools = " \
 baresip \
 python3 \
 "
RDEPENDS:baresip-v4l2 = " \
 baresip \
 glibc \
 "
RDEPENDS:baresip-vp8 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-vp9 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-x11 = " \
 baresip \
 glibc \
 libX11 \
 libXext \
 "
