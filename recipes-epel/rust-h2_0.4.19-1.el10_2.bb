# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-h2"
PV = "0.4.19"
PR = "1.el10_2"
PACKAGES = " \
 rust-h2+default-devel \
 rust-h2+stream-devel \
 rust-h2+unstable-devel \
 rust-h2-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-h2-0.4.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4bb5223972a516ecf3fea439d0c0725b85ffcdc263136e52d7b173d52919df29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+default-devel-0.4.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-h2+default-devel.sha256sum] = "011b4a57f72331423975c2ef167dbe902a1054e311b2d5f9e1db3fa3b8d2ea69"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+stream-devel-0.4.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+stream-devel;unpack=0"
SRC_URI[x86_64_v2_rust-h2+stream-devel.sha256sum] = "6576bf055a60caaf0d4c6e3702f233d68151a7bb0d45ff2265c391d43f759fa2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2+unstable-devel-0.4.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-h2+unstable-devel.sha256sum] = "ae99cc1155771277ebef2a96734c58b52452d9ac2453c2025ca4d43732c32ede"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-h2-devel-0.4.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-h2-devel;unpack=0"
SRC_URI[x86_64_v2_rust-h2-devel.sha256sum] = "575dcfa1a8d18357005f4cf213d5da30a92ba0e8da9a97cc02ba57b13f908032"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+default-devel-0.4.19-1.el10_2.noarch.rpm;name=aarch64_rust-h2+default-devel;unpack=0"
SRC_URI[aarch64_rust-h2+default-devel.sha256sum] = "be1d59722858d6bae2d7973d8b038c1953f16b553e1fe5c61d508ce81cc74045"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+stream-devel-0.4.19-1.el10_2.noarch.rpm;name=aarch64_rust-h2+stream-devel;unpack=0"
SRC_URI[aarch64_rust-h2+stream-devel.sha256sum] = "cf022e406854e8c0afe3c12c63218b456b8c63153c1116e1778cdbd45e86dd2e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-h2+unstable-devel-0.4.19-1.el10_2.noarch.rpm;name=aarch64_rust-h2+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-h2+unstable-devel.sha256sum] = "d6b654645206e539b7ff4ecae5ef280ba89b558e617ebea78b0cf42680675da0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-h2-devel-0.4.19-1.el10_2.noarch.rpm;name=aarch64_rust-h2-devel;unpack=0"
SRC_URI[aarch64_rust-h2-devel.sha256sum] = "35ef26f226d41b45a57cc1635080a142051d1beeb77ad57ac9955ead71a1ac24"

RDEPENDS:rust-h2+default-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+stream-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2+unstable-devel = " \
 cargo \
 rust-h2-devel \
 "
RDEPENDS:rust-h2-devel = " \
 cargo \
 rust \
 rust-atomic-waker+default-devel \
 rust-bytes+default-devel \
 rust-fnv+default-devel \
 rust-futures-core-devel \
 rust-futures-sink-devel \
 rust-http+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-slab+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-util+codec-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+io-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
