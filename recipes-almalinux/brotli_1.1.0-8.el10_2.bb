# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "brotli"
PV = "1.1.0"
PR = "8.el10_2"
PACKAGES = " \
 brotli \
 brotli-devel \
 libbrotli \
 python3-brotli \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/brotli-1.1.0-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "22cc0f3abb53358824715d88ce39f4b67239e1a8fb0054dd2109c958ecdb0e79"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-1.1.0-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_brotli;unpack=0"
SRC_URI[x86_64_v2_brotli.sha256sum] = "bf22b615fe3ea530ee8f28fcde28680dd3816d908a208e2b8215995cc7787e91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/brotli-devel-1.1.0-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_brotli-devel;unpack=0"
SRC_URI[x86_64_v2_brotli-devel.sha256sum] = "fdf230806e1bd9e4d0dec446d851057df1e83cb466ec6d0fc99ef2e793ad6642"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libbrotli-1.1.0-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_libbrotli;unpack=0"
SRC_URI[x86_64_v2_libbrotli.sha256sum] = "90038bd984eae5d810cdc00e5abb9a0d36770792d88a100cc90c09dfebe85f88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-brotli-1.1.0-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-brotli;unpack=0"
SRC_URI[x86_64_v2_python3-brotli.sha256sum] = "2c9c3cc672682ac7247a8798ae8fc42521cfe00869edcd3c8be56246c5db9ca3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-1.1.0-8.el10_2.aarch64.rpm;name=aarch64_brotli;unpack=0"
SRC_URI[aarch64_brotli.sha256sum] = "1e11c9952c20e2c8ef50cf7fa6f88843ed37b0f907fdbf7976567cf6a010afbd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/brotli-devel-1.1.0-8.el10_2.aarch64.rpm;name=aarch64_brotli-devel;unpack=0"
SRC_URI[aarch64_brotli-devel.sha256sum] = "05ec35b1342a163a671734d412362908a01a062aca4975232f76561e694fa04b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libbrotli-1.1.0-8.el10_2.aarch64.rpm;name=aarch64_libbrotli;unpack=0"
SRC_URI[aarch64_libbrotli.sha256sum] = "33869ef9400dcc394edfb29dea9a7fb7c1e337fb6c6cad911b31b7c45f5fd18e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-brotli-1.1.0-8.el10_2.aarch64.rpm;name=aarch64_python3-brotli;unpack=0"
SRC_URI[aarch64_python3-brotli.sha256sum] = "22f9657c1c96d8b046882fe9744202dda6695062e42c6b4e678664b03a0554ab"

RDEPENDS:brotli = " \
 glibc \
 libbrotli \
 "
RDEPENDS:brotli-devel = " \
 brotli \
 brotli-devel \
 libbrotli \
 pkgconf-pkg-config \
 "
RDEPENDS:libbrotli = " \
 glibc \
 "
RDEPENDS:python3-brotli = " \
 glibc \
 python3 \
 "
