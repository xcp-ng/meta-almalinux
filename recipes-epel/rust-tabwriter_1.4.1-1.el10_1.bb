# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tabwriter"
PV = "1.4.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-tabwriter+ansi_formatting-devel \
 rust-tabwriter+default-devel \
 rust-tabwriter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tabwriter-1.4.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41617930cfab1c8062f33da766130e45795cfbb683023a4bb302fcaff591d377"

URI_x86_64_v2_rust-tabwriter+ansi_formatting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tabwriter+ansi_formatting-devel-1.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tabwriter+ansi_formatting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tabwriter+ansi_formatting-devel}"
SRC_URI[x86_64_v2_rust-tabwriter+ansi_formatting-devel.sha256sum] = "36823f282510eb6e63193734d404c0eebc6bf60811962d10566bf4fb8fcce9ac"

URI_x86_64_v2_rust-tabwriter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tabwriter+default-devel-1.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tabwriter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tabwriter+default-devel}"
SRC_URI[x86_64_v2_rust-tabwriter+default-devel.sha256sum] = "43cb7d177264792d0d5c66662a3d7e87ec43dc6a62661d21cd81a2244b84da2b"

URI_x86_64_v2_rust-tabwriter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tabwriter-devel-1.4.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tabwriter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tabwriter-devel}"
SRC_URI[x86_64_v2_rust-tabwriter-devel.sha256sum] = "d5fe1acf74b8e06f134a3dc7e8719d0a4f7336dc3f57b7960204c992275fe834"

URI_aarch64_rust-tabwriter+ansi_formatting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tabwriter+ansi_formatting-devel-1.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-tabwriter+ansi_formatting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tabwriter+ansi_formatting-devel}"
SRC_URI[aarch64_rust-tabwriter+ansi_formatting-devel.sha256sum] = "2a4ff89023da8686b34b83c37864ee6d445578f98b83dc5061a4f8ca61078fba"

URI_aarch64_rust-tabwriter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tabwriter+default-devel-1.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-tabwriter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tabwriter+default-devel}"
SRC_URI[aarch64_rust-tabwriter+default-devel.sha256sum] = "01ad0a37263eb419677a34f2eab80999bbf93266878cce8ad0d0a9c99c1eab34"

URI_aarch64_rust-tabwriter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tabwriter-devel-1.4.1-1.el10_1.noarch.rpm;name=aarch64_rust-tabwriter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tabwriter-devel}"
SRC_URI[aarch64_rust-tabwriter-devel.sha256sum] = "5d8315c8c5f09993f0a17fdc7c0185956c734a16b548fd67a8be0b9cc72f15d3"

RDEPENDS:rust-tabwriter+ansi_formatting-devel = " \
 cargo \
 rust-tabwriter-devel \
 "
RDEPENDS:rust-tabwriter+default-devel = " \
 cargo \
 rust-tabwriter-devel \
 "
RDEPENDS:rust-tabwriter-devel = " \
 cargo \
 rust-unicode-width+default-devel \
 "
