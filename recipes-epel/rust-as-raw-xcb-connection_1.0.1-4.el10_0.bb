# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-as-raw-xcb-connection"
PV = "1.0.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-as-raw-xcb-connection+alloc-devel \
 rust-as-raw-xcb-connection+default-devel \
 rust-as-raw-xcb-connection-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-as-raw-xcb-connection-1.0.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "026f795654b9ea6bf6179cc41f59ea968ec0e165c85bbe4dca8f7902734c58a5"

URI_x86_64_v2_rust-as-raw-xcb-connection+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-as-raw-xcb-connection+alloc-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-as-raw-xcb-connection+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-as-raw-xcb-connection+alloc-devel}"
SRC_URI[x86_64_v2_rust-as-raw-xcb-connection+alloc-devel.sha256sum] = "116cb52e89f8bbf1bf8bf3e7591e611d501bfefddfd50931e765fb9ac389826e"

URI_x86_64_v2_rust-as-raw-xcb-connection+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-as-raw-xcb-connection+default-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-as-raw-xcb-connection+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-as-raw-xcb-connection+default-devel}"
SRC_URI[x86_64_v2_rust-as-raw-xcb-connection+default-devel.sha256sum] = "ab0733a988328f0c79172c35d2167c09c8948f69e7e6e0bd8e23bc4849a5455b"

URI_x86_64_v2_rust-as-raw-xcb-connection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-as-raw-xcb-connection-devel-1.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-as-raw-xcb-connection-devel}"
SRC_URI[x86_64_v2_rust-as-raw-xcb-connection-devel.sha256sum] = "72ca35dda721ffa32520a94160f70cf8bbcfda259330f5f563f357a0fb600e7f"

URI_aarch64_rust-as-raw-xcb-connection+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-as-raw-xcb-connection+alloc-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-as-raw-xcb-connection+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-as-raw-xcb-connection+alloc-devel}"
SRC_URI[aarch64_rust-as-raw-xcb-connection+alloc-devel.sha256sum] = "083515aaf7af8f75a20bc4a49774192d79f04ea1396e454b6c48c96af348c757"

URI_aarch64_rust-as-raw-xcb-connection+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-as-raw-xcb-connection+default-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-as-raw-xcb-connection+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-as-raw-xcb-connection+default-devel}"
SRC_URI[aarch64_rust-as-raw-xcb-connection+default-devel.sha256sum] = "1c037ec8bca8c1753e5904bec65141e084b989cd479e1f5d4662880cd8e69fc8"

URI_aarch64_rust-as-raw-xcb-connection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-as-raw-xcb-connection-devel-1.0.1-4.el10_0.noarch.rpm;name=aarch64_rust-as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-as-raw-xcb-connection-devel}"
SRC_URI[aarch64_rust-as-raw-xcb-connection-devel.sha256sum] = "7348e8a14a7ab509dfc78e8e6f32ddfa286fee31aa194c1527f393a2507c3cd2"

RDEPENDS:rust-as-raw-xcb-connection+alloc-devel = " \
 cargo \
 rust-as-raw-xcb-connection-devel \
 "
RDEPENDS:rust-as-raw-xcb-connection+default-devel = " \
 cargo \
 rust-as-raw-xcb-connection+alloc-devel \
 rust-as-raw-xcb-connection-devel \
 "
RDEPENDS:rust-as-raw-xcb-connection-devel = " \
 cargo \
 "
