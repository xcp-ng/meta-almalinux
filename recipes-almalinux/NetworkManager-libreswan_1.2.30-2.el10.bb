# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-libreswan"
PV = "1.2.30"
PR = "2.el10"
PACKAGES = " \
 NetworkManager-libreswan \
 NetworkManager-libreswan-gnome \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/NetworkManager-libreswan-1.2.30-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20e2030755269979f6f8df1d95c65d8cb7074cf0749a6e5343afa2d73acf10db"

URI_x86_64_v2_NetworkManager-libreswan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-1.2.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libreswan}"
SRC_URI[x86_64_v2_NetworkManager-libreswan.sha256sum] = "dcc68f864c571d07c0acb6a5cb50032b6a8c0e433fe317a8e677448a9cda1c2b"

URI_x86_64_v2_NetworkManager-libreswan-gnome = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-gnome-1.2.30-2.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libreswan-gnome}"
SRC_URI[x86_64_v2_NetworkManager-libreswan-gnome.sha256sum] = "d6bb0d51095b164775fe3ceacde5fef50fe1628279323202af7f5f4e7dd67c88"

URI_aarch64_NetworkManager-libreswan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-1.2.30-2.el10.aarch64.rpm;name=aarch64_NetworkManager-libreswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libreswan}"
SRC_URI[aarch64_NetworkManager-libreswan.sha256sum] = "d649e8860b1ace9906046422d4e20261ab619cc5c579d66f5b768a67af6481b8"

URI_aarch64_NetworkManager-libreswan-gnome = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-gnome-1.2.30-2.el10.aarch64.rpm;name=aarch64_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libreswan-gnome}"
SRC_URI[aarch64_NetworkManager-libreswan-gnome.sha256sum] = "b33b4d8cae985ef53178f7099a8043d3c6929564a1b8a5ce56a8e21f5eb259cf"

RDEPENDS:NetworkManager-libreswan = " \
 NetworkManager \
 NetworkManager-libnm \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 libnl3 \
 libreswan-minimal \
 "
RDEPENDS:NetworkManager-libreswan-gnome = " \
 NetworkManager-libnm \
 NetworkManager-libreswan \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 pango \
 shared-mime-info \
 vulkan-loader \
 "
