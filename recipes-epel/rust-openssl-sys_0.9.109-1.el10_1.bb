# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl-sys"
PV = "0.9.109"
PR = "1.el10_1"
PACKAGES = " \
 rust-openssl-sys+bindgen-devel \
 rust-openssl-sys+default-devel \
 rust-openssl-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-sys-0.9.109-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efff64b83df22b2204b1dee2c27414db37008552d264418bdfeba4f7a1fe3eed"

URI_x86_64_v2_rust-openssl-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys+bindgen-devel-0.9.109-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys+bindgen-devel.sha256sum] = "c068bb940c03d62ae9533328ebc2a5a2bb698efc6c549df6d14884ec04308c7d"

URI_x86_64_v2_rust-openssl-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys+default-devel-0.9.109-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys+default-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys+default-devel.sha256sum] = "4025e1f84023506e65058dc4144a42a2a62b1a6cac887d9052b9221401e97537"

URI_x86_64_v2_rust-openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-sys-devel-0.9.109-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-openssl-sys-devel.sha256sum] = "30c0fa7e0e6638fb7125461a00b9118653518699da80e2995aaedf4f05e2c861"

URI_aarch64_rust-openssl-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys+bindgen-devel-0.9.109-1.el10_1.noarch.rpm;name=aarch64_rust-openssl-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys+bindgen-devel}"
SRC_URI[aarch64_rust-openssl-sys+bindgen-devel.sha256sum] = "589fddacee87e3aacdb3462d393c19b885d001a648856d1373dcf296c2b2ecd0"

URI_aarch64_rust-openssl-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys+default-devel-0.9.109-1.el10_1.noarch.rpm;name=aarch64_rust-openssl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys+default-devel}"
SRC_URI[aarch64_rust-openssl-sys+default-devel.sha256sum] = "35746650c273aac5f637144391ed9ac912de72e893b3db41e2ac606e528e40e4"

URI_aarch64_rust-openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-sys-devel-0.9.109-1.el10_1.noarch.rpm;name=aarch64_rust-openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-sys-devel}"
SRC_URI[aarch64_rust-openssl-sys-devel.sha256sum] = "911950246a27ca01f58164ba8f7935b078f13c426662f85eb96c938609dc65ee"

RDEPENDS:rust-openssl-sys+bindgen-devel = " \
 cargo \
 rust-bindgen0.69+default-devel \
 rust-bindgen0.69+experimental-devel \
 rust-openssl-sys-devel \
 "
RDEPENDS:rust-openssl-sys+default-devel = " \
 cargo \
 rust-openssl-sys-devel \
 "
RDEPENDS:rust-openssl-sys-devel = " \
 cargo \
 openssl-devel \
 rust \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
