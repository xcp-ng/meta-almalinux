# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-arrow"
PV = "1.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-arrow \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-arrow-1.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0e232ffa22574fb49a5b0b965dcf3d447e77149a877bc32e6bbcf30bc7be2a2"

URI_x86_64_v2_python3-arrow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-arrow-1.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-arrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-arrow}"
SRC_URI[x86_64_v2_python3-arrow.sha256sum] = "49b851e5a0d3abd007bae27820beae8308af840d17148c0590cd0ab14d0e2b62"

URI_aarch64_python3-arrow = "${EPEL_MIRROR}/aarch64/Packages/p/python3-arrow-1.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-arrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-arrow}"
SRC_URI[aarch64_python3-arrow.sha256sum] = "d2cdcad7fd32cc20bf38bc871bc342c2a4cd9dd0793ba574068d53283fd8adf2"

RDEPENDS:python3-arrow = " \
 python3 \
 python3-dateutil \
 "
