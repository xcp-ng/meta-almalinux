# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-vmihailenco-msgpack-2"
PV = "2.9.1"
PR = "14.el10_0"
PACKAGES = " \
 golang-gopkg-vmihailenco-msgpack-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-vmihailenco-msgpack-2-2.9.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d484f146423f3bfc930456b624f1ec8ff4269e8f0a470138e08b2ffc0ee520dc"

URI_x86_64_v2_golang-gopkg-vmihailenco-msgpack-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-vmihailenco-msgpack-2-devel-2.9.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-vmihailenco-msgpack-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-vmihailenco-msgpack-2-devel}"
SRC_URI[x86_64_v2_golang-gopkg-vmihailenco-msgpack-2-devel.sha256sum] = "84a75b2d84713f6a84bf6605d748712867dc6766fc9c24117e6d729e000407ae"

URI_aarch64_golang-gopkg-vmihailenco-msgpack-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-vmihailenco-msgpack-2-devel-2.9.1-14.el10_0.noarch.rpm;name=aarch64_golang-gopkg-vmihailenco-msgpack-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-vmihailenco-msgpack-2-devel}"
SRC_URI[aarch64_golang-gopkg-vmihailenco-msgpack-2-devel.sha256sum] = "4d82af54f573ab5cb1a7cc1e4745834942d19386f4e3d778231aad57b2282d7c"

RDEPENDS:golang-gopkg-vmihailenco-msgpack-2-devel = " \
 go-filesystem \
 "
