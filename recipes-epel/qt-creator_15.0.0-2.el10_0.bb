# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt-creator"
PV = "15.0.0"
PR = "2.el10_0"
PACKAGES = " \
 qt-creator \
 qt-creator-data \
 qt-creator-doc \
 qt-creator-translations \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt-creator-15.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efd69834ced849cce9859d00a1e6fd41345769bc68dc4a9279580727a8dae873"

URI_x86_64_v2_qt-creator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-15.0.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt-creator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator}"
SRC_URI[x86_64_v2_qt-creator.sha256sum] = "f1280f7cd866f3abc0187a4b75a24118f551019c32de7879aa89e0cb14b5a51a"

URI_x86_64_v2_qt-creator-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-data-15.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator-data}"
SRC_URI[x86_64_v2_qt-creator-data.sha256sum] = "598885ffe4e9b0a3248cb126479a71414de89fe5aa04c8fba900bb5da90f7cfa"

URI_x86_64_v2_qt-creator-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-doc-15.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator-doc}"
SRC_URI[x86_64_v2_qt-creator-doc.sha256sum] = "7a8e566144523eb00fda7be5a53d7c4e5c06848aa6477dda8bfad6009219a1af"

URI_x86_64_v2_qt-creator-translations = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt-creator-translations-15.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt-creator-translations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt-creator-translations}"
SRC_URI[x86_64_v2_qt-creator-translations.sha256sum] = "500acca4df6c7a947d4893a0bf19a7950a16413b124da00372c6ece591f1c77a"

URI_aarch64_qt-creator = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-15.0.0-2.el10_0.aarch64.rpm;name=aarch64_qt-creator;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator}"
SRC_URI[aarch64_qt-creator.sha256sum] = "086f136bf983bb4c811ae04befe4199a35a066c712d675bed9f673ed08d9a3e9"

URI_aarch64_qt-creator-data = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-data-15.0.0-2.el10_0.noarch.rpm;name=aarch64_qt-creator-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator-data}"
SRC_URI[aarch64_qt-creator-data.sha256sum] = "c348b5c35f29be4b9948d7983d34a5636ca12cd92f9d7e57c22b15a3da8c3b95"

URI_aarch64_qt-creator-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-doc-15.0.0-2.el10_0.noarch.rpm;name=aarch64_qt-creator-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator-doc}"
SRC_URI[aarch64_qt-creator-doc.sha256sum] = "345042225155a2f5d6609dc83572c7b65d418dd547760c2053afab073a85f566"

URI_aarch64_qt-creator-translations = "${EPEL_MIRROR}/aarch64/Packages/q/qt-creator-translations-15.0.0-2.el10_0.noarch.rpm;name=aarch64_qt-creator-translations;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt-creator-translations}"
SRC_URI[aarch64_qt-creator-translations.sha256sum] = "d12bfc76b983670d61468f70a633a82c258a5f5480f0f731d066147b6b1149d2"

RDEPENDS:qt-creator = " \
 bash \
 clang-libs \
 elfutils-libelf \
 elfutils-libs \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 libzstd \
 litehtml \
 llvm-libs \
 qt-creator-data \
 qt-creator-doc \
 qt-creator-translations \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 qt6-qtserialport \
 qt6-qtsvg \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-designercomponents \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 systemd-libs \
 xdg-utils \
 yaml-cpp \
 "
RDEPENDS:qt-creator-data = " \
 qt-creator \
 "
RDEPENDS:qt-creator-doc = " \
 qt-creator \
 "
RDEPENDS:qt-creator-translations = " \
 qt-creator-data \
 qt6-qttranslations \
 "
