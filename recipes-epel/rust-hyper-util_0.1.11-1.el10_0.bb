# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper-util"
PV = "0.1.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+full-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+server-graceful-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util+tracing-devel \
 rust-hyper-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-util-0.1.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d810334cd4a8914b0ea82bb8972031c3e343b077a2f2466f1a5b81c0e4f6ff8"

URI_x86_64_v2_rust-hyper-util+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-devel.sha256sum] = "be53a0ae5b2a565264c37b0bf65ea7400e9ffcaae491d190ae28bd55ee8de33e"

URI_x86_64_v2_rust-hyper-util+client-legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+client-legacy-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+client-legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+client-legacy-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+client-legacy-devel.sha256sum] = "4c4f939c29d83cb6ff198d4f44d2d75820bbbe0ce04e5cd8f6f1d84f3c593d83"

URI_x86_64_v2_rust-hyper-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+default-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+default-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+default-devel.sha256sum] = "06463f7856790a5c92bbc0dc9c242eb72f1ce04fb6276b6c049099045852fabf"

URI_x86_64_v2_rust-hyper-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+full-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+full-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+full-devel.sha256sum] = "73a94281078f45d6becb05b121eb604efe185b73a6c342c0cddac716ff89eb5f"

URI_x86_64_v2_rust-hyper-util+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+http1-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+http1-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+http1-devel.sha256sum] = "4e464b6263bc4d7988fb78ec9bc3b88f53152162204019cb2ede94a7ec96b43b"

URI_x86_64_v2_rust-hyper-util+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+http2-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+http2-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+http2-devel.sha256sum] = "fd792178a7c1318d0aa49fa115bce882c290b22f2702fc38557a82ca5f3175b1"

URI_x86_64_v2_rust-hyper-util+server-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-auto-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+server-auto-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+server-auto-devel.sha256sum] = "ae617d12ec90d0eff5ba98379b0126ed3ac726eeff120ee1654ac308fb6f93d2"

URI_x86_64_v2_rust-hyper-util+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+server-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+server-devel.sha256sum] = "446f2466eb89249edf471c667138207c48481d79f1c645fbc97b87284f2182c3"

URI_x86_64_v2_rust-hyper-util+server-graceful-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+server-graceful-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+server-graceful-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+server-graceful-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+server-graceful-devel.sha256sum] = "f784eeb44a0fc63872ffb5b32c21cfef7af16d75d0cb6c37ad627f92d5bf503d"

URI_x86_64_v2_rust-hyper-util+service-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+service-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+service-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+service-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+service-devel.sha256sum] = "958fdd7ac94eb17864347fe1305574cec34110e8b7d97c26eed76b5a70da3c59"

URI_x86_64_v2_rust-hyper-util+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+tokio-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+tokio-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+tokio-devel.sha256sum] = "ca0f9401953f669fdd88675853c8e6d49fcdaebf97c91fb112d01704ee69674e"

URI_x86_64_v2_rust-hyper-util+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util+tracing-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util+tracing-devel}"
SRC_URI[x86_64_v2_rust-hyper-util+tracing-devel.sha256sum] = "e9443233247b73a8f73ce8c7c95aa863aca0a030e2e383de50e8cd7e64795481"

URI_x86_64_v2_rust-hyper-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-util-devel-0.1.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-util-devel}"
SRC_URI[x86_64_v2_rust-hyper-util-devel.sha256sum] = "308e9f0d6698c8cca23b02c0958a76aa20c39d4db57a8b352263ba913b6baa6a"

URI_aarch64_rust-hyper-util+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-devel}"
SRC_URI[aarch64_rust-hyper-util+client-devel.sha256sum] = "712eec22511bec2b718c68d2ed416d4671e06609215b2c6cfb65a63f1388e2bf"

URI_aarch64_rust-hyper-util+client-legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+client-legacy-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+client-legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+client-legacy-devel}"
SRC_URI[aarch64_rust-hyper-util+client-legacy-devel.sha256sum] = "661e6b7877a015897a4ef012ac517a8892ac3a7660c310c7cef7a979fa9a111f"

URI_aarch64_rust-hyper-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+default-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+default-devel}"
SRC_URI[aarch64_rust-hyper-util+default-devel.sha256sum] = "175b9068675f0bb1af84749e5c8d5dbad9887b7dd01561cb22e2efcc416d1e03"

URI_aarch64_rust-hyper-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+full-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+full-devel}"
SRC_URI[aarch64_rust-hyper-util+full-devel.sha256sum] = "b7c96f3b0c3ffd84e32e63696d28502c6339e3f649f5a9179166676c5e648831"

URI_aarch64_rust-hyper-util+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+http1-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+http1-devel}"
SRC_URI[aarch64_rust-hyper-util+http1-devel.sha256sum] = "088b2d83620e1c30f6ef7eb90152d889327dd25bb63b1f96d86c80323f83eb05"

URI_aarch64_rust-hyper-util+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+http2-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+http2-devel}"
SRC_URI[aarch64_rust-hyper-util+http2-devel.sha256sum] = "a1e470d97b5dd20853c653769acf12fc643eaef1de43748c6fa0b2bd20cdfc96"

URI_aarch64_rust-hyper-util+server-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-auto-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+server-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+server-auto-devel}"
SRC_URI[aarch64_rust-hyper-util+server-auto-devel.sha256sum] = "3a3df327566e36c8be7e75547cb038d946720b77cf4896f05452892a49cbdf55"

URI_aarch64_rust-hyper-util+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+server-devel}"
SRC_URI[aarch64_rust-hyper-util+server-devel.sha256sum] = "4f45318503fe76b6aa7ca559157eb7a238423c77f83347b6ac1d68f73d0a3a15"

URI_aarch64_rust-hyper-util+server-graceful-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+server-graceful-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+server-graceful-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+server-graceful-devel}"
SRC_URI[aarch64_rust-hyper-util+server-graceful-devel.sha256sum] = "641b5b437df8fbf79d553d87fd7c72c1fecf908525f0a7f98202e2f7bf0ab0e4"

URI_aarch64_rust-hyper-util+service-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+service-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+service-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+service-devel}"
SRC_URI[aarch64_rust-hyper-util+service-devel.sha256sum] = "d4ff1a4cad0b80327a39468bc4cbdc78c3bc68727e398d6ee0b3f642a519211a"

URI_aarch64_rust-hyper-util+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+tokio-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+tokio-devel}"
SRC_URI[aarch64_rust-hyper-util+tokio-devel.sha256sum] = "852c5d15cc81419daf8feb1b6e7ad99d302f140156a944f1e36ce04066bb963d"

URI_aarch64_rust-hyper-util+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util+tracing-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util+tracing-devel}"
SRC_URI[aarch64_rust-hyper-util+tracing-devel.sha256sum] = "749ec0873296d3db7c6962028ee812eb483281a7ffb281a388d88376f14b261d"

URI_aarch64_rust-hyper-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-util-devel-0.1.11-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-util-devel}"
SRC_URI[aarch64_rust-hyper-util-devel.sha256sum] = "2fb329addd8cce2fdbfed7534a8006896e4f540bd97d25199cb2a2f13f186883"

RDEPENDS:rust-hyper-util+client-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-hyper+client-devel \
 rust-hyper-util-devel \
 rust-tower-service+default-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-util+client-legacy-devel = " \
 cargo \
 rust-hyper-util+client-devel \
 rust-hyper-util-devel \
 rust-libc+default-devel \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-tokio+sync-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+default-devel = " \
 cargo \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+full-devel = " \
 cargo \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util+server-graceful-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util+tracing-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+http1-devel = " \
 cargo \
 rust-hyper+http1-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+http2-devel = " \
 cargo \
 rust-hyper+http2-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-auto-devel = " \
 cargo \
 rust-hyper-util+http1-devel \
 rust-hyper-util+http2-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-devel = " \
 cargo \
 rust-hyper+server-devel \
 rust-hyper-util-devel \
 "
RDEPENDS:rust-hyper-util+server-graceful-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-hyper-util+server-devel \
 rust-hyper-util-devel \
 rust-tokio+sync-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+service-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tower-service+default-devel \
 "
RDEPENDS:rust-hyper-util+tokio-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-hyper-util+tracing-devel = " \
 cargo \
 rust-hyper-util-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-util-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-hyper+default-devel \
 rust-pin-project-lite+default-devel \
 "
