# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.13-flit-core"
PV = "3.12.0"
PR = "1.el10_0"
PACKAGES = " \
 python3.13-flit-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3.13-flit-core-3.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65787c4539659793b91321d189c865b5c670dcaee5d516d4bc3fb6ebc8a407d2"

URI_x86_64_v2_python3.13-flit-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-flit-core-3.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3.13-flit-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-flit-core}"
SRC_URI[x86_64_v2_python3.13-flit-core.sha256sum] = "a18a11fb93c20be702fc0325f17cfb3f1a5dbdbb913eb0a2da116eb455cf3421"

URI_aarch64_python3.13-flit-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-flit-core-3.12.0-1.el10_0.noarch.rpm;name=aarch64_python3.13-flit-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-flit-core}"
SRC_URI[aarch64_python3.13-flit-core.sha256sum] = "180de4d42a0d44e3478830b401786e4ec22577267d214ab0323a0589dbf38373"

RDEPENDS:python3.13-flit-core = " \
 python3.13 \
 "
