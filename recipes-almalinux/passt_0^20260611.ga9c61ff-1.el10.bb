# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "passt"
PV = "0^20260611.ga9c61ff"
PR = "1.el10"
PACKAGES = " \
 passt \
 passt-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/passt-0^20260611.ga9c61ff-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aee6fc02a795a1d5a1feed697436273eb9c3aa27fb80aa1803fbe5f709ee9b9"

URI_x86_64_v2_passt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-0^20260611.ga9c61ff-1.el10.x86_64_v2.rpm;name=x86_64_v2_passt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_passt}"
SRC_URI[x86_64_v2_passt.sha256sum] = "20702e72080b65bdc1853f49215121fc8539d9d34c26a974988030aaa23bd315"

URI_x86_64_v2_passt-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/passt-selinux-0^20260611.ga9c61ff-1.el10.noarch.rpm;name=x86_64_v2_passt-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_passt-selinux}"
SRC_URI[x86_64_v2_passt-selinux.sha256sum] = "582e2870e97c8510f93d36b023fde56ae5efc8c8ccd0fef971c26b594fb327a8"

URI_aarch64_passt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-0^20260611.ga9c61ff-1.el10.aarch64.rpm;name=aarch64_passt;unpack=0"
SRC_URI:append = " ${URI_aarch64_passt}"
SRC_URI[aarch64_passt.sha256sum] = "365da1a1d4870d294a7e6cd86a1d14192378e4000481620b4c9533ee8822b650"

URI_aarch64_passt-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/passt-selinux-0^20260611.ga9c61ff-1.el10.noarch.rpm;name=aarch64_passt-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_passt-selinux}"
SRC_URI[aarch64_passt-selinux.sha256sum] = "582e2870e97c8510f93d36b023fde56ae5efc8c8ccd0fef971c26b594fb327a8"

RDEPENDS:passt = " \
 glibc \
 passt-selinux \
 "
RDEPENDS:passt-selinux = " \
 bash \
 container-selinux \
 libselinux-utils \
 policycoreutils \
 selinux-policy-targeted \
 "
