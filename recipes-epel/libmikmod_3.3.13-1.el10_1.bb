# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmikmod"
PV = "3.3.13"
PR = "1.el10_1"
PACKAGES = " \
 libmikmod \
 libmikmod-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmikmod-3.3.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22e9f7e3bcfd501aff082d8c0848d5709aa4842a187b97449cef491788ba05c6"

URI_x86_64_v2_libmikmod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmikmod-3.3.13-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmikmod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmikmod}"
SRC_URI[x86_64_v2_libmikmod.sha256sum] = "050c179878bb8252539fbc8dc67c224137b859d240d03cb7fc58c0de8d14297c"

URI_x86_64_v2_libmikmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmikmod-devel-3.3.13-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmikmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmikmod-devel}"
SRC_URI[x86_64_v2_libmikmod-devel.sha256sum] = "f77cd4d1efb3dbe5d43717ee4852bcb98cd8223c9edac649a1f01f433a144655"

URI_aarch64_libmikmod = "${EPEL_MIRROR}/aarch64/Packages/l/libmikmod-3.3.13-1.el10_1.aarch64.rpm;name=aarch64_libmikmod;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmikmod}"
SRC_URI[aarch64_libmikmod.sha256sum] = "2c05ce8ab16510fd6e5d2990e101b8ed572da95bf1512d9bf04412ae2cbb5052"

URI_aarch64_libmikmod-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmikmod-devel-3.3.13-1.el10_1.aarch64.rpm;name=aarch64_libmikmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmikmod-devel}"
SRC_URI[aarch64_libmikmod-devel.sha256sum] = "81cfd3a53c9d095b6ac49f5c1f97886a0eb459e1e4d6029974b6b00529e88ac9"

RDEPENDS:libmikmod = " \
 glibc \
 "
RDEPENDS:libmikmod-devel = " \
 bash \
 libmikmod \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 "
