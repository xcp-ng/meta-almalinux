# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-shared_child"
PV = "1.0.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-shared_child+default-devel \
 rust-shared_child-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-shared_child-1.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "813f7939ee65914a8f51303007cc8a69d28d4bb609ba820955fe5bb38b2dce89"

URI_x86_64_v2_rust-shared_child+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shared_child+default-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shared_child+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shared_child+default-devel}"
SRC_URI[x86_64_v2_rust-shared_child+default-devel.sha256sum] = "2855c9e4168b3916a40d1836dd488987b1e0b14d50aca2cee66410a2f127bb8f"

URI_x86_64_v2_rust-shared_child-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-shared_child-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-shared_child-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-shared_child-devel}"
SRC_URI[x86_64_v2_rust-shared_child-devel.sha256sum] = "c092648c7643a32644727dfddc4e6a4ef9afef8d1cb103118b1af462679779a2"

URI_aarch64_rust-shared_child+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shared_child+default-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-shared_child+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shared_child+default-devel}"
SRC_URI[aarch64_rust-shared_child+default-devel.sha256sum] = "1ed8da423c870a879ddbd7fd773245fac08ef863ee12a93658f9af2558a2de15"

URI_aarch64_rust-shared_child-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-shared_child-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-shared_child-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-shared_child-devel}"
SRC_URI[aarch64_rust-shared_child-devel.sha256sum] = "761fb99eed0a11771ebc623ecc252a8338a5810a1ccaff338d066f6fb5b52e37"

RDEPENDS:rust-shared_child+default-devel = " \
 cargo \
 rust-shared_child-devel \
 "
RDEPENDS:rust-shared_child-devel = " \
 cargo \
 rust-libc+default-devel \
 "
