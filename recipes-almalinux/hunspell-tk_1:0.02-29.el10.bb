# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-tk"
PE = "1"
PV = "0.02"
PR = "29.el10"
PACKAGES = " \
 hunspell-tk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-tk-0.02-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78549690750043e3ff659e98da13207a33485a6996f40d5d58d831a82d9741a5"

URI_x86_64_v2_hunspell-tk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-tk-0.02-29.el10.noarch.rpm;name=x86_64_v2_hunspell-tk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-tk}"
SRC_URI[x86_64_v2_hunspell-tk.sha256sum] = "9a84f445c3835c451145464cbeef7e8408c649e0bb8324a4efdfa6eab13d8047"

URI_aarch64_hunspell-tk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-tk-0.02-29.el10.noarch.rpm;name=aarch64_hunspell-tk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-tk}"
SRC_URI[aarch64_hunspell-tk.sha256sum] = "9a84f445c3835c451145464cbeef7e8408c649e0bb8324a4efdfa6eab13d8047"

RDEPENDS:hunspell-tk = " \
 hunspell-filesystem \
 "
