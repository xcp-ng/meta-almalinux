# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kunitconversion"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kunitconversion \
 kf6-kunitconversion-devel \
 kf6-kunitconversion-doc \
 kf6-kunitconversion-html \
 python3-kf6-kunitconversion \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kunitconversion-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50b88fd7c5f648913711260e0b16a8b145aba3d582796eb122e610da83d2b6b2"

URI_x86_64_v2_kf6-kunitconversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion}"
SRC_URI[x86_64_v2_kf6-kunitconversion.sha256sum] = "fba0448c51b5565bb36cfa260e6eec45aaa6fa6637bd4799b2ca3163f641844b"

URI_x86_64_v2_kf6-kunitconversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kunitconversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-devel}"
SRC_URI[x86_64_v2_kf6-kunitconversion-devel.sha256sum] = "b36424583e170c525e0b2db903c74d44f368f759084f802f171ecd7f90a02dd1"

URI_x86_64_v2_kf6-kunitconversion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kunitconversion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-doc}"
SRC_URI[x86_64_v2_kf6-kunitconversion-doc.sha256sum] = "2d2f1d73da9c321a7b521959b17ecdf505ea212c0042d08a24930da8e4f60f5a"

URI_x86_64_v2_kf6-kunitconversion-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kunitconversion-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kunitconversion-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kunitconversion-html}"
SRC_URI[x86_64_v2_kf6-kunitconversion-html.sha256sum] = "75a4cec86773e4672842be92b408d8293d46924b9b8b43f736350bf7055af3e2"

URI_x86_64_v2_python3-kf6-kunitconversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kunitconversion-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kunitconversion}"
SRC_URI[x86_64_v2_python3-kf6-kunitconversion.sha256sum] = "b12f926c5ffffb38907535575cd6aea73a408a88a6a808e2eb0488de4bfed0cd"

URI_aarch64_kf6-kunitconversion = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion}"
SRC_URI[aarch64_kf6-kunitconversion.sha256sum] = "4dc17bc4a5a77dd5d4b05660ad0df42bd54c42bb043a7c30ac14b33755b2dccd"

URI_aarch64_kf6-kunitconversion-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kunitconversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-devel}"
SRC_URI[aarch64_kf6-kunitconversion-devel.sha256sum] = "4880d95f297b6fb33e4929e5da39ff62bd43328e45e9ef6d083c9eef5ca616ab"

URI_aarch64_kf6-kunitconversion-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kunitconversion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-doc}"
SRC_URI[aarch64_kf6-kunitconversion-doc.sha256sum] = "cc9ceca9a5c3098ae9744376511d90e7d35a442251669ea8e8cb644efdc88025"

URI_aarch64_kf6-kunitconversion-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kunitconversion-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kunitconversion-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kunitconversion-html}"
SRC_URI[aarch64_kf6-kunitconversion-html.sha256sum] = "6a74d04a847f27e9647664faf3ac6813f4c554002ecb98b01b54fdea566c5665"

URI_aarch64_python3-kf6-kunitconversion = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kunitconversion-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kunitconversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kunitconversion}"
SRC_URI[aarch64_python3-kf6-kunitconversion.sha256sum] = "663654491c63949bb63289721fd70fe30b170d39562dce0290a3fafdd3a0bcfb"

RDEPENDS:kf6-kunitconversion = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kunitconversion-devel = " \
 cmake-filesystem \
 kf6-kunitconversion \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kunitconversion-doc = " \
 "
RDEPENDS:kf6-kunitconversion-html = " \
 "
RDEPENDS:python3-kf6-kunitconversion = " \
 glibc \
 kf6-kunitconversion \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
