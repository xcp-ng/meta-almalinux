# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcp"
PE = "12"
PV = "4.4.3"
PR = "23.el10_1"
PACKAGES = " \
 dhcp-common \
 dhcp-relay \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dhcp-4.4.3-23.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "575f4a6c7d210a89df5a27dd2a99a60dfddaaedaa1f494a7c93c6d06a932dd6b"

URI_x86_64_v2_dhcp-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhcp-common-4.4.3-23.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_dhcp-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhcp-common}"
SRC_URI[x86_64_v2_dhcp-common.sha256sum] = "2d0edc43b400c474dae6104aac9020e6e69c58f3435fcb85e9eb3c19e911d57c"

URI_x86_64_v2_dhcp-relay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhcp-relay-4.4.3-23.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dhcp-relay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhcp-relay}"
SRC_URI[x86_64_v2_dhcp-relay.sha256sum] = "f4f7edf729629e245954603b3c2e9ad131ba7d07ce46204e0363f8dd44e26046"

URI_aarch64_dhcp-common = "${EPEL_MIRROR}/aarch64/Packages/d/dhcp-common-4.4.3-23.el10_1.noarch.rpm;name=aarch64_dhcp-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhcp-common}"
SRC_URI[aarch64_dhcp-common.sha256sum] = "038f026aa52b26769a807f8da2676870160fdebc4b0bf020c57a7358965cc9fb"

URI_aarch64_dhcp-relay = "${EPEL_MIRROR}/aarch64/Packages/d/dhcp-relay-4.4.3-23.el10_1.aarch64.rpm;name=aarch64_dhcp-relay;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhcp-relay}"
SRC_URI[aarch64_dhcp-relay.sha256sum] = "24fd55afb67720159187b87df2b087a7925cce4a857f9b751b537b5879e94101"

RDEPENDS:dhcp-common = " \
 "
RDEPENDS:dhcp-relay = " \
 bash \
 dhcp-common \
 glibc \
 grep \
 libcap-ng \
 sed \
 systemd \
 systemd-libs \
 "
