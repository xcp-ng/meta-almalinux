# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inotify"
PV = "0.11.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-inotify+default-devel \
 rust-inotify+futures-util-devel \
 rust-inotify+stream-devel \
 rust-inotify+tokio-devel \
 rust-inotify-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inotify-0.11.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcee0531a473264399253596557825336e60f01b97047f8923f9fa77af9645bc"

URI_x86_64_v2_rust-inotify+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+default-devel-0.11.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+default-devel}"
SRC_URI[x86_64_v2_rust-inotify+default-devel.sha256sum] = "aad2de06bd7b80e4d0db8f9bfab9f4f5d907a9b1705533c581cdd1d5b978e064"

URI_x86_64_v2_rust-inotify+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+futures-util-devel-0.11.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+futures-util-devel}"
SRC_URI[x86_64_v2_rust-inotify+futures-util-devel.sha256sum] = "2c2691e20750a8587c1b1af66b08845950fb1b3e753e235e27f85f1941118ea3"

URI_x86_64_v2_rust-inotify+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+stream-devel-0.11.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+stream-devel}"
SRC_URI[x86_64_v2_rust-inotify+stream-devel.sha256sum] = "eecc78a18307e5d5f5eda956f72dfa5256caff23dadef2f35bc7ad88e8854610"

URI_x86_64_v2_rust-inotify+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify+tokio-devel-0.11.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify+tokio-devel}"
SRC_URI[x86_64_v2_rust-inotify+tokio-devel.sha256sum] = "d219170ee5ff2c4e263d6e7974cd416f98a31e293bf19ea6f8bf1220b3d7293f"

URI_x86_64_v2_rust-inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inotify-devel-0.11.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inotify-devel}"
SRC_URI[x86_64_v2_rust-inotify-devel.sha256sum] = "df654e27cb03e28cf9134c9d0c059cecefebb80f67016626b68fb6982eb9ec93"

URI_aarch64_rust-inotify+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+default-devel-0.11.2-1.el10_3.noarch.rpm;name=aarch64_rust-inotify+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+default-devel}"
SRC_URI[aarch64_rust-inotify+default-devel.sha256sum] = "1e9b70f211d7d86d6c9ad4ff96678fef023b8be18b07010b9e74d144468a6dd2"

URI_aarch64_rust-inotify+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+futures-util-devel-0.11.2-1.el10_3.noarch.rpm;name=aarch64_rust-inotify+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+futures-util-devel}"
SRC_URI[aarch64_rust-inotify+futures-util-devel.sha256sum] = "9e52ba0423ec68d27a2cdac46a3d8936d16fbab7862f1dccd41bba7478d87c57"

URI_aarch64_rust-inotify+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+stream-devel-0.11.2-1.el10_3.noarch.rpm;name=aarch64_rust-inotify+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+stream-devel}"
SRC_URI[aarch64_rust-inotify+stream-devel.sha256sum] = "7f5fba0c1793164bee9a6e93aa0374611562a450948da392a1f9616ecb78fc9a"

URI_aarch64_rust-inotify+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify+tokio-devel-0.11.2-1.el10_3.noarch.rpm;name=aarch64_rust-inotify+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify+tokio-devel}"
SRC_URI[aarch64_rust-inotify+tokio-devel.sha256sum] = "ea59aeb7bc3cf52c2b871c20732e6500f38e52aede755b7c46d8dfd49ce56896"

URI_aarch64_rust-inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inotify-devel-0.11.2-1.el10_3.noarch.rpm;name=aarch64_rust-inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inotify-devel}"
SRC_URI[aarch64_rust-inotify-devel.sha256sum] = "d0942957ed80d1fde555093f56aba6b5e7b9126927d3844b595c88fab724ff16"

RDEPENDS:rust-inotify+default-devel = " \
 cargo \
 rust-inotify+stream-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+stream-devel = " \
 cargo \
 rust-inotify+futures-util-devel \
 rust-inotify+tokio-devel \
 rust-inotify-devel \
 "
RDEPENDS:rust-inotify+tokio-devel = " \
 cargo \
 rust-inotify-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 "
RDEPENDS:rust-inotify-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-inotify-sys+default-devel \
 rust-libc+default-devel \
 "
