# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debhelper"
PV = "13.30"
PR = "2.el10_2"
PACKAGES = " \
 debhelper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debhelper-13.30-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41ddacf5e8adaf691f8c39e5a589cc1cbf0f7f9bc20b14351affdbb03a2812a3"

URI_x86_64_v2_debhelper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debhelper-13.30-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_debhelper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debhelper}"
SRC_URI[x86_64_v2_debhelper.sha256sum] = "f18ad2d13e8c1caa9c483106a6eb4fca082bf09b1173e5256c630e76d1db31f2"

URI_aarch64_debhelper = "${EPEL_MIRROR}/aarch64/Packages/d/debhelper-13.30-2.el10_2.noarch.rpm;name=aarch64_debhelper;unpack=0"
SRC_URI:append = " ${URI_aarch64_debhelper}"
SRC_URI[aarch64_debhelper.sha256sum] = "9b8b790e87478a53f46fa92c269415ef78eb04db9513e013a1b9b932b3fd0a8d"

RDEPENDS:debhelper = " \
 binutils \
 dh-autoreconf \
 dpkg \
 dpkg-dev \
 dpkg-perl \
 gzip \
 perl-Carp \
 perl-Digest-SHA \
 perl-Errno \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-stat \
 perl-Getopt-Long \
 perl-JSON-PP \
 perl-PathTools \
 perl-Time-Piece \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-parent \
 po-debconf \
 "
