# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-conda-package-handling"
PV = "2.4.0"
PR = "6.el10_2"
PACKAGES = " \
 python3-conda-package-handling \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-conda-package-handling-2.4.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b689edcd53cf33d3af32a9d57282318cd12b44633579136769d11d2acf0db91d"

URI_x86_64_v2_python3-conda-package-handling = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-conda-package-handling-2.4.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-conda-package-handling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-conda-package-handling}"
SRC_URI[x86_64_v2_python3-conda-package-handling.sha256sum] = "06d704a6516ae24ce3855009574be6288802baf59c2603c7f6ec9cdf233632c0"

URI_aarch64_python3-conda-package-handling = "${EPEL_MIRROR}/aarch64/Packages/p/python3-conda-package-handling-2.4.0-6.el10_2.noarch.rpm;name=aarch64_python3-conda-package-handling;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-conda-package-handling}"
SRC_URI[aarch64_python3-conda-package-handling.sha256sum] = "059dbe25952b37022f3b11a85e4585e00f00e160c1f870cabf135e3f048fe3b7"

RDEPENDS:python3-conda-package-handling = " \
 python3 \
 python3-conda-package-streaming \
 "
