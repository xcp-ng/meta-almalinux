# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuna"
PV = "0.19"
PR = "16.el10"
PACKAGES = " \
 tuna \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tuna-0.19-16.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "db11b22b2685dde6f5b5af85ced039b8de4c869aef2913369c656ded2d55cef2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuna-0.19-16.el10.noarch.rpm;name=x86_64_v2_tuna;unpack=0"
SRC_URI[x86_64_v2_tuna.sha256sum] = "66d90953aedb6f58c962b54d52e7e2ef09752c04c13d75567e4ed2f3012e05da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuna-0.19-16.el10.noarch.rpm;name=aarch64_tuna;unpack=0"
SRC_URI[aarch64_tuna.sha256sum] = "66d90953aedb6f58c962b54d52e7e2ef09752c04c13d75567e4ed2f3012e05da"

RDEPENDS:tuna = " \
 python3 \
 python3-linux-procfs \
 "
