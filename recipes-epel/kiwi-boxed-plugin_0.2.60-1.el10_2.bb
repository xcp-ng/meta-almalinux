# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiwi-boxed-plugin"
PV = "0.2.60"
PR = "1.el10_2"
PACKAGES = " \
 kiwi-boxed-plugin \
 python3-kiwi-boxed-plugin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiwi-boxed-plugin-0.2.60-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "056be9144c1f46babf4d7333911db8511f14f7717ef8e5100d50c8a8340900fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiwi-boxed-plugin-0.2.60-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kiwi-boxed-plugin;unpack=0"
SRC_URI[x86_64_v2_kiwi-boxed-plugin.sha256sum] = "6fbfcf543bc439eaea8aa970440aa292ff7b4754609405974eb8559ebb88975f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kiwi-boxed-plugin-0.2.60-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI[x86_64_v2_python3-kiwi-boxed-plugin.sha256sum] = "22063562e380d16355949e671a748ef8a312e865323fd6930b89a99f1499a278"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiwi-boxed-plugin-0.2.60-1.el10_2.noarch.rpm;name=aarch64_kiwi-boxed-plugin;unpack=0"
SRC_URI[aarch64_kiwi-boxed-plugin.sha256sum] = "4bddd1a38c38b1558a1b055aed724fd6ddc46a0e478ec4031751c6967711ada5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-kiwi-boxed-plugin-0.2.60-1.el10_2.noarch.rpm;name=aarch64_python3-kiwi-boxed-plugin;unpack=0"
SRC_URI[aarch64_python3-kiwi-boxed-plugin.sha256sum] = "2d71f611fab8d686001c6fe53e9a0a4205ad3ae46049340f030602d02e91ce08"

RDEPENDS:kiwi-boxed-plugin = " \
 python3-kiwi-boxed-plugin \
 "
RDEPENDS:python3-kiwi-boxed-plugin = " \
 python3 \
 python3-cerberus \
 python3-docopt-ng \
 python3-kiwi \
 python3-progressbar2 \
 python3-pyyaml \
 python3-requests \
 qemu-kvm \
 "
