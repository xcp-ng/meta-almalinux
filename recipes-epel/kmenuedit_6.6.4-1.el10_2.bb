# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmenuedit"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kmenuedit \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmenuedit-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c866f8e84c6714872235ee223f0fee188bf644db6c330a4d6337ff23c9448b0"

URI_x86_64_v2_kmenuedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmenuedit-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmenuedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmenuedit}"
SRC_URI[x86_64_v2_kmenuedit.sha256sum] = "4fd3b90cdf400b0b3e28054700804d7492d8d15c95bc9cc2e45d0064db1430f9"

URI_aarch64_kmenuedit = "${EPEL_MIRROR}/aarch64/Packages/k/kmenuedit-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kmenuedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmenuedit}"
SRC_URI[aarch64_kmenuedit.sha256sum] = "cadaa56dcf2c253bed1fcc74e7538665915cd21f50aa580e112460c5e117af4e"

RDEPENDS:kmenuedit = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
