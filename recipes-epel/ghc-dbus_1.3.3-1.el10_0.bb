# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-dbus"
PV = "1.3.3"
PR = "1.el10_0"
PACKAGES = " \
 ghc-dbus \
 ghc-dbus-devel \
 ghc-dbus-doc \
 ghc-dbus-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-dbus-1.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2521ca0941a9697f74bc376dc3f690b17aa1a714a2b443ec5ae96341839ac92a"

URI_x86_64_v2_ghc-dbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dbus-1.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dbus}"
SRC_URI[x86_64_v2_ghc-dbus.sha256sum] = "351a98f4935e9640be08d2617997bc886a7de39cfeaf4785a870138fedce7530"

URI_x86_64_v2_ghc-dbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dbus-devel-1.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dbus-devel}"
SRC_URI[x86_64_v2_ghc-dbus-devel.sha256sum] = "a2e6ba3e90f2006cf92bc418ad7cdd5543cf53e822402484926d3e2883a20355"

URI_x86_64_v2_ghc-dbus-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dbus-doc-1.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-dbus-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dbus-doc}"
SRC_URI[x86_64_v2_ghc-dbus-doc.sha256sum] = "3240fe0498d7c02f79cc4b288a208f5d1eef745e9cd245c396827ff4e9c1dd9f"

URI_x86_64_v2_ghc-dbus-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dbus-prof-1.3.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dbus-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dbus-prof}"
SRC_URI[x86_64_v2_ghc-dbus-prof.sha256sum] = "ea59574403f7f4846f636938973a98182c6abf8fb13807193ab274b11c359aba"

URI_aarch64_ghc-dbus = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dbus-1.3.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dbus}"
SRC_URI[aarch64_ghc-dbus.sha256sum] = "36bcd20a64a3a2c9d0925bb4d9d2bf33a185ed77ae418f7e527e8a576f8dd6db"

URI_aarch64_ghc-dbus-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dbus-devel-1.3.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-dbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dbus-devel}"
SRC_URI[aarch64_ghc-dbus-devel.sha256sum] = "51de09df0a91ab7e9f1bd71e283c3a9509b38150f0db914e95f625f5eb737054"

URI_aarch64_ghc-dbus-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dbus-doc-1.3.3-1.el10_0.noarch.rpm;name=aarch64_ghc-dbus-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dbus-doc}"
SRC_URI[aarch64_ghc-dbus-doc.sha256sum] = "46feee52d68417e9a5fa0dd53eda4f392a7ccae0e8b0b116b1d80e2708800ecb"

URI_aarch64_ghc-dbus-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dbus-prof-1.3.3-1.el10_0.aarch64.rpm;name=aarch64_ghc-dbus-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dbus-prof}"
SRC_URI[aarch64_ghc-dbus-prof.sha256sum] = "3e9635a2f23cc04106b3da638d068b9f3373c9b1b3743b6359e957aee1f5b241"

RDEPENDS:ghc-dbus = " \
 ghc-OneTuple \
 ghc-StateVar \
 ghc-adjunctions \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-bytestring \
 ghc-call-stack \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-exceptions \
 ghc-filepath \
 ghc-free \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-invariant \
 ghc-kan-extensions \
 ghc-lens \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-os-string \
 ghc-parallel \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-profunctors \
 ghc-random \
 ghc-reflection \
 ghc-resourcet \
 ghc-scientific \
 ghc-semigroupoids \
 ghc-semigroups \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-these \
 ghc-time \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-void \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-dbus-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-cereal-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-containers-devel \
 ghc-dbus \
 ghc-deepseq-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-lens-devel \
 ghc-network-devel \
 ghc-parsec-devel \
 ghc-random-devel \
 ghc-split-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-th-lift-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 ghc-vector-devel \
 ghc-xml-conduit-devel \
 ghc-xml-types-devel \
 "
RDEPENDS:ghc-dbus-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-dbus-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cereal-prof \
 ghc-conduit-prof \
 ghc-containers-prof \
 ghc-dbus-devel \
 ghc-deepseq-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-lens-prof \
 ghc-network-prof \
 ghc-parsec-prof \
 ghc-random-prof \
 ghc-split-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-th-lift-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 ghc-vector-prof \
 ghc-xml-conduit-prof \
 ghc-xml-types-prof \
 "
