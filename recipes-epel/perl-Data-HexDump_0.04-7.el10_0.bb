# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-HexDump"
PV = "0.04"
PR = "7.el10_0"
PACKAGES = " \
 perl-Data-HexDump \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-HexDump-0.04-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f2fb5819cd0cd60efd3f1b589ce077ad7b629bbb0cff7d42898f0a406244f41"

URI_x86_64_v2_perl-Data-HexDump = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-HexDump-0.04-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-HexDump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-HexDump}"
SRC_URI[x86_64_v2_perl-Data-HexDump.sha256sum] = "6306796c2594a9819a80d5e9b8a8ba952baa531535ac88f39bbce1222f93df81"

URI_aarch64_perl-Data-HexDump = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-HexDump-0.04-7.el10_0.noarch.rpm;name=aarch64_perl-Data-HexDump;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-HexDump}"
SRC_URI[aarch64_perl-Data-HexDump.sha256sum] = "f2bef3eec089440fd4d41dc87b1675e9634aa96251b20b46ab55cc62ac14f6ce"

RDEPENDS:perl-Data-HexDump = " \
 perl-Carp \
 perl-Exporter \
 perl-FileHandle \
 perl-libs \
 perl-parent \
 "
