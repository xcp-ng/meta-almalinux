# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-deque"
PV = "0.8.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-deque+default-devel \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-deque-0.8.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6519fd6186169728c7faef88045511781443f84838e6aa01985695ead8c520c1"

URI_x86_64_v2_rust-crossbeam-deque+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+default-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-deque+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-deque+default-devel.sha256sum] = "8f0fe0457513170516560ece9ed7497cf5dacd43a5a72889c540ef14d7beb8e8"

URI_x86_64_v2_rust-crossbeam-deque+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque+std-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-deque+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-deque+std-devel.sha256sum] = "030c2744b68b695cbd3a8b7829ff5bcd955653e12550b204d952a0d0784d1ebf"

URI_x86_64_v2_rust-crossbeam-deque-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-deque-devel-0.8.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-deque-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-deque-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-deque-devel.sha256sum] = "d4b3bcc6cc1a431cd4043023da1eeed37f1699ab21de9822a3d057fd5c6b34bb"

URI_aarch64_rust-crossbeam-deque+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+default-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-deque+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-deque+default-devel}"
SRC_URI[aarch64_rust-crossbeam-deque+default-devel.sha256sum] = "dbce8e2e628648ee1b4126507d08bcffbad7b933fb411e4f9a251a9aba69ad61"

URI_aarch64_rust-crossbeam-deque+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque+std-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-deque+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-deque+std-devel}"
SRC_URI[aarch64_rust-crossbeam-deque+std-devel.sha256sum] = "a8323ec16da05888fdca8140121a91f9f878d1084f7bc734b3c28d434f66e0ca"

URI_aarch64_rust-crossbeam-deque-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-deque-devel-0.8.7-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-deque-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-deque-devel}"
SRC_URI[aarch64_rust-crossbeam-deque-devel.sha256sum] = "275763ab4565b0b674f64065dd7b6f4bb054465964793b9072a5c81c68edd183"

RDEPENDS:rust-crossbeam-deque+default-devel = " \
 cargo \
 rust-crossbeam-deque+std-devel \
 rust-crossbeam-deque-devel \
 "
RDEPENDS:rust-crossbeam-deque+std-devel = " \
 cargo \
 rust-crossbeam-deque-devel \
 rust-crossbeam-epoch+std-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-deque-devel = " \
 cargo \
 rust \
 rust-crossbeam-epoch-devel \
 rust-crossbeam-utils-devel \
 "
