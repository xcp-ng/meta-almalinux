# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-isoduration"
PV = "20.11.0"
PR = "11.el10_1"
PACKAGES = " \
 python3-isoduration \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-isoduration-20.11.0-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4ec38cab6274d92a7fdd5d394b04a7b2f587df86d7aeea35118a148a3cc3a7d"

URI_x86_64_v2_python3-isoduration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-isoduration-20.11.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-isoduration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-isoduration}"
SRC_URI[x86_64_v2_python3-isoduration.sha256sum] = "3b3c7649ef45b359a85438fd67a398bfb044cac3316b2a5e5622eff3b5d05c9b"

URI_aarch64_python3-isoduration = "${EPEL_MIRROR}/aarch64/Packages/p/python3-isoduration-20.11.0-11.el10_1.noarch.rpm;name=aarch64_python3-isoduration;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-isoduration}"
SRC_URI[aarch64_python3-isoduration.sha256sum] = "cc3ac967794b861da079e0998292e85d20ffd0ad2660f6ca025f114b4e1b636d"

RDEPENDS:python3-isoduration = " \
 python3 \
 python3-arrow \
 "
