# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-activities-stats"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-activities-stats \
 plasma-activities-stats-devel \
 plasma-activities-stats-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-activities-stats-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1fcfcce6266ccf1506896ca0d823de97fa99c937261350b3acaff320d73364b"

URI_x86_64_v2_plasma-activities-stats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats}"
SRC_URI[x86_64_v2_plasma-activities-stats.sha256sum] = "07f26f13bf8533797f6432856771ca1a5d55b88c3c08b38b3447461968aaff1e"

URI_x86_64_v2_plasma-activities-stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-activities-stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats-devel}"
SRC_URI[x86_64_v2_plasma-activities-stats-devel.sha256sum] = "9b78398ac1f77cb6c2ee27bc14a80e3ee3f79ac7f3c1bd916aae67d91356e366"

URI_x86_64_v2_plasma-activities-stats-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-activities-stats-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-activities-stats-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-activities-stats-doc}"
SRC_URI[x86_64_v2_plasma-activities-stats-doc.sha256sum] = "785f2ced3bba262cd4f66a0a3585e7ff7bdb5a50096bced63b75b40ac286c6e3"

URI_aarch64_plasma-activities-stats = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-activities-stats;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats}"
SRC_URI[aarch64_plasma-activities-stats.sha256sum] = "d1e77f221d6cfb1f3c19cb450496aec3885f7abde3c4741b596f44533538e5b3"

URI_aarch64_plasma-activities-stats-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-activities-stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats-devel}"
SRC_URI[aarch64_plasma-activities-stats-devel.sha256sum] = "250017413dd695c0362063f5f5959b3f5b6215a3e0d1545cf9875ef0e4f0b4a8"

URI_aarch64_plasma-activities-stats-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-activities-stats-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma-activities-stats-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-activities-stats-doc}"
SRC_URI[aarch64_plasma-activities-stats-doc.sha256sum] = "bc60071974aac90c013bdb9d0f857dfda2d5b3302c15e9c1aa5c21002fa6c8a7"

RDEPENDS:plasma-activities-stats = " \
 glibc \
 kf6-kconfig \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 "
RDEPENDS:plasma-activities-stats-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 plasma-activities-stats \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma-activities-stats-doc = " \
 "
