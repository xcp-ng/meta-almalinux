# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs-nodemon"
PV = "3.0.3"
PR = "5.el10"
PACKAGES = " \
 nodejs-nodemon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs-nodemon-3.0.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92c8b6e5e93554e02605ff09f747e521d5e097fb1a8c038c3429173672dc2d8f"

URI_x86_64_v2_nodejs-nodemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-nodemon-3.0.3-5.el10.noarch.rpm;name=x86_64_v2_nodejs-nodemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-nodemon}"
SRC_URI[x86_64_v2_nodejs-nodemon.sha256sum] = "f0067da1d5d70c4974031fa9d58791313dcd07abec90625a6cb1d8c4602a53ae"

URI_aarch64_nodejs-nodemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-nodemon-3.0.3-5.el10.noarch.rpm;name=aarch64_nodejs-nodemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-nodemon}"
SRC_URI[aarch64_nodejs-nodemon.sha256sum] = "f0067da1d5d70c4974031fa9d58791313dcd07abec90625a6cb1d8c4602a53ae"

RDEPENDS:nodejs-nodemon = " \
 virtual/nodejs_engine_ \
 "
