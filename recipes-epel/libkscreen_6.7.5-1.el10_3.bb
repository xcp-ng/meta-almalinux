# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkscreen"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 libkscreen \
 libkscreen-devel \
 libkscreen-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libkscreen-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "562d1c4885fc3bc70c2c3b1a5cfdcff94bf9733dbd1a5fdcaa8b889964c19ddf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen;unpack=0"
SRC_URI[x86_64_v2_libkscreen.sha256sum] = "ce06bbeb6ae2978d2a9e25d99769086373cc9b557d02d76ab25d42508b418a61"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen-devel;unpack=0"
SRC_URI[x86_64_v2_libkscreen-devel.sha256sum] = "7182083775003134f958176895191f22e7e10092616c8fa02dbc1fee4d6a2d3f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkscreen-doc;unpack=0"
SRC_URI[x86_64_v2_libkscreen-doc.sha256sum] = "430f85561e1b86f258d1ceca27255c56cef9f91e800be3f2b30335559a80e435"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_libkscreen;unpack=0"
SRC_URI[aarch64_libkscreen.sha256sum] = "70cb2b1b1f769c5ded95d0665681bcf2a5d5d0b590bb4ce3b8ebb1508c2b5f41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_libkscreen-devel;unpack=0"
SRC_URI[aarch64_libkscreen-devel.sha256sum] = "7cbc49cc43fc08ffb6ea70ec9be21e78fb7f4f5265766699867a9024e4185a53"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_libkscreen-doc;unpack=0"
SRC_URI[aarch64_libkscreen-doc.sha256sum] = "7ff49d63e4a95bcdb284086cf0b84ebce501a5da4f60a0c2aa1de68ddf7bb15e"

RDEPENDS:libkscreen = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkscreen-devel = " \
 cmake-filesystem \
 libkscreen \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:libkscreen-doc = " \
 "
